variables
{
    timer varTimer;
}