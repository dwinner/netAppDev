                                    if(CacheElements ==TRUE)                                    
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSiriusAlertList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSiriusAlertList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =3 ends
                    
                    case 4: //recordaddress =4 -> Attributes, Frequency

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSiriusAlertList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSiriusAlertList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSiriusAlertList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSiriusAlertList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSiriusAlertList_ListHandlingType !=AUDIO_SIRIUSALERTLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;i++) //clear
			                                    gSiriusAlertList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                    
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSiriusAlertList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSiriusAlertList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;i++) //clear
			                                    gSiriusAlertList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =4 ends
                        
                    case 5: //recordaddress =5 -> Attributes, PresetID, Name, Frequency, AlertType, AlertName

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSiriusAlertList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSiriusAlertList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSiriusAlertList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSiriusAlertList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSiriusAlertList_ListHandlingType !=AUDIO_SIRIUSALERTLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;i++) //clear
			                                    gSiriusAlertList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //AlertType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_AlertType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //AlertName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                gSiriusAlertList_AlertName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_AlertName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSiriusAlertList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSiriusAlertList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;i++) //clear
			                                    gSiriusAlertList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //AlertType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_AlertType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //AlertName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                gSiriusAlertList_AlertName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_AlertName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =5 ends                    
                        
                    case 15: //recordaddress =0xf -> Pos

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSiriusAlertList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSiriusAlertList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSiriusAlertList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSiriusAlertList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSiriusAlertList_ListHandlingType !=AUDIO_SIRIUSALERTLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                    
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSiriusAlertList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gSiriusAlertList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0xf ends
                }
                  
                }                   
                
                //Panel
                putvalue(env_ASG_AudioSD_SAL_ASGID, gSiriusAlertList_ASGID);
                putvalue(env_ASG_AudioSD_SAL_TAID, gSiriusAlertList_TAID);

                gSiriusAlertList_recordaddress =recordaddress;
                gSiriusAlertList_transmitpos   =transmitpos;             
            
            break;
			
            case Error_IND:
					
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD SiriusAlertList_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD SiriusAlertList_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD SiriusAlertList_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD SiriusAlertList_Indication: Application-Error: 0x%x", Indication_array[3]);
				
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD SiriusAlertList_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
		}

    //for "sliding window concept"
    if(gSiriusAlertList_TotalNumListElements<=AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE)
        gSiriusAlertList_SlidingWindow_State =AUDIO_SIRIUSALERTLIST_SLIDINGWINDOW_NOTACTIVE;
    else
        gSiriusAlertList_SlidingWindow_State =AUDIO_SIRIUSALERTLIST_SLIDINGWINDOW_ACTIVE;

    if (gSiriusAlertList_CallBackReason !=AUDIO_SIRIUSALERTLIST_CALLBACKREASON_NOCALLBACK)
        SiriusAlertList_ListHandling ();
    else
        SiriusAlertList_display();
}

int SiriusAlertList_GetNextCachedElement (int currentElement,byte direction)
{
    int i=0, nextElement=0;

    switch (direction)
    {
        case AUDIO_SIRIUSALERTLIST_DISPLAYLIST_FIND_NEXT_ELEMENT:                
                nextElement = ++currentElement;

                if (nextElement<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE) //start at next element, if next element is not >8
                {
                    for(i =nextElement; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i= AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;
                        }
                        else
                            nextElement =0;
                    }
                }
                else    //start at first element
                {
                    nextElement =0;

                    for(i =nextElement; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;
                        }   
                    }
                }
        break;

        case AUDIO_SIRIUSALERTLIST_DISPLAYLIST_FIND_PREVIUOS_ELEMENT:
                nextElement = --currentElement;
                if (nextElement ==0 && gSiriusAlertList_ListEntryReceptionInformation[nextElement] ==TRUE)
                    nextElement =0;
                else if (nextElement>0) 
                {
                    for(i =nextElement; i>0; i--)
                    {
                        if(gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =0;
                        }
                        else
                            nextElement =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE-1;
                    }
                }    
                else    //start at last element
                {
                    nextElement =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE-1;

                    for(i =nextElement; i>0; i--)
                    {
                        if(gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =0;
                        }
                        else if(gSiriusAlertList_ListEntryReceptionInformation[0] ==TRUE)
                            nextElement =0;          
                    }
                }
        break;

        default:
        break;
    }
    return(nextElement);
}

int SiriusAlertList_GetNextLineInCache (int currentElement,byte direction)
{
    int i=0, nextElement=0;

    switch (direction)
    {
        case FORWARD:
                           
                if(currentElement<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE-1 && currentElement !=5) 
                    nextElement = ++currentElement;  
                
                else if (currentElement ==8)            
                    nextElement =0;
                else
                    nextElement =AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION;
        break;

        case BACKWARD:
                if(currentElement<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE && currentElement !=0 && currentElement !=6) 
                    nextElement =--currentElement;
                
                else if (currentElement ==0)            
                    nextElement =8;
                
                else
                    nextElement =AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION;
        break;

        default:
        break;
    }
    return(nextElement);
}

void SiriusAlertList_ListHandling () //for sliding window concept, list handling and 'build-up' list...
{
    byte mode, shift, direction, transmitpos, indexsize, recordaddress, buffer_AlertType, buffer_PresetID, buffer_ReceptionInformation;
    byte buffer_Attributes_bit0, buffer_Attributes_bit1, buffer_Attributes_bit2, buffer_Attributes_bit3, 
      buffer_Attributes_bit4, buffer_Attributes_bit5, buffer_Attributes_bit6;
    word requested_startelement, startelement, elements, buffer_Pos, buffer_Attributes;
    char buffer_Name[AUDIO_SIRIUSALERTLIST_NAME_LENGTH], buffer_Frequency[AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH],
      buffer_AlertName[AUDIO_SIRIUSALERTLIST_ALERTNAME_LENGTH], buffer_Extension[AUDIO_SIRIUSALERTLIST_EXTENSION_LENGTH];
    int i,j,k;
    
    // Init local variables. 
    mode                        =0;
    shift                       =0;
    direction                   =0;
    transmitpos                 =0;
    indexsize                   =0;
    recordaddress               =0;
    requested_startelement      =0;
    startelement                =0;
    elements                    =0;
    i                           =0;
    j                           =0;
    k                           =0;
    buffer_Pos                  =0;
    buffer_AlertType            =0;
    buffer_PresetID             =0;
    buffer_ReceptionInformation =0;
    buffer_Attributes           =0;
    buffer_Attributes_bit0      =0;
    buffer_Attributes_bit1      =0;
    buffer_Attributes_bit2      =0;
    buffer_Attributes_bit3      =0;
    buffer_Attributes_bit4      =0;
    buffer_Attributes_bit5      =0;
    buffer_Attributes_bit6      =0;
    buffer_PresetID             =0;
    
    /***build-up complete cache***/

    switch (gSiriusAlertList_ListHandlingType)
    {
        case AUDIO_SIRIUSALERTLIST_BUILDUPCACHE:
             
            switch (gSiriusAlertList_cacheBuildUp)
            {   
                //cache-up  
                case AUDIO_SIRIUSALERTLIST_BUILDUPCACHECACHE_UP:  
                    if(gSiriusAlertList_CallBackReason !=AUDIO_SIRIUSALERTLIST_BUILDUPCACHENOCACHE && gSiriusAlertList_CallBackReason !=AUDIO_SIRIUSALERTLIST_CALLBACKREASON_CACHENEXT)
                    {
                        switch (gSiriusAlertList_CallBackReason)
                        {
                            case AUDIO_SIRIUSALERTLIST_CALLBACKREASON_CHECKCACHE:

                                    if(gSiriusAlertList_ListEntryReceptionInformation[2] ==TRUE) //cache-down required?
                                    {            
                                        gSiriusAlertList_cacheBuildUp      =AUDIO_SIRIUSALERTLIST_BUILDUPCACHECACHE_DOWN;      //next step: build-up upper cache
                                        gSiriusAlertList_CallBackReason    =AUDIO_SIRIUSALERTLIST_CALLBACKREASON_CACHENEXT;    
                                        
                                        
                                        SiriusAlertList_ListHandling ();
                                    }
                                    else //stop caching
                                    {   
                                        gSiriusAlertList_cacheBuildUp      =AUDIO_SIRIUSALERTLIST_BUILDUPCACHENOCACHE;  //"build-up cache" finished
                                        gSiriusAlertList_ListHandlingType  =AUDIO_SIRIUSALERTLIST_NOCACHE;              
                                        gSiriusAlertList_CallBackReason    =AUDIO_SIRIUSALERTLIST_CALLBACKREASON_NOCALLBACK; 
                                        gSiriusAlertList_CursorAction      =AUDIO_SIRIUSALERTLIST_CURSORACTION_NOTHING;
                                        
                                        //putvalue(env_ASG_AudioSD_SAL_ListOpState, empty_string);
                                        SiriusAlertList_display();
                                    }
                            break;
                        }
                    }
                    else
                    {   
                        shift               =TRUE;
                        direction           =BACKWARD;
                        transmitpos         =FALSE;
                        indexsize           =TRUE;
                        recordaddress       =0;
                        startelement        =0;
                        elements            =3;
                
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gSiriusAlertList_CallBackReason  =AUDIO_SIRIUSALERTLIST_CALLBACKREASON_CHECKCACHE;

                        SiriusAlertList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;
                
                //cache "window"
                case AUDIO_SIRIUSALERTLIST_BUILDUPCACHECACHE_WINDOW: 
                    if(gSiriusAlertList_CallBackReason !=AUDIO_SIRIUSALERTLIST_BUILDUPCACHENOCACHE && gSiriusAlertList_CallBackReason !=AUDIO_SIRIUSALERTLIST_CALLBACKREASON_CACHENEXT)
                    {   
                        switch (gSiriusAlertList_CallBackReason)
                        {
                            case AUDIO_SIRIUSALERTLIST_CALLBACKREASON_CHECKCACHE:
                                                 
                                    gSiriusAlertList_cacheBuildUp      =AUDIO_SIRIUSALERTLIST_BUILDUPCACHECACHE_UP;      //next step: build-up upper cache
                                    gSiriusAlertList_CallBackReason    =AUDIO_SIRIUSALERTLIST_CALLBACKREASON_CACHENEXT;    
                                    
                                    SiriusAlertList_ListHandling ();
                            break;
                        }
                    }
                    else
                    { 
                        //putvalue(env_ASG_AudioSD_SAL_ListOpState, "build-up list...");
                        shift               =FALSE;
                        direction           =FORWARD;
                        transmitpos         =FALSE;
                        indexsize           =TRUE;
                        recordaddress       =0;
                        startelement        =0;
                        elements            =3; 
    
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gSiriusAlertList_CallBackReason  =AUDIO_SIRIUSALERTLIST_CALLBACKREASON_CHECKCACHE;

                        SiriusAlertList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;
                
                //cache-down
                case AUDIO_SIRIUSALERTLIST_BUILDUPCACHECACHE_DOWN:
                    if(gSiriusAlertList_CallBackReason !=AUDIO_SIRIUSALERTLIST_BUILDUPCACHENOCACHE && gSiriusAlertList_CallBackReason !=AUDIO_SIRIUSALERTLIST_CALLBACKREASON_CACHENEXT)
                    {
                        switch (gSiriusAlertList_CallBackReason)
                        {
                            case AUDIO_SIRIUSALERTLIST_CALLBACKREASON_CHECKCACHE:
                                    
                                    //stop caching
                                    gSiriusAlertList_cacheBuildUp      =AUDIO_SIRIUSALERTLIST_BUILDUPCACHENOCACHE;  //"build-up cache" finished
                                    gSiriusAlertList_ListHandlingType  =AUDIO_SIRIUSALERTLIST_NOCACHE;              
                                    gSiriusAlertList_CallBackReason    =AUDIO_SIRIUSALERTLIST_CALLBACKREASON_NOCALLBACK;
                                    gSiriusAlertList_CursorAction      =AUDIO_SIRIUSALERTLIST_CURSORACTION_NOTHING;
                                    
                                    gSiriusAlertList_DisplayStatus     =AUDIO_SIRIUSALERTLIST_DISPLAYLIST_REFRESH;
                                    
                                    //putvalue(env_ASG_AudioSD_SAL_ListOpState, empty_string);
                                    SiriusAlertList_display();
                            break;
                        }
                    }
                    else
                    { 
                        shift                   =TRUE;
                        direction               =FORWARD;
                        transmitpos             =FALSE;
                        indexsize               =TRUE;
                        recordaddress           =0;
                        for(i=0;i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++) //find last cached element
                        {   
                            if(gSiriusAlertList_ListEntryReceptionInformation[i] ==FALSE) //abort loop
                                i =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; 
                            else
                                startelement    =gSiriusAlertList_Pos[i];
                        }
                        elements                =3;                         
        
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gSiriusAlertList_CallBackReason    =AUDIO_SIRIUSALERTLIST_CALLBACKREASON_CHECKCACHE;
                        
                        SiriusAlertList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;

                default:
                break;
            }//build-up cache finished
        break;
        
        /********sliding-window********/
        case AUDIO_SIRIUSALERTLIST_DOWN_CACHE: 
                    if (gSiriusAlertList_CallBackReason ==AUDIO_SIRIUSALERTLIST_CALLBACKREASON_CHECKCACHE) //check if valid data received
                    {   
                        if(gSiriusAlertList_ListEntryReceptionInformation[5] ==0) //No valid data in last list pos -> last list element reached, start with element 0!  
                        {    
                            shift                   =FALSE;
                            direction               =FORWARD;
                            transmitpos             =FALSE;
                            indexsize               =TRUE;
                            recordaddress           =0;
                            startelement            =0; //first element
                            elements                =1;        
                            
                            requested_startelement  =startelement;
                            mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;
                            
                            gSiriusAlertList_CallBackReason    =AUDIO_SIRIUSALERTLIST_CALLBACKREASON_DISPLAYLIST; 
                            gSiriusAlertList_cacheDown         =TRUE;

                            SiriusAlertList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);    
                        }
                        else
                        {
                            gSiriusAlertList_CallBackReason =AUDIO_SIRIUSALERTLIST_CALLBACKREASON_DISPLAYLIST;
                            SiriusAlertList_ListHandling(); 
                        }    
                    }
                    else if (gSiriusAlertList_CallBackReason ==AUDIO_SIRIUSALERTLIST_CALLBACKREASON_DISPLAYLIST)
                    {   
                        gSiriusAlertList_ListHandlingType  =AUDIO_SIRIUSALERTLIST_NOCACHE;
                        gSiriusAlertList_cacheDown         =FALSE;
                        gSiriusAlertList_DisplayStatus     =AUDIO_SIRIUSALERTLIST_DISPLAYLIST_FIRST_ELEMENTS;
                        
                        //putvalue(env_ASG_AudioSD_SAL_ListOpState, empty_string);
                        SiriusAlertList_display();
                        gSiriusAlertList_DisplayStatus     =AUDIO_SIRIUSALERTLIST_DISPLAYLIST_REFRESH;
                        gSiriusAlertList_CallBackReason    =AUDIO_SIRIUSALERTLIST_CALLBACKREASON_NOCALLBACK;
                    }
                    else
                    {   
                        //putvalue(env_ASG_AudioSD_SAL_ListOpState, "list operating...");
                                
                        shift                   =TRUE;
                        direction               =FORWARD;
                        transmitpos             =FALSE;
                        indexsize               =TRUE;
                        recordaddress           =0;
                        startelement            =gSiriusAlertList_Pos[5]; //last element
                        elements                =1;
                        
                        for(i=0;i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
                        {   
                            j =i+1;
                            
                            switch (i)
                            {   
                                case 0: 
                                    //buffer data of Pos '0' (local)
                                    buffer_Pos              =gSiriusAlertList_Pos[i];
                                    buffer_AlertType        =gSiriusAlertList_AlertType[i];
                                    buffer_Attributes       =gSiriusAlertList_Attributes[i];
                                    buffer_Attributes_bit0  =gSiriusAlertList_Attributes_Bit0[i];
                                    buffer_Attributes_bit1  =gSiriusAlertList_Attributes_Bit1[i];
                                    buffer_Attributes_bit2  =gSiriusAlertList_Attributes_Bit2[i];
                                    buffer_Attributes_bit3  =gSiriusAlertList_Attributes_Bit3[i];
                                    buffer_Attributes_bit4  =gSiriusAlertList_Attributes_Bit4[i];
                                    buffer_Attributes_bit5  =gSiriusAlertList_Attributes_Bit5[i];
                                    buffer_Attributes_bit6  =gSiriusAlertList_Attributes_Bit6[i];
                                    buffer_PresetID         =gSiriusAlertList_PresetID[i];
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;k++) //clear string
                                        buffer_Name[k] =0;                                     

                                    for(k=0;k<strlen(gSiriusAlertList_Name[i]);k++) 
                                        buffer_Name[k]=gSiriusAlertList_Name[i][k];
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;k++) //clear string
                                        buffer_Frequency[k] =0;                                     

                                    for(k=0;k<strlen(gSiriusAlertList_Frequency[i]);k++) 
                                        buffer_Frequency[k]=gSiriusAlertList_Frequency[i][k];
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_ALERTNAME_LENGTH;k++) //clear string
                                        buffer_AlertName[k] =0;                                     

                                    for(k=0;k<strlen(gSiriusAlertList_AlertName[i]);k++) 
                                        buffer_AlertName[k]=gSiriusAlertList_AlertName[i][k];
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_EXTENSION_LENGTH;k++) //clear string
                                        buffer_Extension[k] =0;                                     

                                    for(k=0;k<strlen(gSiriusAlertList_Extension[i]);k++) 
                                        buffer_Extension[k]=gSiriusAlertList_Extension[i][k];
                                    

                                    //copy data from Pos '1' to Pos '0'
                                    gSiriusAlertList_Pos[i]                       =gSiriusAlertList_Pos[j]; 
                                    gSiriusAlertList_AlertType[i]                 =gSiriusAlertList_AlertType[j];
                                    gSiriusAlertList_Attributes[i]                =gSiriusAlertList_Attributes[j];
                                    gSiriusAlertList_Attributes_Bit0[i]           =gSiriusAlertList_Attributes_Bit0[j];
                                    gSiriusAlertList_Attributes_Bit1[i]           =gSiriusAlertList_Attributes_Bit1[j];
                                    gSiriusAlertList_Attributes_Bit2[i]           =gSiriusAlertList_Attributes_Bit2[j];
                                    gSiriusAlertList_Attributes_Bit3[i]           =gSiriusAlertList_Attributes_Bit3[j];
                                    gSiriusAlertList_Attributes_Bit4[i]           =gSiriusAlertList_Attributes_Bit4[j];
                                    gSiriusAlertList_Attributes_Bit5[i]           =gSiriusAlertList_Attributes_Bit5[j];
                                    gSiriusAlertList_Attributes_Bit6[i]           =gSiriusAlertList_Attributes_Bit6[j];
                                    gSiriusAlertList_PresetID[i]                  =gSiriusAlertList_PresetID[j];
                                
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;k++) //clear string
                                        gSiriusAlertList_Name[i][k] =0;                                     

                                    for(k=0;k<strlen(gSiriusAlertList_Name[j]);k++) 
                                        gSiriusAlertList_Name[i][k]=gSiriusAlertList_Name[j][k];

                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;k++) //clear string
                                        gSiriusAlertList_Frequency[i][k] =0;                                     

                                    for(k=0;k<strlen(gSiriusAlertList_Frequency[j]);k++) 
                                        gSiriusAlertList_Frequency[i][k]=gSiriusAlertList_Frequency[j][k];
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_ALERTNAME_LENGTH;k++) //clear string
                                        gSiriusAlertList_AlertName[i][k] =0;                                     

                                    for(k=0;k<strlen(gSiriusAlertList_AlertName[j]);k++) 
                                        gSiriusAlertList_AlertName[i][k]=gSiriusAlertList_AlertName[j][k];

                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_EXTENSION_LENGTH;k++) //clear string
                                        gSiriusAlertList_Extension[i][k] =0;                                     

                                    for(k=0;k<strlen(gSiriusAlertList_Extension[j]);k++) 
                                        gSiriusAlertList_Extension[i][k]=gSiriusAlertList_Extension[j][k];

                                break;
                            
                                case 5:
                                    //clear last element in list 
                                    gSiriusAlertList_ListEntryReceptionInformation[i] =0;
                                    gSiriusAlertList_Pos[i]                           =0;
                                    gSiriusAlertList_AlertType[i]                          =0;
                                    gSiriusAlertList_Attributes[i]                    =0;
                                    gSiriusAlertList_Attributes_Bit0[i]     =0;
                                    gSiriusAlertList_Attributes_Bit1[i]           =0;
                                    gSiriusAlertList_Attributes_Bit2[i]           =0;
                                    gSiriusAlertList_Attributes_Bit3[i]           =0;
                                    gSiriusAlertList_Attributes_Bit4[i]           =0;
                                    gSiriusAlertList_Attributes_Bit5[i]            =0;
                                    gSiriusAlertList_Attributes_Bit6[i]           =0;
                                    gSiriusAlertList_PresetID[i]                      =0;
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;k++) //clear string
                                        gSiriusAlertList_Name[i][k] =0;
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;k++) //clear string
                                        gSiriusAlertList_Frequency[i][k] =0;
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_ALERTNAME_LENGTH;k++) //clear string
                                        gSiriusAlertList_AlertName[i][k] =0;
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_EXTENSION_LENGTH;k++) //clear string
                                        gSiriusAlertList_Extension[i][k] =0;
                                                                 
                                break;
                            
                                case 8:
                                    //copy data from buffer in Pos '8'
                                    gSiriusAlertList_Pos[i]                       =buffer_Pos; 
                                    gSiriusAlertList_AlertType[i]                 =buffer_AlertType;
                                    gSiriusAlertList_Attributes[i]                =buffer_Attributes;
                                    gSiriusAlertList_Attributes_Bit0[i]       =buffer_Attributes_bit0;
                                    gSiriusAlertList_Attributes_Bit1[i]       =buffer_Attributes_bit1;
                                    gSiriusAlertList_Attributes_Bit2[i]       =buffer_Attributes_bit2;
                                    gSiriusAlertList_Attributes_Bit3[i]       =buffer_Attributes_bit3;
                                    gSiriusAlertList_Attributes_Bit4[i]       =buffer_Attributes_bit4;
                                    gSiriusAlertList_Attributes_Bit5[i]       =buffer_Attributes_bit5;
                                    gSiriusAlertList_Attributes_Bit6[i]       =buffer_Attributes_bit6;
                                    gSiriusAlertList_PresetID[i]              =buffer_PresetID;
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;k++) //clear string
                                        gSiriusAlertList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_Name);k++) 
                                        gSiriusAlertList_Name[i][k]=buffer_Name[k];

                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;k++) //clear string
                                        gSiriusAlertList_Frequency[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_Frequency);k++) 
                                        gSiriusAlertList_Frequency[i][k]=buffer_Frequency[k];
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_ALERTNAME_LENGTH;k++) //clear string
                                        gSiriusAlertList_AlertName[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_AlertName);k++) 
                                        gSiriusAlertList_AlertName[i][k]=buffer_AlertName[k];

                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_EXTENSION_LENGTH;k++) //clear string
                                        gSiriusAlertList_Extension[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_Extension);k++) 
                                        gSiriusAlertList_Extension[i][k]=buffer_Extension[k];
                                    
                                break;
                                
                                default://other elements
                                    //copy element on other position
                                    gSiriusAlertList_Pos[i]                       =gSiriusAlertList_Pos[j]; 
                                    gSiriusAlertList_AlertType[i]                 =gSiriusAlertList_AlertType[j];
                                    gSiriusAlertList_Attributes[i]                =gSiriusAlertList_Attributes[j];
                                    gSiriusAlertList_Attributes_Bit0[i]           =gSiriusAlertList_Attributes_Bit0[j];
                                    gSiriusAlertList_Attributes_Bit1[i]           =gSiriusAlertList_Attributes_Bit1[j]; 
                                    gSiriusAlertList_Attributes_Bit2[i]           =gSiriusAlertList_Attributes_Bit2[j];
                                    gSiriusAlertList_Attributes_Bit3[i]           =gSiriusAlertList_Attributes_Bit3[j];
                                    gSiriusAlertList_Attributes_Bit4[i]           =gSiriusAlertList_Attributes_Bit4[j];
                                    gSiriusAlertList_Attributes_Bit5[i]           =gSiriusAlertList_Attributes_Bit5[j];
                                    gSiriusAlertList_Attributes_Bit6[i]           =gSiriusAlertList_Attributes_Bit6[j];
                                    gSiriusAlertList_PresetID[i]                  =gSiriusAlertList_PresetID[j]; 
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;k++) //clear string
                                        gSiriusAlertList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gSiriusAlertList_Name[j]);k++) 
                                        gSiriusAlertList_Name[i][k]=gSiriusAlertList_Name[j][k];
                                        
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;k++) //clear string
                                        gSiriusAlertList_Frequency[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gSiriusAlertList_Frequency[j]);k++) 
                                        gSiriusAlertList_Frequency[i][k]=gSiriusAlertList_Frequency[j][k]; 
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_ALERTNAME_LENGTH;k++) //clear string
                                        gSiriusAlertList_AlertName[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gSiriusAlertList_AlertName[j]);k++) 
                                        gSiriusAlertList_AlertName[i][k]=gSiriusAlertList_AlertName[j][k];
                                        
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_EXTENSION_LENGTH;k++) //clear string
                                        gSiriusAlertList_Extension[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gSiriusAlertList_Extension[j]);k++) 
                                        gSiriusAlertList_Extension[i][k]=gSiriusAlertList_Extension[j][k]; 
                                break;
                            } // end of switch 'i'
                        }
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        SiriusAlertList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);                        
                        
                        //to check, if valid data received
                        gSiriusAlertList_CallBackReason    =AUDIO_SIRIUSALERTLIST_CALLBACKREASON_CHECKCACHE;
                    }
        break;

        case AUDIO_SIRIUSALERTLIST_UP_CACHE: 
                    if (gSiriusAlertList_CallBackReason ==AUDIO_SIRIUSALERTLIST_CALLBACKREASON_CHECKCACHE) //check if valid data received
                    {   
                        if(gSiriusAlertList_ListEntryReceptionInformation[6] ==0) //No valid data in first list pos -> last list element reached, start with element 0!  
                        {
                            shift                   =TRUE;
                            direction               =BACKWARD;
                            transmitpos             =FALSE;
                            indexsize               =TRUE;
                            recordaddress           =0;
                            startelement            =0; //Last element
                            elements                =1;        
                            
                            requested_startelement  =startelement;
                            mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                            gSiriusAlertList_cacheUp        =TRUE;
                            gSiriusAlertList_CallBackReason =AUDIO_SIRIUSALERTLIST_CALLBACKREASON_DISPLAYLIST;
                            
                            SiriusAlertList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                        }
                        else
                        {
                            gSiriusAlertList_CallBackReason =AUDIO_SIRIUSALERTLIST_CALLBACKREASON_DISPLAYLIST;
                            SiriusAlertList_ListHandling();
                        }           
                    }

                    else if (gSiriusAlertList_CallBackReason ==AUDIO_SIRIUSALERTLIST_CALLBACKREASON_DISPLAYLIST)
                    {   
                        gSiriusAlertList_ListHandlingType  =AUDIO_SIRIUSALERTLIST_NOCACHE;
                        gSiriusAlertList_cacheUp           =FALSE;
                        gSiriusAlertList_DisplayStatus     =AUDIO_SIRIUSALERTLIST_DISPLAYLIST_FIRST_ELEMENTS;
                        
                        //putvalue(env_ASG_AudioSD_SAL_ListOpState, empty_string);
                        SiriusAlertList_display();
                        gSiriusAlertList_DisplayStatus     =AUDIO_SIRIUSALERTLIST_DISPLAYLIST_REFRESH;
                        gSiriusAlertList_CallBackReason    =AUDIO_SIRIUSALERTLIST_CALLBACKREASON_NOCALLBACK;
                    }

                    else
                    {           
                        //putvalue(env_ASG_AudioSD_SAL_ListOpState, "list operating...");

                        shift                   =TRUE;
                        direction               =BACKWARD;
                        transmitpos             =FALSE;
                        indexsize               =TRUE;
                        recordaddress           =0;
                        startelement            =gSiriusAlertList_Pos[6]; //first element
                        elements                =1;
                    
                        for(i=AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE-1;i>=0;i--)
                        {  
                            j =i-1;
                            switch (i)
                            {   
                                case 8: 
                                    //buffer data of Pos '8' (local)
                                    buffer_Pos              =gSiriusAlertList_Pos[i];
                                    buffer_AlertType        =gSiriusAlertList_AlertType[i];
                                    buffer_Attributes       =gSiriusAlertList_Attributes[i];
                                    buffer_Attributes_bit0  =gSiriusAlertList_Attributes_Bit0[i];
                                    buffer_Attributes_bit1  =gSiriusAlertList_Attributes_Bit1[i];
                                    buffer_Attributes_bit2  =gSiriusAlertList_Attributes_Bit2[i];
                                    buffer_Attributes_bit3  =gSiriusAlertList_Attributes_Bit3[i];
                                    buffer_Attributes_bit4  =gSiriusAlertList_Attributes_Bit4[i];
                                    buffer_Attributes_bit5  =gSiriusAlertList_Attributes_Bit5[i];
                                    buffer_Attributes_bit6  =gSiriusAlertList_Attributes_Bit6[i];
                                    buffer_PresetID         =gSiriusAlertList_PresetID[i];
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;k++) //clear string
                                        buffer_Name[k] =0;                                     

                                    for(k=0;k<strlen(gSiriusAlertList_Name[i]);k++) 
                                        buffer_Name[k]=gSiriusAlertList_Name[i][k];

                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;k++) //clear string
                                        buffer_Frequency[k] =0;                                     

                                    for(k=0;k<strlen(gSiriusAlertList_Frequency[i]);k++) 
                                        buffer_Frequency[k]=gSiriusAlertList_Frequency[i][k];
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_ALERTNAME_LENGTH;k++) //clear string
                                        buffer_AlertName[k] =0;                                     

                                    for(k=0;k<strlen(gSiriusAlertList_AlertName[i]);k++) 
                                        buffer_AlertName[k]=gSiriusAlertList_AlertName[i][k];

                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_EXTENSION_LENGTH;k++) //clear string
                                        buffer_Extension[k] =0;                                     

                                    for(k=0;k<strlen(gSiriusAlertList_Extension[i]);k++) 
                                        buffer_Extension[k]=gSiriusAlertList_Extension[i][k];

                                    
                                    //copy data from Pos '7' to Pos '8'
                                    gSiriusAlertList_Pos[i]                       =gSiriusAlertList_Pos[j]; 
                                    gSiriusAlertList_AlertType[i]                 =gSiriusAlertList_AlertType[j];
                                    gSiriusAlertList_Attributes[i]                =gSiriusAlertList_Attributes[j];
                                    gSiriusAlertList_Attributes_Bit0[i]       =gSiriusAlertList_Attributes_Bit0[j];
                                    gSiriusAlertList_Attributes_Bit1[i]       =gSiriusAlertList_Attributes_Bit1[j];
                                    gSiriusAlertList_Attributes_Bit2[i]       =gSiriusAlertList_Attributes_Bit2[j];
                                    gSiriusAlertList_Attributes_Bit3[i]       =gSiriusAlertList_Attributes_Bit3[j];
                                    gSiriusAlertList_Attributes_Bit4[i]       =gSiriusAlertList_Attributes_Bit4[j];
                                    gSiriusAlertList_Attributes_Bit5[i]       =gSiriusAlertList_Attributes_Bit5[j];
                                    gSiriusAlertList_Attributes_Bit6[i]       =gSiriusAlertList_Attributes_Bit6[j];
                                    gSiriusAlertList_PresetID[i]                  =gSiriusAlertList_PresetID[j];
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;k++) //clear string
                                        gSiriusAlertList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gSiriusAlertList_Name[j]);k++) 
                                        gSiriusAlertList_Name[i][k]=gSiriusAlertList_Name[j][k];
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;k++) //clear string
                                        gSiriusAlertList_Frequency[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gSiriusAlertList_Frequency[j]);k++) 
                                        gSiriusAlertList_Frequency[i][k]=gSiriusAlertList_Frequency[j][k]; 
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_ALERTNAME_LENGTH;k++) //clear string
                                        gSiriusAlertList_AlertName[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gSiriusAlertList_AlertName[j]);k++) 
                                        gSiriusAlertList_AlertName[i][k]=gSiriusAlertList_AlertName[j][k];
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_EXTENSION_LENGTH;k++) //clear string
                                        gSiriusAlertList_Extension[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gSiriusAlertList_Extension[j]);k++) 
                                        gSiriusAlertList_Extension[i][k]=gSiriusAlertList_Extension[j][k]; 
                                break;
                            
                                case 6: 
                                    //clear first element in list 
                                    gSiriusAlertList_ListEntryReceptionInformation[i] =0;
                                    gSiriusAlertList_Pos[i]                           =0;
                                    gSiriusAlertList_AlertType[i]                          =0;
                                    gSiriusAlertList_Attributes[i]                    =0;
                                    gSiriusAlertList_Attributes_Bit0[i]     =0;
                                    gSiriusAlertList_Attributes_Bit1[i]           =0;
                                    gSiriusAlertList_Attributes_Bit2[i]           =0;
                                    gSiriusAlertList_Attributes_Bit3[i]           =0;
                                    gSiriusAlertList_Attributes_Bit4[i]           =0;
                                    gSiriusAlertList_Attributes_Bit5[i]            =0;
                                    gSiriusAlertList_Attributes_Bit6[i]           =0;
                                    gSiriusAlertList_PresetID[i]                      =0;
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;k++) //clear string
                                        gSiriusAlertList_Name[i][k] =0;
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;k++) //clear string
                                        gSiriusAlertList_Frequency[i][k] =0;
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_ALERTNAME_LENGTH;k++) //clear string
                                        gSiriusAlertList_AlertName[i][k] =0;
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_EXTENSION_LENGTH;k++) //clear string
                                        gSiriusAlertList_Extension[i][k] =0;
                                                                            
                                break;
                            
                                case 0: 
                                    //copy data from buffer in Pos '0'
                                    gSiriusAlertList_Pos[i]                       =buffer_Pos; 
                                    gSiriusAlertList_AlertType[i]                      =buffer_AlertType;
                                    gSiriusAlertList_Attributes[i]                =buffer_Attributes;
                                    gSiriusAlertList_Attributes_Bit0[i] =buffer_Attributes_bit0;
                                    gSiriusAlertList_Attributes_Bit1[i]       =buffer_Attributes_bit1;
                                    gSiriusAlertList_Attributes_Bit2[i]       =buffer_Attributes_bit2;
                                    gSiriusAlertList_Attributes_Bit3[i]       =buffer_Attributes_bit3;
                                    gSiriusAlertList_Attributes_Bit4[i]       =buffer_Attributes_bit4;
                                    gSiriusAlertList_Attributes_Bit5[i]        =buffer_Attributes_bit5;
                                    gSiriusAlertList_Attributes_Bit6[i]       =buffer_Attributes_bit6;
                                    gSiriusAlertList_PresetID[i]                  =buffer_PresetID;
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;k++) //clear string
                                        gSiriusAlertList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_Name);k++) 
                                        gSiriusAlertList_Name[i][k]=buffer_Name[k];

                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;k++) //clear string
                                        gSiriusAlertList_Frequency[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_Frequency);k++) 
                                        gSiriusAlertList_Frequency[i][k]=buffer_Frequency[k];
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_ALERTNAME_LENGTH;k++) //clear string
                                        gSiriusAlertList_AlertName[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_AlertName);k++) 
                                        gSiriusAlertList_AlertName[i][k]=buffer_AlertName[k];

                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_EXTENSION_LENGTH;k++) //clear string
                                        gSiriusAlertList_Extension[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_Extension);k++) 
                                        gSiriusAlertList_Extension[i][k]=buffer_Extension[k];
                                break;
                                
                                default: //other elements
                                    //copy element on other position
                                    gSiriusAlertList_Pos[i]                       =gSiriusAlertList_Pos[j]; 
                                    gSiriusAlertList_AlertType[i]                 =gSiriusAlertList_AlertType[j];
                                    gSiriusAlertList_Attributes[i]                =gSiriusAlertList_Attributes[j];
                                    gSiriusAlertList_Attributes_Bit0[i]       =gSiriusAlertList_Attributes_Bit0[j];
                                    gSiriusAlertList_Attributes_Bit1[i]       =gSiriusAlertList_Attributes_Bit1[j];
                                    gSiriusAlertList_Attributes_Bit2[i]       =gSiriusAlertList_Attributes_Bit2[j];
                                    gSiriusAlertList_Attributes_Bit3[i]       =gSiriusAlertList_Attributes_Bit3[j];
                                    gSiriusAlertList_Attributes_Bit4[i]       =gSiriusAlertList_Attributes_Bit4[j];
                                    gSiriusAlertList_Attributes_Bit5[i]       =gSiriusAlertList_Attributes_Bit5[j];
                                    gSiriusAlertList_Attributes_Bit6[i]       =gSiriusAlertList_Attributes_Bit6[j];
                                    gSiriusAlertList_PresetID[i]                  =gSiriusAlertList_PresetID[j];
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;k++) //clear string
                                        gSiriusAlertList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gSiriusAlertList_Name[j]);k++) 
                                        gSiriusAlertList_Name[i][k]=gSiriusAlertList_Name[j][k];
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;k++) //clear string
                                        gSiriusAlertList_Frequency[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gSiriusAlertList_Frequency[j]);k++) 
                                        gSiriusAlertList_Frequency[i][k]=gSiriusAlertList_Frequency[j][k];
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_ALERTNAME_LENGTH;k++) //clear string
                                        gSiriusAlertList_AlertName[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gSiriusAlertList_AlertName[j]);k++) 
                                        gSiriusAlertList_AlertName[i][k]=gSiriusAlertList_AlertName[j][k];
                                    
                                    for (k=0; k<AUDIO_SIRIUSALERTLIST_EXTENSION_LENGTH;k++) //clear string
                                        gSiriusAlertList_Extension[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gSiriusAlertList_Extension[j]);k++) 
                                        gSiriusAlertList_Extension[i][k]=gSiriusAlertList_Extension[j][k];
                                    
                                break;
                            } // end of switch 'i'
                        }
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        SiriusAlertList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);                        
                        
                        //to check, if valid data received
                        gSiriusAlertList_CallBackReason    =AUDIO_SIRIUSALERTLIST_CALLBACKREASON_CHECKCACHE;
                    }
        break;

        default:
        break;
    } //end of switch 'type of cache handling' 
}

void SiriusAlertList_display()
{   
    int Element_1 =0, Element_2 =1, Element_3 =2;

    if(POWER_ON==gASG_PowerOnOff && getvalue(env_ASG_AudioSD_SAL_OnOff))
	{   
        /******'sliding window' not active******/         
        if(gSiriusAlertList_DisplayStatus ==AUDIO_SIRIUSALERTLIST_DISPLAYLIST_SEARCH_ELEMENTS)
        {
            //1. Element              
            if(gSiriusAlertList_CursorAction ==AUDIO_SIRIUSALERTLIST_CURSORACTION_DOWN)
                Element_1 =SiriusAlertList_GetNextCachedElement(gSiriusAlertList_LastFirstElement, AUDIO_SIRIUSALERTLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);
            
            else if(gSiriusAlertList_CursorAction ==AUDIO_SIRIUSALERTLIST_CURSORACTION_UP)            
                Element_1 =SiriusAlertList_GetNextCachedElement(gSiriusAlertList_LastFirstElement, AUDIO_SIRIUSALERTLIST_DISPLAYLIST_FIND_PREVIUOS_ELEMENT);

            //Pos
            putvalue(env_ASG_AudioSD_SAL_pos_0, gSiriusAlertList_Pos[Element_1]);               
            
            //AlertType
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==5) 
            {
                putvalue(env_ASG_AudioSD_SAL_AType_0, gSiriusAlertList_AlertType[Element_1]);

                if(gSiriusAlertList_AlertType[Element_1] <0x08)
                    putvalue(env_ASG_AudioSD_SAL_AType_s_0,gSiriusAlertList_AlertType_s[gSiriusAlertList_AlertType[Element_1]]);
                else
                    putvalue(env_ASG_AudioSD_SAL_AType_s_0,gstring_reserved);
            }

            //Attributes
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1|| gSiriusAlertList_recordaddress ==2|| gSiriusAlertList_recordaddress ==4|| gSiriusAlertList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_SAL_Attr_bit0_0, gSiriusAlertList_Attributes_Bit0[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit0_0,gSiriusAlertList_Attributes_Bit0_s[gSiriusAlertList_Attributes_Bit0[Element_1]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit1_0, gSiriusAlertList_Attributes_Bit1[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit1_0,gSiriusAlertList_Attributes_Bit1_s[gSiriusAlertList_Attributes_Bit1[Element_1]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit2_0, gSiriusAlertList_Attributes_Bit2[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit2_0,gSiriusAlertList_Attributes_Bit2_s[gSiriusAlertList_Attributes_Bit2[Element_1]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit3_0, gSiriusAlertList_Attributes_Bit3[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit3_0,gSiriusAlertList_Attributes_Bit3_s[gSiriusAlertList_Attributes_Bit3[Element_1]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit4_0, gSiriusAlertList_Attributes_Bit4[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit4_0,gSiriusAlertList_Attributes_Bit4_s[gSiriusAlertList_Attributes_Bit4[Element_1]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit5_0, gSiriusAlertList_Attributes_Bit5[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit5_0,gSiriusAlertList_Attributes_Bit5_s[gSiriusAlertList_Attributes_Bit5[Element_1]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit6_0, gSiriusAlertList_Attributes_Bit6[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit6_0,gSiriusAlertList_Attributes_Bit6_s[gSiriusAlertList_Attributes_Bit6[Element_1]]);
            }

            //PresetID
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==2 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_PrID_0,gSiriusAlertList_PresetID[Element_1]);
            
            //Name
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==2 || gSiriusAlertList_recordaddress ==3 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_Name_s_0,gSiriusAlertList_Name[Element_1]);
            
            //Frequency
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==4 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_Freq_s_0,gSiriusAlertList_Frequency[Element_1]);
                
            //AlertName
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_AName_s_0,gSiriusAlertList_AlertName[Element_1]);
            
            //Extension
            if (gSiriusAlertList_recordaddress ==0)
                putvalue(env_ASG_AudioSD_SAL_Ext_s_0,gSiriusAlertList_Extension[Element_1]);

            gSiriusAlertList_LastFirstElement =Element_1;
            
            
            //2. Element             
            Element_2 =SiriusAlertList_GetNextCachedElement(Element_1, AUDIO_SIRIUSALERTLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);
            
            //Pos
            putvalue(env_ASG_AudioSD_SAL_pos_1, gSiriusAlertList_Pos[Element_2]);               
            
            //AlertType
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==5) 
            {
                putvalue(env_ASG_AudioSD_SAL_AType_1, gSiriusAlertList_AlertType[Element_2]);

                if(gSiriusAlertList_AlertType[Element_2] <0x08)
                    putvalue(env_ASG_AudioSD_SAL_AType_s_1,gSiriusAlertList_AlertType_s[gSiriusAlertList_AlertType[Element_2]]);
                else
                    putvalue(env_ASG_AudioSD_SAL_AType_s_1,gstring_reserved);
            }

            //Attributes
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1|| gSiriusAlertList_recordaddress ==2|| gSiriusAlertList_recordaddress ==4|| gSiriusAlertList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_SAL_Attr_bit0_1, gSiriusAlertList_Attributes_Bit0[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit0_1,gSiriusAlertList_Attributes_Bit0_s[gSiriusAlertList_Attributes_Bit0[Element_2]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit1_1, gSiriusAlertList_Attributes_Bit1[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit1_1,gSiriusAlertList_Attributes_Bit1_s[gSiriusAlertList_Attributes_Bit1[Element_2]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit2_1, gSiriusAlertList_Attributes_Bit2[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit2_1,gSiriusAlertList_Attributes_Bit2_s[gSiriusAlertList_Attributes_Bit2[Element_2]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit3_1, gSiriusAlertList_Attributes_Bit3[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit3_1,gSiriusAlertList_Attributes_Bit3_s[gSiriusAlertList_Attributes_Bit3[Element_2]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit4_1, gSiriusAlertList_Attributes_Bit4[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit4_1,gSiriusAlertList_Attributes_Bit4_s[gSiriusAlertList_Attributes_Bit4[Element_2]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit5_1, gSiriusAlertList_Attributes_Bit5[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit5_1,gSiriusAlertList_Attributes_Bit5_s[gSiriusAlertList_Attributes_Bit5[Element_2]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit6_1, gSiriusAlertList_Attributes_Bit6[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit6_1,gSiriusAlertList_Attributes_Bit6_s[gSiriusAlertList_Attributes_Bit6[Element_2]]);
            }

            //PresetID
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==2 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_PrID_1,gSiriusAlertList_PresetID[Element_2]);
            
            //Name
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==2 || gSiriusAlertList_recordaddress ==3 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_Name_s_1,gSiriusAlertList_Name[Element_2]);
            
            //Frequency
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==4 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_Freq_s_1,gSiriusAlertList_Frequency[Element_2]);
                
            //AlertName
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_AName_s_1,gSiriusAlertList_AlertName[Element_2]);
            
            //Extension
            if (gSiriusAlertList_recordaddress ==0)
                putvalue(env_ASG_AudioSD_SAL_Ext_s_1,gSiriusAlertList_Extension[Element_2]);
            
            //3. Element          
            Element_3 =SiriusAlertList_GetNextCachedElement(Element_2, AUDIO_SIRIUSALERTLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);

            //Pos
            putvalue(env_ASG_AudioSD_SAL_pos_2, gSiriusAlertList_Pos[Element_3]);               
            
            //AlertType
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==5) 
            {
                putvalue(env_ASG_AudioSD_SAL_AType_2, gSiriusAlertList_AlertType[Element_3]);

                if(gSiriusAlertList_AlertType[Element_3] <0x08)
                    putvalue(env_ASG_AudioSD_SAL_AType_s_2,gSiriusAlertList_AlertType_s[gSiriusAlertList_AlertType[Element_3]]);
                else
                    putvalue(env_ASG_AudioSD_SAL_AType_s_2,gstring_reserved);
            }

            //Attributes
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1|| gSiriusAlertList_recordaddress ==2|| gSiriusAlertList_recordaddress ==4|| gSiriusAlertList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_SAL_Attr_bit0_2, gSiriusAlertList_Attributes_Bit0[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit0_2,gSiriusAlertList_Attributes_Bit0_s[gSiriusAlertList_Attributes_Bit0[Element_3]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit1_2, gSiriusAlertList_Attributes_Bit1[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit1_2,gSiriusAlertList_Attributes_Bit1_s[gSiriusAlertList_Attributes_Bit1[Element_3]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit2_2, gSiriusAlertList_Attributes_Bit2[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit2_2,gSiriusAlertList_Attributes_Bit2_s[gSiriusAlertList_Attributes_Bit2[Element_3]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit3_2, gSiriusAlertList_Attributes_Bit3[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit3_2,gSiriusAlertList_Attributes_Bit3_s[gSiriusAlertList_Attributes_Bit3[Element_3]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit4_2, gSiriusAlertList_Attributes_Bit4[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit4_2,gSiriusAlertList_Attributes_Bit4_s[gSiriusAlertList_Attributes_Bit4[Element_3]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit5_2, gSiriusAlertList_Attributes_Bit5[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit5_2,gSiriusAlertList_Attributes_Bit5_s[gSiriusAlertList_Attributes_Bit5[Element_3]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit6_2, gSiriusAlertList_Attributes_Bit6[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit6_2,gSiriusAlertList_Attributes_Bit6_s[gSiriusAlertList_Attributes_Bit6[Element_3]]);
            }

            //PresetID
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==2 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_PrID_2,gSiriusAlertList_PresetID[Element_3]);
            
            //Name
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==2 || gSiriusAlertList_recordaddress ==3 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_Name_s_2,gSiriusAlertList_Name[Element_3]);
            
            //Frequency
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==4 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_Freq_s_2,gSiriusAlertList_Frequency[Element_3]);
                
            //AlertName
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_AName_s_2,gSiriusAlertList_AlertName[Element_3]);
            
            //Extension
            if (gSiriusAlertList_recordaddress ==0)
                putvalue(env_ASG_AudioSD_SAL_Ext_s_2,gSiriusAlertList_Extension[Element_3]);
        }

        /******'sliding Window' active or 'build-up List'******/
        else if(gSiriusAlertList_DisplayStatus ==AUDIO_SIRIUSALERTLIST_DISPLAYLIST_FIRST_ELEMENTS) 
        {
            //1. Element    
            if(gSiriusAlertList_ListEntryReceptionInformation [0] ==TRUE && getvalue(env_ASG_AudioSD_SAL_OnOff))
            {   
                Element_1 =0;
                
            //Pos
            if (gSiriusAlertList_transmitpos)
                putvalue(env_ASG_AudioSD_SAL_pos_0, gSiriusAlertList_Pos[Element_1]);               
            
            //AlertType
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==5) 
            {
                putvalue(env_ASG_AudioSD_SAL_AType_0, gSiriusAlertList_AlertType[Element_1]);

                if(gSiriusAlertList_AlertType[Element_1] <0x08)
                    putvalue(env_ASG_AudioSD_SAL_AType_s_0,gSiriusAlertList_AlertType_s[gSiriusAlertList_AlertType[Element_1]]);
                else
                    putvalue(env_ASG_AudioSD_SAL_AType_s_0,gstring_reserved);
            }

            //Attributes
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1|| gSiriusAlertList_recordaddress ==2|| gSiriusAlertList_recordaddress ==4|| gSiriusAlertList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_SAL_Attr_bit0_0, gSiriusAlertList_Attributes_Bit0[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit0_0,gSiriusAlertList_Attributes_Bit0_s[gSiriusAlertList_Attributes_Bit0[Element_1]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit1_0, gSiriusAlertList_Attributes_Bit1[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit1_0,gSiriusAlertList_Attributes_Bit1_s[gSiriusAlertList_Attributes_Bit1[Element_1]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit2_0, gSiriusAlertList_Attributes_Bit2[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit2_0,gSiriusAlertList_Attributes_Bit2_s[gSiriusAlertList_Attributes_Bit2[Element_1]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit3_0, gSiriusAlertList_Attributes_Bit3[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit3_0,gSiriusAlertList_Attributes_Bit3_s[gSiriusAlertList_Attributes_Bit3[Element_1]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit4_0, gSiriusAlertList_Attributes_Bit4[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit4_0,gSiriusAlertList_Attributes_Bit4_s[gSiriusAlertList_Attributes_Bit4[Element_1]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit5_0, gSiriusAlertList_Attributes_Bit5[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit5_0,gSiriusAlertList_Attributes_Bit5_s[gSiriusAlertList_Attributes_Bit5[Element_1]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit6_0, gSiriusAlertList_Attributes_Bit6[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit6_0,gSiriusAlertList_Attributes_Bit6_s[gSiriusAlertList_Attributes_Bit6[Element_1]]);
            }

            //PresetID
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==2 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_PrID_0,gSiriusAlertList_PresetID[Element_1]);
            
            //Name
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==2 || gSiriusAlertList_recordaddress ==3 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_Name_s_0,gSiriusAlertList_Name[Element_1]);
            
            //Frequency
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==4 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_Freq_s_0,gSiriusAlertList_Frequency[Element_1]);
                
            //AlertName
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_AName_s_0,gSiriusAlertList_AlertName[Element_1]);
            
            //Extension
            if (gSiriusAlertList_recordaddress ==0)
                putvalue(env_ASG_AudioSD_SAL_Ext_s_0,gSiriusAlertList_Extension[Element_1]);
             }

            
            //2. Element    
            if(gSiriusAlertList_ListEntryReceptionInformation [1] ==TRUE && getvalue(env_ASG_AudioSD_SAL_OnOff))
            {
                Element_2 =1;
            //Pos
            if (gSiriusAlertList_transmitpos)        
                putvalue(env_ASG_AudioSD_SAL_pos_1, gSiriusAlertList_Pos[Element_2]);               
            
            //AlertType
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==5) 
            {
                putvalue(env_ASG_AudioSD_SAL_AType_1, gSiriusAlertList_AlertType[Element_2]);

                if(gSiriusAlertList_AlertType[Element_2] <0x08)
                    putvalue(env_ASG_AudioSD_SAL_AType_s_1,gSiriusAlertList_AlertType_s[gSiriusAlertList_AlertType[Element_2]]);
                else
                    putvalue(env_ASG_AudioSD_SAL_AType_s_1,gstring_reserved);
            }

            //Attributes
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1|| gSiriusAlertList_recordaddress ==2|| gSiriusAlertList_recordaddress ==4|| gSiriusAlertList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_SAL_Attr_bit0_1, gSiriusAlertList_Attributes_Bit0[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit0_1,gSiriusAlertList_Attributes_Bit0_s[gSiriusAlertList_Attributes_Bit0[Element_2]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit1_1, gSiriusAlertList_Attributes_Bit1[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit1_1,gSiriusAlertList_Attributes_Bit1_s[gSiriusAlertList_Attributes_Bit1[Element_2]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit2_1, gSiriusAlertList_Attributes_Bit2[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit2_1,gSiriusAlertList_Attributes_Bit2_s[gSiriusAlertList_Attributes_Bit2[Element_2]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit3_1, gSiriusAlertList_Attributes_Bit3[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit3_1,gSiriusAlertList_Attributes_Bit3_s[gSiriusAlertList_Attributes_Bit3[Element_2]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit4_1, gSiriusAlertList_Attributes_Bit4[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit4_1,gSiriusAlertList_Attributes_Bit4_s[gSiriusAlertList_Attributes_Bit4[Element_2]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit5_1, gSiriusAlertList_Attributes_Bit5[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit5_1,gSiriusAlertList_Attributes_Bit5_s[gSiriusAlertList_Attributes_Bit5[Element_2]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit6_1, gSiriusAlertList_Attributes_Bit6[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit6_1,gSiriusAlertList_Attributes_Bit6_s[gSiriusAlertList_Attributes_Bit6[Element_2]]);
            }

            //PresetID
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==2 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_PrID_1,gSiriusAlertList_PresetID[Element_2]);
            
            //Name
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==2 || gSiriusAlertList_recordaddress ==3 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_Name_s_1,gSiriusAlertList_Name[Element_2]);
            
            //Frequency
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==4 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_Freq_s_1,gSiriusAlertList_Frequency[Element_2]);
                
            //AlertName
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_AName_s_1,gSiriusAlertList_AlertName[Element_2]);
            
            //Extension
            if (gSiriusAlertList_recordaddress ==0)
                putvalue(env_ASG_AudioSD_SAL_Ext_s_1,gSiriusAlertList_Extension[Element_2]);
             }

             //3. Element    
            if(gSiriusAlertList_ListEntryReceptionInformation [2] ==TRUE && getvalue(env_ASG_AudioSD_SAL_OnOff))
            {
             Element_3 =2;
             //Pos
             if (gSiriusAlertList_transmitpos)       
                putvalue(env_ASG_AudioSD_SAL_pos_2, gSiriusAlertList_Pos[Element_3]);               
            
             //AlertType
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==5) 
            {
                putvalue(env_ASG_AudioSD_SAL_AType_2, gSiriusAlertList_AlertType[Element_1]);

                if(gSiriusAlertList_AlertType[Element_3] <0x08)
                    putvalue(env_ASG_AudioSD_SAL_AType_s_2,gSiriusAlertList_AlertType_s[gSiriusAlertList_AlertType[Element_3]]);
                else
                    putvalue(env_ASG_AudioSD_SAL_AType_s_2,gstring_reserved);
            }

            //Attributes
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1|| gSiriusAlertList_recordaddress ==2|| gSiriusAlertList_recordaddress ==4|| gSiriusAlertList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_SAL_Attr_bit0_2, gSiriusAlertList_Attributes_Bit0[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit0_2,gSiriusAlertList_Attributes_Bit0_s[gSiriusAlertList_Attributes_Bit0[Element_3]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit1_2, gSiriusAlertList_Attributes_Bit1[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit1_2,gSiriusAlertList_Attributes_Bit1_s[gSiriusAlertList_Attributes_Bit1[Element_3]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit2_2, gSiriusAlertList_Attributes_Bit2[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit2_2,gSiriusAlertList_Attributes_Bit2_s[gSiriusAlertList_Attributes_Bit2[Element_3]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit3_2, gSiriusAlertList_Attributes_Bit3[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit3_2,gSiriusAlertList_Attributes_Bit3_s[gSiriusAlertList_Attributes_Bit3[Element_3]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit4_2, gSiriusAlertList_Attributes_Bit4[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit4_2,gSiriusAlertList_Attributes_Bit4_s[gSiriusAlertList_Attributes_Bit4[Element_3]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit5_2, gSiriusAlertList_Attributes_Bit5[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit5_2,gSiriusAlertList_Attributes_Bit5_s[gSiriusAlertList_Attributes_Bit5[Element_3]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit6_2, gSiriusAlertList_Attributes_Bit6[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit6_2,gSiriusAlertList_Attributes_Bit6_s[gSiriusAlertList_Attributes_Bit6[Element_3]]);
            }

            //PresetID
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==2 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_PrID_2,gSiriusAlertList_PresetID[Element_3]);
            
            //Name
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==2 || gSiriusAlertList_recordaddress ==3 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_Name_s_2,gSiriusAlertList_Name[Element_3]);
            
            //Frequency
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==4 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_Freq_s_2,gSiriusAlertList_Frequency[Element_3]);
                
            //AlertName
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_AName_s_2,gSiriusAlertList_AlertName[Element_3]);
            
            //Extension
            if (gSiriusAlertList_recordaddress ==0)
                putvalue(env_ASG_AudioSD_SAL_Ext_s_2,gSiriusAlertList_Extension[Element_3]);   
            }
        }
        else if (gSiriusAlertList_DisplayStatus ==AUDIO_SIRIUSALERTLIST_DISPLAYLIST_REFRESH)
        {               
            //1. Element
            if(gSiriusAlertList_SlidingWindow_State ==AUDIO_SIRIUSALERTLIST_SLIDINGWINDOW_NOTACTIVE)
                Element_1 =gSiriusAlertList_LastFirstElement; 
            else
                Element_1 =0;

            if(gSiriusAlertList_ListEntryReceptionInformation[Element_1])
            {
            //Pos
            putvalue(env_ASG_AudioSD_SAL_pos_0, gSiriusAlertList_Pos[Element_1]);               
            
            //AlertType
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==5) 
            {
                putvalue(env_ASG_AudioSD_SAL_AType_0, gSiriusAlertList_AlertType[Element_1]);

                if(gSiriusAlertList_AlertType[Element_1] <0x08)
                    putvalue(env_ASG_AudioSD_SAL_AType_s_0,gSiriusAlertList_AlertType_s[gSiriusAlertList_AlertType[Element_1]]);
                else
                    putvalue(env_ASG_AudioSD_SAL_AType_s_0,gstring_reserved);
            }

            //Attributes
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1|| gSiriusAlertList_recordaddress ==2|| gSiriusAlertList_recordaddress ==4|| gSiriusAlertList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_SAL_Attr_bit0_0, gSiriusAlertList_Attributes_Bit0[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit0_0,gSiriusAlertList_Attributes_Bit0_s[gSiriusAlertList_Attributes_Bit0[Element_1]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit1_0, gSiriusAlertList_Attributes_Bit1[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit1_0,gSiriusAlertList_Attributes_Bit1_s[gSiriusAlertList_Attributes_Bit1[Element_1]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit2_0, gSiriusAlertList_Attributes_Bit2[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit2_0,gSiriusAlertList_Attributes_Bit2_s[gSiriusAlertList_Attributes_Bit2[Element_1]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit3_0, gSiriusAlertList_Attributes_Bit3[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit3_0,gSiriusAlertList_Attributes_Bit3_s[gSiriusAlertList_Attributes_Bit3[Element_1]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit4_0, gSiriusAlertList_Attributes_Bit4[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit4_0,gSiriusAlertList_Attributes_Bit4_s[gSiriusAlertList_Attributes_Bit4[Element_1]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit5_0, gSiriusAlertList_Attributes_Bit5[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit5_0,gSiriusAlertList_Attributes_Bit5_s[gSiriusAlertList_Attributes_Bit5[Element_1]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit6_0, gSiriusAlertList_Attributes_Bit6[Element_1]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit6_0,gSiriusAlertList_Attributes_Bit6_s[gSiriusAlertList_Attributes_Bit6[Element_1]]);
            }

            //PresetID
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==2 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_PrID_0,gSiriusAlertList_PresetID[Element_1]);
            
            //Name
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==2 || gSiriusAlertList_recordaddress ==3 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_Name_s_0,gSiriusAlertList_Name[Element_1]);
            
            //Frequency
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==4 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_Freq_s_0,gSiriusAlertList_Frequency[Element_1]);
                
            //AlertName
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_AName_s_0,gSiriusAlertList_AlertName[Element_1]);
            
            //Extension
            if (gSiriusAlertList_recordaddress ==0)
                putvalue(env_ASG_AudioSD_SAL_Ext_s_0,gSiriusAlertList_Extension[Element_1]);
            }

            //2. Element             
            if(gSiriusAlertList_SlidingWindow_State ==AUDIO_SIRIUSALERTLIST_SLIDINGWINDOW_NOTACTIVE)
                Element_2 =SiriusAlertList_GetNextCachedElement(Element_1, AUDIO_SIRIUSALERTLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);
            else
                Element_2 =1;

            if(gSiriusAlertList_ListEntryReceptionInformation[Element_2])
            {
            //Pos
            putvalue(env_ASG_AudioSD_SAL_pos_1, gSiriusAlertList_Pos[Element_2]);               
            
            //AlertType
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==5) 
            {
                putvalue(env_ASG_AudioSD_SAL_AType_1, gSiriusAlertList_AlertType[Element_2]);

                if(gSiriusAlertList_AlertType[Element_2] <0x08)
                    putvalue(env_ASG_AudioSD_SAL_AType_s_1,gSiriusAlertList_AlertType_s[gSiriusAlertList_AlertType[Element_2]]);
                else
                    putvalue(env_ASG_AudioSD_SAL_AType_s_1,gstring_reserved);
            }

            //Attributes
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1|| gSiriusAlertList_recordaddress ==2|| gSiriusAlertList_recordaddress ==4|| gSiriusAlertList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_SAL_Attr_bit0_1, gSiriusAlertList_Attributes_Bit0[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit0_1,gSiriusAlertList_Attributes_Bit0_s[gSiriusAlertList_Attributes_Bit0[Element_2]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit1_1, gSiriusAlertList_Attributes_Bit1[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit1_1,gSiriusAlertList_Attributes_Bit1_s[gSiriusAlertList_Attributes_Bit1[Element_2]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit2_1, gSiriusAlertList_Attributes_Bit2[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit2_1,gSiriusAlertList_Attributes_Bit2_s[gSiriusAlertList_Attributes_Bit2[Element_2]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit3_1, gSiriusAlertList_Attributes_Bit3[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit3_1,gSiriusAlertList_Attributes_Bit3_s[gSiriusAlertList_Attributes_Bit3[Element_2]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit4_1, gSiriusAlertList_Attributes_Bit4[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit4_1,gSiriusAlertList_Attributes_Bit4_s[gSiriusAlertList_Attributes_Bit4[Element_2]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit5_1, gSiriusAlertList_Attributes_Bit5[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit5_1,gSiriusAlertList_Attributes_Bit5_s[gSiriusAlertList_Attributes_Bit5[Element_2]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit6_1, gSiriusAlertList_Attributes_Bit6[Element_2]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit6_1,gSiriusAlertList_Attributes_Bit6_s[gSiriusAlertList_Attributes_Bit6[Element_2]]);
            }

            //PresetID
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==2 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_PrID_1,gSiriusAlertList_PresetID[Element_2]);
            
            //Name
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==2 || gSiriusAlertList_recordaddress ==3 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_Name_s_1,gSiriusAlertList_Name[Element_2]);
            
            //Frequency
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==4 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_Freq_s_1,gSiriusAlertList_Frequency[Element_2]);
                
            //AlertName
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_AName_s_1,gSiriusAlertList_AlertName[Element_2]);
            
            //Extension
            if (gSiriusAlertList_recordaddress ==0)
                putvalue(env_ASG_AudioSD_SAL_Ext_s_1,gSiriusAlertList_Extension[Element_2]);
            }

            //3. Element          
            if(gSiriusAlertList_SlidingWindow_State ==AUDIO_SIRIUSALERTLIST_SLIDINGWINDOW_NOTACTIVE)
                Element_3 =SiriusAlertList_GetNextCachedElement(Element_2, AUDIO_SIRIUSALERTLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);
            else
                Element_3 =2;

            if(gSiriusAlertList_ListEntryReceptionInformation[Element_3])
            {    
            //Pos
            putvalue(env_ASG_AudioSD_SAL_pos_2, gSiriusAlertList_Pos[Element_3]);               
            
            //AlertType
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==5) 
            {
                putvalue(env_ASG_AudioSD_SAL_AType_2, gSiriusAlertList_AlertType[Element_3]);

                if(gSiriusAlertList_AlertType[Element_3] <0x08)
                    putvalue(env_ASG_AudioSD_SAL_AType_s_2,gSiriusAlertList_AlertType_s[gSiriusAlertList_AlertType[Element_3]]);
                else
                    putvalue(env_ASG_AudioSD_SAL_AType_s_2,gstring_reserved);
            }

            //Attributes
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1|| gSiriusAlertList_recordaddress ==2|| gSiriusAlertList_recordaddress ==4|| gSiriusAlertList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_SAL_Attr_bit0_2, gSiriusAlertList_Attributes_Bit0[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit0_2,gSiriusAlertList_Attributes_Bit0_s[gSiriusAlertList_Attributes_Bit0[Element_3]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit1_2, gSiriusAlertList_Attributes_Bit1[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit1_2,gSiriusAlertList_Attributes_Bit1_s[gSiriusAlertList_Attributes_Bit1[Element_3]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit2_2, gSiriusAlertList_Attributes_Bit2[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit2_2,gSiriusAlertList_Attributes_Bit2_s[gSiriusAlertList_Attributes_Bit2[Element_3]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit3_2, gSiriusAlertList_Attributes_Bit3[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit3_2,gSiriusAlertList_Attributes_Bit3_s[gSiriusAlertList_Attributes_Bit3[Element_3]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit4_2, gSiriusAlertList_Attributes_Bit4[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit4_2,gSiriusAlertList_Attributes_Bit4_s[gSiriusAlertList_Attributes_Bit4[Element_3]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit5_2, gSiriusAlertList_Attributes_Bit5[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit5_2,gSiriusAlertList_Attributes_Bit5_s[gSiriusAlertList_Attributes_Bit5[Element_3]]);

                putvalue(env_ASG_AudioSD_SAL_Attr_bit6_2, gSiriusAlertList_Attributes_Bit6[Element_3]);
                putvalue(env_ASG_AudioSD_SAL_Attr_sbit6_2,gSiriusAlertList_Attributes_Bit6_s[gSiriusAlertList_Attributes_Bit6[Element_3]]);
            }

            //PresetID
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==2 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_PrID_2,gSiriusAlertList_PresetID[Element_3]);
            
            //Name
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==2 || gSiriusAlertList_recordaddress ==3 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_Name_s_2,gSiriusAlertList_Name[Element_3]);
            
            //Frequency
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==1 || gSiriusAlertList_recordaddress ==4 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_Freq_s_2,gSiriusAlertList_Frequency[Element_3]);
                
            //AlertName
            if (gSiriusAlertList_recordaddress ==0 || gSiriusAlertList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_SAL_AName_s_2,gSiriusAlertList_AlertName[Element_3]);
            
            //Extension
            if (gSiriusAlertList_recordaddress ==0)
                putvalue(env_ASG_AudioSD_SAL_Ext_s_2,gSiriusAlertList_Extension[Element_3]);
            }
        }
    }
}

on envVar env_ASG_AudioSD_SAL_GetArray
{
    byte mode, shift, direction, transmitpos, indexsize,recordaddress;
    word requested_startelement, startelement, elements;

    // Init local variables. 
    mode                    =0;
    shift                   =0;
    direction               =0;
    transmitpos             =0;
    indexsize               =0;
    recordaddress           =0;
    requested_startelement  =0;
    startelement            =0;
    elements                =0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gSiriusAlertList_ListHandlingType ==AUDIO_SIRIUSALERTLIST_NOCACHE)
	{
        gSiriusAlertList_ASGID            =getvalue(env_ASG_AudioSD_SAL_ASGID);
        gSiriusAlertList_TAID             =getvalue(env_ASG_AudioSD_SAL_TAID);
        
        shift                           =getvalue(env_ASG_AudioSD_SAL_AH_shift);
        direction                       =getvalue(env_ASG_AudioSD_SAL_AH_dir);
        transmitpos                     =getvalue(env_ASG_AudioSD_SAL_AH_PosTrans);
        indexsize                       =getvalue(env_ASG_AudioSD_SAL_AH_IS);
        recordaddress                   =getvalue(env_ASG_AudioSD_SAL_AH_RA);
        startelement                    =getvalue(env_ASG_AudioSD_SAL_AH_start);
        elements                        =getvalue(env_ASG_AudioSD_SAL_AH_elements);
        
        requested_startelement  =startelement;
        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

        SiriusAlertList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
    }
}

on envVar env_ASG_AudioSD_SAL_OnOff
{
    int i =0, j =0;
    if(POWER_ON==gASG_PowerOnOff)
	{   
        if(getvalue(this))
        {
            gSiriusAlertList_ListHandlingType      =AUDIO_SIRIUSALERTLIST_BUILDUPCACHE;             //build-up complete cache...
            gSiriusAlertList_cacheBuildUp          =AUDIO_SIRIUSALERTLIST_BUILDUPCACHECACHE_WINDOW; //...and start with area "window"            
        
            SiriusAlertList_ListHandling ();
        }
        else
        {
            gSiriusAlertList_SlidingWindow_State   =AUDIO_SIRIUSALERTLIST_SLIDINGWINDOW_NOTACTIVE;
            gSiriusAlertList_ListHandlingType      =AUDIO_SIRIUSALERTLIST_NOCACHE;
            gSiriusAlertList_cacheBuildUp          =AUDIO_SIRIUSALERTLIST_BUILDUPCACHENOCACHE;
            gSiriusAlertList_CallBackReason        =AUDIO_SIRIUSALERTLIST_CALLBACKREASON_NOCALLBACK;

            gSiriusAlertList_cacheDown             =FALSE;
            gSiriusAlertList_cacheUp               =FALSE;
            gSiriusAlertList_LastFirstElement      =0;

            gSiriusAlertList_recordaddress         =0;
            gSiriusAlertList_transmitpos           =1;
            gSiriusAlertList_CursorAction          =AUDIO_SIRIUSALERTLIST_CURSORACTION_NOTHING;
            gSiriusAlertList_DisplayStatus         =AUDIO_SIRIUSALERTLIST_DISPLAYLIST_FIRST_ELEMENTS;
            
            for(j=0; j<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; j++)
            {     
                gSiriusAlertList_Pos[j]                            =0;
                gSiriusAlertList_AlertType[j]                           =0;
                gSiriusAlertList_Attributes_Bit0[j]      =0;
                gSiriusAlertList_Attributes_Bit1[j]            =0;
                gSiriusAlertList_Attributes_Bit2[j]            =0;
                gSiriusAlertList_Attributes_Bit3[j]            =0;
                gSiriusAlertList_Attributes_Bit4[j]            =0;
                gSiriusAlertList_Attributes_Bit5[j]             =0;
                gSiriusAlertList_Attributes_Bit6[j]            =0;
                gSiriusAlertList_Attributes[j]                     =0;
                gSiriusAlertList_PresetID[j]                       =0;
                gSiriusAlertList_ListEntryReceptionInformation[j]  =0;

                for(i=0;i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++)
			            gSiriusAlertList_Name[j][i] =0;
                
                for(i=0;i<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;i++)
			            gSiriusAlertList_Frequency[j][i] =0;
                
                for(i=0;i<AUDIO_SIRIUSALERTLIST_ALERTNAME_LENGTH;i++)
			            gSiriusAlertList_AlertName[j][i] =0;
                
                for(i=0;i<AUDIO_SIRIUSALERTLIST_EXTENSION_LENGTH;i++)
			            gSiriusAlertList_Extension[j][i] =0;
            }
            putvalue(env_ASG_AudioSD_SAL_pos_0, 0);
            putvalue(env_ASG_AudioSD_SAL_pos_1, 0);
            putvalue(env_ASG_AudioSD_SAL_pos_2, 0);
    
            putvalue(env_ASG_AudioSD_SAL_AType_0, 0);
            putvalue(env_ASG_AudioSD_SAL_AType_1, 0);
            putvalue(env_ASG_AudioSD_SAL_AType_2, 0);

            putvalue(env_ASG_AudioSD_SAL_AType_s_0,empty_string);
            putvalue(env_ASG_AudioSD_SAL_AType_s_1,empty_string);
            putvalue(env_ASG_AudioSD_SAL_AType_s_2,empty_string);

            putvalue(env_ASG_AudioSD_SAL_Attr_bit0_0, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_bit0_1, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_bit0_2, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit0_0, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit0_1, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit0_2, empty_string);

            putvalue(env_ASG_AudioSD_SAL_Attr_bit1_0, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_bit1_1, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_bit1_2, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit1_0, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit1_1, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit1_2, empty_string);

            putvalue(env_ASG_AudioSD_SAL_Attr_bit2_0, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_bit2_1, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_bit2_2, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit2_0, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit2_1, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit2_2, empty_string);

            putvalue(env_ASG_AudioSD_SAL_Attr_bit3_0, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_bit3_1, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_bit3_2, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit3_0, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit3_1, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit3_2, empty_string);

            putvalue(env_ASG_AudioSD_SAL_Attr_bit4_0, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_bit4_1, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_bit4_2, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit4_0, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit4_1, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit4_2, empty_string);

            putvalue(env_ASG_AudioSD_SAL_Attr_bit5_0, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_bit5_1, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_bit5_2, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit5_0, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit5_1, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit5_2, empty_string);

            putvalue(env_ASG_AudioSD_SAL_Attr_bit6_0, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_bit6_1, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_bit6_2, 0);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit6_0, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit6_1, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Attr_sbit6_2, empty_string);

            putvalue(env_ASG_AudioSD_SAL_PrID_0, 0);
            putvalue(env_ASG_AudioSD_SAL_PrID_1, 0);
            putvalue(env_ASG_AudioSD_SAL_PrID_2, 0);

            putvalue(env_ASG_AudioSD_SAL_Name_s_0, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Name_s_1, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Name_s_2, empty_string);

            putvalue(env_ASG_AudioSD_SAL_Freq_s_0, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Freq_s_1, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Freq_s_2, empty_string);
            
            putvalue(env_ASG_AudioSD_SAL_AName_s_0, empty_string);
            putvalue(env_ASG_AudioSD_SAL_AName_s_1, empty_string);
            putvalue(env_ASG_AudioSD_SAL_AName_s_2, empty_string);

            putvalue(env_ASG_AudioSD_SAL_Ext_s_0, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Ext_s_1, empty_string);
            putvalue(env_ASG_AudioSD_SAL_Ext_s_2, empty_string);
            
        }
    }
}   

on envVar env_ASG_AudioSD_SAL_down
{
    int i=0, j=0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gSiriusAlertList_ListHandlingType ==AUDIO_SIRIUSALERTLIST_NOCACHE)
	{      
        gSiriusAlertList_CursorAction =AUDIO_SIRIUSALERTLIST_CURSORACTION_DOWN;
        
        if(gSiriusAlertList_SlidingWindow_State ==AUDIO_SIRIUSALERTLIST_SLIDINGWINDOW_ACTIVE)
        {   
            gSiriusAlertList_ListHandlingType  =AUDIO_SIRIUSALERTLIST_DOWN_CACHE;
            gSiriusAlertList_DisplayStatus     =AUDIO_SIRIUSALERTLIST_DISPLAYLIST_FIRST_ELEMENTS;
            gSiriusAlertList_CursorAction      =AUDIO_SIRIUSALERTLIST_CURSORACTION_NOTHING;
            
            SiriusAlertList_ListHandling ();
        }
        else if(gSiriusAlertList_SlidingWindow_State ==AUDIO_SIRIUSALERTLIST_SLIDINGWINDOW_NOTACTIVE)
        {
            gSiriusAlertList_DisplayStatus     =AUDIO_SIRIUSALERTLIST_DISPLAYLIST_SEARCH_ELEMENTS;
            gSiriusAlertList_CursorAction      =AUDIO_SIRIUSALERTLIST_CURSORACTION_DOWN;

            SiriusAlertList_display();

            //reset values
            gSiriusAlertList_DisplayStatus     =AUDIO_SIRIUSALERTLIST_DISPLAYLIST_REFRESH;
            gSiriusAlertList_CursorAction      =AUDIO_SIRIUSALERTLIST_CURSORACTION_NOTHING;
        }
    }
}

on envVar env_ASG_AudioSD_SAL_up
{
    int i=0, j=0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gSiriusAlertList_ListHandlingType ==AUDIO_SIRIUSALERTLIST_NOCACHE)
	{   
        gSiriusAlertList_CursorAction =AUDIO_SIRIUSALERTLIST_CURSORACTION_UP;

        if(gSiriusAlertList_SlidingWindow_State ==AUDIO_SIRIUSALERTLIST_SLIDINGWINDOW_ACTIVE)
        {  
            gSiriusAlertList_ListHandlingType  =AUDIO_SIRIUSALERTLIST_UP_CACHE;
            gSiriusAlertList_DisplayStatus     =AUDIO_SIRIUSALERTLIST_DISPLAYLIST_FIRST_ELEMENTS;
            gSiriusAlertList_CursorAction      =AUDIO_SIRIUSALERTLIST_CURSORACTION_NOTHING;
            
            SiriusAlertList_ListHandling ();
        }
        else if(gSiriusAlertList_SlidingWindow_State ==AUDIO_SIRIUSALERTLIST_SLIDINGWINDOW_NOTACTIVE)
        {
            gSiriusAlertList_DisplayStatus     =AUDIO_SIRIUSALERTLIST_DISPLAYLIST_SEARCH_ELEMENTS;
            gSiriusAlertList_CursorAction      =AUDIO_SIRIUSALERTLIST_CURSORACTION_UP;

            SiriusAlertList_ListHandling();
            
            SiriusAlertList_display();

            //reset values
            gSiriusAlertList_DisplayStatus     =AUDIO_SIRIUSALERTLIST_DISPLAYLIST_REFRESH;
            gSiriusAlertList_CursorAction      =AUDIO_SIRIUSALERTLIST_CURSORACTION_NOTHING;
        }    
    }
}

on envVar env_ASG_AudioSD_PP_get
{
}

void PlayPosition_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	            //LSG-ID
  	requestarray[1] =FctID_PlayPosition;	    //Fct.-ID
  	requestarray[2] =request;                 //request type
	
    switch(request)
  	{
  		case DataGet_REQ:
  			set_status_requestbuffer (requestarray, 3, Bap_Void);
  		break;
  		default:	
  			writelineEx(gError_Trace, 0, "ASG-AudioSD PlayPosition_Request: invalid request %d", request);
  		break;
  	}
}

void PlayPosition_Indication (dword Indication_array [], int datalength)
{
		switch (gBAP_Indication[2])
		{
			case Data_IND:
        //get data
  			gAudioSD_PlayPosition_TimePosition = Indication_array[3];
  			gAudioSD_PlayPosition_TimePosition  += Indication_array[4] *0x100;
        gAudioSD_PlayPosition_TotalPlayTime = Indication_array[5];
        gAudioSD_PlayPosition_TotalPlayTime   += Indication_array[6] *0x100;
        gAudioSD_PlayPosition_Attributes = Indication_array[7];
        gAudioSD_PlayPosition_Attributes_Bit0 =gAudioSD_PlayPosition_Attributes &0x01; //Bit '0'
        gAudioSD_PlayPosition_BufferLevel = Indication_array[8];
        
        putvalue(env_ASG_AudioSD_PP_TimePos,gAudioSD_PlayPosition_TimePosition);
        putvalue(env_ASG_AudioSD_PP_TotalPlayTime,gAudioSD_PlayPosition_TotalPlayTime);
        putvalue(env_ASG_AudioSD_PP_Attr_Bit0,gAudioSD_PlayPosition_Attributes_Bit0);
        putvalue(env_ASG_AudioSD_PP_BufferLevel,gAudioSD_PlayPosition_BufferLevel);
      break;	
      case Error_IND:
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD PlayPosition_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD PlayPosition_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD PlayPosition_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD PlayPosition_Indication: Application-Error: 0x%x", Indication_array[3]);
  		break;
  		default:
  			writelineEx(gError_Trace, 0,"ASG-AudioSD PlayPosition_Indication: unknown indication %x", gBAP_Indication[2]);
  		break;
		}
}

on envVar env_ASG_AudioSD_SRS_get
{
}

void SDS_RecognizerState_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	            //LSG-ID
  	requestarray[1] =FctID_SDS_RecognizerState;	    //Fct.-ID
  	requestarray[2] =request;                 //request type
	
    switch(request)
  	{
  		case DataGet_REQ:
  			set_status_requestbuffer (requestarray, 3, Bap_Void);
  		break;
  		default:	
  			writelineEx(gError_Trace, 0, "ASG-AudioSD SDS_RecognizerState_Request: invalid request %d", request);
  		break;
  	}
}

void SDS_RecognizerState_Indication (dword Indication_array [], int datalength)
{
		switch (gBAP_Indication[2])
		{
			case Data_IND:
        //get data
  			gAudioSD_SDS_RecognizerState_InputLevel   = Indication_array[3];
  			gAudioSD_SDS_RecognizerState_InputQuality = Indication_array[4];
        gAudioSD_SDS_RecognizerState_Extension1   = Indication_array[5];
        gAudioSD_SDS_RecognizerState_Extension2   = Indication_array[6];
        gAudioSD_SDS_RecognizerState_Extension3   = Indication_array[7];
        gAudioSD_SDS_RecognizerState_Extension4   = Indication_array[8];
        
        putvalue(env_ASG_AudioSD_SRS_InputLevel,gAudioSD_SDS_RecognizerState_InputLevel);
        putvalue(env_ASG_AudioSD_SRS_InputQuality,gAudioSD_SDS_RecognizerState_InputQuality);
      break;	
      case Error_IND:
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD SDS_RecognizerState_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD SDS_RecognizerState_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD SDS_RecognizerState_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD SDS_RecognizerState_Indication: Application-Error: 0x%x", Indication_array[3]);
  		break;
  		default:
  			writelineEx(gError_Trace, 0,"ASG-AudioSD SDS_RecognizerState_Indication: unknown indication %x", gBAP_Indication[2]);
  		break;
		}
}

on envVar env_ASG_AudioSD_CSI2_get
{
}

void CurrentStationInfo2_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	            //LSG-ID
  	requestarray[1] =FctID_CurrentStationInfo2;	    //Fct.-ID
  	requestarray[2] =request;                 //request type
	
    switch(request)
  	{
  		case DataGet_REQ:
  			set_status_requestbuffer (requestarray, 3, Bap_Void);
  		break;
  		default:	
  			writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStationInfo2_Request: invalid request %d", request);
  		break;
  	}
}

void CurrentStationInfo2_Indication (dword Indication_array [], int datalength)
{
		int i =0, Offset =0, length =0;
  
    switch (gBAP_Indication[2])
		{
			case Data_IND:
        //get data
        length =Indication_array[3];
        Offset =4;
        //Name
        for (i=0; i<CSI2_INFORMATION_TEXTLENGTH; i++)
            gAudioSD_CSI2_Information1[i] =0;
        for (i=0; i< length; i++)
        { 
            gAudioSD_CSI2_Information1[i] =Indication_array[Offset];
            Offset++;
        }
        //Type
        gAudioSD_CSI2_InfoType1 =Indication_array[Offset];
        Offset++;
        //ID
        gAudioSD_CSI2_InfoID1 =Indication_array[Offset]; 
        Offset++;
        gAudioSD_CSI2_InfoID1 +=Indication_array[Offset] *0x100;
        Offset++;
        //Name
        length =Indication_array[Offset];
        Offset++;
        for (i=0; i<CSI2_INFORMATION_TEXTLENGTH; i++)
            gAudioSD_CSI2_Information2[i] =0;
        for (i=0; i< length; i++)
        { 
            gAudioSD_CSI2_Information2[i] =Indication_array[Offset];
            Offset++;
        }
        //Type
        gAudioSD_CSI2_InfoType2 =Indication_array[Offset];
        Offset++;
        //Name
        length =Indication_array[Offset];
        Offset++;
        for (i=0; i<CSI2_INFORMATION_TEXTLENGTH; i++)
            gAudioSD_CSI2_Information3[i] =0;
        for (i=0; i< length; i++)
        { 
            gAudioSD_CSI2_Information3[i] =Indication_array[Offset];
            Offset++;
        }
        //Type
        gAudioSD_CSI2_InfoType3 =Indication_array[Offset];
        Offset++;
        //Name
        length =Indication_array[Offset];
        Offset++;
        for (i=0; i<CSI2_INFORMATION_TEXTLENGTH; i++)
            gAudioSD_CSI2_Information4[i] =0;
        for (i=0; i< length; i++)
        { 
            gAudioSD_CSI2_Information4[i] =Indication_array[Offset];
            Offset++;
        }
        //Type
        gAudioSD_CSI2_InfoType4 =Indication_array[Offset];
        Offset++;
        //Name
        length =Indication_array[Offset];
        Offset++;
        for (i=0; i<CSI2_INFORMATION_TEXTLENGTH; i++)
            gAudioSD_CSI2_Information5[i] =0;
        for (i=0; i< length; i++)
        { 
            gAudioSD_CSI2_Information5[i] =Indication_array[Offset];
            Offset++;
        }
        //Type
        gAudioSD_CSI2_InfoType5 =Indication_array[Offset];
        Offset++;
        //Name
        length =Indication_array[Offset];
        Offset++;
        for (i=0; i<CSI2_INFORMATION_TEXTLENGTH; i++)
            gAudioSD_CSI2_Information6[i] =0;
        for (i=0; i< length; i++)
        { 
            gAudioSD_CSI2_Information6[i] =Indication_array[Offset];
            Offset++;
        }
        //Type
        gAudioSD_CSI2_InfoType6 =Indication_array[Offset];
        Offset++;
        //Name
        length =Indication_array[Offset];
        Offset++;
        for (i=0; i<CSI2_INFORMATION_TEXTLENGTH; i++)
            gAudioSD_CSI2_Information7[i] =0;
        for (i=0; i< length; i++)
        { 
            gAudioSD_CSI2_Information7[i] =Indication_array[Offset];
            Offset++;
        }
        //Type
        gAudioSD_CSI2_InfoType7 =Indication_array[Offset];
        Offset++;
        //Name
        length =Indication_array[Offset];
        Offset++;
        for (i=0; i<CSI2_INFORMATION_TEXTLENGTH; i++)
            gAudioSD_CSI2_Information8[i] =0;
        for (i=0; i< length; i++)
        { 
            gAudioSD_CSI2_Information8[i] =Indication_array[Offset];
            Offset++;
        }
        //Type
        gAudioSD_CSI2_InfoType8 =Indication_array[Offset];
        Offset++;
        //StationInfoSwitches
        gAudioSD_CSI2_StationInfoSwitches =Indication_array[Offset]; 
        Offset++;
        gAudioSD_CSI2_StationInfoSwitches +=Indication_array[Offset] *0x100;
        Offset++;
        gAudioSD_CSI2_StationInfoSwitches_Bit0  =gAudioSD_CSI2_StationInfoSwitches &0x01;
        gAudioSD_CSI2_StationInfoSwitches_Bit1  =(gAudioSD_CSI2_StationInfoSwitches &0x02) /0x02;
        gAudioSD_CSI2_StationInfoSwitches_Bit2  =(gAudioSD_CSI2_StationInfoSwitches &0x04) /0x04;
        gAudioSD_CSI2_StationInfoSwitches_Bit3  =(gAudioSD_CSI2_StationInfoSwitches &0x08) /0x08;
        gAudioSD_CSI2_StationInfoSwitches_Bit4  =(gAudioSD_CSI2_StationInfoSwitches &0x10) /0x10;
        //StationProperties
        gAudioSD_CSI2_StationProperties =Indication_array[Offset]; 
        Offset++;
        gAudioSD_CSI2_StationProperties +=Indication_array[Offset] *0x100;
        Offset++;
        gAudioSD_CSI2_StationProperties_Bit0  =gAudioSD_CSI2_StationProperties &0x01;
        gAudioSD_CSI2_StationProperties_Bit1  =(gAudioSD_CSI2_StationProperties &0x02) /0x02;
        gAudioSD_CSI2_StationProperties_Bit2  =(gAudioSD_CSI2_StationProperties &0x04) /0x04;
        gAudioSD_CSI2_StationProperties_Bit3  =(gAudioSD_CSI2_StationProperties &0x08) /0x08;
        gAudioSD_CSI2_StationProperties_Bit4  =(gAudioSD_CSI2_StationProperties &0x10) /0x10;
        gAudioSD_CSI2_StationProperties_Bit5  =(gAudioSD_CSI2_StationProperties &0x20) /0x20;
        gAudioSD_CSI2_StationProperties_Bit6  =(gAudioSD_CSI2_StationProperties &0x40) /0x40;
        //Channel_ID
        gAudioSD_CSI2_ChannelID =Indication_array[Offset]; 
        Offset++;
        gAudioSD_CSI2_ChannelID +=Indication_array[Offset] *0x100;
        Offset++;
        
        putvalue(env_ASG_AudioSD_CSI2_InfoID1,gAudioSD_CSI2_InfoID1);
        putvalue(env_ASG_AudioSD_CSI2_InfoTy1,gAudioSD_CSI2_InfoType1);
        putvalue(env_ASG_AudioSD_CSI2_InfoTy2,gAudioSD_CSI2_InfoType2);
        putvalue(env_ASG_AudioSD_CSI2_InfoTy3,gAudioSD_CSI2_InfoType3);
        putvalue(env_ASG_AudioSD_CSI2_InfoTy4,gAudioSD_CSI2_InfoType4);
        putvalue(env_ASG_AudioSD_CSI2_InfoTy5,gAudioSD_CSI2_InfoType5);
        putvalue(env_ASG_AudioSD_CSI2_InfoTy6,gAudioSD_CSI2_InfoType6);
        putvalue(env_ASG_AudioSD_CSI2_InfoTy7,gAudioSD_CSI2_InfoType7);
        putvalue(env_ASG_AudioSD_CSI2_InfoTy8,gAudioSD_CSI2_InfoType8);
        putvalue(env_ASG_AudioSD_CSI2_Info1,gAudioSD_CSI2_Information1);
        putvalue(env_ASG_AudioSD_CSI2_Info2,gAudioSD_CSI2_Information2);
        putvalue(env_ASG_AudioSD_CSI2_Info3,gAudioSD_CSI2_Information3);
        putvalue(env_ASG_AudioSD_CSI2_Info4,gAudioSD_CSI2_Information4);
        putvalue(env_ASG_AudioSD_CSI2_Info5,gAudioSD_CSI2_Information5);
        putvalue(env_ASG_AudioSD_CSI2_Info6,gAudioSD_CSI2_Information6);
        putvalue(env_ASG_AudioSD_CSI2_Info7,gAudioSD_CSI2_Information7);
        putvalue(env_ASG_AudioSD_CSI2_Info8,gAudioSD_CSI2_Information8);
        putvalue(env_ASG_AudioSD_CSI2_ChanID,gAudioSD_CSI2_ChannelID);
        putvalue(env_ASG_AudioSD_CSI2_SIS_Bit0,gAudioSD_CSI2_StationInfoSwitches_Bit0);
        putvalue(env_ASG_AudioSD_CSI2_SIS_Bit1,gAudioSD_CSI2_StationInfoSwitches_Bit1);
        putvalue(env_ASG_AudioSD_CSI2_SIS_Bit2,gAudioSD_CSI2_StationInfoSwitches_Bit2);
        putvalue(env_ASG_AudioSD_CSI2_SIS_Bit3,gAudioSD_CSI2_StationInfoSwitches_Bit3);
        putvalue(env_ASG_AudioSD_CSI2_SIS_Bit4,gAudioSD_CSI2_StationInfoSwitches_Bit4);
        putvalue(env_ASG_AudioSD_CSI2_SP_Bit0,gAudioSD_CSI2_StationProperties_Bit0);
        putvalue(env_ASG_AudioSD_CSI2_SP_Bit1,gAudioSD_CSI2_StationProperties_Bit1);
        putvalue(env_ASG_AudioSD_CSI2_SP_Bit2,gAudioSD_CSI2_StationProperties_Bit2);
        putvalue(env_ASG_AudioSD_CSI2_SP_Bit3,gAudioSD_CSI2_StationProperties_Bit3);
        putvalue(env_ASG_AudioSD_CSI2_SP_Bit4,gAudioSD_CSI2_StationProperties_Bit4);
        putvalue(env_ASG_AudioSD_CSI2_SP_Bit5,gAudioSD_CSI2_StationProperties_Bit5);
        putvalue(env_ASG_AudioSD_CSI2_SP_Bit6,gAudioSD_CSI2_StationProperties_Bit6);
      break;	
      case Error_IND:
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStationInfo2_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStationInfo2_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStationInfo2_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStationInfo2_Indication: Application-Error: 0x%x", Indication_array[3]);
  		break;
  		default:
  			writelineEx(gError_Trace, 0,"ASG-AudioSD CurrentStationInfo2_Indication: unknown indication %x", gBAP_Indication[2]);
  		break;
		}
}

on envVar env_ASG_AudioSD_CSH3_get
{
}

void CurrentStation_Handle3_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	            //LSG-ID
  	requestarray[1] =FctID_CurrentStation_Handle3;	    //Fct.-ID
  	requestarray[2] =request;                 //request type
	
    switch(request)
  	{
  		case DataGet_REQ:
  			set_status_requestbuffer (requestarray, 3, Bap_Void);
  		break;
  		default:	
  			writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStation_Handle3_Request: invalid request %d", request);
  		break;
  	}
}

void CurrentStation_Handle3_Indication (dword Indication_array [], int datalength)
{
		switch (gBAP_Indication[2])
		{
			case Data_IND:
        //get data
  			gAudioSD_CurrentStation_Handle3_FavList      = Indication_array[3];
  			gAudioSD_CurrentStation_Handle3_FavListaP    = Indication_array[4];
        gAudioSD_CurrentStation_Handle3_Extension1   = Indication_array[5];
        gAudioSD_CurrentStation_Handle3_Extension2   = Indication_array[6];
        gAudioSD_CurrentStation_Handle3_Extension3   = Indication_array[7];
        gAudioSD_CurrentStation_Handle3_Extension4   = Indication_array[8];
        
        putvalue(env_ASG_AudioSD_CSH3_FavList,gAudioSD_CurrentStation_Handle3_FavList);
        putvalue(env_ASG_AudioSD_CSH3_FLaP,gAudioSD_CurrentStation_Handle3_FavListaP);
        putvalue(env_ASG_AudioSD_CSH3_Extension1,gAudioSD_CurrentStation_Handle3_Extension1);
        putvalue(env_ASG_AudioSD_CSH3_Extension2,gAudioSD_CurrentStation_Handle3_Extension2);
        putvalue(env_ASG_AudioSD_CSH3_Extension3,gAudioSD_CurrentStation_Handle3_Extension3);
        putvalue(env_ASG_AudioSD_CSH3_Extension4,gAudioSD_CurrentStation_Handle3_Extension4);
      break;	
      case Error_IND:
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStation_Handle3_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStation_Handle3_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStation_Handle3_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStation_Handle3_Indication: Application-Error: 0x%x", Indication_array[3]);
  		break;
  		default:
  			writelineEx(gError_Trace, 0,"ASG-AudioSD CurrentStation_Handle3_Indication: unknown indication %x", gBAP_Indication[2]);
  		break;
		}
}

on envVar env_ASG_AudioSD_SAI_get
{
}

void SiriusAlertInfo_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	            //LSG-ID
  	requestarray[1] =FctID_SiriusAlertInfo;	    //Fct.-ID
  	requestarray[2] =request;                 //request type
	
    switch(request)
  	{
  		case DataGet_REQ:
  			set_status_requestbuffer (requestarray, 3, Bap_Void);
  		break;
  		default:	
  			writelineEx(gError_Trace, 0, "ASG-AudioSD SiriusAlertInfo_Request: invalid request %d", request);
  		break;
  	}
}

void SiriusAlertInfo_Indication (dword Indication_array [], int datalength)
{
		int i =0, Offset =0, length =0;
  
    switch (gBAP_Indication[2])
		{
			case Data_IND:
        //get data
        Offset=3;
        //AlertType
        gAudioSD_SAI_AlertType =Indication_array[Offset];
        Offset++;
        //AlertName
        length =Indication_array[Offset];
        Offset++;
        for (i=0; i<SAI_ALERTNAME_TEXTLENGTH; i++)
            gAudioSD_SAI_AlertName[i] =0;
        for (i=0; i< length; i++)
        { 
            gAudioSD_SAI_AlertName[i] =Indication_array[Offset];
            Offset++;
        }
        //StationName
        length =Indication_array[Offset];
        Offset++;
        for (i=0; i<SAI_STATIONNAME_TEXTLENGTH; i++)
            gAudioSD_SAI_StationName[i] =0;
        for (i=0; i< length; i++)
        { 
            gAudioSD_SAI_StationName[i] =Indication_array[Offset];
            Offset++;
        }
        //SALref
        gAudioSD_SAI_SALref =Indication_array[Offset]; 
        Offset++;
        gAudioSD_SAI_SALref +=Indication_array[Offset] *0x100;
        Offset++;
        //Extension1
        gAudioSD_SAI_Extension1 =Indication_array[Offset];
        Offset++; 
        //Extension2
        gAudioSD_SAI_Extension2 =Indication_array[Offset];
        Offset++; 
        //Extension3
        gAudioSD_SAI_Extension3 =Indication_array[Offset];
        Offset++; 
        
        putvalue(env_ASG_AudioSD_SAI_AlertType,gAudioSD_SAI_AlertType);
        putvalue(env_ASG_AudioSD_SAI_AlertName,gAudioSD_SAI_AlertName);
        putvalue(env_ASG_AudioSD_SAI_StatName,gAudioSD_SAI_StationName);
        putvalue(env_ASG_AudioSD_SAI_SALref,gAudioSD_SAI_SALref);
        putvalue(env_ASG_AudioSD_SAI_Extension1,gAudioSD_SAI_Extension1);
        putvalue(env_ASG_AudioSD_SAI_Extension2,gAudioSD_SAI_Extension2);
        putvalue(env_ASG_AudioSD_SAI_Extension3,gAudioSD_SAI_Extension3);
      break;	
      case Error_IND:
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD SiriusAlertInfo_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD SiriusAlertInfo_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD SiriusAlertInfo_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD SiriusAlertInfo_Indication: Application-Error: 0x%x", Indication_array[3]);
  		break;
  		default:
  			writelineEx(gError_Trace, 0,"ASG-AudioSD SiriusAlertInfo_Indication: unknown indication %x", gBAP_Indication[2]);
  		break;
		}
}

on envVar env_ASG_AudioSD_STS_get
{
}

void Station_Track_Switch_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	            //LSG-ID
  	requestarray[1] =FctID_Station_Track_Switch;	    //Fct.-ID
  	requestarray[2] =request;                 //request type
	
    switch(request)
  	{
  		case DataGet_REQ:
  			set_status_requestbuffer (requestarray, 3, Bap_Void);
  		break;
  		default:	
  			writelineEx(gError_Trace, 0, "ASG-AudioSD Station_Track_Switch_Request: invalid request %d", request);
  		break;
  	}
}

void Station_Track_Switch_Indication (dword Indication_array [], int datalength)
{
  byte temp;
		
  switch (gBAP_Indication[2])
		{
			case Data_IND:      
        //get data
        temp = Indication_array[3];
  			gAudioSD_Station_Track_Switch_Event       = (temp & 0xF0)/0x10;
  			gAudioSD_Station_Track_Switch_Direction   = temp & 0x0F;
        temp = Indication_array[4];
        gAudioSD_Station_Track_Switch_PlayState   = (temp & 0xF0)/0x10;
        gAudioSD_Station_Track_Switch_Extension1  = temp & 0x0F;
        gAudioSD_Station_Track_Switch_Extension2  = Indication_array[5];
        gAudioSD_Station_Track_Switch_Extension3  = Indication_array[6];
        gAudioSD_Station_Track_Switch_Extension4  = Indication_array[7];
        gAudioSD_Station_Track_Switch_Extension5  = Indication_array[8];
        
        putvalue(env_ASG_AudioSD_STS_Event,gAudioSD_Station_Track_Switch_Event);
        putvalue(env_ASG_AudioSD_STS_Direction,gAudioSD_Station_Track_Switch_Direction);
        putvalue(env_ASG_AudioSD_STS_PlayState,gAudioSD_Station_Track_Switch_PlayState);
        putvalue(env_ASG_AudioSD_STS_Extension1,gAudioSD_Station_Track_Switch_Extension1);
        putvalue(env_ASG_AudioSD_STS_Extension2,gAudioSD_Station_Track_Switch_Extension2);
        putvalue(env_ASG_AudioSD_STS_Extension3,gAudioSD_Station_Track_Switch_Extension3);
        putvalue(env_ASG_AudioSD_STS_Extension4,gAudioSD_Station_Track_Switch_Extension4);
        putvalue(env_ASG_AudioSD_STS_Extension4,gAudioSD_Station_Track_Switch_Extension5);
      break;	
      case Error_IND:
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD Station_Track_Switch_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD Station_Track_Switch_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD Station_Track_Switch_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD Station_Track_Switch_Indication: Application-Error: 0x%x", Indication_array[3]);
  		break;
  		default:
  			writelineEx(gError_Trace, 0,"ASG-AudioSD Station_Track_Switch_Indication: unknown indication %x", gBAP_Indication[2]);
  		break;
		}
}

on envVar env_ASG_AudioSD_Pic_GetArray
{
  byte mode, shift, direction, transmitpos, indexsize,recordaddress;
  word requested_startelement, startelement, elements;
  
  // Init local variables. 
  mode                    =0;
  shift                   =0;
  direction               =0;
  transmitpos             =0;
  indexsize               =0;
  recordaddress           =0;
  requested_startelement  =0;
  startelement            =0;
  elements                =0;

  if(POWER_ON==gASG_PowerOnOff && getvalue(this))
	{
    gPicture_ASGID                  =getvalue(env_ASG_AudioSD_Pic_ASGID);
    gPicture_TAID                   =getvalue(env_ASG_AudioSD_Pic_TAID);;
    shift                           =getvalue(env_ASG_AudioSD_Pic_AH_shift);;
    direction                       =getvalue(env_ASG_AudioSD_Pic_AH_dir);;
    transmitpos                     =getvalue(env_ASG_AudioSD_Pic_AH_PosTrans);;
    indexsize                       =getvalue(env_ASG_AudioSD_Pic_AH_IS);;
    recordaddress                   =getvalue(env_ASG_AudioSD_Pic_AH_RA);;
    startelement                    =getvalue(env_ASG_AudioSD_Pic_AH_start);;
    elements                        =getvalue(env_ASG_AudioSD_Pic_AH_elements);;
    
    requested_startelement  =startelement;
    mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;
    //writeEX(gBAP_Trace, 0, "GetArray_indexSize %x",indexsize); //debug
    Picture_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
  }
}

on envVar env_ASG_AudioSD_Pic_OnOff
{
    int i =0, j =0;
    if(POWER_ON==gASG_PowerOnOff)
	{   
        if(getvalue(this))
        {
            gPicture_ListHandlingType      =AUDIO_PICTURE_BUILDUPCACHE;             //build-up complete cache...
            gPicture_cacheBuildUp          =AUDIO_PICTURE_BUILDUPCACHECACHE_WINDOW; //...and start with area "window"            
        
            Picture_ListHandling ();
        }
        else
        {
            gPicture_SlidingWindow_State   =AUDIO_PICTURE_SLIDINGWINDOW_NOTACTIVE;
            gPicture_ListHandlingType      =AUDIO_PICTURE_NOCACHE;
            gPicture_cacheBuildUp          =AUDIO_PICTURE_BUILDUPCACHENOCACHE;
            gPicture_CallBackReason        =AUDIO_PICTURE_CALLBACKREASON_NOCALLBACK;

            gPicture_cacheDown             =FALSE;
            gPicture_cacheUp               =FALSE;
            gPicture_LastFirstElement      =0;

            gPicture_recordaddress         =0;
            gPicture_transmitpos           =1;
            gPicture_CursorAction          =AUDIO_PICTURE_CURSORACTION_NOTHING;
            gPicture_DisplayStatus         =AUDIO_PICTURE_DISPLAYLIST_FIRST_ELEMENTS;
            
            for(j=0; j<AUDIOSD_PICTURE_ENTRIES; j++)
            {     
                gPicture_Pos[j]                            =0;
                gPicture_Type[j]                           =0;
                gPicture_Handle[j]                         =0;
                gPicture_TcpPort[j]                        =0;
                gPicture_ListEntryReceptionInformation[j]  =0;

                for(i=0;i<AUDIOSD_PICTURE_IPADDRESS_LENGTH;i++)
			            gPicture_IpAddress[j][i] =0;
                
                for(i=0;i<AUDIOSD_PICTURE_URI_LENGTH;i++)
			            gPicture_Uri[j][i] =0;
            }
            putvalue(env_ASG_AudioSD_Pic_Pos_0, 0);
            putvalue(env_ASG_AudioSD_Pic_Pos_1, 0);
            putvalue(env_ASG_AudioSD_Pic_Pos_2, 0);
    
            putvalue(env_ASG_AudioSD_Pic_PType_0, 0);
            putvalue(env_ASG_AudioSD_Pic_PType_1, 0);
            putvalue(env_ASG_AudioSD_Pic_PType_2, 0);

            putvalue(env_ASG_AudioSD_Pic_PType_s_0,empty_string);
            putvalue(env_ASG_AudioSD_Pic_PType_s_1,empty_string);
            putvalue(env_ASG_AudioSD_Pic_PType_s_2,empty_string);

            putvalue(env_ASG_AudioSD_Pic_Handle_0, 0);
            putvalue(env_ASG_AudioSD_Pic_Handle_1, 0);
            putvalue(env_ASG_AudioSD_Pic_Handle_2, 0);

            putvalue(env_ASG_AudioSD_Pic_IPv6_s_0, empty_string);
            putvalue(env_ASG_AudioSD_Pic_IPv6_s_1, empty_string);
            putvalue(env_ASG_AudioSD_Pic_IPv6_s_2, empty_string);
            
            putvalue(env_ASG_AudioSD_Pic_TCPport_0, 0);
            putvalue(env_ASG_AudioSD_Pic_TCPport_1, 0);
            putvalue(env_ASG_AudioSD_Pic_TCPport_2, 0);

            putvalue(env_ASG_AudioSD_Pic_URI_s_0, empty_string);
            putvalue(env_ASG_AudioSD_Pic_URI_s_1, empty_string);
            putvalue(env_ASG_AudioSD_Pic_URI_s_2, empty_string);            
        }
    }
}   

on envVar env_ASG_AudioSD_Pic_down
{
    int i=0, j=0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gPicture_ListHandlingType ==AUDIO_PICTURE_NOCACHE)
	{      
        gPicture_CursorAction =AUDIO_PICTURE_CURSORACTION_DOWN;
        
        if(gPicture_SlidingWindow_State ==AUDIO_PICTURE_SLIDINGWINDOW_ACTIVE)
        {   
            gPicture_ListHandlingType  =AUDIO_PICTURE_DOWN_CACHE;
            gPicture_DisplayStatus     =AUDIO_PICTURE_DISPLAYLIST_FIRST_ELEMENTS;
            gPicture_CursorAction      =AUDIO_PICTURE_CURSORACTION_NOTHING;
            
            Picture_ListHandling ();
        }
        else if(gPicture_SlidingWindow_State ==AUDIO_PICTURE_SLIDINGWINDOW_NOTACTIVE)
        {
            gPicture_DisplayStatus     =AUDIO_PICTURE_DISPLAYLIST_SEARCH_ELEMENTS;
            gPicture_CursorAction      =AUDIO_PICTURE_CURSORACTION_DOWN;

            Picture_display();

            //reset values
            gPicture_DisplayStatus     =AUDIO_PICTURE_DISPLAYLIST_REFRESH;
            gPicture_CursorAction      =AUDIO_PICTURE_CURSORACTION_NOTHING;
        }
    }
}

on envVar env_ASG_AudioSD_Pic_up
{
    int i=0, j=0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gPicture_ListHandlingType ==AUDIO_PICTURE_NOCACHE)
	{   
        gPicture_CursorAction =AUDIO_PICTURE_CURSORACTION_UP;

        if(gPicture_SlidingWindow_State ==AUDIO_PICTURE_SLIDINGWINDOW_ACTIVE)
        {  
            gPicture_ListHandlingType  =AUDIO_PICTURE_UP_CACHE;
            gPicture_DisplayStatus     =AUDIO_PICTURE_DISPLAYLIST_FIRST_ELEMENTS;
            gPicture_CursorAction      =AUDIO_PICTURE_CURSORACTION_NOTHING;
            
            Picture_ListHandling ();
        }
        else if(gPicture_SlidingWindow_State ==AUDIO_PICTURE_SLIDINGWINDOW_NOTACTIVE)
        {
            gPicture_DisplayStatus     =AUDIO_PICTURE_DISPLAYLIST_SEARCH_ELEMENTS;
            gPicture_CursorAction      =AUDIO_PICTURE_CURSORACTION_UP;

            //Picture_ListHandling();
            
            Picture_display();

            //reset values
            gPicture_DisplayStatus     =AUDIO_PICTURE_DISPLAYLIST_REFRESH;
            gPicture_CursorAction      =AUDIO_PICTURE_CURSORACTION_NOTHING;
        }    
    }
}

int Picture_GetNextCachedElement (int currentElement,byte direction)
{
    int i=0, nextElement=0;

    switch (direction)
    {
        case AUDIO_PICTURE_DISPLAYLIST_FIND_NEXT_ELEMENT:                
                nextElement = ++currentElement;

                if (nextElement<AUDIOSD_PICTURE_ENTRIES) //start at next element, if next element is not >8
                {
                    for(i =nextElement; i<AUDIOSD_PICTURE_ENTRIES;i++)
                    {
                        if(gPicture_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i= AUDIOSD_PICTURE_ENTRIES;
                        }
                        else
                            nextElement =0;
                    }
                }
                else    //start at first element
                {
                    nextElement =0;

                    for(i =nextElement; i<AUDIOSD_PICTURE_ENTRIES;i++)
                    {
                        if(gPicture_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =AUDIOSD_PICTURE_ENTRIES;
                        }   
                    }
                }
        break;

        case AUDIO_PICTURE_DISPLAYLIST_FIND_PREVIUOS_ELEMENT:
                nextElement = --currentElement;
                if (nextElement ==0 && gPicture_ListEntryReceptionInformation[nextElement] ==TRUE)
                    nextElement =0;
                else if (nextElement>0) 
                {
                    for(i =nextElement; i>0; i--)
                    {
                        if(gPicture_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =0;
                        }
                        else
                            nextElement =AUDIOSD_PICTURE_ENTRIES-1;
                    }
                }    
                else    //start at last element
                {
                    nextElement =AUDIOSD_PICTURE_ENTRIES-1;

                    for(i =nextElement; i>0; i--)
                    {
                        if(gPicture_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =0;
                        }
                        else if(gPicture_ListEntryReceptionInformation[0] ==TRUE)
                            nextElement =0;          
                    }
                }
        break;

        default:
        break;
    }
    return(nextElement);
}

int Picture_GetNextLineInCache (int currentElement,byte direction)
{
    int i=0, nextElement=0;

    switch (direction)
    {
        case FORWARD:
                           
                if(currentElement<AUDIOSD_PICTURE_ENTRIES-1 && currentElement !=5) 
                    nextElement = ++currentElement;  
                
                else if (currentElement ==8)            
                    nextElement =0;
                else
                    nextElement =AUDIO_PICTURE_NO_NEXT_POSITION;
        break;

        case BACKWARD:
                if(currentElement<AUDIOSD_PICTURE_ENTRIES && currentElement !=0 && currentElement !=6) 
                    nextElement =--currentElement;
                
                else if (currentElement ==0)            
                    nextElement =8;
                
                else
                    nextElement =AUDIO_PICTURE_NO_NEXT_POSITION;
        break;

        default:
        break;
    }
    return(nextElement);
}

void Picture_ListHandling () //for sliding window concept, list handling and 'build-up' list...
{
    byte mode, shift, direction, transmitpos, indexsize, recordaddress, buffer_ReceptionInformation,
      buffer_Pos, buffer_PictureType;
    word requested_startelement, startelement, elements, buffer_Handle, buffer_TcpPort;
    char buffer_IPAddress[AUDIOSD_PICTURE_IPADDRESS_LENGTH], buffer_URI[AUDIOSD_PICTURE_URI_LENGTH];
    int i,j,k;
    
    // Init local variables. 
    mode                        =0;
    shift                       =0;
    direction                   =0;
    transmitpos                 =0;
    indexsize                   =0;
    recordaddress               =0;
    requested_startelement      =0;
    startelement                =0;
    elements                    =0;
    i                           =0;
    j                           =0;
    k                           =0;
    buffer_Pos                  =0;
    buffer_PictureType          =0;
    buffer_Handle               =0;
    buffer_ReceptionInformation =0;
    buffer_TcpPort              =0;
    
    /***build-up complete cache***/

    switch (gPicture_ListHandlingType)
    {
        case AUDIO_PICTURE_BUILDUPCACHE:
             
            switch (gPicture_cacheBuildUp)
            {   
                //cache-up  
                case AUDIO_PICTURE_BUILDUPCACHECACHE_UP:  
                    if(gPicture_CallBackReason !=AUDIO_PICTURE_BUILDUPCACHENOCACHE && gPicture_CallBackReason !=AUDIO_PICTURE_CALLBACKREASON_CACHENEXT)
                    {
                        switch (gPicture_CallBackReason)
                        {
                            case AUDIO_PICTURE_CALLBACKREASON_CHECKCACHE:

                                    if(gPicture_ListEntryReceptionInformation[2] ==TRUE) //cache-down required?
                                    {            
                                        gPicture_cacheBuildUp      =AUDIO_PICTURE_BUILDUPCACHECACHE_DOWN;      //next step: build-up upper cache
                                        gPicture_CallBackReason    =AUDIO_PICTURE_CALLBACKREASON_CACHENEXT;    
                                        
                                        
                                        Picture_ListHandling ();
                                    }
                                    else //stop caching
                                    {   
                                        gPicture_cacheBuildUp      =AUDIO_PICTURE_BUILDUPCACHENOCACHE;  //"build-up cache" finished
                                        gPicture_ListHandlingType  =AUDIO_PICTURE_NOCACHE;              
                                        gPicture_CallBackReason    =AUDIO_PICTURE_CALLBACKREASON_NOCALLBACK; 
                                        gPicture_CursorAction      =AUDIO_PICTURE_CURSORACTION_NOTHING;
                                        
                                        //putvalue(env_ASG_AudioSD_Pic_ListOpState, empty_string);
                                        Picture_display();
                                    }
                            break;
                        }
                    }
                    else
                    {   
                        shift               =TRUE;
                        direction           =BACKWARD;
                        transmitpos         =FALSE;
                        indexsize           =FALSE;
                        recordaddress       =0;
                        startelement        =0;
                        elements            =3;
                
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gPicture_CallBackReason  =AUDIO_PICTURE_CALLBACKREASON_CHECKCACHE;

                        Picture_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;
                
                //cache "window"
                case AUDIO_PICTURE_BUILDUPCACHECACHE_WINDOW: 
                    if(gPicture_CallBackReason !=AUDIO_PICTURE_BUILDUPCACHENOCACHE && gPicture_CallBackReason !=AUDIO_PICTURE_CALLBACKREASON_CACHENEXT)
                    {   
                        switch (gPicture_CallBackReason)
                        {
                            case AUDIO_PICTURE_CALLBACKREASON_CHECKCACHE:
                                                 
                                    gPicture_cacheBuildUp      =AUDIO_PICTURE_BUILDUPCACHECACHE_UP;      //next step: build-up upper cache
                                    gPicture_CallBackReason    =AUDIO_PICTURE_CALLBACKREASON_CACHENEXT;    
                                    
                                    Picture_ListHandling ();
                            break;
                        }
                    }
                    else
                    { 
                        //putvalue(env_ASG_AudioSD_Pic_ListOpState, "build-up list...");
                        shift               =FALSE;
                        direction           =FORWARD;
                        transmitpos         =FALSE;
                        indexsize           =FALSE;
                        recordaddress       =0;
                        startelement        =0;
                        elements            =3; 
    
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gPicture_CallBackReason  =AUDIO_PICTURE_CALLBACKREASON_CHECKCACHE;
                        
                        Picture_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;
                
                //cache-down
                case AUDIO_PICTURE_BUILDUPCACHECACHE_DOWN:
                    if(gPicture_CallBackReason !=AUDIO_PICTURE_BUILDUPCACHENOCACHE && gPicture_CallBackReason !=AUDIO_PICTURE_CALLBACKREASON_CACHENEXT)
                    {
                        switch (gPicture_CallBackReason)
                        {
                            case AUDIO_PICTURE_CALLBACKREASON_CHECKCACHE:
                                    
                                    //stop caching
                                    gPicture_cacheBuildUp      =AUDIO_PICTURE_BUILDUPCACHENOCACHE;  //"build-up cache" finished
                                    gPicture_ListHandlingType  =AUDIO_PICTURE_NOCACHE;              
                                    gPicture_CallBackReason    =AUDIO_PICTURE_CALLBACKREASON_NOCALLBACK;
                                    gPicture_CursorAction      =AUDIO_PICTURE_CURSORACTION_NOTHING;
                                    
                                    gPicture_DisplayStatus     =AUDIO_PICTURE_DISPLAYLIST_REFRESH;
                                    
                                    //putvalue(env_ASG_AudioSD_Pic_ListOpState, empty_string);
                                    Picture_display();
                            break;
                        }
                    }
                    else
                    { 
                        shift                   =TRUE;
                        direction               =FORWARD;
                        transmitpos             =FALSE;
                        indexsize               =FALSE;
                        recordaddress           =0;
                        for(i=0;i<AUDIOSD_PICTURE_ENTRIES; i++) //find last cached element
                        {   
                            if(gPicture_ListEntryReceptionInformation[i] ==FALSE) //abort loop
                                i =AUDIOSD_PICTURE_ENTRIES; 
                            else
                                startelement    =gPicture_Pos[i];
                        }
                        elements                =3;                         
        
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gPicture_CallBackReason    =AUDIO_PICTURE_CALLBACKREASON_CHECKCACHE;
                        
                        Picture_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;

                default:
                break;
            }//build-up cache finished
        break;
        
        /********sliding-window********/
        case AUDIO_PICTURE_DOWN_CACHE: 
                    if (gPicture_CallBackReason ==AUDIO_PICTURE_CALLBACKREASON_CHECKCACHE) //check if valid data received
                    {   
                        if(gPicture_ListEntryReceptionInformation[5] ==0) //No valid data in last list pos -> last list element reached, start with element 0!  
                        {    
                            shift                   =FALSE;
                            direction               =FORWARD;
                            transmitpos             =FALSE;
                            indexsize               =FALSE;
                            recordaddress           =0;
                            startelement            =0; //first element
                            elements                =1;        
                            
                            requested_startelement  =startelement;
                            mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;
                            
                            gPicture_CallBackReason    =AUDIO_PICTURE_CALLBACKREASON_DISPLAYLIST; 
                            gPicture_cacheDown         =TRUE;

                            Picture_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);    
                        }
                        else
                        {
                            gPicture_CallBackReason =AUDIO_PICTURE_CALLBACKREASON_DISPLAYLIST;
                            Picture_ListHandling(); 
                        }    
                    }
                    else if (gPicture_CallBackReason ==AUDIO_PICTURE_CALLBACKREASON_DISPLAYLIST)
                    {   
                        gPicture_ListHandlingType  =AUDIO_PICTURE_NOCACHE;
                        gPicture_cacheDown         =FALSE;
                        gPicture_DisplayStatus     =AUDIO_PICTURE_DISPLAYLIST_FIRST_ELEMENTS;
                        
                        //putvalue(env_ASG_AudioSD_Pic_ListOpState, empty_string);
                        Picture_display();
                        gPicture_DisplayStatus     =AUDIO_PICTURE_DISPLAYLIST_REFRESH;
                        gPicture_CallBackReason    =AUDIO_PICTURE_CALLBACKREASON_NOCALLBACK;
                    }
                    else
                    {   
                        //putvalue(env_ASG_AudioSD_Pic_ListOpState, "list operating...");
                                
                        shift                   =TRUE;
                        direction               =FORWARD;
                        transmitpos             =FALSE;
                        indexsize               =FALSE;
                        recordaddress           =0;
                        startelement            =gPicture_Pos[5]; //last element
                        elements                =1;
                        
                        for(i=0;i<AUDIOSD_PICTURE_ENTRIES;i++)
                        {   
                            j =i+1;
                            
                            switch (i)
                            {   
                                case 0: 
                                    //buffer data of Pos '0' (local)
                                    buffer_Pos              =gPicture_Pos[i];
                                    buffer_PictureType      =gPicture_Type[i];
                                    buffer_Handle           =gPicture_Handle[i];
                                    buffer_TcpPort          =gPicture_TcpPort[i];
                                    
                                    for (k=0; k<AUDIOSD_PICTURE_IPADDRESS_LENGTH;k++) //clear string
                                        buffer_IPAddress[k] =0;                                     

                                    for(k=0;k<strlen(gPicture_IpAddress[i]);k++) 
                                        buffer_IPAddress[k]=gPicture_IpAddress[i][k];
                                    
                                    for (k=0; k<AUDIOSD_PICTURE_URI_LENGTH;k++) //clear string
                                        buffer_URI[k] =0;                                     

                                    for(k=0;k<strlen(gPicture_Uri[i]);k++) 
                                        buffer_URI[k]=gPicture_Uri[i][k];

                                    //copy data from Pos '1' to Pos '0'
                                    gPicture_Pos[i]             =gPicture_Pos[j]; 
                                    gPicture_Type[i]       =gPicture_Type[j];
                                    gPicture_Handle[i]      =gPicture_Handle[j];
                                    gPicture_TcpPort[i] =gPicture_TcpPort[j];
                                    
                                    for (k=0; k<AUDIOSD_PICTURE_IPADDRESS_LENGTH;k++) //clear string
                                        gPicture_IpAddress[i][k] =0;                                     

                                    for(k=0;k<strlen(gPicture_IpAddress[j]);k++) 
                                        gPicture_IpAddress[i][k]=gPicture_IpAddress[j][k];

                                    for (k=0; k<AUDIOSD_PICTURE_URI_LENGTH;k++) //clear string
                                        gPicture_Uri[i][k] =0;                                     

                                    for(k=0;k<strlen(gPicture_Uri[j]);k++) 
                                        gPicture_Uri[i][k]=gPicture_Uri[j][k];
                                break;
                            
                                case 5:
                                    //clear last element in list 
                                    gPicture_ListEntryReceptionInformation[i] =0;
                                    gPicture_Pos[i]                           =0;
                                    gPicture_Type[i]                          =0;
                                    gPicture_Handle[i]                    =0;
                                    gPicture_TcpPort[i]     =0;
                                    
                                    for (k=0; k<AUDIOSD_PICTURE_IPADDRESS_LENGTH;k++) //clear string
                                        gPicture_IpAddress[i][k] =0;
                                    
                                    for (k=0; k<AUDIOSD_PICTURE_URI_LENGTH;k++) //clear string
                                        gPicture_Uri[i][k] =0;
                                break;
                            
                                case 8:
                                    //copy data from buffer in Pos '8'
                                    gPicture_Pos[i]                       =buffer_Pos; 
                                    gPicture_Type[i]                 =buffer_PictureType;
                                    gPicture_Handle[i]                =buffer_Handle;
                                    gPicture_TcpPort[i]             =buffer_TcpPort;
                                                                        
                                    for (k=0; k<AUDIOSD_PICTURE_IPADDRESS_LENGTH;k++) //clear string
                                        gPicture_IpAddress[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_IPAddress);k++) 
                                        gPicture_IpAddress[i][k]=buffer_IPAddress[k];

                                    for (k=0; k<AUDIOSD_PICTURE_URI_LENGTH;k++) //clear string
                                        gPicture_Uri[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_URI);k++) 
                                        gPicture_Uri[i][k]=buffer_URI[k];
                                break;
                                
                                default://other elements
                                    //copy element on other position
                                    gPicture_Pos[i]                       =gPicture_Pos[j]; 
                                    gPicture_Type[i]                 =gPicture_Type[j];
                                    gPicture_Handle[i]                =gPicture_Handle[j];
                                    gPicture_TcpPort[i]           =gPicture_TcpPort[j];
                                    
                                    for (k=0; k<AUDIOSD_PICTURE_IPADDRESS_LENGTH;k++) //clear string
                                        gPicture_IpAddress[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gPicture_IpAddress[j]);k++) 
                                        gPicture_IpAddress[i][k]=gPicture_IpAddress[j][k];
                                        
                                    for (k=0; k<AUDIOSD_PICTURE_URI_LENGTH;k++) //clear string
                                        gPicture_Uri[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gPicture_Uri[j]);k++) 
                                        gPicture_Uri[i][k]=gPicture_Uri[j][k]; 
                                 break;
                            } // end of switch 'i'
                        }
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        Picture_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);                        
                        
                        //to check, if valid data received
                        gPicture_CallBackReason    =AUDIO_PICTURE_CALLBACKREASON_CHECKCACHE;
                    }
        break;

        case AUDIO_PICTURE_UP_CACHE: 
                    if (gPicture_CallBackReason ==AUDIO_PICTURE_CALLBACKREASON_CHECKCACHE) //check if valid data received
                    {   
                        if(gPicture_ListEntryReceptionInformation[6] ==0) //No valid data in first list pos -> last list element reached, start with element 0!  
                        {
                            shift                   =TRUE;
                            direction               =BACKWARD;
                            transmitpos             =FALSE;
                            indexsize               =FALSE;
                            recordaddress           =0;
                            startelement            =0; //Last element
                            elements                =1;        
                            
                            requested_startelement  =startelement;
                            mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                            gPicture_cacheUp        =TRUE;
                            gPicture_CallBackReason =AUDIO_PICTURE_CALLBACKREASON_DISPLAYLIST;
                            
                            Picture_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                        }
                        else
                        {
                            gPicture_CallBackReason =AUDIO_PICTURE_CALLBACKREASON_DISPLAYLIST;
                            Picture_ListHandling();
                        }           
                    }

                    else if (gPicture_CallBackReason ==AUDIO_PICTURE_CALLBACKREASON_DISPLAYLIST)
                    {   
                        gPicture_ListHandlingType  =AUDIO_PICTURE_NOCACHE;
                        gPicture_cacheUp           =FALSE;
                        gPicture_DisplayStatus     =AUDIO_PICTURE_DISPLAYLIST_FIRST_ELEMENTS;
                        
                        //putvalue(env_ASG_AudioSD_Pic_ListOpState, empty_string);
                        Picture_display();
                        gPicture_DisplayStatus     =AUDIO_PICTURE_DISPLAYLIST_REFRESH;
                        gPicture_CallBackReason    =AUDIO_PICTURE_CALLBACKREASON_NOCALLBACK;
                    }

                    else
                    {           
                        //putvalue(env_ASG_AudioSD_Pic_ListOpState, "list operating...");

                        shift                   =TRUE;
                        direction               =BACKWARD;
                        transmitpos             =FALSE;
                        indexsize               =TRUE;
                        recordaddress           =0;
                        startelement            =gPicture_Pos[6]; //first element
                        elements                =1;
                    
                        for(i=AUDIOSD_PICTURE_ENTRIES-1;i>=0;i--)
                        {  
                            j =i-1;
                            switch (i)
                            {   
                                case 8: 
                                    //buffer data of Pos '8' (local)
                                    buffer_Pos              =gPicture_Pos[i];
                                    buffer_PictureType      =gPicture_Type[i];
                                    buffer_Handle           =gPicture_Handle[i];
                                    buffer_TcpPort          =gPicture_TcpPort[i];
                                    
                                    for (k=0; k<AUDIOSD_PICTURE_IPADDRESS_LENGTH;k++) //clear string
                                        buffer_IPAddress[k] =0;                                     

                                    for(k=0;k<strlen(gPicture_IpAddress[i]);k++) 
                                        buffer_IPAddress[k]=gPicture_IpAddress[i][k];

                                    for (k=0; k<AUDIOSD_PICTURE_URI_LENGTH;k++) //clear string
                                        buffer_URI[k] =0;                                     

                                    for(k=0;k<strlen(gPicture_Uri[i]);k++) 
                                        buffer_URI[k]=gPicture_Uri[i][k];
                                    
                                    
                                    //copy data from Pos '7' to Pos '8'
                                    gPicture_Pos[i]                       =gPicture_Pos[j]; 
                                    gPicture_Type[i]                 =gPicture_Type[j];
                                    gPicture_Handle[i]                =gPicture_Handle[j];
                                    gPicture_TcpPort[i]           =gPicture_TcpPort[j];
                                    
                                    for (k=0; k<AUDIOSD_PICTURE_IPADDRESS_LENGTH;k++) //clear string
                                        gPicture_IpAddress[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gPicture_IpAddress[j]);k++) 
                                        gPicture_IpAddress[i][k]=gPicture_IpAddress[j][k];
                                    
                                    for (k=0; k<AUDIOSD_PICTURE_URI_LENGTH;k++) //clear string
                                        gPicture_Uri[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gPicture_Uri[j]);k++) 
                                        gPicture_Uri[i][k]=gPicture_Uri[j][k]; 
                                    
                                break;
                            
                                case 6: 
                                    //clear first element in list 
                                    gPicture_ListEntryReceptionInformation[i] =0;
                                    gPicture_Pos[i]                           =0;
                                    gPicture_Type[i]                          =0;
                                    gPicture_Handle[i]                    =0;
                                    gPicture_TcpPort[i]     =0;
                                    
                                    for (k=0; k<AUDIOSD_PICTURE_IPADDRESS_LENGTH;k++) //clear string
                                        gPicture_IpAddress[i][k] =0;
                                    
                                    for (k=0; k<AUDIOSD_PICTURE_URI_LENGTH;k++) //clear string
                                        gPicture_Uri[i][k] =0;                                       
                                break;
                            
                                case 0: 
                                    //copy data from buffer in Pos '0'
                                    gPicture_Pos[i]                       =buffer_Pos; 
                                    gPicture_Type[i]                      =buffer_PictureType;
                                    gPicture_Handle[i]                =buffer_Handle;
                                    gPicture_TcpPort[i]               =buffer_TcpPort;
                                    
                                    for (k=0; k<AUDIOSD_PICTURE_IPADDRESS_LENGTH;k++) //clear string
                                        gPicture_IpAddress[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_IPAddress);k++) 
                                        gPicture_IpAddress[i][k]=buffer_IPAddress[k];

                                    for (k=0; k<AUDIOSD_PICTURE_URI_LENGTH;k++) //clear string
                                        gPicture_Uri[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_URI);k++) 
                                        gPicture_Uri[i][k]=buffer_URI[k];
                                break;
                                
                                default: //other elements
                                    //copy element on other position
                                    gPicture_Pos[i]                       =gPicture_Pos[j]; 
                                    gPicture_Type[i]                 =gPicture_Type[j];
                                    gPicture_Handle[i]                =gPicture_Handle[j];
                                    gPicture_TcpPort[i]               =gPicture_TcpPort[j];
                                    
                                    for (k=0; k<AUDIOSD_PICTURE_IPADDRESS_LENGTH;k++) //clear string
                                        gPicture_IpAddress[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gPicture_IpAddress[j]);k++) 
                                        gPicture_IpAddress[i][k]=gPicture_IpAddress[j][k];
                                    
                                    for (k=0; k<AUDIOSD_PICTURE_URI_LENGTH;k++) //clear string
                                        gPicture_Uri[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gPicture_Uri[j]);k++) 
                                        gPicture_Uri[i][k]=gPicture_Uri[j][k];
                                break;
                            } // end of switch 'i'
                        }
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        Picture_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);                        
                        
                        //to check, if valid data received
                        gPicture_CallBackReason    =AUDIO_PICTURE_CALLBACKREASON_CHECKCACHE;
                    }
        break;

        default:
        break;
    } //end of switch 'type of cache handling' 
}

void Picture_display()
{   
    int Element_1 =0, Element_2 =1, Element_3 =2;

    if(POWER_ON==gASG_PowerOnOff && getvalue(env_ASG_AudioSD_Pic_OnOff))
	{   
        /******'sliding window' not active******/         
        if(gPicture_DisplayStatus ==AUDIO_PICTURE_DISPLAYLIST_SEARCH_ELEMENTS)
        {
            //1. Element              
            if(gPicture_CursorAction ==AUDIO_PICTURE_CURSORACTION_DOWN)
                Element_1 =Picture_GetNextCachedElement(gPicture_LastFirstElement, AUDIO_PICTURE_DISPLAYLIST_FIND_NEXT_ELEMENT);
            
            else if(gPicture_CursorAction ==AUDIO_PICTURE_CURSORACTION_UP)            
                Element_1 =Picture_GetNextCachedElement(gPicture_LastFirstElement, AUDIO_PICTURE_DISPLAYLIST_FIND_PREVIUOS_ELEMENT);

            //Pos
            putvalue(env_ASG_AudioSD_Pic_Pos_0, gPicture_Pos[Element_1]);               
            
            //PictureType
            if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_Pic_PType_0, gPicture_Type[Element_1]);

                if(gPicture_Type[Element_1] <0x06)
                    putvalue(env_ASG_AudioSD_Pic_PType_s_0,gPicture_Type_s[gPicture_Type[Element_1]]);
                else if (gPicture_Type[Element_1] == 0xFF)
                    putvalue(env_ASG_AudioSD_Pic_PType_s_0,gstring_unknown);
                else
                    putvalue(env_ASG_AudioSD_Pic_PType_s_0,gstring_reserved);
            }

            //Handle
            if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                putvalue(env_ASG_AudioSD_Pic_Handle_0,gPicture_Handle[Element_1]);
            
            //IPv6 address
            if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                putvalue(env_ASG_AudioSD_Pic_IPv6_s_0,gPicture_IpAddress[Element_1]);
            
            //TCP Port
            if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                putvalue(env_ASG_AudioSD_Pic_TCPport_0,gPicture_TcpPort[Element_1]);
            
            //URI
            if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                putvalue(env_ASG_AudioSD_Pic_URI_s_0,gPicture_Uri[Element_1]);
                
            gPicture_LastFirstElement =Element_1;
            
            
            //2. Element             
            Element_2 =Picture_GetNextCachedElement(Element_1, AUDIO_PICTURE_DISPLAYLIST_FIND_NEXT_ELEMENT);
            
            //Pos
            putvalue(env_ASG_AudioSD_Pic_Pos_1, gPicture_Pos[Element_2]);               
            
            //PictureType
            if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_Pic_PType_1, gPicture_Type[Element_2]);

                if(gPicture_Type[Element_2] <0x06)
                    putvalue(env_ASG_AudioSD_Pic_PType_s_1,gPicture_Type_s[gPicture_Type[Element_2]]);
                else if (gPicture_Type[Element_2] == 0xFF)
                    putvalue(env_ASG_AudioSD_Pic_PType_s_1,gstring_unknown);
                else
                    putvalue(env_ASG_AudioSD_Pic_PType_s_1,gstring_reserved);
            }

            //Handle
            if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                putvalue(env_ASG_AudioSD_Pic_Handle_1,gPicture_Handle[Element_2]);
            
            //IPv6 address
            if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                putvalue(env_ASG_AudioSD_Pic_IPv6_s_1,gPicture_IpAddress[Element_2]);
            
            //TCP Port
            if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                putvalue(env_ASG_AudioSD_Pic_TCPport_1,gPicture_TcpPort[Element_2]);
            
            //URI
            if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                putvalue(env_ASG_AudioSD_Pic_URI_s_1,gPicture_Uri[Element_2]);
            
            //3. Element          
            Element_3 =Picture_GetNextCachedElement(Element_2, AUDIO_PICTURE_DISPLAYLIST_FIND_NEXT_ELEMENT);

            //Pos
            putvalue(env_ASG_AudioSD_Pic_Pos_2, gPicture_Pos[Element_3]);               
            
            //PictureType
            if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_Pic_PType_2, gPicture_Type[Element_3]);

                if(gPicture_Type[Element_3] <0x06)
                    putvalue(env_ASG_AudioSD_Pic_PType_s_2,gPicture_Type_s[gPicture_Type[Element_3]]);
                else if (gPicture_Type[Element_3] == 0xFF)
                    putvalue(env_ASG_AudioSD_Pic_PType_s_2,gstring_unknown);
                else
                    putvalue(env_ASG_AudioSD_Pic_PType_s_2,gstring_reserved);
            }

            //Handle
            if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                putvalue(env_ASG_AudioSD_Pic_Handle_2,gPicture_Handle[Element_3]);
            
            //IPv6 address
            if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                putvalue(env_ASG_AudioSD_Pic_IPv6_s_2,gPicture_IpAddress[Element_3]);
            
            //TCP Port
            if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                putvalue(env_ASG_AudioSD_Pic_TCPport_2,gPicture_TcpPort[Element_3]);
            
            //URI
            if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                putvalue(env_ASG_AudioSD_Pic_URI_s_2,gPicture_Uri[Element_3]);
        }

        /******'sliding Window' active or 'build-up List'******/
        else if(gPicture_DisplayStatus ==AUDIO_PICTURE_DISPLAYLIST_FIRST_ELEMENTS) 
        {
            //1. Element    
            if(gPicture_ListEntryReceptionInformation [0] ==TRUE && getvalue(env_ASG_AudioSD_Pic_OnOff))
            {   
                Element_1 =0;
                
                //Pos
                putvalue(env_ASG_AudioSD_Pic_Pos_0, gPicture_Pos[Element_1]);               
                
                //PictureType
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_Pic_PType_0, gPicture_Type[Element_1]);

                    if(gPicture_Type[Element_1] <0x06)
                        putvalue(env_ASG_AudioSD_Pic_PType_s_0,gPicture_Type_s[gPicture_Type[Element_1]]);
                    else if (gPicture_Type[Element_1] == 0xFF)
                      putvalue(env_ASG_AudioSD_Pic_PType_s_0,gstring_unknown);
                    else
                        putvalue(env_ASG_AudioSD_Pic_PType_s_0,gstring_reserved);
                }

                //Handle
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_Handle_0,gPicture_Handle[Element_1]);
                
                //IPv6 address
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_IPv6_s_0,gPicture_IpAddress[Element_1]);
                
                //TCP Port
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_TCPport_0,gPicture_TcpPort[Element_1]);
                
                //URI
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_URI_s_0,gPicture_Uri[Element_1]);
            }
            
            //2. Element    
            if(gPicture_ListEntryReceptionInformation [1] ==TRUE && getvalue(env_ASG_AudioSD_Pic_OnOff))
            {
                Element_2 =1;
                //Pos
                putvalue(env_ASG_AudioSD_Pic_Pos_1, gPicture_Pos[Element_2]);               
                
                //PictureType
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_Pic_PType_1, gPicture_Type[Element_2]);

                    if(gPicture_Type[Element_2] <0x06)
                        putvalue(env_ASG_AudioSD_Pic_PType_s_1,gPicture_Type_s[gPicture_Type[Element_2]]);
                    else if (gPicture_Type[Element_2] == 0xFF)
                      putvalue(env_ASG_AudioSD_Pic_PType_s_1,gstring_unknown);
                    else
                        putvalue(env_ASG_AudioSD_Pic_PType_s_1,gstring_reserved);
                }

                //Handle
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_Handle_1,gPicture_Handle[Element_2]);
                
                //IPv6 address
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_IPv6_s_1,gPicture_IpAddress[Element_2]);
                
                //TCP Port
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_TCPport_1,gPicture_TcpPort[Element_2]);
                
                //URI
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_URI_s_1,gPicture_Uri[Element_2]);
            }
             //3. Element    
            if(gPicture_ListEntryReceptionInformation [2] ==TRUE && getvalue(env_ASG_AudioSD_Pic_OnOff))
            {
             Element_3 =2;
             //Pos
                putvalue(env_ASG_AudioSD_Pic_Pos_2, gPicture_Pos[Element_3]);               
                
                //PictureType
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_Pic_PType_2, gPicture_Type[Element_3]);

                    if(gPicture_Type[Element_3] <0x06)
                        putvalue(env_ASG_AudioSD_Pic_PType_s_2,gPicture_Type_s[gPicture_Type[Element_3]]);
                    else if (gPicture_Type[Element_3] == 0xFF)
                      putvalue(env_ASG_AudioSD_Pic_PType_s_2,gstring_unknown);
                    else
                        putvalue(env_ASG_AudioSD_Pic_PType_s_2,gstring_reserved);
                }

                //Handle
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_Handle_2,gPicture_Handle[Element_3]);
                
                //IPv6 address
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_IPv6_s_2,gPicture_IpAddress[Element_3]);
                
                //TCP Port
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_TCPport_2,gPicture_TcpPort[Element_3]);
                
                //URI
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_URI_s_2,gPicture_Uri[Element_3]);
            }
        }
        else if (gPicture_DisplayStatus ==AUDIO_PICTURE_DISPLAYLIST_REFRESH)
        {               
            //1. Element
            if(gPicture_SlidingWindow_State ==AUDIO_PICTURE_SLIDINGWINDOW_NOTACTIVE)
                Element_1 =gPicture_LastFirstElement; 
            else
                Element_1 =0;

            if(gPicture_ListEntryReceptionInformation[Element_1])
            {
                //Pos
                putvalue(env_ASG_AudioSD_Pic_Pos_0, gPicture_Pos[Element_1]);               
                
                //PictureType
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_Pic_PType_0, gPicture_Type[Element_1]);

                    if(gPicture_Type[Element_1] <0x06)
                        putvalue(env_ASG_AudioSD_Pic_PType_s_0,gPicture_Type_s[gPicture_Type[Element_1]]);
                    else if (gPicture_Type[Element_1] == 0xFF)
                      putvalue(env_ASG_AudioSD_Pic_PType_s_0,gstring_unknown);
                    else
                        putvalue(env_ASG_AudioSD_Pic_PType_s_0,gstring_reserved);
                }

                //Handle
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_Handle_0,gPicture_Handle[Element_1]);
                
                //IPv6 address
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_IPv6_s_0,gPicture_IpAddress[Element_1]);
                
                //TCP Port
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_TCPport_0,gPicture_TcpPort[Element_1]);
                
                //URI
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_URI_s_0,gPicture_Uri[Element_1]);
            }
            //2. Element             
            if(gPicture_SlidingWindow_State ==AUDIO_PICTURE_SLIDINGWINDOW_NOTACTIVE)
                Element_2 =Picture_GetNextCachedElement(Element_1, AUDIO_PICTURE_DISPLAYLIST_FIND_NEXT_ELEMENT);
            else
                Element_2 =1;

            if(gPicture_ListEntryReceptionInformation[Element_2])
            {
                //Pos
                putvalue(env_ASG_AudioSD_Pic_Pos_1, gPicture_Pos[Element_2]);               
                
                //PictureType
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_Pic_PType_1, gPicture_Type[Element_2]);

                    if(gPicture_Type[Element_2] <0x06)
                        putvalue(env_ASG_AudioSD_Pic_PType_s_1,gPicture_Type_s[gPicture_Type[Element_2]]);
                    else if (gPicture_Type[Element_2] == 0xFF)
                      putvalue(env_ASG_AudioSD_Pic_PType_s_1,gstring_unknown);
                    else
                        putvalue(env_ASG_AudioSD_Pic_PType_s_1,gstring_reserved);
                }

                //Handle
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_Handle_1,gPicture_Handle[Element_2]);
                
                //IPv6 address
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_IPv6_s_1,gPicture_IpAddress[Element_2]);
                
                //TCP Port
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_TCPport_1,gPicture_TcpPort[Element_2]);
                
                //URI
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_URI_s_1,gPicture_Uri[Element_2]);
            }
            //3. Element          
            if(gPicture_SlidingWindow_State ==AUDIO_PICTURE_SLIDINGWINDOW_NOTACTIVE)
                Element_3 =Picture_GetNextCachedElement(Element_2, AUDIO_PICTURE_DISPLAYLIST_FIND_NEXT_ELEMENT);
            else
                Element_3 =2;

            if(gPicture_ListEntryReceptionInformation[Element_3])
            {    
                //Pos
                putvalue(env_ASG_AudioSD_Pic_Pos_2, gPicture_Pos[Element_3]);               
                
                //PictureType
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_Pic_PType_2, gPicture_Type[Element_3]);

                    if(gPicture_Type[Element_3] <0x06)
                        putvalue(env_ASG_AudioSD_Pic_PType_s_2,gPicture_Type_s[gPicture_Type[Element_3]]);
                    else if (gPicture_Type[Element_3] == 0xFF)
                      putvalue(env_ASG_AudioSD_Pic_PType_s_2,gstring_unknown);
                    else
                        putvalue(env_ASG_AudioSD_Pic_PType_s_2,gstring_reserved);
                }

                //Handle
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_Handle_2,gPicture_Handle[Element_3]);
                
                //IPv6 address
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_IPv6_s_2,gPicture_IpAddress[Element_3]);
                
                //TCP Port
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_TCPport_2,gPicture_TcpPort[Element_3]);
                
                //URI
                if (gPicture_recordaddress ==0 || gPicture_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_Pic_URI_s_2,gPicture_Uri[Element_3]);
            }
        }
    }
}

void Picture_Request(byte request, byte mode, byte recordaddress, word requested_startelement, word startelement, word elements)
{   
  int  i;
  dword requestarray [BAP_BUFFER_SIZE];
  byte Offset;
  word indexsize;

  // Init local variables. 
  for(i=0;i<BAP_BUFFER_SIZE;i++)
    requestarray [i]=0;
  
  indexsize   =0;
  Offset      =0;

  // decode "mode-byte"
  indexsize   =(mode &0x08)/0x08; 

  // Handle request.
  requestarray[0] =LSG_AudioSD;	    //LSG-ID
	requestarray[1] =FctID_Picture;	//Fct.-ID
	requestarray[2] =request;           //request type

  switch(request)
	{
    case DataGet_REQ:              
      requestarray[3] =((gPicture_ASGID *0x10) &0xF0) +(gPicture_TAID &0x0F);      
      /***ArrayHeader***/
	    requestarray[4] =((mode *0x10) &0xF0) +(recordaddress &0x0F);          
      Offset =5;
      if(indexsize)
      {
        requestarray[Offset] =requested_startelement &0x00FF;
        Offset++;
        requestarray[Offset] =(requested_startelement &0xFF00) /0x100;
        Offset++;  
        requestarray[Offset] =elements &0x00FF;
        Offset++;
        requestarray[Offset] =(elements &0xFF00) /0x100;
        Offset++;       
        //writeEX(gBAP_Trace, 0, "ASG_Request_indexSize_16bit %x",indexsize); //debug
      }
      else
      {
        requestarray[Offset] =requested_startelement;
        Offset++;
        requestarray[Offset] =elements;
        Offset++;
        //writeEX(gBAP_Trace, 0, "ASG_Request_indexSize_8bit %x",indexsize); //debug
      }
      set_status_requestbuffer (requestarray, Offset, Bap_ByteSequence);
    break;
    default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD Request_Picture: invalid request %d", request);
		break;
  }
}

void Picture_Indication(dword Indication_array [], int datalength)
{
  byte mode, direction, shift, recordaddress, transmitpos, length, indexsize, CacheElements;
  word startelement, elements, current_element;
  int i =0, j=0, Offset =0;
  
  // Init local variables
  mode                    =0;
  direction               =0;
  shift                   =0;
  recordaddress           =0;
  startelement            =0;
  elements                =0;
  current_element         =0;
  transmitpos             =0;
  length                  =0;
  CacheElements =FALSE;
  
  write("Debug: Indication_Picture -> ind-type=%d",gBAP_Indication[2]);
  
	switch (gBAP_Indication[2])
	{
		case Data_IND:
		//get data
      gPicture_ASGID =(Indication_array[3] &0xF0) /0x10;
      gPicture_TAID  =Indication_array[3] &0x0F; 
      gPicture_TotalNumListElements =Indication_array[4];
      /***ArrayHeader***/
      mode            =(Indication_array[5] &0xF0) /0x10;
      recordaddress   =Indication_array[5] &0x0F;
      startelement    =Indication_array[6];
      elements        =Indication_array[7];
      Offset =8;
      // decode "mode-byte"
      shift       =mode &0x01;
      direction   =(mode &0x02)/0x02;
      transmitpos =(mode &0x04)/0x04;
      indexsize   =(mode &0x08)/0x08;             
 
      if(startelement !=0)
      {
        for (i=0;i<AUDIOSD_PICTURE_ENTRIES;i++)
        {
          if(startelement ==gPicture_Pos[i])  
            i =AUDIOSD_PICTURE_ENTRIES;              
        }
      }
      switch (recordaddress)
      { 
        case 0: //recordaddress =0 -> complete record
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;             
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gPicture_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PictureType
                if (CacheElements ==TRUE)
                  gPicture_Type[current_element] =Indication_array[Offset];
                Offset++;
                //Handle
                if (CacheElements ==TRUE)
                  gPicture_Handle[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gPicture_Handle[current_element] +=Indication_array[Offset]*0x100;
                Offset++;
                //IPv6Address
                for(i=0; i<AUDIOSD_PICTURE_IPADDRESS_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gPicture_IpAddress[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gPicture_IpAddress[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //TCP_Port
                if (CacheElements ==TRUE)
                  gPicture_TcpPort[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gPicture_TcpPort[current_element] +=Indication_array[Offset]*0x100;
                Offset++;
                //URI
                for(i=0; i<AUDIOSD_PICTURE_URI_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gPicture_Uri[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gPicture_Uri[current_element][i] =Indication_array[Offset];
                  Offset++;
                }       
                //next element
                if (CacheElements ==TRUE)
                  gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element  
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
			    	{
              current_element =AUDIOSD_PICTURE_ENTRIES-1; //NAV_VIDEOSTREAMS_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  } 
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gPicture_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PictureType
                if (CacheElements ==TRUE)
                  gPicture_Type[current_element] =Indication_array[Offset];
                Offset++;
                //Handle
                if (CacheElements ==TRUE)
                  gPicture_Handle[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gPicture_Handle[current_element] +=Indication_array[Offset]*0x100;
                Offset++;
                //IPv6Address
                for(i=0; i<AUDIOSD_PICTURE_IPADDRESS_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gPicture_IpAddress[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gPicture_IpAddress[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //TCP_Port
                if (CacheElements ==TRUE)
                  gPicture_TcpPort[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gPicture_TcpPort[current_element] +=Indication_array[Offset]*0x100;
                Offset++;
                //URI
                for(i=0; i<AUDIOSD_PICTURE_URI_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gPicture_Uri[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gPicture_Uri[current_element][i] =Indication_array[Offset];
                  Offset++;
                }    
                //next element
                if (CacheElements ==TRUE)
                  gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is next element
                current_element++;
                                
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gPicture_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PictureType
                if (CacheElements ==TRUE)
                  gPicture_Type[current_element] =Indication_array[Offset];
                Offset++;
                //Handle
                if (CacheElements ==TRUE)
                  gPicture_Handle[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gPicture_Handle[current_element] +=Indication_array[Offset]*0x100;
                Offset++;
                //IPv6Address
                for(i=0; i<AUDIOSD_PICTURE_IPADDRESS_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gPicture_IpAddress[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gPicture_IpAddress[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //TCP_Port
                if (CacheElements ==TRUE)
                  gPicture_TcpPort[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gPicture_TcpPort[current_element] +=Indication_array[Offset]*0x100;
                Offset++;
                //URI
                for(i=0; i<AUDIOSD_PICTURE_URI_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gPicture_Uri[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gPicture_Uri[current_element][i] =Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element    
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;         
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gPicture_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PictureType
                if (CacheElements ==TRUE)
                  gPicture_Type[current_element] =Indication_array[Offset];
                Offset++;
                //Handle
                if (CacheElements ==TRUE)
                  gPicture_Handle[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gPicture_Handle[current_element] +=Indication_array[Offset]*0x100;
                Offset++;
                //IPv6Address
                for(i=0; i<AUDIOSD_PICTURE_IPADDRESS_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gPicture_IpAddress[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gPicture_IpAddress[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //TCP_Port
                if (CacheElements ==TRUE)
                  gPicture_TcpPort[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gPicture_TcpPort[current_element] +=Indication_array[Offset]*0x100;
                Offset++;
                //URI
                for(i=0; i<AUDIOSD_PICTURE_URI_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gPicture_Uri[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gPicture_Uri[current_element][i] =Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =0 ends
        case 1: //recordaddress =1 -> PicType, Handle, IPV6_Address, TCP_Port, URI
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;             
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gPicture_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PictureType
                if (CacheElements ==TRUE)
                  gPicture_Type[current_element] =Indication_array[Offset];
                Offset++;
                //Handle
                if (CacheElements ==TRUE)
                  gPicture_Handle[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gPicture_Handle[current_element] +=Indication_array[Offset]*0x100;
                Offset++;
                //IPv6Address
                for(i=0; i<AUDIOSD_PICTURE_IPADDRESS_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gPicture_IpAddress[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gPicture_IpAddress[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //TCP_Port
                if (CacheElements ==TRUE)
                  gPicture_TcpPort[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gPicture_TcpPort[current_element] +=Indication_array[Offset]*0x100;
                Offset++;
                //URI
                for(i=0; i<AUDIOSD_PICTURE_URI_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gPicture_Uri[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gPicture_Uri[current_element][i] =Indication_array[Offset];
                  Offset++;
                }       
                //next element
                if (CacheElements ==TRUE)
                  gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element  
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
			    	{
              current_element =AUDIOSD_PICTURE_ENTRIES-1; //NAV_VIDEOSTREAMS_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  } 
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gPicture_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PictureType
                if (CacheElements ==TRUE)
                  gPicture_Type[current_element] =Indication_array[Offset];
                Offset++;
                //Handle
                if (CacheElements ==TRUE)
                  gPicture_Handle[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gPicture_Handle[current_element] +=Indication_array[Offset]*0x100;
                Offset++;
                //IPv6Address
                for(i=0; i<AUDIOSD_PICTURE_IPADDRESS_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gPicture_IpAddress[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gPicture_IpAddress[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //TCP_Port
                if (CacheElements ==TRUE)
                  gPicture_TcpPort[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gPicture_TcpPort[current_element] +=Indication_array[Offset]*0x100;
                Offset++;
                //URI
                for(i=0; i<AUDIOSD_PICTURE_URI_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gPicture_Uri[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gPicture_Uri[current_element][i] =Indication_array[Offset];
                  Offset++;
                }    
                //next element
                if (CacheElements ==TRUE)
                  gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is next element
                current_element++;
                                
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gPicture_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PictureType
                if (CacheElements ==TRUE)
                  gPicture_Type[current_element] =Indication_array[Offset];
                Offset++;
                //Handle
                if (CacheElements ==TRUE)
                  gPicture_Handle[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gPicture_Handle[current_element] +=Indication_array[Offset]*0x100;
                Offset++;
                //IPv6Address
                for(i=0; i<AUDIOSD_PICTURE_IPADDRESS_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gPicture_IpAddress[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gPicture_IpAddress[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //TCP_Port
                if (CacheElements ==TRUE)
                  gPicture_TcpPort[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gPicture_TcpPort[current_element] +=Indication_array[Offset]*0x100;
                Offset++;
                //URI
                for(i=0; i<AUDIOSD_PICTURE_URI_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gPicture_Uri[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gPicture_Uri[current_element][i] =Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element    
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;         
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gPicture_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PictureType
                if (CacheElements ==TRUE)
                  gPicture_Type[current_element] =Indication_array[Offset];
                Offset++;
                //Handle
                if (CacheElements ==TRUE)
                  gPicture_Handle[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gPicture_Handle[current_element] +=Indication_array[Offset]*0x100;
                Offset++;
                //IPv6Address
                for(i=0; i<AUDIOSD_PICTURE_IPADDRESS_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gPicture_IpAddress[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gPicture_IpAddress[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //TCP_Port
                if (CacheElements ==TRUE)
                  gPicture_TcpPort[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gPicture_TcpPort[current_element] +=Indication_array[Offset]*0x100;
                Offset++;
                //URI
                for(i=0; i<AUDIOSD_PICTURE_URI_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gPicture_Uri[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gPicture_Uri[current_element][i] =Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =1 ends
        case 15: //recordaddress =15 -> POS 
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gPicture_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element       
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
    		    {
              current_element =AUDIOSD_PICTURE_ENTRIES-1; //NAV_VIDEOSTREAMS_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gPicture_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement;
              if (shift ==TRUE) //startelement is next element
                current_element++;
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gPicture_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element       
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gPicture_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =15 ends    
      }                             
      //Panel
      putvalue(env_ASG_AudioSD_Pic_ASGID, gPicture_ASGID);
      putvalue(env_ASG_AudioSD_Pic_TAID, gPicture_TAID);
      putvalue(env_ASG_AudioSD_Pic_TotalNumLE, gPicture_TotalNumListElements);
      
      /*
      if (gPicture_CallBackReason !=AUDIOSD_PICTURE_CALLBACKREASON_NOCALLBACK)
        Picture_ListHandling ();
      else
        Picture_display(recordaddress, transmitpos);         
      */
		break;
    case Changed_IND:
      //get data
      /***ArrayHeader***/
      mode            =(Indication_array[3] &0xF0) /0x10;
      recordaddress   =Indication_array[3] &0x0F;
      Offset =4;
      // decode "mode-byte"
      shift       =mode &0x01;
      direction   =(mode &0x02)/0x02;
      transmitpos =(mode &0x04)/0x04;
      indexsize   =(mode &0x08)/0x08;               
      if (indexsize)
      {   
        startelement =Indication_array[Offset];
        Offset++;
        startelement +=(Indication_array[Offset] *0x100);
        Offset++;
        elements =Indication_array[Offset];
        Offset++;
        elements +=(Indication_array[Offset] *0x100);
        Offset++;
      }
      else
      {   
        startelement =Indication_array[Offset];
        Offset++;
        elements =Indication_array[Offset];
        Offset++;
      }           
      if(startelement ==0 && shift==0 && transmitpos==0 && recordaddress==0 && elements==255) //check 'full range update'?
      {
        /*
        putvalue(env_ASG_NaviSD_LG_OnOff, FALSE);
        putvalue(env_ASG_NaviSD_LG_ListOpState, "'full range update' received");
        */
      }
      else if (datalength>9)
      {
        if(startelement !=0)
        {
          for (i=0;i<AUDIOSD_PICTURE_ENTRIES;i++)
          {
            if(startelement ==gPicture_Pos[i])  
              i =AUDIOSD_PICTURE_ENTRIES;              
          }
        }
        switch (recordaddress)
        {  
          case 0: //recordaddress =0 -> complete record
            if(0==startelement)
            {
              if(FORWARD==direction)  //forward-start
      		    {          
                current_element =startelement;             
                if (shift ==TRUE) //startelement is next element
                  current_element++;                 
   
                for (j=0; j<elements;j++) //copy elements
                {
                  //check, if elements must be cached and in case find position in array
                  CacheElements =FALSE;
                  for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                  {  
                    //if element already cached, find position in ASG-cache
                    if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                    {    
                      current_element =i; 
                      CacheElements   =TRUE;
                    }
                    //if not already cached, then store element only, if Cache is build-up!
                    else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                      CacheElements   =TRUE;
                  }
                  //Pos
                  if (transmitpos)
                  {   
                    if (CacheElements ==TRUE)
                        gPicture_Pos[current_element]=Indication_array[Offset];
                    Offset++;
                  }
                  //PictureType
                  if (CacheElements ==TRUE)
                    gPicture_Type[current_element] =Indication_array[Offset];
                  Offset++;
                  //Handle
                  if (CacheElements ==TRUE)
                    gPicture_Handle[current_element] =Indication_array[Offset];
                  Offset++;
                  if (CacheElements ==TRUE)
                    gPicture_Handle[current_element] +=Indication_array[Offset]*0x100;
                  Offset++;
                  //IPv6Address
                  for(i=0; i<AUDIOSD_PICTURE_IPADDRESS_LENGTH;i++) //clear
                  {
                    if (CacheElements ==TRUE)
                      gPicture_IpAddress[current_element][i] =0; 
                  }
                  length =Indication_array[Offset];
                  Offset++;                
                  for(i=0; i<length;i++) //copy data
                  {   
                    if (CacheElements ==TRUE)
                        gPicture_IpAddress[current_element][i] =Indication_array[Offset];
                    Offset++;
                  } 
                  //TCP_Port
                  if (CacheElements ==TRUE)
                    gPicture_TcpPort[current_element] =Indication_array[Offset];
                  Offset++;
                  if (CacheElements ==TRUE)
                    gPicture_TcpPort[current_element] +=Indication_array[Offset]*0x100;
                  Offset++;
                  //URI
                  for(i=0; i<AUDIOSD_PICTURE_URI_LENGTH;i++) //clear
                  {
                    if (CacheElements ==TRUE)
                      gPicture_Uri[current_element][i] =0; 
                  }
                  length =Indication_array[Offset];
                  Offset++;                
                  for(i=0; i<length;i++) //copy data
                  {   
                    if (CacheElements ==TRUE)
                        gPicture_Uri[current_element][i] =Indication_array[Offset];
                    Offset++;
                  }       
                  //next element
                  if (CacheElements ==TRUE)
                    gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                  current_element++; //go on with next element  
                }   //copy data of current element finished
              }       //forward ends
              if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
  			    	{
                current_element =AUDIOSD_PICTURE_ENTRIES-1; //NAV_VIDEOSTREAMS_ENTRIES =8, but range: 0...7!
                for (j=0; j<elements;j++) //copy elements
                {
                  //check, if elements must be cached and in case find position in array
                  CacheElements =FALSE;
                  for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                  {  
                    //if element already cached, find position in ASG-cache
                    if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                    {    
                      current_element =i; 
                      CacheElements   =TRUE;
                    } 
                    //if not already cached, then store element only, if Cache is build-up!
                    else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                      CacheElements   =TRUE;
                  }
                  //Pos
                  if (transmitpos)
                  {   
                    if (CacheElements ==TRUE)
                      gPicture_Pos[current_element]=Indication_array[Offset];
                    Offset++;
                  }
                  //PictureType
                  if (CacheElements ==TRUE)
                    gPicture_Type[current_element] =Indication_array[Offset];
                  Offset++;
                  //Handle
                  if (CacheElements ==TRUE)
                    gPicture_Handle[current_element] =Indication_array[Offset];
                  Offset++;
                  if (CacheElements ==TRUE)
                    gPicture_Handle[current_element] +=Indication_array[Offset]*0x100;
                  Offset++;
                  //IPv6Address
                  for(i=0; i<AUDIOSD_PICTURE_IPADDRESS_LENGTH;i++) //clear
                  {
                    if (CacheElements ==TRUE)
                      gPicture_IpAddress[current_element][i] =0; 
                  }
                  length =Indication_array[Offset];
                  Offset++;                
                  for(i=0; i<length;i++) //copy data
                  {   
                    if (CacheElements ==TRUE)
                        gPicture_IpAddress[current_element][i] =Indication_array[Offset];
                    Offset++;
                  } 
                  //TCP_Port
                  if (CacheElements ==TRUE)
                    gPicture_TcpPort[current_element] =Indication_array[Offset];
                  Offset++;
                  if (CacheElements ==TRUE)
                    gPicture_TcpPort[current_element] +=Indication_array[Offset]*0x100;
                  Offset++;
                  //URI
                  for(i=0; i<AUDIOSD_PICTURE_URI_LENGTH;i++) //clear
                  {
                    if (CacheElements ==TRUE)
                      gPicture_Uri[current_element][i] =0; 
                  }
                  length =Indication_array[Offset];
                  Offset++;                
                  for(i=0; i<length;i++) //copy data
                  {   
                    if (CacheElements ==TRUE)
                        gPicture_Uri[current_element][i] =Indication_array[Offset];
                    Offset++;
                  }    
                  //next element
                  if (CacheElements ==TRUE)
                    gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                  current_element--;
                }   //copy data of current element finished                     
              }       //backward ends
            }          //startelement=0 ends
            else if (startelement !=0) //startelement !=0
            {
              if(FORWARD==direction)  //forward-start
      		    {
                current_element =startelement; 
                if (shift ==TRUE) //startelement is next element
                  current_element++;
                                  
                for (j=0; j<elements;j++) //copy elements
                {
                  //check, if elements must be cached and in case find position in array
                  CacheElements =FALSE;
                  for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                  {  
                    //if element already cached, find position in ASG-cache
                    if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                    {    
                      current_element =i; 
                      CacheElements   =TRUE;
                    }
                    //if not already cached, then store element only, if Cache is build-up!
                    else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                      CacheElements   =TRUE;
                  }
                  //Pos
                  if (transmitpos)
                  {   
                    if (CacheElements ==TRUE)
                      gPicture_Pos[current_element]=Indication_array[Offset];
                    Offset++;
                  }
                  //PictureType
                  if (CacheElements ==TRUE)
                    gPicture_Type[current_element] =Indication_array[Offset];
                  Offset++;
                  //Handle
                  if (CacheElements ==TRUE)
                    gPicture_Handle[current_element] =Indication_array[Offset];
                  Offset++;
                  if (CacheElements ==TRUE)
                    gPicture_Handle[current_element] +=Indication_array[Offset]*0x100;
                  Offset++;
                  //IPv6Address
                  for(i=0; i<AUDIOSD_PICTURE_IPADDRESS_LENGTH;i++) //clear
                  {
                    if (CacheElements ==TRUE)
                      gPicture_IpAddress[current_element][i] =0; 
                  }
                  length =Indication_array[Offset];
                  Offset++;                
                  for(i=0; i<length;i++) //copy data
                  {   
                    if (CacheElements ==TRUE)
                        gPicture_IpAddress[current_element][i] =Indication_array[Offset];
                    Offset++;
                  } 
                  //TCP_Port
                  if (CacheElements ==TRUE)
                    gPicture_TcpPort[current_element] =Indication_array[Offset];
                  Offset++;
                  if (CacheElements ==TRUE)
                    gPicture_TcpPort[current_element] +=Indication_array[Offset]*0x100;
                  Offset++;
                  //URI
                  for(i=0; i<AUDIOSD_PICTURE_URI_LENGTH;i++) //clear
                  {
                    if (CacheElements ==TRUE)
                      gPicture_Uri[current_element][i] =0; 
                  }
                  length =Indication_array[Offset];
                  Offset++;                
                  for(i=0; i<length;i++) //copy data
                  {   
                    if (CacheElements ==TRUE)
                        gPicture_Uri[current_element][i] =Indication_array[Offset];
                    Offset++;
                  }
                  //next element
                  if (CacheElements ==TRUE)
                    gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                  current_element++; //go on with next element    
                }   //copy data of current element finished
              }       //forward ends
              else if(BACKWARD==direction)
              {
                current_element =startelement; 
                if (shift ==TRUE) //startelement is previous element
                  current_element--;         
                for (j=0; j<elements;j++) //copy elements
                {
                  //check, if elements must be cached and in case find position in array
                  CacheElements =FALSE;
                  for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                  {  
                    //if element already cached, find position in ASG-cache
                    if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                    {    
                      current_element =i; 
                      CacheElements   =TRUE;
                    }
                    //if not already cached, then store element only, if Cache is build-up!
                    else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                      CacheElements   =TRUE;
                  }
                  //Pos
                  if (transmitpos)
                  {   
                    if (CacheElements ==TRUE)
                      gPicture_Pos[current_element]=Indication_array[Offset];
                    Offset++;
                  }
                  //PictureType
                  if (CacheElements ==TRUE)
                    gPicture_Type[current_element] =Indication_array[Offset];
                  Offset++;
                  //Handle
                  if (CacheElements ==TRUE)
                    gPicture_Handle[current_element] =Indication_array[Offset];
                  Offset++;
                  if (CacheElements ==TRUE)
                    gPicture_Handle[current_element] +=Indication_array[Offset]*0x100;
                  Offset++;
                  //IPv6Address
                  for(i=0; i<AUDIOSD_PICTURE_IPADDRESS_LENGTH;i++) //clear
                  {
                    if (CacheElements ==TRUE)
                      gPicture_IpAddress[current_element][i] =0; 
                  }
                  length =Indication_array[Offset];
                  Offset++;                
                  for(i=0; i<length;i++) //copy data
                  {   
                    if (CacheElements ==TRUE)
                        gPicture_IpAddress[current_element][i] =Indication_array[Offset];
                    Offset++;
                  } 
                  //TCP_Port
                  if (CacheElements ==TRUE)
                    gPicture_TcpPort[current_element] =Indication_array[Offset];
                  Offset++;
                  if (CacheElements ==TRUE)
                    gPicture_TcpPort[current_element] +=Indication_array[Offset]*0x100;
                  Offset++;
                  //URI
                  for(i=0; i<AUDIOSD_PICTURE_URI_LENGTH;i++) //clear
                  {
                    if (CacheElements ==TRUE)
                      gPicture_Uri[current_element][i] =0; 
                  }
                  length =Indication_array[Offset];
                  Offset++;                
                  for(i=0; i<length;i++) //copy data
                  {   
                    if (CacheElements ==TRUE)
                        gPicture_Uri[current_element][i] =Indication_array[Offset];
                    Offset++;
                  }
                  //next element
                  if (CacheElements ==TRUE)
                    gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                  current_element--;
                }   //copy data of current element finished                                 
              }
            }          //startelement !=0 ends
          break;         //recordaddress =0 ends
          case 1: //recordaddress =1 -> PictureType, Handle, IPV6_Address, TCP_Port, URI
            if(0==startelement)
            {
              if(FORWARD==direction)  //forward-start
      		    {          
                current_element =startelement;             
                if (shift ==TRUE) //startelement is next element
                  current_element++;                 
   
                for (j=0; j<elements;j++) //copy elements
                {
                  //check, if elements must be cached and in case find position in array
                  CacheElements =FALSE;
                  for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                  {  
                    //if element already cached, find position in ASG-cache
                    if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                    {    
                      current_element =i; 
                      CacheElements   =TRUE;
                    }
                    //if not already cached, then store element only, if Cache is build-up!
                    else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                      CacheElements   =TRUE;
                  }
                  //Pos
                  if (transmitpos)
                  {   
                    if (CacheElements ==TRUE)
                        gPicture_Pos[current_element]=Indication_array[Offset];
                    Offset++;
                  }
                  //PictureType
                  if (CacheElements ==TRUE)
                    gPicture_Type[current_element] =Indication_array[Offset];
                  Offset++;
                  //Handle
                  if (CacheElements ==TRUE)
                    gPicture_Handle[current_element] =Indication_array[Offset];
                  Offset++;
                  if (CacheElements ==TRUE)
                    gPicture_Handle[current_element] +=Indication_array[Offset]*0x100;
                  Offset++;
                  //IPv6Address
                  for(i=0; i<AUDIOSD_PICTURE_IPADDRESS_LENGTH;i++) //clear
                  {
                    if (CacheElements ==TRUE)
                      gPicture_IpAddress[current_element][i] =0; 
                  }
                  length =Indication_array[Offset];
                  Offset++;                
                  for(i=0; i<length;i++) //copy data
                  {   
                    if (CacheElements ==TRUE)
                        gPicture_IpAddress[current_element][i] =Indication_array[Offset];
                    Offset++;
                  } 
                  //TCP_Port
                  if (CacheElements ==TRUE)
                    gPicture_TcpPort[current_element] =Indication_array[Offset];
                  Offset++;
                  if (CacheElements ==TRUE)
                    gPicture_TcpPort[current_element] +=Indication_array[Offset]*0x100;
                  Offset++;
                  //URI
                  for(i=0; i<AUDIOSD_PICTURE_URI_LENGTH;i++) //clear
                  {
                    if (CacheElements ==TRUE)
                      gPicture_Uri[current_element][i] =0; 
                  }
                  length =Indication_array[Offset];
                  Offset++;                
                  for(i=0; i<length;i++) //copy data
                  {   
                    if (CacheElements ==TRUE)
                        gPicture_Uri[current_element][i] =Indication_array[Offset];
                    Offset++;
                  }       
                  //next element
                  if (CacheElements ==TRUE)
                    gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                  current_element++; //go on with next element  
                }   //copy data of current element finished
              }       //forward ends
              if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
  			    	{
                current_element =AUDIOSD_PICTURE_ENTRIES-1; //NAV_VIDEOSTREAMS_ENTRIES =8, but range: 0...7!
                for (j=0; j<elements;j++) //copy elements
                {
                  //check, if elements must be cached and in case find position in array
                  CacheElements =FALSE;
                  for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                  {  
                    //if element already cached, find position in ASG-cache
                    if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                    {    
                      current_element =i; 
                      CacheElements   =TRUE;
                    } 
                    //if not already cached, then store element only, if Cache is build-up!
                    else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                      CacheElements   =TRUE;
                  }
                  //Pos
                  if (transmitpos)
                  {   
                    if (CacheElements ==TRUE)
                      gPicture_Pos[current_element]=Indication_array[Offset];
                    Offset++;
                  }
                  //PictureType
                  if (CacheElements ==TRUE)
                    gPicture_Type[current_element] =Indication_array[Offset];
                  Offset++;
                  //Handle
                  if (CacheElements ==TRUE)
                    gPicture_Handle[current_element] =Indication_array[Offset];
                  Offset++;
                  if (CacheElements ==TRUE)
                    gPicture_Handle[current_element] +=Indication_array[Offset]*0x100;
                  Offset++;
                  //IPv6Address
                  for(i=0; i<AUDIOSD_PICTURE_IPADDRESS_LENGTH;i++) //clear
                  {
                    if (CacheElements ==TRUE)
                      gPicture_IpAddress[current_element][i] =0; 
                  }
                  length =Indication_array[Offset];
                  Offset++;                
                  for(i=0; i<length;i++) //copy data
                  {   
                    if (CacheElements ==TRUE)
                        gPicture_IpAddress[current_element][i] =Indication_array[Offset];
                    Offset++;
                  } 
                  //TCP_Port
                  if (CacheElements ==TRUE)
                    gPicture_TcpPort[current_element] =Indication_array[Offset];
                  Offset++;
                  if (CacheElements ==TRUE)
                    gPicture_TcpPort[current_element] +=Indication_array[Offset]*0x100;
                  Offset++;
                  //URI
                  for(i=0; i<AUDIOSD_PICTURE_URI_LENGTH;i++) //clear
                  {
                    if (CacheElements ==TRUE)
                      gPicture_Uri[current_element][i] =0; 
                  }
                  length =Indication_array[Offset];
                  Offset++;                
                  for(i=0; i<length;i++) //copy data
                  {   
                    if (CacheElements ==TRUE)
                        gPicture_Uri[current_element][i] =Indication_array[Offset];
                    Offset++;
                  }    
                  //next element
                  if (CacheElements ==TRUE)
                    gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                  current_element--;
                }   //copy data of current element finished                     
              }       //backward ends
            }          //startelement=0 ends
            else if (startelement !=0) //startelement !=0
            {
              if(FORWARD==direction)  //forward-start
      		    {
                current_element =startelement; 
                if (shift ==TRUE) //startelement is next element
                  current_element++;
                                  
                for (j=0; j<elements;j++) //copy elements
                {
                  //check, if elements must be cached and in case find position in array
                  CacheElements =FALSE;
                  for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                  {  
                    //if element already cached, find position in ASG-cache
                    if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                    {    
                      current_element =i; 
                      CacheElements   =TRUE;
                    }
                    //if not already cached, then store element only, if Cache is build-up!
                    else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                      CacheElements   =TRUE;
                  }
                  //Pos
                  if (transmitpos)
                  {   
                    if (CacheElements ==TRUE)
                      gPicture_Pos[current_element]=Indication_array[Offset];
                    Offset++;
                  }
                  //PictureType
                  if (CacheElements ==TRUE)
                    gPicture_Type[current_element] =Indication_array[Offset];
                  Offset++;
                  //Handle
                  if (CacheElements ==TRUE)
                    gPicture_Handle[current_element] =Indication_array[Offset];
                  Offset++;
                  if (CacheElements ==TRUE)
                    gPicture_Handle[current_element] +=Indication_array[Offset]*0x100;
                  Offset++;
                  //IPv6Address
                  for(i=0; i<AUDIOSD_PICTURE_IPADDRESS_LENGTH;i++) //clear
                  {
                    if (CacheElements ==TRUE)
                      gPicture_IpAddress[current_element][i] =0; 
                  }
                  length =Indication_array[Offset];
                  Offset++;                
                  for(i=0; i<length;i++) //copy data
                  {   
                    if (CacheElements ==TRUE)
                        gPicture_IpAddress[current_element][i] =Indication_array[Offset];
                    Offset++;
                  } 
                  //TCP_Port
                  if (CacheElements ==TRUE)
                    gPicture_TcpPort[current_element] =Indication_array[Offset];
                  Offset++;
                  if (CacheElements ==TRUE)
                    gPicture_TcpPort[current_element] +=Indication_array[Offset]*0x100;
                  Offset++;
                  //URI
                  for(i=0; i<AUDIOSD_PICTURE_URI_LENGTH;i++) //clear
                  {
                    if (CacheElements ==TRUE)
                      gPicture_Uri[current_element][i] =0; 
                  }
                  length =Indication_array[Offset];
                  Offset++;                
                  for(i=0; i<length;i++) //copy data
                  {   
                    if (CacheElements ==TRUE)
                        gPicture_Uri[current_element][i] =Indication_array[Offset];
                    Offset++;
                  }
                  //next element
                  if (CacheElements ==TRUE)
                    gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                  current_element++; //go on with next element    
                }   //copy data of current element finished
              }       //forward ends
              else if(BACKWARD==direction)
              {
                current_element =startelement; 
                if (shift ==TRUE) //startelement is previous element
                  current_element--;         
                for (j=0; j<elements;j++) //copy elements
                {
                  //check, if elements must be cached and in case find position in array
                  CacheElements =FALSE;
                  for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                  {  
                    //if element already cached, find position in ASG-cache
                    if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                    {    
                      current_element =i; 
                      CacheElements   =TRUE;
                    }
                    //if not already cached, then store element only, if Cache is build-up!
                    else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                      CacheElements   =TRUE;
                  }
                  //Pos
                  if (transmitpos)
                  {   
                    if (CacheElements ==TRUE)
                      gPicture_Pos[current_element]=Indication_array[Offset];
                    Offset++;
                  }
                  //PictureType
                  if (CacheElements ==TRUE)
                    gPicture_Type[current_element] =Indication_array[Offset];
                  Offset++;
                  //Handle
                  if (CacheElements ==TRUE)
                    gPicture_Handle[current_element] =Indication_array[Offset];
                  Offset++;
                  if (CacheElements ==TRUE)
                    gPicture_Handle[current_element] +=Indication_array[Offset]*0x100;
                  Offset++;
                  //IPv6Address
                  for(i=0; i<AUDIOSD_PICTURE_IPADDRESS_LENGTH;i++) //clear
                  {
                    if (CacheElements ==TRUE)
                      gPicture_IpAddress[current_element][i] =0; 
                  }
                  length =Indication_array[Offset];
                  Offset++;                
                  for(i=0; i<length;i++) //copy data
                  {   
                    if (CacheElements ==TRUE)
                        gPicture_IpAddress[current_element][i] =Indication_array[Offset];
                    Offset++;
                  } 
                  //TCP_Port
                  if (CacheElements ==TRUE)
                    gPicture_TcpPort[current_element] =Indication_array[Offset];
                  Offset++;
                  if (CacheElements ==TRUE)
                    gPicture_TcpPort[current_element] +=Indication_array[Offset]*0x100;
                  Offset++;
                  //URI
                  for(i=0; i<AUDIOSD_PICTURE_URI_LENGTH;i++) //clear
                  {
                    if (CacheElements ==TRUE)
                      gPicture_Uri[current_element][i] =0; 
                  }
                  length =Indication_array[Offset];
                  Offset++;                
                  for(i=0; i<length;i++) //copy data
                  {   
                    if (CacheElements ==TRUE)
                        gPicture_Uri[current_element][i] =Indication_array[Offset];
                    Offset++;
                  }
                  //next element
                  if (CacheElements ==TRUE)
                    gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                  current_element--;
                }   //copy data of current element finished                                 
              }
            }          //startelement !=0 ends
          break;         //recordaddress =1 ends
          case 15: //recordaddress =15 -> POS 
            if(0==startelement)
            {
              if(FORWARD==direction)  //forward-start
      		    {          
                current_element =startelement;
                if (shift ==TRUE) //startelement is next element
                  current_element++;                 
                for (j=0; j<elements;j++) //copy elements
                {
                  //check, if elements must be cached and in case find position in array
                  CacheElements =FALSE;
                  for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                  {  
                    //if element already cached, find position in ASG-cache
                    if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                    {    
                      current_element =i; 
                      CacheElements   =TRUE;
                    }
                    //if not already cached, then store element only, if Cache is build-up!
                    else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                      CacheElements   =TRUE;
                  }
                  //Pos
                  if (transmitpos)
                  {   
                    if (CacheElements ==TRUE)
                      gPicture_Pos[current_element]=Indication_array[Offset];
                    Offset++;
                  }
                  //next element
                  if (CacheElements ==TRUE)
                    gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                  current_element++; //go on with next element       
                }   //copy data of current element finished
              }       //forward ends
              if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
      		    {
                current_element =AUDIOSD_PICTURE_ENTRIES-1; //NAV_VIDEOSTREAMS_ENTRIES =8, but range: 0...7!
                for (j=0; j<elements;j++) //copy elements
                {
                  //check, if elements must be cached and in case find position in array
                  CacheElements =FALSE;
                  for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                  {  
                    //if element already cached, find position in ASG-cache
                    if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                    {    
                      current_element =i; 
                      CacheElements   =TRUE;
                    }
                    //if not already cached, then store element only, if Cache is build-up!
                    else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                      CacheElements   =TRUE;
                  }
                  //Pos
                  if (transmitpos)
                  {   
                    if (CacheElements ==TRUE)
                      gPicture_Pos[current_element]=Indication_array[Offset];
                    Offset++;
                  }
                  //next element
                  if (CacheElements ==TRUE)
                    gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                  current_element--;
                }   //copy data of current element finished                     
              }       //backward ends
            }          //startelement=0 ends
            else if (startelement !=0) //startelement !=0
            {
              if(FORWARD==direction)  //forward-start
      		    {
                current_element =startelement;
                if (shift ==TRUE) //startelement is next element
                  current_element++;
                for (j=0; j<elements;j++) //copy elements
                {
                  //check, if elements must be cached and in case find position in array
                  CacheElements =FALSE;
                  for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                  {  
                    //if element already cached, find position in ASG-cache
                    if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                    {    
                      current_element =i; 
                      CacheElements   =TRUE;
                    }
                    //if not already cached, then store element only, if Cache is build-up!
                    else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                      CacheElements   =TRUE;
                  }
                  //Pos
                  if (transmitpos)
                  {   
                    if (CacheElements ==TRUE)
                      gPicture_Pos[current_element]=Indication_array[Offset];
                    Offset++;
                  }
                  //next element
                  if (CacheElements ==TRUE)
                    gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                  current_element++; //go on with next element       
                }   //copy data of current element finished
              }       //forward ends
              else if(BACKWARD==direction)
              {
                current_element =startelement; 
                if (shift ==TRUE) //startelement is previous element
                  current_element--;
                for (j=0; j<elements;j++) //copy elements
                {
                  //check, if elements must be cached and in case find position in array
                  CacheElements =FALSE;
                  for (i=0; i<AUDIOSD_PICTURE_ENTRIES; i++)
                  {  
                    //if element already cached, find position in ASG-cache
                    if((transmitpos ==1) && Indication_array[Offset] ==gPicture_Pos[i] && gPicture_ListEntryReceptionInformation[i] ==TRUE)
                    {    
                      current_element =i; 
                      CacheElements   =TRUE;
                    }
                    //if not already cached, then store element only, if Cache is build-up!
                    else if((gPicture_ListHandlingType !=AUDIO_PICTURE_NOCACHE))
                      CacheElements   =TRUE;
                  }
                  //Pos
                  if (transmitpos)
                  {   
                    if (CacheElements ==TRUE)
                      gPicture_Pos[current_element]=Indication_array[Offset];
                    Offset++;
                  }
                  //next element
                  if (CacheElements ==TRUE)
                    gPicture_ListEntryReceptionInformation [current_element] =TRUE;
                  current_element--;
                }   //copy data of current element finished                                 
              }
            }          //startelement !=0 ends
          break;         //recordaddress =15 ends    
        }
      }
    break;            
    case Error_IND:	
			if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
				writelineEx(gError_Trace, 0, "ASG-AudioSD Indication_Picture: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
			else if(Indication_array[3]<0x30 && Indication_array[3] !=0)			//BPL-error
				writelineEx(gError_Trace, 0, "ASG-AudioSD Indication_Picture: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
			else if(Indication_array[3]<0x40 && Indication_array[3] !=0)			//BAL-error
				writelineEx(gError_Trace, 0, "ASG-AudioSD Indication_Picture: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
			else
				writelineEx(gError_Trace, 0, "ASG-AudioSD Indication_Picture: Application-Error: 0x%x", Indication_array[3]);
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD Indication_Picture: unknown indication %x", gBAP_Indication[2]);
		break;
	}  
  //for "sliding window concept"
  /*  
  if(gPicture_TotalNumListElements<=AUDIOSD_PICTURE_ENTRIES)
        gPicture_SlidingWindow_State =AUDIO_PICTURE_SLIDINGWINDOW_NOTACTIVE;
    else
        gPicture_SlidingWindow_State =AUDIO_PICTURE_SLIDINGWINDOW_ACTIVE;

    if (gPicture_CallBackReason !=AUDIO_PICTURE_CALLBACKREASON_NOCALLBACK)
    {
      write("Pic: handling");  
      Picture_ListHandling ();
    }
    else
    {
      write("Pic: display");
      Picture_display();
    }
  */
}

on envVar env_ASG_AudioSD_LSL_GetArray
{
  byte mode, shift, direction, transmitpos, indexsize,recordaddress;
  word requested_startelement, startelement, elements;
  
  // Init local variables. 
  mode                    =0;
  shift                   =0;
  direction               =0;
  transmitpos             =0;
  indexsize               =0;
  recordaddress           =0;
  requested_startelement  =0;
  startelement            =0;
  elements                =0;

  if(POWER_ON==gASG_PowerOnOff && getvalue(this))
	{
    gLSL_ASGID                  =getvalue(env_ASG_AudioSD_LSL_ASGID);
    gLSL_TAID                   =getvalue(env_ASG_AudioSD_LSL_TAID);;
    shift                           =getvalue(env_ASG_AudioSD_LSL_AH_shift);;
    direction                       =getvalue(env_ASG_AudioSD_LSL_AH_dir);;
    transmitpos                     =getvalue(env_ASG_AudioSD_LSL_AH_PosTrans);;
    indexsize                       =getvalue(env_ASG_AudioSD_LSL_AH_IS);;
    recordaddress                   =getvalue(env_ASG_AudioSD_LSL_AH_RA);;
    startelement                    =getvalue(env_ASG_AudioSD_LSL_AH_start);;
    elements                        =getvalue(env_ASG_AudioSD_LSL_AH_elements);;
    
    requested_startelement  =startelement;
    mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;
    //writeEX(gBAP_Trace, 0, "GetArray_indexSize %x",indexsize); //debug
    LastStationList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
  }
}

void LastStationList_Request(byte request, byte mode, byte recordaddress, word requested_startelement, word startelement, word elements)
{   
  int  i;
  dword requestarray [BAP_BUFFER_SIZE];
  byte Offset;
  word indexsize;

  // Init local variables. 
  for(i=0;i<BAP_BUFFER_SIZE;i++)
    requestarray [i]=0;
  
  indexsize   =0;
  Offset      =0;

  // decode "mode-byte"
  indexsize   =(mode &0x08)/0x08; 

  // Handle request.
  requestarray[0] =LSG_AudioSD;	    //LSG-ID
	requestarray[1] =FctID_LastStationList;	//Fct.-ID
	requestarray[2] =request;           //request type

  switch(request)
	{
    case DataGet_REQ:              
      requestarray[3] =((gLSL_ASGID *0x10) &0xF0) +(gLSL_TAID &0x0F);      
      /***ArrayHeader***/
	    requestarray[4] =((mode *0x10) &0xF0) +(recordaddress &0x0F);          
      Offset =5;
      if(indexsize)
      {
        requestarray[Offset] =requested_startelement &0x00FF;
        Offset++;
        requestarray[Offset] =(requested_startelement &0xFF00) /0x100;
        Offset++;  
        requestarray[Offset] =elements &0x00FF;
        Offset++;
        requestarray[Offset] =(elements &0xFF00) /0x100;
        Offset++;       
        //writeEX(gBAP_Trace, 0, "ASG_Request_indexSize_16bit %x",indexsize); //debug
      }
      else
      {
        requestarray[Offset] =requested_startelement;
        Offset++;
        requestarray[Offset] =elements;
        Offset++;
        //writeEX(gBAP_Trace, 0, "ASG_Request_indexSize_8bit %x",indexsize); //debug
      }
      set_status_requestbuffer (requestarray, Offset, Bap_ByteSequence);
    break;
    default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD LastStationList_Picture: invalid request %d", request);
		break;
  }
}

void LastStationList_Indication(dword Indication_array [], int datalength)
{
  byte mode, direction, shift, recordaddress, transmitpos, length, indexsize, CacheElements;
  word startelement, elements, current_element;
  int i =0, j=0, Offset =0;
  
  // Init local variables
  mode                    =0;
  direction               =0;
  shift                   =0;
  recordaddress           =0;
  startelement            =0;
  elements                =0;
  current_element         =0;
  transmitpos             =0;
  length                  =0;
  CacheElements =FALSE;
  
  write("Debug: LastStationList_Indication -> ind-type=%d",gBAP_Indication[2]);
  
	switch (gBAP_Indication[2])
	{
		case Data_IND:
		//get data
      gLSL_ASGID =(Indication_array[3] &0xF0) /0x10;
      gLSL_TAID  =Indication_array[3] &0x0F; 
      gLSL_TotalNumListElements =Indication_array[4];
      /***ArrayHeader***/
      mode            =(Indication_array[5] &0xF0) /0x10;
      recordaddress   =Indication_array[5] &0x0F;
      startelement    =Indication_array[6];
      elements        =Indication_array[7];
      Offset =8;
      // decode "mode-byte"
      shift       =mode &0x01;
      direction   =(mode &0x02)/0x02;
      transmitpos =(mode &0x04)/0x04;
      indexsize   =(mode &0x08)/0x08;             
 
      if(startelement !=0)
      {
        for (i=0;i<AUDIO_LSL_ASGCACHE_MAX_SIZE;i++)
        {
          if(startelement ==gLSL_Pos[i])  
            i =AUDIO_LSL_ASGCACHE_MAX_SIZE;              
        }
      }
      switch (recordaddress)
      { 
        case 1: //recordaddress =1 -> PresetIndex, Waveband, Attributes, Name, Frequency
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;             
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gLSL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Attributes
                if (CacheElements ==TRUE)
                  gLSL_Attributes[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gLSL_Attributes[current_element] +=Indication_array[Offset] *0x100;
                Offset++;
                LastStationList_GetAttributesBits(current_element);
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_LSL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element  
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
			    	{
              current_element =AUDIO_LSL_ASGCACHE_MAX_SIZE-1; //AUDIO_LSL_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  } 
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gLSL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Attributes
                if (CacheElements ==TRUE)
                  gLSL_Attributes[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gLSL_Attributes[current_element] +=Indication_array[Offset] *0x100;
                Offset++;
                LastStationList_GetAttributesBits(current_element);
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_LSL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is next element
                current_element++;
                                
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gLSL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Attributes
                if (CacheElements ==TRUE)
                  gLSL_Attributes[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gLSL_Attributes[current_element] +=Indication_array[Offset] *0x100;
                Offset++;
                LastStationList_GetAttributesBits(current_element);
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_LSL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element    
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;         
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gLSL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Attributes
                if (CacheElements ==TRUE)
                  gLSL_Attributes[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gLSL_Attributes[current_element] +=Indication_array[Offset] *0x100;
                Offset++;
                LastStationList_GetAttributesBits(current_element);
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_LSL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =1 ends
        case 2: //recordaddress =2 -> PresetIndex, Waveband, Name
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;             
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gLSL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element  
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
			    	{
              current_element =AUDIO_LSL_ASGCACHE_MAX_SIZE-1; //AUDIO_LSL_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  } 
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gLSL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is next element
                current_element++;
                                
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gLSL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element    
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;         
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gLSL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =2 ends
        case 3: //recordaddress =3 -> PresetIndex, Name, Frequency
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;             
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_LSL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element  
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
			    	{
              current_element =AUDIO_LSL_ASGCACHE_MAX_SIZE-1; //AUDIO_LSL_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  } 
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_LSL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is next element
                current_element++;
                                
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_LSL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element    
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;         
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_LSL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =3 ends  
        case 15: //recordaddress =15 -> POS 
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element       
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
    		    {
              current_element =AUDIO_LSL_ASGCACHE_MAX_SIZE-1; //NAV_VIDEOSTREAMS_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement;
              if (shift ==TRUE) //startelement is next element
                current_element++;
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element       
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =15 ends    
      }                             
      //Panel
      putvalue(env_ASG_AudioSD_LSL_ASGID, gLSL_ASGID);
      putvalue(env_ASG_AudioSD_LSL_TAID, gLSL_TAID);
      putvalue(env_ASG_AudioSD_LSL_TotalNumLE, gLSL_TotalNumListElements);
      
      /*
      if (gLSL_CallBackReason !=AUDIO_LSL_CALLBACKREASON_NOCALLBACK)
        LSL_ListHandling ();
      else
        LSL_display(recordaddress, transmitpos);         
      */
		break;
    case Changed_IND:
      //get data
      /***ArrayHeader***/
      mode            =(Indication_array[3] &0xF0) /0x10;
      recordaddress   =Indication_array[3] &0x0F;
      Offset =4;
      // decode "mode-byte"
      shift       =mode &0x01;
      direction   =(mode &0x02)/0x02;
      transmitpos =(mode &0x04)/0x04;
      indexsize   =(mode &0x08)/0x08;               
      if (indexsize)
      {   
        startelement =Indication_array[Offset];
        Offset++;
        startelement +=(Indication_array[Offset] *0x100);
        Offset++;
        elements =Indication_array[Offset];
        Offset++;
        elements +=(Indication_array[Offset] *0x100);
        Offset++;
      }
      else
      {   
        startelement =Indication_array[Offset];
        Offset++;
        elements =Indication_array[Offset];
        Offset++;
      }           
      if(startelement ==0 && shift==0 && transmitpos==0 && recordaddress==0 && elements==255) //check 'full range update'?
      {
        /*
        putvalue(env_ASG_NaviSD_LG_OnOff, FALSE);
        putvalue(env_ASG_NaviSD_LG_ListOpState, "'full range update' received");
        */
      }
      else if (datalength>9)
      {
        if(startelement !=0)
        {
          for (i=0;i<AUDIO_LSL_ASGCACHE_MAX_SIZE;i++)
          {
            if(startelement ==gLSL_Pos[i])  
              i =AUDIO_LSL_ASGCACHE_MAX_SIZE;              
          }
        }
        switch (recordaddress)
        {  
          case 1: //recordaddress =1 -> PresetIndex, Waveband, Attributes, Name, Frequency
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;             
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gLSL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Attributes
                if (CacheElements ==TRUE)
                  gLSL_Attributes[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gLSL_Attributes[current_element] +=Indication_array[Offset] *0x100;
                Offset++;
                LastStationList_GetAttributesBits(current_element);
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_LSL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element  
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
			    	{
              current_element =AUDIO_LSL_ASGCACHE_MAX_SIZE-1; //AUDIO_LSL_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  } 
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gLSL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Attributes
                if (CacheElements ==TRUE)
                  gLSL_Attributes[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gLSL_Attributes[current_element] +=Indication_array[Offset] *0x100;
                Offset++;
                LastStationList_GetAttributesBits(current_element);
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_LSL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is next element
                current_element++;
                                
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gLSL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Attributes
                if (CacheElements ==TRUE)
                  gLSL_Attributes[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gLSL_Attributes[current_element] +=Indication_array[Offset] *0x100;
                Offset++;
                LastStationList_GetAttributesBits(current_element);
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_LSL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element    
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;         
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gLSL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Attributes
                if (CacheElements ==TRUE)
                  gLSL_Attributes[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gLSL_Attributes[current_element] +=Indication_array[Offset] *0x100;
                Offset++;
                LastStationList_GetAttributesBits(current_element);
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_LSL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =1 ends
        case 2: //recordaddress =2 -> PresetIndex, Waveband, Name
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;             
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gLSL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element  
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
			    	{
              current_element =AUDIO_LSL_ASGCACHE_MAX_SIZE-1; //AUDIO_LSL_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  } 
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gLSL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is next element
                current_element++;
                                
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gLSL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element    
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;         
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gLSL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =2 ends
        case 3: //recordaddress =3 -> PresetIndex, Name, Frequency
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;             
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_LSL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element  
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
			    	{
              current_element =AUDIO_LSL_ASGCACHE_MAX_SIZE-1; //AUDIO_LSL_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  } 
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_LSL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is next element
                current_element++;
                                
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
