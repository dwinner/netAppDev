                     break; //recordaddress =2 ends
                    
                    case 3: //recordaddress =3 -> Attributes
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSourceList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSourceList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSourceList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSourceList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSourceList_ListHandlingType !=AUDIO_SOURCELIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        
                                        gSourceList_Attributes_BuiltIn_Bit0[current_element]    =(gSourceList_Attributes[current_element] &0x01);
                                        gSourceList_Attributes_MediaError_Bit1[current_element] =(gSourceList_Attributes[current_element] &0x02) /0x02;
                                        gSourceList_Attributes_MediaPlay_Bit2[current_element]  =(gSourceList_Attributes[current_element] &0x04) /0x04; 
                                        gSourceList_Attributes_MediaRead_Bit3[current_element]  =(gSourceList_Attributes[current_element] &0x08) /0x08;
                                        gSourceList_Attributes_MediaLoad_Bit4[current_element]  =(gSourceList_Attributes[current_element] &0x10) /0x10;
                                        gSourceList_Attributes_ImportRun_Bit5[current_element]  =(gSourceList_Attributes[current_element] &0x20) /0x20;
                                        gSourceList_Attributes_MediaSupp_Bit6[current_element]  =(gSourceList_Attributes[current_element] &0x40) /0x40;                                         
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSourceList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSourceList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        
                                        gSourceList_Attributes_BuiltIn_Bit0[current_element]    =(gSourceList_Attributes[current_element] &0x01);
                                        gSourceList_Attributes_MediaError_Bit1[current_element] =(gSourceList_Attributes[current_element] &0x02) /0x02;
                                        gSourceList_Attributes_MediaPlay_Bit2[current_element]  =(gSourceList_Attributes[current_element] &0x04) /0x04; 
                                        gSourceList_Attributes_MediaRead_Bit3[current_element]  =(gSourceList_Attributes[current_element] &0x08) /0x08;
                                        gSourceList_Attributes_MediaLoad_Bit4[current_element]  =(gSourceList_Attributes[current_element] &0x10) /0x10;
                                        gSourceList_Attributes_ImportRun_Bit5[current_element]  =(gSourceList_Attributes[current_element] &0x20) /0x20;
                                        gSourceList_Attributes_MediaSupp_Bit6[current_element]  =(gSourceList_Attributes[current_element] &0x40) /0x40;                             
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =3 ends
                    
                    case 4: //recordaddress =4 -> Mediatype
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSourceList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSourceList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSourceList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSourceList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSourceList_ListHandlingType !=AUDIO_SOURCELIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }

                                    //MediaType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_MediaType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSourceList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSourceList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }

                                    //MediaType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_MediaType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =4 ends 
                    
                    case 15: //recordaddress =0xf -> Pos
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSourceList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSourceList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSourceList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSourceList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSourceList_ListHandlingType !=AUDIO_SOURCELIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                    
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSourceList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSourceList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0xf ends
                }                  

                gSourceList_recordaddress =recordaddress;
                gSourceList_transmitpos   =transmitpos;             
                }
            break;
			
            case Error_IND:
					
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD SourceList_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD SourceList_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD SourceList_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD SourceList_Indication: Application-Error: 0x%x", Indication_array[3]);
				
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD SourceList_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
		}

    //for "sliding window concept"
    if(gSourceList_TotalNumListElements<=AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE)
        gSourceList_SlidingWindow_State =AUDIO_SOURCELIST_SLIDINGWINDOW_NOTACTIVE;
    else
        gSourceList_SlidingWindow_State =AUDIO_SOURCELIST_SLIDINGWINDOW_ACTIVE;

    if (gSourceList_CallBackReason !=AUDIO_SOURCELIST_CALLBACKREASON_NOCALLBACK)
        SourceList_ListHandling ();
    else
        SourceList_display();
}

display_SourceList ()
{/*
byte Attributes_built, Attributes_Error, Attributes_playable, Attributes_read;
//only visible elements
/****first element****
	Attributes_built    =  (gSourceList_Attributes[3] & 0x01) / 0x01;
    Attributes_Error    =  (gSourceList_Attributes[3] & 0x02) / 0x02;
    Attributes_playable =  (gSourceList_Attributes[3] & 0x04) / 0x04;
    Attributes_read     =  (gSourceList_Attributes[3] & 0x08) / 0x08;	
    
    putvalue(env_ASG_AudioSD_SL_Name_1, gSourceList_Name[3]);
    putvalue(env_ASG_AudioSD_SL_Type_1, gSourceList_Type_s[gSourceList_Type[3]]);
	putvalue(env_ASG_AudioSD_SL_ID_1, gSourceList_InstanceID[3]);
    putvalue(env_ASG_AudioSD_SL_Pos_1, gSourceList_FSGHandle[3]);

    putvalue(env_ASG_AudioSD_SL_built_1,gSourceList_Attributes_built_s[Attributes_built]);
    putvalue(env_ASG_AudioSD_SL_Error_1,gSourceList_Attributes_Error_s[Attributes_Error]);
    putvalue(env_ASG_AudioSD_SL_playable_1,gSourceList_Attributes_playable_s[Attributes_playable]);
    putvalue(env_ASG_AudioSD_SL_read_1,gSourceList_Attributes_read_s[Attributes_read]);                                            

/****second element****   
    Attributes_built    =  (gSourceList_Attributes[4] & 0x01) / 0x01;
    Attributes_Error    =  (gSourceList_Attributes[4] & 0x02) / 0x02;
    Attributes_playable =  (gSourceList_Attributes[4] & 0x04) / 0x04;
    Attributes_read     =  (gSourceList_Attributes[4] & 0x08) / 0x08;	

    putvalue(env_ASG_AudioSD_SL_Name_2, gSourceList_Name[4]);
	putvalue(env_ASG_AudioSD_SL_Type_2, gSourceList_Type_s[gSourceList_Type[4]]);
	putvalue(env_ASG_AudioSD_SL_ID_2, gSourceList_InstanceID[4]);
    putvalue(env_ASG_AudioSD_SL_Pos_2, gSourceList_FSGHandle[4]);
    putvalue(env_ASG_AudioSD_SwSource_Ref, gSourceList_FSGHandle[4]);  

    putvalue(env_ASG_AudioSD_SL_built_2,gSourceList_Attributes_built_s[Attributes_built]);
    putvalue(env_ASG_AudioSD_SL_Error_2,gSourceList_Attributes_Error_s[Attributes_Error]);
    putvalue(env_ASG_AudioSD_SL_playable_2,gSourceList_Attributes_playable_s[Attributes_playable]);
    putvalue(env_ASG_AudioSD_SL_read_2,gSourceList_Attributes_read_s[Attributes_read]); 
    
/****third element****       
    
    Attributes_built    =  (gSourceList_Attributes[5] & 0x01) / 0x01;
    Attributes_Error    =  (gSourceList_Attributes[5] & 0x02) / 0x02;
    Attributes_playable =  (gSourceList_Attributes[5] & 0x04) / 0x04;
    Attributes_read     =  (gSourceList_Attributes[5] & 0x08) / 0x08;	

    putvalue(env_ASG_AudioSD_SL_Name_3, gSourceList_Name[5]);
	putvalue(env_ASG_AudioSD_SL_Type_3, gSourceList_Type_s[gSourceList_Type[5]]);
    putvalue(env_ASG_AudioSD_SL_ID_3, gSourceList_InstanceID[5]);
    putvalue(env_ASG_AudioSD_SL_Pos_3, gSourceList_FSGHandle[5]);

    putvalue(env_ASG_AudioSD_SL_built_3,gSourceList_Attributes_built_s[Attributes_built]);
    putvalue(env_ASG_AudioSD_SL_Error_3,gSourceList_Attributes_Error_s[Attributes_Error]);
    putvalue(env_ASG_AudioSD_SL_playable_3,gSourceList_Attributes_playable_s[Attributes_playable]);
    putvalue(env_ASG_AudioSD_SL_read_3,gSourceList_Attributes_read_s[Attributes_read]);*/
}

on envVar env_ASG_AudioSD_SL_OnOff
{
    int i =0, j =0;
    if(POWER_ON==gASG_PowerOnOff)
	{   
        if(getvalue(this))
        {
            gSourceList_ListHandlingType      =AUDIO_SOURCELIST_BUILDUPCACHE;             //build-up complete cache...
            gSourceList_cacheBuildUp          =AUDIO_SOURCELIST_BUILDUPCACHECACHE_WINDOW; //...and start with area "window"            
        
            SourceList_ListHandling ();
        }
        else
        {
            gSourceList_SlidingWindow_State   =AUDIO_SOURCELIST_SLIDINGWINDOW_NOTACTIVE;
            gSourceList_ListHandlingType      =AUDIO_SOURCELIST_NOCACHE;
            gSourceList_cacheBuildUp          =AUDIO_SOURCELIST_BUILDUPCACHENOCACHE;
            gSourceList_CallBackReason        =AUDIO_SOURCELIST_CALLBACKREASON_NOCALLBACK;

            gSourceList_cacheDown             =FALSE;
            gSourceList_cacheUp               =FALSE;
            gSourceList_LastFirstElement      =0;

            gSourceList_recordaddress         =0;
            gSourceList_transmitpos           =1;
            gSourceList_CursorAction          =AUDIO_SOURCELIST_CURSORACTION_NOTHING;
            gSourceList_DisplayStatus         =AUDIO_SOURCELIST_DISPLAYLIST_FIRST_ELEMENTS;
            
            for(j=0; j<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; j++)
            {     
                gSourceList_Pos[j]                              =0;
                gSourceList_SourceType[j]                       =0;
                gSourceList_InstanceID[j]                       =0;
                gSourceList_MediaType[j]                        =0;
                gSourceList_Attributes_BuiltIn_Bit0[j]          =0;
                gSourceList_Attributes_MediaError_Bit1[j]       =0;
                gSourceList_Attributes_MediaPlay_Bit2[j]        =0;
                gSourceList_Attributes_MediaRead_Bit3[j]        =0;
                gSourceList_Attributes_MediaLoad_Bit4[j]        =0;
                gSourceList_Attributes_ImportRun_Bit5[j]        =0;
                gSourceList_Attributes_MediaSupp_Bit6[j]        =0;
                gSourceList_Attributes[j]                       =0;
                gSourceList_ListEntryReceptionInformation[j]    =0;

                for(i=0;i<AUDIO_SOURCELIST_NAME_LENGTH;i++)
			        gSourceList_Name[j][i] =0;
            }
            putvalue(env_ASG_AudioSD_SL_pos_0, 0);
            putvalue(env_ASG_AudioSD_SL_pos_1, 0);
            putvalue(env_ASG_AudioSD_SL_pos_2, 0);
    
            putvalue(env_ASG_AudioSD_SL_SrcType_0, 0);
            putvalue(env_ASG_AudioSD_SL_SrcType_1, 0);
            putvalue(env_ASG_AudioSD_SL_SrcType_2, 0);

            putvalue(env_ASG_AudioSD_SL_SrcType_s_0,empty_string);
            putvalue(env_ASG_AudioSD_SL_SrcType_s_1,empty_string);
            putvalue(env_ASG_AudioSD_SL_SrcType_s_2,empty_string);

            putvalue(env_ASG_AudioSD_SL_IID_0, 0);
            putvalue(env_ASG_AudioSD_SL_IID_1, 0);
            putvalue(env_ASG_AudioSD_SL_IID_2, 0);

            putvalue(env_ASG_AudioSD_SL_MedType_0, 0);
            putvalue(env_ASG_AudioSD_SL_MedType_1, 0);
            putvalue(env_ASG_AudioSD_SL_MedType_2, 0);

            putvalue(env_ASG_AudioSD_SL_MedType_s_0,empty_string);
            putvalue(env_ASG_AudioSD_SL_MedType_s_1,empty_string);
            putvalue(env_ASG_AudioSD_SL_MedType_s_2,empty_string);

            putvalue(env_ASG_AudioSD_SL_Attr_bit0_0, 0);
            putvalue(env_ASG_AudioSD_SL_Attr_bit0_1, 0);
            putvalue(env_ASG_AudioSD_SL_Attr_bit0_2, 0);
            putvalue(env_ASG_AudioSD_SL_Attr_s_bit0_0, empty_string);
            putvalue(env_ASG_AudioSD_SL_Attr_s_bit0_1, empty_string);
            putvalue(env_ASG_AudioSD_SL_Attr_s_bit0_2, empty_string);

            putvalue(env_ASG_AudioSD_SL_Attr_bit1_0, 0);
            putvalue(env_ASG_AudioSD_SL_Attr_bit1_1, 0);
            putvalue(env_ASG_AudioSD_SL_Attr_bit1_2, 0);
            putvalue(env_ASG_AudioSD_SL_Attr_s_bit1_0, empty_string);
            putvalue(env_ASG_AudioSD_SL_Attr_s_bit1_1, empty_string);
            putvalue(env_ASG_AudioSD_SL_Attr_s_bit1_2, empty_string);

            putvalue(env_ASG_AudioSD_SL_Attr_bit2_0, 0);
            putvalue(env_ASG_AudioSD_SL_Attr_bit2_1, 0);
            putvalue(env_ASG_AudioSD_SL_Attr_bit2_2, 0);
            putvalue(env_ASG_AudioSD_SL_Attr_s_bit2_0, empty_string);
            putvalue(env_ASG_AudioSD_SL_Attr_s_bit2_1, empty_string);
            putvalue(env_ASG_AudioSD_SL_Attr_s_bit2_2, empty_string);

            putvalue(env_ASG_AudioSD_SL_Attr_bit3_0, 0);
            putvalue(env_ASG_AudioSD_SL_Attr_bit3_1, 0);
            putvalue(env_ASG_AudioSD_SL_Attr_bit3_2, 0);
            putvalue(env_ASG_AudioSD_SL_Attr_s_bit3_0, empty_string);
            putvalue(env_ASG_AudioSD_SL_Attr_s_bit3_1, empty_string);
            putvalue(env_ASG_AudioSD_SL_Attr_s_bit3_2, empty_string);

            putvalue(env_ASG_AudioSD_SL_Attr_bit4_0, 0);
            putvalue(env_ASG_AudioSD_SL_Attr_bit4_1, 0);
            putvalue(env_ASG_AudioSD_SL_Attr_bit4_2, 0);
            putvalue(env_ASG_AudioSD_SL_Attr_s_bit4_0, empty_string);
            putvalue(env_ASG_AudioSD_SL_Attr_s_bit4_1, empty_string);
            putvalue(env_ASG_AudioSD_SL_Attr_s_bit4_2, empty_string);

            putvalue(env_ASG_AudioSD_SL_Attr_bit5_0, 0);
            putvalue(env_ASG_AudioSD_SL_Attr_bit5_1, 0);
            putvalue(env_ASG_AudioSD_SL_Attr_bit5_2, 0);
            putvalue(env_ASG_AudioSD_SL_Attr_s_bit5_0, empty_string);
            putvalue(env_ASG_AudioSD_SL_Attr_s_bit5_1, empty_string);
            putvalue(env_ASG_AudioSD_SL_Attr_s_bit5_2, empty_string);
            
            putvalue(env_ASG_AudioSD_SL_Name_s_0, empty_string);
            putvalue(env_ASG_AudioSD_SL_Name_s_1, empty_string);
            putvalue(env_ASG_AudioSD_SL_Name_s_2, empty_string);
            
        }
    }
}   

SwitchSource_Indication(dword Indication_array [], int datalength)
{
	switch (gBAP_Indication[2])
	{
		case Processing_IND:
		break;
		case Result_IND:
				
                gAudioSD_SwitchSource_Result =Indication_array[3];
                if(gAudioSD_SwitchSource_Result <0x04)	
					putvalue(env_ASG_AudioSD_SwSource_Res_s, gAudioSD_SwitchSource_Result_s[gAudioSD_SwitchSource_Result]);   
				else
					putvalue(env_ASG_AudioSD_SwSource_Res_s, gstring_reserved);               
		break;
		case Error_IND:
				
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD SwitchSource_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30 && Indication_array[3] !=0)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD SwitchSource_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40 && Indication_array[3] !=0)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD SwitchSource_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
				{	
                    writelineEx(gError_Trace, 0, "ASG-AudioSD SwitchSource_Indication: Application-Error: 0x%x", Indication_array[3]);
                    putvalue(env_ASG_AudioSD_SwSource_Err,Indication_array[3]);
                    
                    if (Indication_array[3] ==0)
                        putvalue(env_ASG_AudioSD_SwSource_Err_s,"no error");
                    
                    else if((Indication_array[3]-0x40)<17)
                        putvalue(env_ASG_AudioSD_SwSource_Err_s,gerror_codes_0x40_0x7F[Indication_array[3]-0x40]);
                    else
                        putvalue(env_ASG_AudioSD_SwSource_Err_s,gstring_reserved);
                }
			
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD SwitchSource_Indication:: unknown indication %d", gBAP_Indication[2]);
		break;
	}
}

SwitchSource_Request (byte request, byte errorcode)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	        //LSG-ID
	requestarray[1] =FctID_SwitchSource;	//Fct.-ID
	requestarray[2] =request;               //request type
	
    switch(request)
	{
		case StartResult_REQ:               
		    requestarray[3] =gAudioSD_SwitchSource_Ref;

			set_status_requestbuffer (requestarray, 4, Bap_UInt16);
		break;
        case AbortResult_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD SwitchSource_Request: invalid request %d", request);
		break;
	}
}

on envVar env_ASG_AudioSD_SrcSt_Set
{
	if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
	{
		gAudioSD_SourceState_StateInfo  =getvalue(env_ASG_AudioSD_SrcSt_SateInfo);
        gAudioSD_SourceState_Scope      =getvalue(env_ASG_AudioSD_SrcSt_Scope);    
		
        SourceState_Request(DataSetGet_REQ);
	}
}

CurrentStationHandle_Indication (dword Indication_array [], int datalength)
{
	/*if(gBAP_Indication[5] !=4)
		writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStationHandle_Indication: BAP-datalength-error");
	else*/
	{
		switch (gBAP_Indication[2])
		{
			case Data_IND:
                //get data
                gAudioSD_CSIhandle_FSGhandle                =Indication_array[3] +(Indication_array[4] *0x100);
                gAudioSD_CSIhandle_FSGhandle_absolutePOS    =Indication_array[5] +(Indication_array[6] *0x100);
                gAudioSD_CSIhandle_PresetListRef            =Indication_array[7];
                gAudioSD_CSIhandle_PresetListabsolutePos    =Indication_array[8];
                gAudioSD_CSIhandle_DABEnsembleHandle        =Indication_array[9] +(Indication_array[10] *0x100);
                gAudioSD_CSIhandle_DABEnsembleAbsPos        =Indication_array[11] +(Indication_array[12] *0x100);
                
                //Panel
                putvalue(env_ASG_AudioSD_CSH_FSGh,gAudioSD_CSIhandle_FSGhandle);
                putvalue(env_ASG_AudioSD_CSH_FSGh_abs,gAudioSD_CSIhandle_FSGhandle_absolutePOS);
                putvalue(env_ASG_AudioSD_CSH_PL_Ref,gAudioSD_CSIhandle_PresetListRef);
                putvalue(env_ASG_AudioSD_CSH_PL_abs,gAudioSD_CSIhandle_PresetListabsolutePos);
                putvalue(env_ASG_AudioSD_CSH_DAB_E_han,gAudioSD_CSIhandle_DABEnsembleHandle);
                putvalue(env_ASG_AudioSD_CSH_DAB_E_abs,gAudioSD_CSIhandle_DABEnsembleAbsPos);

            break;
			
            case Error_IND:
					
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStationHandle_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStationHandle_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStationHandle_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStationHandle_Indication: Application-Error: 0x%x", Indication_array[3]);
				
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD CurrentStationHandle_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
		}
	}
}

CurrentStationHandle_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	                //LSG-ID
	requestarray[1] =FctID_CurrentStation_Handle;	//Fct.-ID
	requestarray[2] =request;                       //request type
	
    switch(request)
	{
		case DataGet_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStationHandle_Request: invalid request %d", request);
		break;
	}
}

MediaBrowserFolderLevel_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	                    //LSG-ID
	requestarray[1] =FctID_MediaBrowser_FolderLevel;	//Fct.-ID
	requestarray[2] =request;                           //request type
	
    switch(request)
	{
		case DataGet_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD MediaBrowserFolderLevel_Request: invalid request %d", request);
		break;
	}
}

MediaBrowserFolderLevel_Indication (dword Indication_array [], int datalength)
{
		switch (gBAP_Indication[2])
		{
			case Data_IND:
                //get data
				gAudioSD_MediaBrowser_FL_FolderLevel            =Indication_array[3];
                gAudioSD_MediaBrowser_FL_RefMediaBrowser        =Indication_array[4] +(Indication_array[5] *0x100);
                gAudioSD_MediaBrowser_FL_RefMediaBrowser_AbsPos =Indication_array[6] +(Indication_array[7] *0x100);        
                
                //Panel
                putvalue(env_ASG_AudioSD_MeBrLevel_FL, gAudioSD_MediaBrowser_FL_FolderLevel);
                putvalue(env_ASG_AudioSD_MeBrLevel_Ref, gAudioSD_MediaBrowser_FL_RefMediaBrowser);
                putvalue(env_ASG_AudioSD_MeBrLevel_Ref_a, gAudioSD_MediaBrowser_FL_RefMediaBrowser_AbsPos);      

            break;
			
            case Error_IND:
					
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaBrowserFolderLevel_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaBrowserFolderLevel_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaBrowserFolderLevel_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaBrowserFolderLevel_Indication: Application-Error: 0x%x", Indication_array[3]);
				
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD MediaBrowserFolderLevel_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
		}
}

MediaPath_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	    //LSG-ID
	requestarray[1] =FctID_MediaPath;   //Fct.-ID
	requestarray[2] =request;           //request type
	
    switch(request)
	{
		case DataGet_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD MediaPath_Request: invalid request %d", request);
		break;
	}
}

MediaPath_Indication (dword Indication_array [], int datalength)
{
    int i =0;

		switch (gBAP_Indication[2])
		{
			case Data_IND:
            if(datalength>= 5) 
            {
                //get data
				gAudioSD_MediaPath_FolderType =Indication_array[3];
                
                //clear
                for (i=0; i<MEDIAPATH_PATH_TEXTLENGTH; i++)
                    gAudioSD_MediaPath_Path[i] =0;
                
                for (i=0; i<Indication_array[4]; i++)
                    gAudioSD_MediaPath_Path[i] =Indication_array[5+i];      
                
                //Panel
                if(gAudioSD_MediaPath_FolderType <0x55)
                  putvalue(env_ASG_AudioSD_MePath_Type_s, gAudioSD_MediaPath_FolderType_string[gAudioSD_MediaPath_FolderType]);
                else if (gAudioSD_MediaPath_FolderType <0xFF)
                  putvalue(env_ASG_AudioSD_MePath_Type_s, gstring_reserved);
                else
                  putvalue(env_ASG_AudioSD_MePath_Type_s, "not supported");

                putvalue(env_ASG_AudioSD_MePath_Path_s, gAudioSD_MediaPath_Path);
            }
            break;
			
            case Error_IND:
					
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaPath_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaPath_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaPath_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaPath_Indication: Application-Error: 0x%x", Indication_array[3]);
				
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD MediaPath_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
		}
}

PreferredList_Indication (dword Indication_array [], int datalength)
{
		switch (gBAP_Indication[2])
		{
			case Data_IND:
        //get data
        gAudioSD_PreferredList_List =Indication_array[3];
               
        //Panel
        putValue(env_ASG_AudioSD_PrefList_List, gAudioSD_PreferredList_List);
        if(gAudioSD_PreferredList_List <0x06)
            putvalue(env_ASG_AudioSD_PrefList_List_s, gAudioSD_PreferredList_List_string[gAudioSD_PreferredList_List]);
        else
            putvalue(env_ASG_AudioSD_PrefList_List_s, gstring_reserved);
      break;
      case Error_IND:		
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD PreferredList_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD PreferredList_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD PreferredList_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD PreferredList_Indication: Application-Error: 0x%x", Indication_array[3]);
  		break;
  		default:
  			writelineEx(gError_Trace, 0,"ASG-AudioSD PreferredList_Indication: unknown indication %x", gBAP_Indication[2]);
  		break;
		}
}

PreferredList_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	        //LSG-ID
	requestarray[1] =FctID_PreferredList;	//Fct.-ID
	requestarray[2] =request;               //request type
	
    switch(request)
	{
		case DataGet_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
 
		break;
        case DataSetGet_REQ:

            requestarray[3] = getValue(env_ASG_AudioSD_PrefList_List);		    
			set_status_requestbuffer (requestarray, 4, Bap_UInt8);

		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD PreferredList_Request: invalid request %d", request);
		break;
	}
}

SDSState_Indication (dword Indication_array [], int datalength)
{
		switch (gBAP_Indication[2])
		{
			case Data_IND:
          //get data
	        gAudioSD_SDSState_State =Indication_array[3];
          
          //Panel
          putvalue(env_ASG_AudioSD_SDSState_State, gAudioSD_SDSState_State);
          if(gAudioSD_SDSState_State <0x13)
              putvalue(env_ASG_AudioSD_SDSState_State_s, gAudioSD_SDSState_State_string[gAudioSD_SDSState_State]);
          else
              putvalue(env_ASG_AudioSD_SDSState_State_s, gstring_reserved);
      break;
      case Error_IND:
  				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
  					writelineEx(gError_Trace, 0, "ASG-AudioSD SDSState_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
  				else if(Indication_array[3]<0x30)			//BPL-error
  					writelineEx(gError_Trace, 0, "ASG-AudioSD SDSState_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
  				else if(Indication_array[3]<0x40)			//BAL-error
  					writelineEx(gError_Trace, 0, "ASG-AudioSD SDSState_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
  				else
  					writelineEx(gError_Trace, 0, "ASG-AudioSD SDSState_Indication: Application-Error: 0x%x", Indication_array[3]);
  		break;
  		default:
  			  writelineEx(gError_Trace, 0,"ASG-AudioSD SDSState_Indication: unknown indication %x", gBAP_Indication[2]);
  		break;
		}
}

SDSState_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	    //LSG-ID
	requestarray[1] =FctID_SDS_State;	//Fct.-ID
	requestarray[2] =request;           //request type
	
    switch(request)
	{
		case DataGet_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
        case DataSetGet_REQ:

                requestarray[3] = gSDS_State_state;		    

			set_status_requestbuffer (requestarray, 4, Bap_UInt8);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD SDSState_Request: invalid request %d", request);
		break;
	}
}

ASGCapabilities_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	            //LSG-ID
	requestarray[1] =FctID_ASG_Capabilities;	//Fct.-ID
	requestarray[2] =request;                   //request type
	
    switch(request)
	{
		case DataGet_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;

        case DataSetGet_REQ:

                requestarray[3] =gAudioSD_ASGCapabilities_PresentationCapabilities;		    

			set_status_requestbuffer (requestarray, 4, Bap_UInt8);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD ASGCapabilities_Request: invalid request %d", request);
		break;
	}
}

on envVar env_ASG_AudioSD_ASGCap_set
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
	{
        gAudioSD_ASGCapabilities_PresentationCapabilities =getvalue(env_ASG_AudioSD_ASGCap_PrC_DAB);
        gAudioSD_ASGCapabilities_PresentationCapabilities +=(getvalue(env_ASG_AudioSD_ASGCap_PrC_SDARS))*0x02;

        ASGCapabilities_Request(DataSetGet_REQ);
    }
}

ASGCapabilities_Indication (dword Indication_array [], int datalength)
{
		switch (gBAP_Indication[2])
		{
			case Data_IND:
                //get data
				gAudioSD_ASGCapabilities_PresentationCapabilities     =Indication_array[3];
         
                gAudioSD_ASGCapabilities_PresentationCapabilities_Bit0 =gAudioSD_ASGCapabilities_PresentationCapabilities &0x01;
                gAudioSD_ASGCapabilities_PresentationCapabilities_Bit1 =(gAudioSD_ASGCapabilities_PresentationCapabilities &0x02)/0x02;               
                
                //Panel
                putvalue(env_ASG_AudioSD_ASGCap_PrC_DAB, gAudioSD_ASGCapabilities_PresentationCapabilities_Bit0);
                putvalue(env_ASG_AudioSD_ASGCap_PrC_DAB_s, gAudioSD_ASGCapabilities_PresentationCapabilities_Bit0_string[gAudioSD_ASGCapabilities_PresentationCapabilities_Bit0]);

                putvalue(env_ASG_AudioSD_ASGCap_PrC_SDARS, gAudioSD_ASGCapabilities_PresentationCapabilities_Bit1);
                putvalue(env_ASG_AudioSD_ASGCap_PrC_SDA_s, gAudioSD_ASGCapabilities_PresentationCapabilities_Bit1_string[gAudioSD_ASGCapabilities_PresentationCapabilities_Bit1]);

            break;
			
            case Error_IND:
					
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD ASGCapabilities_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD ASGCapabilities_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD ASGCapabilities_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD ASGCapabilities_Indication: Application-Error: 0x%x", Indication_array[3]);
				
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD ASGCapabilities_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
		}
}

FunctionSynchronisation_Indication (dword Indication_array [], int datalength)
{   
    int i =0;

		switch (gBAP_Indication[2])
		{
			case Data_IND:
                
                //clear
                for(i=0;i<8;i++)
                    gAudioSD_FunctionSynchronisation_FctList[i] =0;

                //get data
				        gAudioSD_FunctionSynchronisation_FctList[0] =Indication_array[3];
                gAudioSD_FunctionSynchronisation_FctList[1] =Indication_array[4];
                gAudioSD_FunctionSynchronisation_FctList[2] =Indication_array[5];
                gAudioSD_FunctionSynchronisation_FctList[3] =Indication_array[6];
                gAudioSD_FunctionSynchronisation_FctList[4] =Indication_array[7];
                gAudioSD_FunctionSynchronisation_FctList[5] =Indication_array[8];
                gAudioSD_FunctionSynchronisation_FctList[6] =Indication_array[9];
                gAudioSD_FunctionSynchronisation_FctList[7] =Indication_array[10];                
                                              
                //Byte 2
                gAudioSD_FunctionSynchronisation_FctList_Bit23  =gAudioSD_FunctionSynchronisation_FctList[2] &0x01;   
                gAudioSD_FunctionSynchronisation_FctList_Bit22  =(gAudioSD_FunctionSynchronisation_FctList[2] &0x02) /0x02;
                gAudioSD_FunctionSynchronisation_FctList_Bit21  =(gAudioSD_FunctionSynchronisation_FctList[2] &0x04) /0x04;
                gAudioSD_FunctionSynchronisation_FctList_Bit20  =(gAudioSD_FunctionSynchronisation_FctList[2] &0x08) /0x08;
                gAudioSD_FunctionSynchronisation_FctList_Bit19  =(gAudioSD_FunctionSynchronisation_FctList[2] &0x10) /0x10;
                gAudioSD_FunctionSynchronisation_FctList_Bit18  =(gAudioSD_FunctionSynchronisation_FctList[2] &0x20) /0x20;
                gAudioSD_FunctionSynchronisation_FctList_Bit17  =(gAudioSD_FunctionSynchronisation_FctList[2] &0x40) /0x40;
                gAudioSD_FunctionSynchronisation_FctList_Bit16  =(gAudioSD_FunctionSynchronisation_FctList[2] &0x80) /0x80;

                //Byte 3
                gAudioSD_FunctionSynchronisation_FctList_Bit31  =gAudioSD_FunctionSynchronisation_FctList[3] &0x01;   
                gAudioSD_FunctionSynchronisation_FctList_Bit30  =(gAudioSD_FunctionSynchronisation_FctList[3] &0x02) /0x02;
                gAudioSD_FunctionSynchronisation_FctList_Bit29  =(gAudioSD_FunctionSynchronisation_FctList[3] &0x04) /0x04;
                gAudioSD_FunctionSynchronisation_FctList_Bit28  =(gAudioSD_FunctionSynchronisation_FctList[3] &0x08) /0x08;
                gAudioSD_FunctionSynchronisation_FctList_Bit27  =(gAudioSD_FunctionSynchronisation_FctList[3] &0x10) /0x10;
                gAudioSD_FunctionSynchronisation_FctList_Bit26  =(gAudioSD_FunctionSynchronisation_FctList[3] &0x20) /0x20;
                gAudioSD_FunctionSynchronisation_FctList_Bit25  =(gAudioSD_FunctionSynchronisation_FctList[3] &0x40) /0x40;
                gAudioSD_FunctionSynchronisation_FctList_Bit24  =(gAudioSD_FunctionSynchronisation_FctList[3] &0x80) /0x80;

                //Byte 4
                gAudioSD_FunctionSynchronisation_FctList_Bit39  =gAudioSD_FunctionSynchronisation_FctList[4] &0x01;   
                gAudioSD_FunctionSynchronisation_FctList_Bit38  =(gAudioSD_FunctionSynchronisation_FctList[4] &0x02) /0x02;
                gAudioSD_FunctionSynchronisation_FctList_Bit37  =(gAudioSD_FunctionSynchronisation_FctList[4] &0x04) /0x04;
                gAudioSD_FunctionSynchronisation_FctList_Bit36  =(gAudioSD_FunctionSynchronisation_FctList[4] &0x08) /0x08;
                gAudioSD_FunctionSynchronisation_FctList_Bit35  =(gAudioSD_FunctionSynchronisation_FctList[4] &0x10) /0x10;
                gAudioSD_FunctionSynchronisation_FctList_Bit34  =(gAudioSD_FunctionSynchronisation_FctList[4] &0x20) /0x20;
                gAudioSD_FunctionSynchronisation_FctList_Bit33  =(gAudioSD_FunctionSynchronisation_FctList[4] &0x40) /0x40;
                gAudioSD_FunctionSynchronisation_FctList_Bit32  =(gAudioSD_FunctionSynchronisation_FctList[4] &0x80) /0x80;

                //Byte 5
                gAudioSD_FunctionSynchronisation_FctList_Bit47  =gAudioSD_FunctionSynchronisation_FctList[5] &0x01;   
                gAudioSD_FunctionSynchronisation_FctList_Bit46  =(gAudioSD_FunctionSynchronisation_FctList[5] &0x02) /0x02;
                gAudioSD_FunctionSynchronisation_FctList_Bit45  =(gAudioSD_FunctionSynchronisation_FctList[5] &0x04) /0x04;
                gAudioSD_FunctionSynchronisation_FctList_Bit44  =(gAudioSD_FunctionSynchronisation_FctList[5] &0x08) /0x08;
                gAudioSD_FunctionSynchronisation_FctList_Bit43  =(gAudioSD_FunctionSynchronisation_FctList[5] &0x10) /0x10;
                gAudioSD_FunctionSynchronisation_FctList_Bit42  =(gAudioSD_FunctionSynchronisation_FctList[5] &0x20) /0x20;
                gAudioSD_FunctionSynchronisation_FctList_Bit41  =(gAudioSD_FunctionSynchronisation_FctList[5] &0x40) /0x40;
                gAudioSD_FunctionSynchronisation_FctList_Bit40  =(gAudioSD_FunctionSynchronisation_FctList[5] &0x80) /0x80;

                //Byte 6
                gAudioSD_FunctionSynchronisation_FctList_2_Bit07  =gAudioSD_FunctionSynchronisation_FctList[6] &0x01;   
                gAudioSD_FunctionSynchronisation_FctList_2_Bit06  =(gAudioSD_FunctionSynchronisation_FctList[6] &0x02) /0x02;
                gAudioSD_FunctionSynchronisation_FctList_2_Bit05  =(gAudioSD_FunctionSynchronisation_FctList[6] &0x04) /0x04;
                gAudioSD_FunctionSynchronisation_FctList_2_Bit04  =(gAudioSD_FunctionSynchronisation_FctList[6] &0x08) /0x08;
                gAudioSD_FunctionSynchronisation_FctList_2_Bit03  =(gAudioSD_FunctionSynchronisation_FctList[6] &0x10) /0x10;
                gAudioSD_FunctionSynchronisation_FctList_2_Bit02  =(gAudioSD_FunctionSynchronisation_FctList[6] &0x20) /0x20;
                gAudioSD_FunctionSynchronisation_FctList_2_Bit01  =(gAudioSD_FunctionSynchronisation_FctList[6] &0x40) /0x40;
                gAudioSD_FunctionSynchronisation_FctList_2_Bit00  =(gAudioSD_FunctionSynchronisation_FctList[6] &0x80) /0x80;
                
                //Byte 7
                gAudioSD_FunctionSynchronisation_FctList_3_Bit04  =(gAudioSD_FunctionSynchronisation_FctList[7] &0x08) /0x08;
                gAudioSD_FunctionSynchronisation_FctList_3_Bit03  =(gAudioSD_FunctionSynchronisation_FctList[7] &0x10) /0x10;
                gAudioSD_FunctionSynchronisation_FctList_3_Bit02  =(gAudioSD_FunctionSynchronisation_FctList[7] &0x20) /0x20;
                gAudioSD_FunctionSynchronisation_FctList_3_Bit01  =(gAudioSD_FunctionSynchronisation_FctList[7] &0x40) /0x40;
                gAudioSD_FunctionSynchronisation_FctList_3_Bit00  =(gAudioSD_FunctionSynchronisation_FctList[7] &0x80) /0x80;


                //Panel
                putvalue(env_ASG_AudioSD_FctSyn_Bit16,gAudioSD_FunctionSynchronisation_FctList_Bit16);
                putvalue(env_ASG_AudioSD_FctSyn_Bit17,gAudioSD_FunctionSynchronisation_FctList_Bit17);
                putvalue(env_ASG_AudioSD_FctSyn_Bit18,gAudioSD_FunctionSynchronisation_FctList_Bit18);
                putvalue(env_ASG_AudioSD_FctSyn_Bit19,gAudioSD_FunctionSynchronisation_FctList_Bit19);
                putvalue(env_ASG_AudioSD_FctSyn_Bit20,gAudioSD_FunctionSynchronisation_FctList_Bit20);
                putvalue(env_ASG_AudioSD_FctSyn_Bit21,gAudioSD_FunctionSynchronisation_FctList_Bit21);
                putvalue(env_ASG_AudioSD_FctSyn_Bit22,gAudioSD_FunctionSynchronisation_FctList_Bit22);
                putvalue(env_ASG_AudioSD_FctSyn_Bit23,gAudioSD_FunctionSynchronisation_FctList_Bit23);
                putvalue(env_ASG_AudioSD_FctSyn_Bit24,gAudioSD_FunctionSynchronisation_FctList_Bit24);
                putvalue(env_ASG_AudioSD_FctSyn_Bit25,gAudioSD_FunctionSynchronisation_FctList_Bit25);
                putvalue(env_ASG_AudioSD_FctSyn_Bit26,gAudioSD_FunctionSynchronisation_FctList_Bit26);
                putvalue(env_ASG_AudioSD_FctSyn_Bit27,gAudioSD_FunctionSynchronisation_FctList_Bit27);
                putvalue(env_ASG_AudioSD_FctSyn_Bit28,gAudioSD_FunctionSynchronisation_FctList_Bit28);
                putvalue(env_ASG_AudioSD_FctSyn_Bit29,gAudioSD_FunctionSynchronisation_FctList_Bit29);
                putvalue(env_ASG_AudioSD_FctSyn_Bit30,gAudioSD_FunctionSynchronisation_FctList_Bit30);
                putvalue(env_ASG_AudioSD_FctSyn_Bit31,gAudioSD_FunctionSynchronisation_FctList_Bit31);
                putvalue(env_ASG_AudioSD_FctSyn_Bit32,gAudioSD_FunctionSynchronisation_FctList_Bit32);
                putvalue(env_ASG_AudioSD_FctSyn_Bit33,gAudioSD_FunctionSynchronisation_FctList_Bit33);
                putvalue(env_ASG_AudioSD_FctSyn_Bit34,gAudioSD_FunctionSynchronisation_FctList_Bit34);
                putvalue(env_ASG_AudioSD_FctSyn_Bit35,gAudioSD_FunctionSynchronisation_FctList_Bit35);
                putvalue(env_ASG_AudioSD_FctSyn_Bit36,gAudioSD_FunctionSynchronisation_FctList_Bit36);
                putvalue(env_ASG_AudioSD_FctSyn_Bit37,gAudioSD_FunctionSynchronisation_FctList_Bit37);
                putvalue(env_ASG_AudioSD_FctSyn_Bit38,gAudioSD_FunctionSynchronisation_FctList_Bit38);
                putvalue(env_ASG_AudioSD_FctSyn_Bit39,gAudioSD_FunctionSynchronisation_FctList_Bit39);
                putvalue(env_ASG_AudioSD_FctSyn_Bit40,gAudioSD_FunctionSynchronisation_FctList_Bit40);
                putvalue(env_ASG_AudioSD_FctSyn_Bit41,gAudioSD_FunctionSynchronisation_FctList_Bit41);
                putvalue(env_ASG_AudioSD_FctSyn_Bit42,gAudioSD_FunctionSynchronisation_FctList_Bit42);
                putvalue(env_ASG_AudioSD_FctSyn_Bit43,gAudioSD_FunctionSynchronisation_FctList_Bit43);
                putvalue(env_ASG_AudioSD_FctSyn_Bit44,gAudioSD_FunctionSynchronisation_FctList_Bit44);
                putvalue(env_ASG_AudioSD_FctSyn_Bit45,gAudioSD_FunctionSynchronisation_FctList_Bit45);
                putvalue(env_ASG_AudioSD_FctSyn_Bit46,gAudioSD_FunctionSynchronisation_FctList_Bit46);
                putvalue(env_ASG_AudioSD_FctSyn_Bit47,gAudioSD_FunctionSynchronisation_FctList_Bit47);

                putvalue(env_ASG_AudioSD_FctSyn_2_Bit00,gAudioSD_FunctionSynchronisation_FctList_2_Bit00);
                putvalue(env_ASG_AudioSD_FctSyn_2_Bit01,gAudioSD_FunctionSynchronisation_FctList_2_Bit01);
                putvalue(env_ASG_AudioSD_FctSyn_2_Bit02,gAudioSD_FunctionSynchronisation_FctList_2_Bit02);
                putvalue(env_ASG_AudioSD_FctSyn_2_Bit03,gAudioSD_FunctionSynchronisation_FctList_2_Bit03);
                putvalue(env_ASG_AudioSD_FctSyn_2_Bit04,gAudioSD_FunctionSynchronisation_FctList_2_Bit04);
                putvalue(env_ASG_AudioSD_FctSyn_2_Bit05,gAudioSD_FunctionSynchronisation_FctList_2_Bit05);
                putvalue(env_ASG_AudioSD_FctSyn_2_Bit06,gAudioSD_FunctionSynchronisation_FctList_2_Bit06);
                putvalue(env_ASG_AudioSD_FctSyn_2_Bit07,gAudioSD_FunctionSynchronisation_FctList_2_Bit07);
                
                putvalue(env_ASG_AudioSD_FctSyn_3_Bit00,gAudioSD_FunctionSynchronisation_FctList_3_Bit00);
                putvalue(env_ASG_AudioSD_FctSyn_3_Bit01,gAudioSD_FunctionSynchronisation_FctList_3_Bit01);
                putvalue(env_ASG_AudioSD_FctSyn_3_Bit02,gAudioSD_FunctionSynchronisation_FctList_3_Bit02);
                putvalue(env_ASG_AudioSD_FctSyn_3_Bit03,gAudioSD_FunctionSynchronisation_FctList_3_Bit03);
                putvalue(env_ASG_AudioSD_FctSyn_3_Bit04,gAudioSD_FunctionSynchronisation_FctList_3_Bit04);

                putvalue(env_ASG_AudioSD_FctSyn_Bit16_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit16]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit17_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit17]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit18_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit18]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit19_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit19]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit20_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit20]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit21_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit21]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit22_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit22]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit23_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit23]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit24_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit24]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit25_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit25]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit26_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit26]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit27_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit27]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit28_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit28]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit29_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit29]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit30_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit30]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit31_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit31]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit32_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit32]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit33_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit33]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit34_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit34]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit35_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit35]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit36_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit36]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit37_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit37]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit38_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit38]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit39_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit39]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit40_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit40]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit41_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit41]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit42_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit42]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit43_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit43]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit44_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit44]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit45_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit45]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit46_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit46]);
                putvalue(env_ASG_AudioSD_FctSyn_Bit47_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_Bit47]);

                putvalue(env_ASG_AudioSD_FctSyn_2_Bit00_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_2_Bit00]);
                putvalue(env_ASG_AudioSD_FctSyn_2_Bit01_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_2_Bit01]);
                putvalue(env_ASG_AudioSD_FctSyn_2_Bit02_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_2_Bit02]);
                putvalue(env_ASG_AudioSD_FctSyn_2_Bit03_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_2_Bit03]);
                putvalue(env_ASG_AudioSD_FctSyn_2_Bit04_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_2_Bit04]);
                putvalue(env_ASG_AudioSD_FctSyn_2_Bit05_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_2_Bit05]);
                putvalue(env_ASG_AudioSD_FctSyn_2_Bit06_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_2_Bit06]);
                putvalue(env_ASG_AudioSD_FctSyn_2_Bit07_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_2_Bit07]);
                
                putvalue(env_ASG_AudioSD_FctSyn_3_Bit00_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_3_Bit00]);
                putvalue(env_ASG_AudioSD_FctSyn_3_Bit01_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_3_Bit01]);
                putvalue(env_ASG_AudioSD_FctSyn_3_Bit02_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_3_Bit02]);
                putvalue(env_ASG_AudioSD_FctSyn_3_Bit03_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_3_Bit03]);
                putvalue(env_ASG_AudioSD_FctSyn_3_Bit04_s,gAudioSD_FunctionSynchronisation_FctList_string[gAudioSD_FunctionSynchronisation_FctList_3_Bit04]);
            
            break;
			
            case Error_IND:
					
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD FunctionSynchronisation_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD FunctionSynchronisation_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD FunctionSynchronisation_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD FunctionSynchronisation_Indication: Application-Error: 0x%x", Indication_array[3]);
				
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD FunctionSynchronisation_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
		}
}

FunctionSynchronisation_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	                //LSG-ID
	requestarray[1] =FctID_FunctionSynchronisation;	//Fct.-ID
	requestarray[2] =request;                       //request type
	
    switch(request)
	{
		case DataGet_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD FunctionSynchronisation_Request: invalid request %d", request);
		break;
	}
}

display_FunctionSynchronisation ()
{
    putvalue(env_ASG_AudioSD_FctSyn_Bit16, (gAudioSD_FunctionSynchronisation_FctList[2] &0x01));
    putvalue(env_ASG_AudioSD_FctSyn_Bit16_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[2] &0x01)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit17, (gAudioSD_FunctionSynchronisation_FctList[2] &0x02));
    putvalue(env_ASG_AudioSD_FctSyn_Bit17_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[2] &0x02)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit18, (gAudioSD_FunctionSynchronisation_FctList[2] &0x04));
    putvalue(env_ASG_AudioSD_FctSyn_Bit18_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[2] &0x04)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit19, (gAudioSD_FunctionSynchronisation_FctList[2] &0x08));
    putvalue(env_ASG_AudioSD_FctSyn_Bit19_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[2] &0x08)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit20, (gAudioSD_FunctionSynchronisation_FctList[2] &0x10));
    putvalue(env_ASG_AudioSD_FctSyn_Bit20_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[2] &0x10)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit21, (gAudioSD_FunctionSynchronisation_FctList[2] &0x20));
    putvalue(env_ASG_AudioSD_FctSyn_Bit21_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[2] &0x20)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit22, (gAudioSD_FunctionSynchronisation_FctList[2] &0x40));
    putvalue(env_ASG_AudioSD_FctSyn_Bit22_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[2] &0x40)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit23, (gAudioSD_FunctionSynchronisation_FctList[2] &0x80));
    putvalue(env_ASG_AudioSD_FctSyn_Bit23_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[2] &0x80)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit24, (gAudioSD_FunctionSynchronisation_FctList[3] &0x01));
    putvalue(env_ASG_AudioSD_FctSyn_Bit24_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[3] &0x01)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit25, (gAudioSD_FunctionSynchronisation_FctList[3] &0x02));
    putvalue(env_ASG_AudioSD_FctSyn_Bit25_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[3] &0x02)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit26, (gAudioSD_FunctionSynchronisation_FctList[3] &0x04));
    putvalue(env_ASG_AudioSD_FctSyn_Bit26_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[3] &0x04)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit27, (gAudioSD_FunctionSynchronisation_FctList[3] &0x08));
    putvalue(env_ASG_AudioSD_FctSyn_Bit27_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[3] &0x08)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit28, (gAudioSD_FunctionSynchronisation_FctList[3] &0x10));
    putvalue(env_ASG_AudioSD_FctSyn_Bit28_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[3] &0x10)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit29, (gAudioSD_FunctionSynchronisation_FctList[3] &0x20));
    putvalue(env_ASG_AudioSD_FctSyn_Bit29_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[3] &0x20)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit30, (gAudioSD_FunctionSynchronisation_FctList[3] &0x40));
    putvalue(env_ASG_AudioSD_FctSyn_Bit30_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[3] &0x40)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit31, (gAudioSD_FunctionSynchronisation_FctList[3] &0x80));
    putvalue(env_ASG_AudioSD_FctSyn_Bit31_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[3] &0x80)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit32, (gAudioSD_FunctionSynchronisation_FctList[4] &0x01));
    putvalue(env_ASG_AudioSD_FctSyn_Bit32_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[4] &0x01)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit33, (gAudioSD_FunctionSynchronisation_FctList[4] &0x02));
    putvalue(env_ASG_AudioSD_FctSyn_Bit33_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[4] &0x02)]);
                
    putvalue(env_ASG_AudioSD_FctSyn_Bit34, (gAudioSD_FunctionSynchronisation_FctList[4] &0x04));
    putvalue(env_ASG_AudioSD_FctSyn_Bit34_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[4] &0x04)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit35, (gAudioSD_FunctionSynchronisation_FctList[4] &0x08));
    putvalue(env_ASG_AudioSD_FctSyn_Bit35_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[4] &0x08)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit36, (gAudioSD_FunctionSynchronisation_FctList[4] &0x10));
    putvalue(env_ASG_AudioSD_FctSyn_Bit36_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[4] &0x10)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit37, (gAudioSD_FunctionSynchronisation_FctList[4] &0x20));
    putvalue(env_ASG_AudioSD_FctSyn_Bit37_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[4] &0x20)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit38, (gAudioSD_FunctionSynchronisation_FctList[4] &0x40));
    putvalue(env_ASG_AudioSD_FctSyn_Bit38_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[4] &0x40)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit39, (gAudioSD_FunctionSynchronisation_FctList[4] &0x80));
    putvalue(env_ASG_AudioSD_FctSyn_Bit39_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[4] &0x80)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit40, (gAudioSD_FunctionSynchronisation_FctList[5] &0x01));
    putvalue(env_ASG_AudioSD_FctSyn_Bit40_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[5] &0x01)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit41, (gAudioSD_FunctionSynchronisation_FctList[5] &0x02));
    putvalue(env_ASG_AudioSD_FctSyn_Bit41_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[5] &0x02)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit42, (gAudioSD_FunctionSynchronisation_FctList[5] &0x04));
    putvalue(env_ASG_AudioSD_FctSyn_Bit42_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[5] &0x04)]);

    putvalue(env_ASG_AudioSD_FctSyn_Bit43, (gAudioSD_FunctionSynchronisation_FctList[5] &0x10));
    putvalue(env_ASG_AudioSD_FctSyn_Bit43_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[5] &0x10)]);
                
    putvalue(env_ASG_AudioSD_FctSyn_Bit44, (gAudioSD_FunctionSynchronisation_FctList[5] &0x20));
    putvalue(env_ASG_AudioSD_FctSyn_Bit44_s, gAudioSD_FunctionSynchronisation_FctList_string[(gAudioSD_FunctionSynchronisation_FctList[5] &0x20)]);
}

RadioTVPresetList_Indication(dword Indication_array [], int datalength)
{
    byte mode, direction, shift, recordaddress, indexsize, current_element, transmitpos, length, CacheElements, StartElementInCache;
    word  startelement, elements, startelement_check, Offset =0;
    int i =0, j=0;
    
    // Init local variables
    mode                    =0;
    direction               =0;
    shift                   =0;
    recordaddress           =0;
    startelement            =0;
    elements                =0;
    current_element         =0;
    transmitpos             =0;
    length                  =0;
    startelement_check      =0;
    StartElementInCache     =FALSE;
    CacheElements           =FALSE;

		switch (gBAP_Indication[2])
		{
			case Data_IND:
				//get data
                gRadioTVPresetList_ASGID =(Indication_array[3] &0xF0) /0x10;
                gRadioTVPresetList_TAID  =Indication_array[3] &0x0F;             

                gRadioTVPresetList_TotalNumListElements =Indication_array[4];
              
                /***ArrayHeader***/
                mode            =(Indication_array[5] &0xF0) /0x10;
                recordaddress   =Indication_array[5] &0x0F;
                Offset =6;
                
                // decode "mode-byte"
                shift       =mode &0x01;
                direction   =(mode &0x02)/0x02;
                transmitpos =(mode &0x04)/0x04;
                indexsize   =(mode &0x08)/0x08; 
                
                if (indexsize)
                {   
                    startelement =Indication_array[Offset];
                    Offset++;
                    startelement +=(Indication_array[Offset] *0x100);
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                    elements +=(Indication_array[Offset] *0x100);
                    Offset++;
                }
                else
                {   
                    startelement =Indication_array[Offset];
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                }           
                
                if(startelement !=0)
                {
                    for (i=0;i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(startelement ==gRadioTVPresetList_Pos[i])  
                            i =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;              
                    }
                }
                
                switch (recordaddress)
                {
                    case 0: //recordaddress =0 -> complete record
                         
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gRadioTVPresetList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gRadioTVPresetList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gRadioTVPresetList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gRadioTVPresetList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                              
                            /***copy elements***/
                            if (current_element !=AUDIO_RADIOTVPRESETLIST_NO_NEXT_POSITION) 
                            {   
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gRadioTVPresetList_Pos[i] && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gRadioTVPresetList_Pos[i] && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gRadioTVPresetList_ListHandlingType !=AUDIO_RADIOTVPRESETLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gRadioTVPresetList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //PresetIndex
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_PresetIndex[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Waveband
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_Waveband[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gRadioTVPresetList_Attributes[current_element] +=Indication_array[Offset] *0x100;
                                        Offset++;
                                        
                                        gRadioTVPresetList_Attributes_IBOC_Bit0[current_element]        =(gRadioTVPresetList_Attributes[current_element] &0x01);
                                        gRadioTVPresetList_Attributes_DABSecServ_Bit1[current_element]  =(gRadioTVPresetList_Attributes[current_element] &0x02) /0x02;
                                        gRadioTVPresetList_Attributes_DABPrimServ_Bit2[current_element] =(gRadioTVPresetList_Attributes[current_element] &0x04) /0x04;
                                        gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[current_element]=(gRadioTVPresetList_Attributes[current_element] &0x08) /0x08;
                                        gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[current_element]=(gRadioTVPresetList_Attributes[current_element] &0x10) /0x10;
                                        gRadioTVPresetList_Attributes_TP_Bit5[current_element]          =(gRadioTVPresetList_Attributes[current_element] &0x20) /0x20;
                                        gRadioTVPresetList_Attributes_TMC_Bit6[current_element]         =(gRadioTVPresetList_Attributes[current_element] &0x40) /0x40;
                                        gRadioTVPresetList_Attributes_SDRAS_Bit7[current_element]       =(gRadioTVPresetList_Attributes[current_element] &0x80) /0x80;
                                        gRadioTVPresetList_Attributes_StationSelect_Bit8[current_element]=(gRadioTVPresetList_Attributes[current_element] &0x100) /0x100;
                                        gRadioTVPresetList_Attributes_OnRadMute_Bit9[current_element]    =(gRadioTVPresetList_Attributes[current_element] &0x200) /0x200;
                                        gRadioTVPresetList_Attributes_StationLinked_BitA[current_element]=(gRadioTVPresetList_Attributes[current_element] &0x400) /0x400;
                                    }

                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;i++) //clear
			                                gRadioTVPresetList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gRadioTVPresetList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gRadioTVPresetList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gRadioTVPresetList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RADIOTVPRESETLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gRadioTVPresetList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gRadioTVPresetList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //PresetIndex
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_PresetIndex[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Waveband
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_Waveband[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gRadioTVPresetList_Attributes[current_element] +=Indication_array[Offset] *0x100;
                                        Offset++;
                                        
                                        gRadioTVPresetList_Attributes_IBOC_Bit0[current_element]        =(gRadioTVPresetList_Attributes[current_element] &0x01);
                                        gRadioTVPresetList_Attributes_DABSecServ_Bit1[current_element]  =(gRadioTVPresetList_Attributes[current_element] &0x02) /0x02;
                                        gRadioTVPresetList_Attributes_DABPrimServ_Bit2[current_element] =(gRadioTVPresetList_Attributes[current_element] &0x04) /0x04;
                                        gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[current_element]=(gRadioTVPresetList_Attributes[current_element] &0x08) /0x08;
                                        gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[current_element]=(gRadioTVPresetList_Attributes[current_element] &0x10) /0x10;
                                        gRadioTVPresetList_Attributes_TP_Bit5[current_element]          =(gRadioTVPresetList_Attributes[current_element] &0x20) /0x20;
                                        gRadioTVPresetList_Attributes_TMC_Bit6[current_element]         =(gRadioTVPresetList_Attributes[current_element] &0x40) /0x40;
                                        gRadioTVPresetList_Attributes_SDRAS_Bit7[current_element]       =(gRadioTVPresetList_Attributes[current_element] &0x80) /0x80;
                                        gRadioTVPresetList_Attributes_StationSelect_Bit8[current_element]=(gRadioTVPresetList_Attributes[current_element] &0x100) /0x100;
                                        gRadioTVPresetList_Attributes_OnRadMute_Bit9[current_element]    =(gRadioTVPresetList_Attributes[current_element] &0x200) /0x200;
                                        gRadioTVPresetList_Attributes_StationLinked_BitA[current_element]=(gRadioTVPresetList_Attributes[current_element] &0x400) /0x400;
                                    }

                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;i++) //clear
			                                gRadioTVPresetList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gRadioTVPresetList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gRadioTVPresetList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0 ends
                    
                    case 1: //recordaddress =1 -> PresetIndex, Waveband, Name
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gRadioTVPresetList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gRadioTVPresetList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gRadioTVPresetList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gRadioTVPresetList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RADIOTVPRESETLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gRadioTVPresetList_Pos[i] && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gRadioTVPresetList_Pos[i] && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gRadioTVPresetList_ListHandlingType !=AUDIO_RADIOTVPRESETLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gRadioTVPresetList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //PresetIndex
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_PresetIndex[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Waveband
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_Waveband[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;i++) //clear
			                                gRadioTVPresetList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gRadioTVPresetList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gRadioTVPresetList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gRadioTVPresetList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RADIOTVPRESETLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gRadioTVPresetList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gRadioTVPresetList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //PresetIndex
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_PresetIndex[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Waveband
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_Waveband[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;i++) //clear
			                                gRadioTVPresetList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gRadioTVPresetList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gRadioTVPresetList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends 
                     break; //recordaddress =1 ends
                    
                    case 2: //recordaddress =2 -> PresetIndex, Name
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gRadioTVPresetList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gRadioTVPresetList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gRadioTVPresetList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gRadioTVPresetList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RADIOTVPRESETLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gRadioTVPresetList_Pos[i] && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gRadioTVPresetList_Pos[i] && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gRadioTVPresetList_ListHandlingType !=AUDIO_RADIOTVPRESETLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gRadioTVPresetList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //PresetIndex
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_PresetIndex[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;i++) //clear
			                                gRadioTVPresetList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gRadioTVPresetList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gRadioTVPresetList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gRadioTVPresetList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RADIOTVPRESETLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gRadioTVPresetList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gRadioTVPresetList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //PresetIndex
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_PresetIndex[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;i++) //clear
			                                gRadioTVPresetList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gRadioTVPresetList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gRadioTVPresetList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =2 ends
                    
                    case 15: //recordaddress =0xf -> Pos
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gRadioTVPresetList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gRadioTVPresetList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gRadioTVPresetList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gRadioTVPresetList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RADIOTVPRESETLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gRadioTVPresetList_Pos[i] && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gRadioTVPresetList_Pos[i] && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gRadioTVPresetList_ListHandlingType !=AUDIO_RADIOTVPRESETLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gRadioTVPresetList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                    
                                        gRadioTVPresetList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gRadioTVPresetList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RADIOTVPRESETLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gRadioTVPresetList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gRadioTVPresetList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gRadioTVPresetList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0xf ends
                }
                                   
                //Panel
                putvalue(env_ASG_AudioSD_RTPL_ASGID, gRadioTVPresetList_ASGID);
                putvalue(env_ASG_AudioSD_RTPL_TAID, gRadioTVPresetList_TAID);
                putvalue(env_ASG_AudioSD_RTPL_TotalNumLE, gRadioTVPresetList_TotalNumListElements);

                gRadioTVPresetList_recordaddress =recordaddress;
                gRadioTVPresetList_transmitpos   =transmitpos;             
            
			break;

            case Changed_IND:
                //get data
                /***ArrayHeader***/
                mode            =(Indication_array[3] &0xF0) /0x10;
                recordaddress   =Indication_array[3] &0x0F;
                Offset =4;
                
                // decode "mode-byte"
                shift       =mode &0x01;
                direction   =(mode &0x02)/0x02;
                transmitpos =(mode &0x04)/0x04;
                indexsize   =(mode &0x08)/0x08; 

                if (indexsize)
                {   
                    startelement =Indication_array[Offset];
                    Offset++;
                    startelement +=(Indication_array[Offset] *0x100);
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                    elements +=(Indication_array[Offset] *0x100);
                    Offset++;
                }
                else
                {   
                    startelement =Indication_array[Offset];
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                }           
            
                if(startelement !=0)
                {
                    for (i=0;i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(startelement ==gRadioTVPresetList_Pos[i])  
                            i =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;              
                    }
                }
                
                if(startelement ==0 && shift==0 && transmitpos==0 && recordaddress==0 && elements==255) //check 'full range update'?
                {
                    putvalue(env_ASG_AudioSD_RTPL_OnOff, FALSE);
                    putvalue(env_ASG_AudioSD_RTPL_ListOpState, "'full range update' received");
                }
                else if (datalength>8)
                {
                switch (recordaddress)
                {
                    case 0: //recordaddress =0 -> complete record

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gRadioTVPresetList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gRadioTVPresetList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gRadioTVPresetList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gRadioTVPresetList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RADIOTVPRESETLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gRadioTVPresetList_Pos[i] && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gRadioTVPresetList_Pos[i] && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gRadioTVPresetList_ListHandlingType !=AUDIO_RADIOTVPRESETLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gRadioTVPresetList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //PresetIndex
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_PresetIndex[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Waveband
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_Waveband[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gRadioTVPresetList_Attributes[current_element] +=Indication_array[Offset] *0x100;
                                        Offset++;
                                        
                                        gRadioTVPresetList_Attributes_IBOC_Bit0[current_element]        =(gRadioTVPresetList_Attributes[current_element] &0x01);
                                        gRadioTVPresetList_Attributes_DABSecServ_Bit1[current_element]  =(gRadioTVPresetList_Attributes[current_element] &0x02) /0x02;
                                        gRadioTVPresetList_Attributes_DABPrimServ_Bit2[current_element] =(gRadioTVPresetList_Attributes[current_element] &0x04) /0x04;
                                        gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[current_element]=(gRadioTVPresetList_Attributes[current_element] &0x08) /0x08;
                                        gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[current_element]=(gRadioTVPresetList_Attributes[current_element] &0x10) /0x10;
                                        gRadioTVPresetList_Attributes_TP_Bit5[current_element]          =(gRadioTVPresetList_Attributes[current_element] &0x20) /0x20;
                                        gRadioTVPresetList_Attributes_TMC_Bit6[current_element]         =(gRadioTVPresetList_Attributes[current_element] &0x40) /0x40;
                                        gRadioTVPresetList_Attributes_SDRAS_Bit7[current_element]       =(gRadioTVPresetList_Attributes[current_element] &0x80) /0x80;
                                        gRadioTVPresetList_Attributes_StationSelect_Bit8[current_element]=(gRadioTVPresetList_Attributes[current_element] &0x100) /0x100;
                                        gRadioTVPresetList_Attributes_OnRadMute_Bit9[current_element]    =(gRadioTVPresetList_Attributes[current_element] &0x200) /0x200;
                                        gRadioTVPresetList_Attributes_StationLinked_BitA[current_element]=(gRadioTVPresetList_Attributes[current_element] &0x400) /0x400;
                                    }

                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;i++) //clear
			                                gRadioTVPresetList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gRadioTVPresetList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gRadioTVPresetList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gRadioTVPresetList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RADIOTVPRESETLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gRadioTVPresetList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gRadioTVPresetList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //PresetIndex
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_PresetIndex[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Waveband
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_Waveband[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gRadioTVPresetList_Attributes[current_element] +=Indication_array[Offset] *0x100;
                                        Offset++;
                                        
                                        gRadioTVPresetList_Attributes_IBOC_Bit0[current_element]        =(gRadioTVPresetList_Attributes[current_element] &0x01);
                                        gRadioTVPresetList_Attributes_DABSecServ_Bit1[current_element]  =(gRadioTVPresetList_Attributes[current_element] &0x02) /0x02;
                                        gRadioTVPresetList_Attributes_DABPrimServ_Bit2[current_element] =(gRadioTVPresetList_Attributes[current_element] &0x04) /0x04;
                                        gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[current_element]=(gRadioTVPresetList_Attributes[current_element] &0x08) /0x08;
                                        gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[current_element]=(gRadioTVPresetList_Attributes[current_element] &0x10) /0x10;
                                        gRadioTVPresetList_Attributes_TP_Bit5[current_element]          =(gRadioTVPresetList_Attributes[current_element] &0x20) /0x20;
                                        gRadioTVPresetList_Attributes_TMC_Bit6[current_element]         =(gRadioTVPresetList_Attributes[current_element] &0x40) /0x40;
                                        gRadioTVPresetList_Attributes_SDRAS_Bit7[current_element]       =(gRadioTVPresetList_Attributes[current_element] &0x80) /0x80;
                                        gRadioTVPresetList_Attributes_StationSelect_Bit8[current_element]=(gRadioTVPresetList_Attributes[current_element] &0x100) /0x100;
                                        gRadioTVPresetList_Attributes_OnRadMute_Bit9[current_element]    =(gRadioTVPresetList_Attributes[current_element] &0x200) /0x200;
                                        gRadioTVPresetList_Attributes_StationLinked_BitA[current_element]=(gRadioTVPresetList_Attributes[current_element] &0x400) /0x400;
                                    }

                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;i++) //clear
			                                gRadioTVPresetList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gRadioTVPresetList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gRadioTVPresetList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0 ends
                    
                    case 1: //recordaddress =1 -> PresetIndex, Waveband, Name
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gRadioTVPresetList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gRadioTVPresetList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gRadioTVPresetList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gRadioTVPresetList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RADIOTVPRESETLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gRadioTVPresetList_Pos[i] && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gRadioTVPresetList_Pos[i] && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gRadioTVPresetList_ListHandlingType !=AUDIO_RADIOTVPRESETLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gRadioTVPresetList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //PresetIndex
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_PresetIndex[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Waveband
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_Waveband[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;i++) //clear
			                                gRadioTVPresetList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gRadioTVPresetList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gRadioTVPresetList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gRadioTVPresetList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RADIOTVPRESETLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gRadioTVPresetList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gRadioTVPresetList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //PresetIndex
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_PresetIndex[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Waveband
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_Waveband[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;i++) //clear
			                                gRadioTVPresetList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gRadioTVPresetList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gRadioTVPresetList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends 
                     break; //recordaddress =1 ends
                    
                    case 2: //recordaddress =2 -> PresetIndex, Name
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gRadioTVPresetList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gRadioTVPresetList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gRadioTVPresetList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gRadioTVPresetList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RADIOTVPRESETLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gRadioTVPresetList_Pos[i] && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gRadioTVPresetList_Pos[i] && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gRadioTVPresetList_ListHandlingType !=AUDIO_RADIOTVPRESETLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gRadioTVPresetList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //PresetIndex
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_PresetIndex[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;i++) //clear
			                                gRadioTVPresetList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gRadioTVPresetList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gRadioTVPresetList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gRadioTVPresetList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RADIOTVPRESETLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gRadioTVPresetList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gRadioTVPresetList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //PresetIndex
                                    if(CacheElements ==TRUE)
                                    {
                                        gRadioTVPresetList_PresetIndex[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;i++) //clear
			                                gRadioTVPresetList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gRadioTVPresetList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gRadioTVPresetList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =2 ends
                    
                    case 15: //recordaddress =0xf -> Pos
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gRadioTVPresetList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gRadioTVPresetList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gRadioTVPresetList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gRadioTVPresetList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RADIOTVPRESETLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gRadioTVPresetList_Pos[i] && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gRadioTVPresetList_Pos[i] && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gRadioTVPresetList_ListHandlingType !=AUDIO_RADIOTVPRESETLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gRadioTVPresetList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                    
                                        gRadioTVPresetList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gRadioTVPresetList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RADIOTVPRESETLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gRadioTVPresetList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gRadioTVPresetList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gRadioTVPresetList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gRadioTVPresetList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =RadioTVPresetList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0xf ends
                }                  
                }
                gRadioTVPresetList_recordaddress =recordaddress;
                gRadioTVPresetList_transmitpos   =transmitpos;             
            
            break;
			
            case Error_IND:
					
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD RadioTVPresetList_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD RadioTVPresetList_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD RadioTVPresetList_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD RadioTVPresetList_Indication: Application-Error: 0x%x", Indication_array[3]);
				
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD RadioTVPresetList_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
		}

    //for "sliding window concept"
    if(gRadioTVPresetList_TotalNumListElements<=AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE)
        gRadioTVPresetList_SlidingWindow_State =AUDIO_RADIOTVPRESETLIST_SLIDINGWINDOW_NOTACTIVE;
    else
        gRadioTVPresetList_SlidingWindow_State =AUDIO_RADIOTVPRESETLIST_SLIDINGWINDOW_ACTIVE;

    if (gRadioTVPresetList_CallBackReason !=AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_NOCALLBACK)
        RadioTVPresetList_ListHandling ();
    else
        RadioTVPresetList_display();
}

RadioTVPresetList_Request(byte request, byte mode, byte recordaddress, word requested_startelement, word startelement, word elements)
{   
    int  i;
    dword requestarray [BAP_BUFFER_SIZE], Offset;
    word indexsize;

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;
    
    indexsize   =0;
    Offset      =0;

    // decode "mode-byte"
    indexsize   =(mode &0x08)/0x08; 

    // Handle request.
    requestarray[0] =LSG_AudioSD;	            //LSG-ID
	requestarray[1] =FctID_RadioTV_PresetList;	//Fct.-ID
	requestarray[2] =request;                   //request type
    
    switch(request)
	{
        case DataGet_REQ:            
                requestarray[3] =((gRadioTVPresetList_ASGID *0x10) &0xF0) +(gRadioTVPresetList_TAID &0x0F);
                
                /***ArrayHeader***/
			    requestarray[4] =((mode *0x10) &0xF0) +(recordaddress &0x0F);          
                Offset =5;

                if(indexsize)
                {
                    requestarray[Offset] =requested_startelement &0x00FF;
                    Offset++;
                    requestarray[Offset] =(requested_startelement &0xFF00) /0x100;
                    Offset++;  

                    requestarray[Offset] =elements &0x00FF;
                    Offset++;
                    requestarray[Offset] =(elements &0xFF00) /0x100;
                    Offset++;       
                }
                else
                {
                    requestarray[Offset] =requested_startelement;
                    Offset++;

                    requestarray[Offset] =elements;
                    Offset++;
                }
            
            set_status_requestbuffer (requestarray, Offset, Bap_ByteSequence);
         break;

        default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD RadioTVPresetList_Request: invalid request %d", request);
		break;
    }
}

MediaBrowser_Indication (dword Indication_array [], int datalength)
{
    byte mode, direction, shift, recordaddress, indexsize, current_element, transmitpos, length, CacheElements, StartElementInCache;
    word  startelement, elements, startelement_check, Offset =0;
    int i =0, j=0;

    // Init local variables
    mode                    =0;
    direction               =0;
    shift                   =0;
    recordaddress           =0;
    startelement            =0;
    elements                =0;
    current_element         =0;
    transmitpos             =0;
    length                  =0;
    startelement_check      =0;
    StartElementInCache     =FALSE;
    CacheElements           =FALSE;

		switch (gBAP_Indication[2])
		{
			case Data_IND:
				//get data
                gMediaBrowser_ASGID =(Indication_array[3] &0xF0) /0x10;
                gMediaBrowser_TAID  =Indication_array[3] &0x0F;
                
                gMediaBrowser_TotalNumListElements =Indication_array[4];
                gMediaBrowser_TotalNumListElements +=(Indication_array[5] *0x100);
                
                gMediaBrowser_ActiveListPos =Indication_array[6]; 
                gMediaBrowser_ActiveListPos +=(Indication_array[7] *0x100);                              
              
                /***ArrayHeader***/
                mode            =(Indication_array[8] &0xF0) /0x10;
                recordaddress   =Indication_array[8] &0x0F;
                Offset =9;
                
                // decode "mode-byte"
                shift       =mode &0x01;
                direction   =(mode &0x02)/0x02;
                transmitpos =(mode &0x04)/0x04;
                indexsize   =(mode &0x08)/0x08; 

                if (indexsize)
                {   
                    startelement =Indication_array[Offset];
                    Offset++;
                    startelement +=(Indication_array[Offset] *0x100);
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                    elements +=(Indication_array[Offset] *0x100);
                    Offset++;
                }
                else
                {   
                    startelement =Indication_array[Offset];
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                }           
            
                if(startelement !=0)
                {
                    for (i=0;i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(startelement ==gMediaBrowser_Pos[i])  
                            i =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;              
                    }
                }

                switch (recordaddress)
                {
                    case 0: //recordaddress =0 -> complete record

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gMediaBrowser_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gMediaBrowser_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gMediaBrowser_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gMediaBrowser_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_MEDIABROWSER_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gMediaBrowser_Pos[i] && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gMediaBrowser_Pos[i] && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gMediaBrowser_ListHandlingType !=AUDIO_MEDIABROWSER_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gMediaBrowser_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //FileType
                                    if(CacheElements ==TRUE)
                                    {
                                        gMediaBrowser_FileType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FileState
                                    if(CacheElements ==TRUE)
                                    {
                                        gMediaBrowser_FileState[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gMediaBrowser_FileState[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gMediaBrowser_FileState_emptyFolder_Bit0[current_element]       =(gMediaBrowser_FileState[current_element] &0x01);
                                        gMediaBrowser_FileState_DRM_Bit1[current_element]               =(gMediaBrowser_FileState[current_element] &0x02) /0x02;
                                        gMediaBrowser_FileState_FileCorrupted_Bit2[current_element]     =(gMediaBrowser_FileState[current_element] &0x04) /0x04; 
                                        gMediaBrowser_FileState_DeadLink_Bit3[current_element]          =(gMediaBrowser_FileState[current_element] &0x08) /0x08;
                                        gMediaBrowser_FileState_ImportFinished_Bit4[current_element]    =(gMediaBrowser_FileState[current_element] &0x10) /0x10;
                                        gMediaBrowser_FileState_ImportPending_Bit5[current_element]     =(gMediaBrowser_FileState[current_element] &0x20) /0x20;
                                        gMediaBrowser_FileState_ImportPlayable_Bit6[current_element]    =(gMediaBrowser_FileState[current_element] &0x40) /0x40;
                                    }

                                   
                                    //FileName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_MEDIABROWSER_FILENAME_LENGTH;i++) //clear
			                                gMediaBrowser_FileName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gMediaBrowser_FileName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gMediaBrowser_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gMediaBrowser_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_MEDIABROWSER_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gMediaBrowser_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gMediaBrowser_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //FileType
                                    if(CacheElements ==TRUE)
                                    {
                                        gMediaBrowser_FileType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FileState
                                    if(CacheElements ==TRUE)
                                    {
                                        gMediaBrowser_FileState[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gMediaBrowser_FileState[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gMediaBrowser_FileState_emptyFolder_Bit0[current_element]       =(gMediaBrowser_FileState[current_element] &0x01);
                                        gMediaBrowser_FileState_DRM_Bit1[current_element]               =(gMediaBrowser_FileState[current_element] &0x02) /0x02;
                                        gMediaBrowser_FileState_FileCorrupted_Bit2[current_element]     =(gMediaBrowser_FileState[current_element] &0x04) /0x04; 
                                        gMediaBrowser_FileState_DeadLink_Bit3[current_element]          =(gMediaBrowser_FileState[current_element] &0x08) /0x08;
                                        gMediaBrowser_FileState_ImportFinished_Bit4[current_element]    =(gMediaBrowser_FileState[current_element] &0x10) /0x10;
                                        gMediaBrowser_FileState_ImportPending_Bit5[current_element]     =(gMediaBrowser_FileState[current_element] &0x20) /0x20;
                                        gMediaBrowser_FileState_ImportPlayable_Bit6[current_element]    =(gMediaBrowser_FileState[current_element] &0x40) /0x40;
                                    }
                                    
                                    //FileName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_MEDIABROWSER_FILENAME_LENGTH;i++) //clear
			                                gMediaBrowser_FileName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gMediaBrowser_FileName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gMediaBrowser_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =MediaBrowser_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0 ends
                    
                    case 1: //recordaddress =1 -> FileType, FileState
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gMediaBrowser_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gMediaBrowser_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gMediaBrowser_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gMediaBrowser_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_MEDIABROWSER_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gMediaBrowser_Pos[i] && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gMediaBrowser_Pos[i] && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gMediaBrowser_ListHandlingType !=AUDIO_MEDIABROWSER_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gMediaBrowser_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //FileType
                                    if(CacheElements ==TRUE)
                                    {
                                        gMediaBrowser_FileType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FileState
                                    if(CacheElements ==TRUE)
                                    {
                                        gMediaBrowser_FileState[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gMediaBrowser_FileState[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gMediaBrowser_FileState_emptyFolder_Bit0[current_element]       =(gMediaBrowser_FileState[current_element] &0x01);
                                        gMediaBrowser_FileState_DRM_Bit1[current_element]               =(gMediaBrowser_FileState[current_element] &0x02) /0x02;
                                        gMediaBrowser_FileState_FileCorrupted_Bit2[current_element]     =(gMediaBrowser_FileState[current_element] &0x04) /0x04; 
                                        gMediaBrowser_FileState_DeadLink_Bit3[current_element]          =(gMediaBrowser_FileState[current_element] &0x08) /0x08;
                                        gMediaBrowser_FileState_ImportFinished_Bit4[current_element]    =(gMediaBrowser_FileState[current_element] &0x10) /0x10;
                                        gMediaBrowser_FileState_ImportPending_Bit5[current_element]     =(gMediaBrowser_FileState[current_element] &0x20) /0x20;
                                        gMediaBrowser_FileState_ImportPlayable_Bit6[current_element]    =(gMediaBrowser_FileState[current_element] &0x40) /0x40;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gMediaBrowser_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gMediaBrowser_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_MEDIABROWSER_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gMediaBrowser_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gMediaBrowser_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //FileType
                                    if(CacheElements ==TRUE)
                                    {
                                        gMediaBrowser_FileType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FileState
                                    if(CacheElements ==TRUE)
                                    {
                                        gMediaBrowser_FileState[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gMediaBrowser_FileState[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gMediaBrowser_FileState_emptyFolder_Bit0[current_element]       =(gMediaBrowser_FileState[current_element] &0x01);
                                        gMediaBrowser_FileState_DRM_Bit1[current_element]               =(gMediaBrowser_FileState[current_element] &0x02) /0x02;
                                        gMediaBrowser_FileState_FileCorrupted_Bit2[current_element]     =(gMediaBrowser_FileState[current_element] &0x04) /0x04; 
                                        gMediaBrowser_FileState_DeadLink_Bit3[current_element]          =(gMediaBrowser_FileState[current_element] &0x08) /0x08;
                                        gMediaBrowser_FileState_ImportFinished_Bit4[current_element]    =(gMediaBrowser_FileState[current_element] &0x10) /0x10;
                                        gMediaBrowser_FileState_ImportPending_Bit5[current_element]     =(gMediaBrowser_FileState[current_element] &0x20) /0x20;
                                        gMediaBrowser_FileState_ImportPlayable_Bit6[current_element]    =(gMediaBrowser_FileState[current_element] &0x40) /0x40;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gMediaBrowser_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =MediaBrowser_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =1 ends
                    
                    case 2: //recordaddress =2 -> FileName
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gMediaBrowser_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gMediaBrowser_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gMediaBrowser_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gMediaBrowser_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_MEDIABROWSER_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gMediaBrowser_Pos[i] && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gMediaBrowser_Pos[i] && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gMediaBrowser_ListHandlingType !=AUDIO_MEDIABROWSER_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gMediaBrowser_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //FileName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_MEDIABROWSER_FILENAME_LENGTH;i++) //clear
			                                gMediaBrowser_FileName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gMediaBrowser_FileName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gMediaBrowser_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gMediaBrowser_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_MEDIABROWSER_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gMediaBrowser_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gMediaBrowser_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }

                                    //FileName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_MEDIABROWSER_FILENAME_LENGTH;i++) //clear
			                                gMediaBrowser_FileName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gMediaBrowser_FileName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gMediaBrowser_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =MediaBrowser_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =2 ends
                    
                    case 15: //recordaddress =0xf -> Pos

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gMediaBrowser_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gMediaBrowser_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gMediaBrowser_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gMediaBrowser_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_MEDIABROWSER_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gMediaBrowser_Pos[i] && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gMediaBrowser_Pos[i] && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gMediaBrowser_ListHandlingType !=AUDIO_MEDIABROWSER_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gMediaBrowser_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                    
                                        gMediaBrowser_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gMediaBrowser_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_MEDIABROWSER_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gMediaBrowser_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gMediaBrowser_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gMediaBrowser_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =MediaBrowser_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0xf ends
                }
                                   
                //Panel
                putvalue(env_ASG_AudioSD_MB_ASGID, gMediaBrowser_ASGID);
                putvalue(env_ASG_AudioSD_MB_TAID, gMediaBrowser_TAID);
                putvalue(env_ASG_AudioSD_MB_TotalNumLE, gMediaBrowser_TotalNumListElements);
                putvalue(env_ASG_AudioSD_MB_ActiveListPos, gMediaBrowser_ActiveListPos);

                gMediaBrowser_recordaddress =recordaddress;
                gMediaBrowser_transmitpos   =transmitpos;             
            
			break;

            case Changed_IND:
                             
              /***ArrayHeader***/
                mode            =(Indication_array[3] &0xF0) /0x10;
                recordaddress   =Indication_array[3] &0x0F;
                Offset =4;
                
                // decode "mode-byte"
                shift       =mode &0x01;
                direction   =(mode &0x02)/0x02;
                transmitpos =(mode &0x04)/0x04;
                indexsize   =(mode &0x08)/0x08; 

                if (indexsize)
                {   
                    startelement =Indication_array[Offset];
                    Offset++;
                    startelement +=(Indication_array[Offset] *0x100);
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                    elements +=(Indication_array[Offset] *0x100);
                    Offset++;
                }
                else
                {   
                    startelement =Indication_array[Offset];
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                }           
            
                if(startelement !=0)
                {
                    for (i=0;i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(startelement ==gMediaBrowser_Pos[i])  
                            i =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;              
                    }
                }

                if(startelement ==0 && shift==0 && transmitpos==0 && recordaddress==0 && elements==65535) //check 'full range update'?
                {
                    putvalue(env_ASG_AudioSD_MB_OnOff, FALSE);
                    putvalue(env_ASG_AudioSD_MB_ListOpState, "'full range update' received");
                }
                else if (datalength>8)
                {
                switch (recordaddress)
                {
                    case 0: //recordaddress =0 -> complete record

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gMediaBrowser_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gMediaBrowser_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gMediaBrowser_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gMediaBrowser_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_MEDIABROWSER_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gMediaBrowser_Pos[i] && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gMediaBrowser_Pos[i] && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gMediaBrowser_ListHandlingType !=AUDIO_MEDIABROWSER_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gMediaBrowser_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //FileType
                                    if(CacheElements ==TRUE)
                                    {
                                        gMediaBrowser_FileType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FileState
                                    if(CacheElements ==TRUE)
                                    {
                                        gMediaBrowser_FileState[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gMediaBrowser_FileState[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gMediaBrowser_FileState_emptyFolder_Bit0[current_element]       =(gMediaBrowser_FileState[current_element] &0x01);
                                        gMediaBrowser_FileState_DRM_Bit1[current_element]               =(gMediaBrowser_FileState[current_element] &0x02) /0x02;
                                        gMediaBrowser_FileState_FileCorrupted_Bit2[current_element]     =(gMediaBrowser_FileState[current_element] &0x04) /0x04; 
                                        gMediaBrowser_FileState_DeadLink_Bit3[current_element]          =(gMediaBrowser_FileState[current_element] &0x08) /0x08;
                                        gMediaBrowser_FileState_ImportFinished_Bit4[current_element]    =(gMediaBrowser_FileState[current_element] &0x10) /0x10;
                                        gMediaBrowser_FileState_ImportPending_Bit5[current_element]     =(gMediaBrowser_FileState[current_element] &0x20) /0x20;
                                        gMediaBrowser_FileState_ImportPlayable_Bit6[current_element]    =(gMediaBrowser_FileState[current_element] &0x40) /0x40;
                                    }

                                   
                                    //FileName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_MEDIABROWSER_FILENAME_LENGTH;i++) //clear
			                                gMediaBrowser_FileName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gMediaBrowser_FileName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gMediaBrowser_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gMediaBrowser_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_MEDIABROWSER_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gMediaBrowser_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gMediaBrowser_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //FileType
                                    if(CacheElements ==TRUE)
                                    {
                                        gMediaBrowser_FileType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FileState
                                    if(CacheElements ==TRUE)
                                    {
                                        gMediaBrowser_FileState[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gMediaBrowser_FileState[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gMediaBrowser_FileState_emptyFolder_Bit0[current_element]       =(gMediaBrowser_FileState[current_element] &0x01);
                                        gMediaBrowser_FileState_DRM_Bit1[current_element]               =(gMediaBrowser_FileState[current_element] &0x02) /0x02;
                                        gMediaBrowser_FileState_FileCorrupted_Bit2[current_element]     =(gMediaBrowser_FileState[current_element] &0x04) /0x04; 
                                        gMediaBrowser_FileState_DeadLink_Bit3[current_element]          =(gMediaBrowser_FileState[current_element] &0x08) /0x08;
                                        gMediaBrowser_FileState_ImportFinished_Bit4[current_element]    =(gMediaBrowser_FileState[current_element] &0x10) /0x10;
                                        gMediaBrowser_FileState_ImportPending_Bit5[current_element]     =(gMediaBrowser_FileState[current_element] &0x20) /0x20;
                                        gMediaBrowser_FileState_ImportPlayable_Bit6[current_element]    =(gMediaBrowser_FileState[current_element] &0x40) /0x40;
                                    }
                                    
                                    //FileName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_MEDIABROWSER_FILENAME_LENGTH;i++) //clear
			                                gMediaBrowser_FileName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gMediaBrowser_FileName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gMediaBrowser_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =MediaBrowser_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0 ends
                    
                    case 1: //recordaddress =1 -> FileType, FileState
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gMediaBrowser_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gMediaBrowser_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gMediaBrowser_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gMediaBrowser_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_MEDIABROWSER_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gMediaBrowser_Pos[i] && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gMediaBrowser_Pos[i] && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gMediaBrowser_ListHandlingType !=AUDIO_MEDIABROWSER_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gMediaBrowser_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //FileType
                                    if(CacheElements ==TRUE)
                                    {
                                        gMediaBrowser_FileType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FileState
                                    if(CacheElements ==TRUE)
                                    {
                                        gMediaBrowser_FileState[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gMediaBrowser_FileState[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gMediaBrowser_FileState_emptyFolder_Bit0[current_element]       =(gMediaBrowser_FileState[current_element] &0x01);
                                        gMediaBrowser_FileState_DRM_Bit1[current_element]               =(gMediaBrowser_FileState[current_element] &0x02) /0x02;
                                        gMediaBrowser_FileState_FileCorrupted_Bit2[current_element]     =(gMediaBrowser_FileState[current_element] &0x04) /0x04; 
                                        gMediaBrowser_FileState_DeadLink_Bit3[current_element]          =(gMediaBrowser_FileState[current_element] &0x08) /0x08;
                                        gMediaBrowser_FileState_ImportFinished_Bit4[current_element]    =(gMediaBrowser_FileState[current_element] &0x10) /0x10;
                                        gMediaBrowser_FileState_ImportPending_Bit5[current_element]     =(gMediaBrowser_FileState[current_element] &0x20) /0x20;
                                        gMediaBrowser_FileState_ImportPlayable_Bit6[current_element]    =(gMediaBrowser_FileState[current_element] &0x40) /0x40;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gMediaBrowser_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gMediaBrowser_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_MEDIABROWSER_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gMediaBrowser_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gMediaBrowser_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //FileType
                                    if(CacheElements ==TRUE)
                                    {
                                        gMediaBrowser_FileType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FileState
                                    if(CacheElements ==TRUE)
                                    {
                                        gMediaBrowser_FileState[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gMediaBrowser_FileState[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gMediaBrowser_FileState_emptyFolder_Bit0[current_element]       =(gMediaBrowser_FileState[current_element] &0x01);
                                        gMediaBrowser_FileState_DRM_Bit1[current_element]               =(gMediaBrowser_FileState[current_element] &0x02) /0x02;
                                        gMediaBrowser_FileState_FileCorrupted_Bit2[current_element]     =(gMediaBrowser_FileState[current_element] &0x04) /0x04; 
                                        gMediaBrowser_FileState_DeadLink_Bit3[current_element]          =(gMediaBrowser_FileState[current_element] &0x08) /0x08;
                                        gMediaBrowser_FileState_ImportFinished_Bit4[current_element]    =(gMediaBrowser_FileState[current_element] &0x10) /0x10;
                                        gMediaBrowser_FileState_ImportPending_Bit5[current_element]     =(gMediaBrowser_FileState[current_element] &0x20) /0x20;
                                        gMediaBrowser_FileState_ImportPlayable_Bit6[current_element]    =(gMediaBrowser_FileState[current_element] &0x40) /0x40;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gMediaBrowser_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =MediaBrowser_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =1 ends
                    
                    case 2: //recordaddress =2 -> FileName
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gMediaBrowser_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gMediaBrowser_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gMediaBrowser_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gMediaBrowser_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_MEDIABROWSER_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gMediaBrowser_Pos[i] && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gMediaBrowser_Pos[i] && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gMediaBrowser_ListHandlingType !=AUDIO_MEDIABROWSER_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gMediaBrowser_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //FileName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_MEDIABROWSER_FILENAME_LENGTH;i++) //clear
			                                gMediaBrowser_FileName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gMediaBrowser_FileName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gMediaBrowser_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gMediaBrowser_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_MEDIABROWSER_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gMediaBrowser_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gMediaBrowser_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }

                                    //FileName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_MEDIABROWSER_FILENAME_LENGTH;i++) //clear
			                                gMediaBrowser_FileName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gMediaBrowser_FileName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gMediaBrowser_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =MediaBrowser_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =2 ends
                    
                    case 15: //recordaddress =0xf -> Pos

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gMediaBrowser_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gMediaBrowser_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gMediaBrowser_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gMediaBrowser_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_MEDIABROWSER_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gMediaBrowser_Pos[i] && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gMediaBrowser_Pos[i] && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gMediaBrowser_ListHandlingType !=AUDIO_MEDIABROWSER_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gMediaBrowser_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                    
                                        gMediaBrowser_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gMediaBrowser_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =MediaBrowser_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_MEDIABROWSER_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gMediaBrowser_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gMediaBrowser_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gMediaBrowser_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gMediaBrowser_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =MediaBrowser_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0xf ends
                }
                }                   
                
                //Panel
                gMediaBrowser_recordaddress =recordaddress;
                gMediaBrowser_transmitpos   =transmitpos;             
            
            break;
			
            case Error_IND:
					
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaBrowser_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaBrowser_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaBrowser_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaBrowser_Indication: Application-Error: 0x%x", Indication_array[3]);
				
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD MediaBrowser_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
		}

    //for "sliding window concept"
    if(gMediaBrowser_TotalNumListElements<=AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE)
        gMediaBrowser_SlidingWindow_State =AUDIO_MEDIABROWSER_SLIDINGWINDOW_NOTACTIVE;
    else
        gMediaBrowser_SlidingWindow_State =AUDIO_MEDIABROWSER_SLIDINGWINDOW_ACTIVE;

    if (gMediaBrowser_CallBackReason !=AUDIO_MEDIABROWSER_CALLBACKREASON_NOCALLBACK)
        MediaBrowser_ListHandling ();
    else
        MediaBrowser_display();
}

MediaBrowser_Request (byte request, byte mode, byte recordaddress, word requested_startelement, word startelement, word elements)
{   
    int  i;
    dword requestarray [BAP_BUFFER_SIZE], Offset;
    word indexsize;

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;
    
    indexsize   =0;
    Offset      =0;

    // decode "mode-byte"
    indexsize   =(mode &0x08)/0x08; 

    // Handle request.
    requestarray[0] =LSG_AudioSD;	        //LSG-ID
	requestarray[1] =FctID_MediaBrowser;	//Fct.-ID
	requestarray[2] =request;               //request type

    switch(request)
	{
        case DataGet_REQ:              
                requestarray[3] =((gMediaBrowser_ASGID *0x10) &0xF0) +(gMediaBrowser_TAID &0x0F);
                
                /***ArrayHeader***/
			    requestarray[4] =((mode *0x10) &0xF0) +(recordaddress &0x0F);          
                Offset =5;

                if(indexsize)
                {
                    requestarray[Offset] =requested_startelement &0x00FF;
                    Offset++;
                    requestarray[Offset] =(requested_startelement &0xFF00) /0x100;
                    Offset++;  

                    requestarray[Offset] =elements &0x00FF;
                    Offset++;
                    requestarray[Offset] =(elements &0xFF00) /0x100;
                    Offset++;       
                }
                else
                {
                    requestarray[Offset] =requested_startelement;
                    Offset++;

                    requestarray[Offset] =elements;
                    Offset++;
                }
            
            set_status_requestbuffer (requestarray, Offset, Bap_ByteSequence);
         break;

        default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD MediaBrowser_Request: invalid request %d", request);
		break;
    }
}

MediaBrowserControl_Indication (dword Indication_array [], int datalength)
{
	switch (gBAP_Indication[2])
	{
		case Processing_IND:
		break;
		case Result_IND:
				
                gAudioSD_MBrC_Result =Indication_array[3];
                if(gAudioSD_MBrC_Result <0x04)	
					putvalue(env_ASG_AudioSD_MBrC_Res_s, gAudioSD_MBrC_Result_s[gAudioSD_MBrC_Result]);   
				else
					putvalue(env_ASG_AudioSD_MBrC_Res_s, gstring_reserved);               
		break;
		case Error_IND:
				
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaBrowserControl_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30 && Indication_array[3] !=0)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaBrowserControl_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40 && Indication_array[3] !=0)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaBrowserControl_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
				{	
                    writelineEx(gError_Trace, 0, "ASG-AudioSD MediaBrowserControl_Indication: Application-Error: 0x%x", Indication_array[3]);
                    putvalue(env_ASG_AudioSD_MBrC_Err,Indication_array[3]);
                    
                    if (Indication_array[3] ==0)
                        putvalue(env_ASG_AudioSD_MBrC_Err_s,"no error");
                    
                    else if((Indication_array[3]-0x40)<17)
                        putvalue(env_ASG_AudioSD_MBrC_Err_s,gerror_codes_0x40_0x7F[Indication_array[3]-0x40]);
                    else
                        putvalue(env_ASG_AudioSD_MBrC_Err_s,gstring_reserved); 
                }
			
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD MediaBrowserControl_Indication:: unknown indication %d", gBAP_Indication[2]);
		break;
	}
}

MediaBrowserControl_Request (byte request, byte errorcode)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	                //LSG-ID
	requestarray[1] =FctID_MediaBrowserControl;	    //Fct.-ID
	requestarray[2] =request;                       //request type
	
    switch(request)
	{
		case StartResult_REQ:
            requestarray[3] =gAudioSD_MBrC_Control;                 
		    requestarray[4] =gAudioSD_MBrC_Ref &0x00FF;
            requestarray[5] =(gAudioSD_MBrC_Ref &0xFF00) /0x100;

			set_status_requestbuffer (requestarray, 6, Bap_ByteSequence);
		break;
        case AbortResult_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD MediaBrowserControl_Request: invalid request %d", request);
		break;
	}
}

MediaFileInfo_Indication (dword Indication_array [], int datalength)
{
    int i =0, Offset =0, length =0;
	
    switch (gBAP_Indication[2])
	{
		case Processing_IND:
		break;
		case Result_IND:
				
            if(datalength >=5) 
            {
                gAudioSD_MediaFileInfo_Result =Indication_array[3];

                //Artist
                //clear string
                for(i=0; i<AUDIO_MEDIAFILINFO_ARTIST_LENGTH; i++)
                    gAudioSD_MediaFileInfo_Artist_s[i] =0;
                    
                length =Indication_array[4];
                Offset=5;

                for (i=0; i<length;i++)
                {
                    gAudioSD_MediaFileInfo_Artist_s[i]  =Indication_array[Offset];
                    Offset++;
                }

                //Title
                //clear string
                for(i=0; i<AUDIO_MEDIAFILINFO_TITLE_LENGTH; i++)
                    gAudioSD_MediaFileInfo_Title_s[i] =0;
                    
                length =Indication_array[Offset];
                Offset++;

                for (i=0; i<length;i++)
                {
                    gAudioSD_MediaFileInfo_Title_s[i]  =Indication_array[Offset];
                    Offset++;
                }

                //Album
                //clear string
                for(i=0; i<AUDIO_MEDIAFILINFO_ALBUM_LENGTH; i++)
                    gAudioSD_MediaFileInfo_Album_s[i] =0;
                    
                length =Indication_array[Offset];
                Offset++;

                for (i=0; i<length;i++)
                {
                    gAudioSD_MediaFileInfo_Album_s[i]  =Indication_array[Offset];
                    Offset++;
                } 
                
                //Panel
                if(gAudioSD_MediaFileInfo_Result <0x04)	
					putvalue(env_ASG_AudioSD_MFI_Res_s, gAudioSD_MediaFileInfo_Result_s[gAudioSD_MediaFileInfo_Result]);   
				else
					putvalue(env_ASG_AudioSD_MFI_Res_s, gstring_reserved);  

                putvalue(env_ASG_AudioSD_MFI_Artist_s, gAudioSD_MediaFileInfo_Artist_s);
                putvalue(env_ASG_AudioSD_MFI_Title_s, gAudioSD_MediaFileInfo_Title_s);
                putvalue(env_ASG_AudioSD_MFI_Album_s, gAudioSD_MediaFileInfo_Album_s);             
            }		
        break;
		case Error_IND:
				
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaFileInfo_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30 && Indication_array[3] !=0)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaFileInfo_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40 && Indication_array[3] !=0)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaFileInfo_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
				{	
                    writelineEx(gError_Trace, 0, "ASG-AudioSD MediaFileInfo_Indication: Application-Error: 0x%x", Indication_array[3]);
                    putvalue(env_ASG_AudioSD_MFI_Err,Indication_array[3]);
                    
                    if (Indication_array[3] ==0)
                        putvalue(env_ASG_AudioSD_MFI_Err_s,"no error");
                    
                    else if((Indication_array[3]-0x40)<17)
                        putvalue(env_ASG_AudioSD_MFI_Err_s,gerror_codes_0x40_0x7F[Indication_array[3]-0x40]);
                    else
                        putvalue(env_ASG_AudioSD_MFI_Err_s,gstring_reserved);
                }
			
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD MediaFileInfo_Indication:: unknown indication %d", gBAP_Indication[2]);
		break;
	}
}

MediaFileInfo_Request (byte request, byte errorcode)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	        //LSG-ID
	requestarray[1] =FctID_MediaFileInfo;	//Fct.-ID
	requestarray[2] =request;               //request type
	
    switch(request)
	{
		case StartResult_REQ:               
		    requestarray[3] =gAudioSD_MediaFileInfo_Ref;

			set_status_requestbuffer (requestarray, 4, Bap_UInt16);
		break;
        case AbortResult_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD MediaFileInfo_Request: invalid request %d", request);
		break;
	}
}

GetNextListPos_Indication (dword Indication_array [], int datalength)
{
	switch (gBAP_Indication[2])
	{
		case Processing_IND:
		break;
		case Result_IND:
				
                gAudioSD_GetNextListPos_Result          =Indication_array[3];
                gAudioSD_GetNextListPos_CurrentPos      =Indication_array[4] +(Indication_array[5] *0x100);
                gAudioSD_GetNextListPos_nextPos         =Indication_array[6] +(Indication_array[7] *0x100);
                gAudioSD_GetNextListPos_absoluteListPos =Indication_array[8] +(Indication_array[9] *0x100);

                //Panel
                if(gAudioSD_GetNextListPos_Result <0x04)	
        					putvalue(env_ASG_AudioSD_GNLP_Res_s, gAudioSD_GetNextListPos_Result_string[gAudioSD_GetNextListPos_Result]);   
        				else
        					putvalue(env_ASG_AudioSD_GNLP_Res_s, gstring_reserved);
                    
                putvalue(env_ASG_AudioSD_GNLP_CurrPos, gAudioSD_GetNextListPos_CurrentPos);
                putvalue(env_ASG_AudioSD_GNLP_nextPos, gAudioSD_GetNextListPos_nextPos);
                putvalue(env_ASG_AudioSD_GNLP_AbsPos, gAudioSD_GetNextListPos_absoluteListPos);               
		break;
		case Error_IND:
				
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD GetNextListPos_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30 && Indication_array[3] !=0)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD GetNextListPos_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40 && Indication_array[3] !=0)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD GetNextListPos_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
				{	
                    writelineEx(gError_Trace, 0, "ASG-AudioSD GetNextListPos_Indication: Application-Error: 0x%x", Indication_array[3]);
                    putvalue(env_ASG_AudioSD_GNLP_Err,Indication_array[3]);
                    
                    if (Indication_array[3] ==0)
                        putvalue(env_ASG_AudioSD_GNLP_Err_s,"no error");
                    
                    else if((Indication_array[3]-0x40)<17)
                        putvalue(env_ASG_AudioSD_GNLP_Err_s,gerror_codes_0x40_0x7F[Indication_array[3]-0x40]);
                    else
                        putvalue(env_ASG_AudioSD_GNLP_Err_s,gstring_reserved); 
                }
			
		        
        break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD GetNextListPos_Indication:: unknown indication %d", gBAP_Indication[2]);
		break;
	}
}

GetNextListPos_Request (byte request, byte errorcode)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	        //LSG-ID
	requestarray[1] =FctID_GetNextListPos;	//Fct.-ID
	requestarray[2] =request;               //request type
	
    switch(request)
	{
		case StartResult_REQ:                
		    requestarray[3] =gAudioSD_GetNextListPos_CurrentPos &0x00FF;
            requestarray[4] =(gAudioSD_GetNextListPos_CurrentPos &0xFF00) /0x100;
            requestarray[5] =gAudioSD_GetNextListPos_Offset &0x00FF;
            requestarray[6] =(gAudioSD_GetNextListPos_Offset &0xFF00) /0x100;
            requestarray[7] =gAudioSD_GetNextListPos_ListType;

			set_status_requestbuffer (requestarray, 8, Bap_ByteSequence);
		break;
        case AbortResult_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD GetNextListPos_Request: invalid request %d", request);
		break;
	}
}

on envVar env_ASG_AudioSD_DAC_Abort
{
	if(POWER_ON==gASG_PowerOnOff && TRUE==gBAP_AudioSD_available && getvalue(this))
    {        
        DedicatedAudioControl_Request(AbortResult_REQ, 0);
        
        putvalue(env_ASG_AudioSD_DAC_Err,0);
        putvalue(env_ASG_AudioSD_DAC_Err_s,empty_string);
        putvalue(env_ASG_AudioSD_DAC_Res_s,empty_string);
    }
}

on envVar env_ASG_AudioSD_AnE_SR
{
    if(POWER_ON==gASG_PowerOnOff && TRUE==gBAP_AudioSD_available && getvalue(this))
    {
        putvalue(env_ASG_AudioSD_AnE_Err,0);
        putvalue(env_ASG_AudioSD_AnE_Err_s,empty_string);
        putvalue(env_ASG_AudioSD_AnE_Res_s,empty_string);
        
        AnnouncementEscape_Request(StartResult_REQ, 0);
    }
}

on envVar env_ASG_AudioSD_AnE_Abort
{
    if(POWER_ON==gASG_PowerOnOff && TRUE==gBAP_AudioSD_available && getvalue(this))
    {
        AnnouncementEscape_Request(AbortResult_REQ, 0);
        
        putvalue(env_ASG_AudioSD_AnE_Err,0);
        putvalue(env_ASG_AudioSD_AnE_Err_s,empty_string);
        putvalue(env_ASG_AudioSD_AnE_Res_s,empty_string);
    }
}

on envVar env_ASG_AudioSD_SwSource_SR
{
	if(POWER_ON==gASG_PowerOnOff && TRUE==gBAP_AudioSD_available && getvalue(this))
    {
        gAudioSD_SwitchSource_Ref  =getvalue(env_ASG_AudioSD_SwSource_Ref);

        putvalue(env_ASG_AudioSD_SwSource_Err,0);
        putvalue(env_ASG_AudioSD_SwSource_Err_s,empty_string);
        putvalue(env_ASG_AudioSD_SwSource_Res_s,empty_string);
        
        SwitchSource_Request(StartResult_REQ, 0);
    }
}

on envVar env_ASG_AudioSD_SwSource_abort
{
	if(POWER_ON==gASG_PowerOnOff && TRUE==gBAP_AudioSD_available && getvalue(this))
    {
        putvalue(env_ASG_AudioSD_SwSource_Err,0);
        putvalue(env_ASG_AudioSD_SwSource_Err_s,empty_string);
        putvalue(env_ASG_AudioSD_SwSource_Res_s,empty_string);

        SwitchSource_Request(AbortResult_REQ, 0);
    }
}

on envVar env_ASG_AudioSD_MBrC_SR
{
	if(POWER_ON==gASG_PowerOnOff && TRUE==gBAP_AudioSD_available && getvalue(this))
	{
		gAudioSD_MBrC_Control     =getvalue(env_ASG_AudioSD_MBrC_Control);
        gAudioSD_MBrC_Ref         =getvalue(env_ASG_AudioSD_MBrC_Ref);

        putvalue(env_ASG_AudioSD_MBrC_Err,0);
        putvalue(env_ASG_AudioSD_MBrC_Err_s,empty_string);
        putvalue(env_ASG_AudioSD_MBrC_Res_s,empty_string);
        
        MediaBrowserControl_Request(StartResult_REQ, 0);
	}
}

on envVar env_ASG_AudioSD_MBrC_Abort
{
	if(POWER_ON==gASG_PowerOnOff && TRUE==gBAP_AudioSD_available && getvalue(this))
    {
        putvalue(env_ASG_AudioSD_MBrC_Err,0);
        putvalue(env_ASG_AudioSD_MBrC_Err_s,empty_string);
        putvalue(env_ASG_AudioSD_MBrC_Res_s,empty_string);
            
        MediaBrowserControl_Request(AbortResult_REQ, 0);
    }
}

on envVar env_ASG_AudioSD_MFI_SR
{
	if(POWER_ON==gASG_PowerOnOff && TRUE==gBAP_AudioSD_available && getvalue(this))
	{
		gAudioSD_MediaFileInfo_Ref  =getvalue(env_ASG_AudioSD_MFI_Ref);

        putvalue(env_ASG_AudioSD_MFI_Err,0);
        putvalue(env_ASG_AudioSD_MFI_Err_s,empty_string);
        putvalue(env_ASG_AudioSD_MFI_Res_s,empty_string);
        
        MediaFileInfo_Request(StartResult_REQ, 0);
	}
}

on envVar env_ASG_AudioSD_MFI_abort
{
	if(POWER_ON==gASG_PowerOnOff && TRUE==gBAP_AudioSD_available && getvalue(this))
    {
        putvalue(env_ASG_AudioSD_MFI_Err,0);
        putvalue(env_ASG_AudioSD_MFI_Err_s,empty_string);
        putvalue(env_ASG_AudioSD_MFI_Res_s,empty_string);

        MediaFileInfo_Request(AbortResult_REQ, 0);
    }
}

on envVar env_ASG_AudioSD_GNLP_SR
{
	if(POWER_ON==gASG_PowerOnOff && TRUE==gBAP_AudioSD_available && getvalue(this))
	{
		gAudioSD_GetNextListPos_CurrentPos  =getvalue(env_ASG_AudioSD_GNLP_CurrPos);
        gAudioSD_GetNextListPos_Offset      =getvalue(env_ASG_AudioSD_GNLP_Offset);
        gAudioSD_GetNextListPos_ListType    =getvalue(env_ASG_AudioSD_GNLP_LT);

        putvalue(env_ASG_AudioSD_GNLP_Err,0);
        putvalue(env_ASG_AudioSD_GNLP_Err_s,empty_string);
        putvalue(env_ASG_AudioSD_GNLP_Res_s,empty_string);
        
        GetNextListPos_Request(StartResult_REQ, 0);
	}
}

on envVar env_ASG_AudioSD_GNLP_abort
{
	if(POWER_ON==gASG_PowerOnOff && TRUE==gBAP_AudioSD_available && getvalue(this))
    {
        putvalue(env_ASG_AudioSD_GNLP_Err,0);
        putvalue(env_ASG_AudioSD_GNLP_Err_s,empty_string);
        putvalue(env_ASG_AudioSD_GNLP_Res_s,empty_string);

        GetNextListPos_Request(AbortResult_REQ, 0);
    }
}

int ReceptionList_GetNextCachedElement (int currentElement,byte direction)
{
    int i=0, nextElement=0;

    switch (direction)
    {
        case AUDIO_RECEPTIONLIST_DISPLAYLIST_FIND_NEXT_ELEMENT:                
                nextElement = ++currentElement;

                if (nextElement<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE) //start at next element, if next element is not >8
                {
                    for(i =nextElement; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i= AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;
                        }
                        else
                            nextElement =0;
                    }
                }
                else    //start at first element
                {
                    nextElement =0;

                    for(i =nextElement; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;
                        }   
                    }
                }
        break;

        case AUDIO_RECEPTIONLIST_DISPLAYLIST_FIND_PREVIUOS_ELEMENT:
                nextElement = --currentElement;
                if (nextElement ==0 && gReceptionList_ListEntryReceptionInformation[nextElement] ==TRUE)
                    nextElement =0;
                else if (nextElement>0) 
                {
                    for(i =nextElement; i>0; i--)
                    {
                        if(gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =0;
                        }
                        else
                            nextElement =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE-1;
                    }
                }    
                else    //start at last element
                {
                    nextElement =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE-1;

                    for(i =nextElement; i>0; i--)
                    {
                        if(gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =0;
                        }
                        else if(gReceptionList_ListEntryReceptionInformation[0] ==TRUE)
                            nextElement =0;          
                    }
                }
        break;

        default:
        break;
    }
    return(nextElement);
}

int ReceptionList_GetNextLineInCache (int currentElement,byte direction)
{
    int i=0, nextElement=0;

    switch (direction)
    {
        case FORWARD:
                           
                if(currentElement<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE-1 && currentElement !=5) 
                    nextElement = ++currentElement;  
                
                else if (currentElement ==8)            
                    nextElement =0;
                else
                    nextElement =AUDIO_RECEPTIONLIST_NO_NEXT_POSITION;
        break;

        case BACKWARD:
                if(currentElement<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE && currentElement !=0 && currentElement !=6) 
                    nextElement =--currentElement;
                
                else if (currentElement ==0)            
                    nextElement =8;
                
                else
                    nextElement =AUDIO_RECEPTIONLIST_NO_NEXT_POSITION;
        break;

        default:
        break;
    }
    return(nextElement);
}

ReceptionList_ListHandling () //for sliding window concept, list handling and 'build-up' list...
{
    byte mode, shift, direction, transmitpos, indexsize, recordaddress, buffer_Type, buffer_PresetID, buffer_FmREG_Code, buffer_Category, buffer_ReceptionInformation;
    byte buffer_Attributes_bit0, buffer_Attributes_bit1, buffer_Attributes_bit2, buffer_Attributes_bit3, 
      buffer_Attributes_bit4, buffer_Attributes_bit5, buffer_Attributes_bit6, buffer_Attributes_bit7, 
      buffer_Attributes_bit8, buffer_Attributes_bit9, buffer_Attributes_bitA, buffer_Attributes_bitB, buffer_Attributes_bitC;
    word requested_startelement, startelement, elements, buffer_Pos, buffer_Attributes;
    char buffer_Name[AUDIO_RECEPTIONLIST_NAME_LENGTH], buffer_Frequency[AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH];
    int i,j,k;
    
    // Init local variables. 
    mode                        =0;
    shift                       =0;
    direction                   =0;
    transmitpos                 =0;
    indexsize                   =0;
    recordaddress               =0;
    requested_startelement      =0;
    startelement                =0;
    elements                    =0;
    i                           =0;
    j                           =0;
    k                           =0;
    buffer_Pos                  =0;
    buffer_Type                 =0;
    buffer_PresetID             =0;
    buffer_ReceptionInformation =0;
    buffer_Attributes           =0;
    buffer_Attributes_bit0      =0;
    buffer_Attributes_bit1      =0;
    buffer_Attributes_bit2      =0;
    buffer_Attributes_bit3      =0;
    buffer_Attributes_bit4      =0;
    buffer_Attributes_bit5      =0;
    buffer_Attributes_bit6      =0;
    buffer_Attributes_bit7      =0;
    buffer_Attributes_bit8      =0;
    buffer_Attributes_bit9      =0;
    buffer_Attributes_bitA      =0;
    buffer_Attributes_bitB      =0;
    buffer_Attributes_bitC      =0;
    buffer_PresetID             =0;
    
    /***build-up complete cache***/

    switch (gReceptionList_ListHandlingType)
    {
        case AUDIO_RECEPTIONLIST_BUILDUPCACHE:
             
            switch (gReceptionList_cacheBuildUp)
            {   
                //cache-up  
                case AUDIO_RECEPTIONLIST_BUILDUPCACHECACHE_UP:  
                    if(gReceptionList_CallBackReason !=AUDIO_RECEPTIONLIST_BUILDUPCACHENOCACHE && gReceptionList_CallBackReason !=AUDIO_RECEPTIONLIST_CALLBACKREASON_CACHENEXT)
                    {
                        switch (gReceptionList_CallBackReason)
                        {
                            case AUDIO_RECEPTIONLIST_CALLBACKREASON_CHECKCACHE:

                                    if(gReceptionList_ListEntryReceptionInformation[2] ==TRUE) //cache-down required?
                                    {            
                                        gReceptionList_cacheBuildUp      =AUDIO_RECEPTIONLIST_BUILDUPCACHECACHE_DOWN;      //next step: build-up upper cache
                                        gReceptionList_CallBackReason    =AUDIO_RECEPTIONLIST_CALLBACKREASON_CACHENEXT;    
                                        
                                        
                                        ReceptionList_ListHandling ();
                                    }
                                    else //stop caching
                                    {   
                                        gReceptionList_cacheBuildUp      =AUDIO_RECEPTIONLIST_BUILDUPCACHENOCACHE;  //"build-up cache" finished
                                        gReceptionList_ListHandlingType  =AUDIO_RECEPTIONLIST_NOCACHE;              
                                        gReceptionList_CallBackReason    =AUDIO_RECEPTIONLIST_CALLBACKREASON_NOCALLBACK; 
                                        gReceptionList_CursorAction      =AUDIO_RECEPTIONLIST_CURSORACTION_NOTHING;
                                        
                                        putvalue(env_ASG_AudioSD_RL_ListOpState, empty_string);
                                        ReceptionList_display();
                                    }
                            break;
                        }
                    }
                    else
                    {   
                        shift               =TRUE;
                        direction           =BACKWARD;
                        transmitpos         =FALSE;
                        indexsize           =TRUE;
                        recordaddress       =0;
                        startelement        =0;
                        elements            =3;
                
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gReceptionList_CallBackReason  =AUDIO_RECEPTIONLIST_CALLBACKREASON_CHECKCACHE;

                        ReceptionList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;
                
                //cache "window"
                case AUDIO_RECEPTIONLIST_BUILDUPCACHECACHE_WINDOW: 
                    if(gReceptionList_CallBackReason !=AUDIO_RECEPTIONLIST_BUILDUPCACHENOCACHE && gReceptionList_CallBackReason !=AUDIO_RECEPTIONLIST_CALLBACKREASON_CACHENEXT)
                    {   
                        switch (gReceptionList_CallBackReason)
                        {
                            case AUDIO_RECEPTIONLIST_CALLBACKREASON_CHECKCACHE:
                                                 
                                    gReceptionList_cacheBuildUp      =AUDIO_RECEPTIONLIST_BUILDUPCACHECACHE_UP;      //next step: build-up upper cache
                                    gReceptionList_CallBackReason    =AUDIO_RECEPTIONLIST_CALLBACKREASON_CACHENEXT;    
                                    
                                    ReceptionList_ListHandling ();
                            break;
                        }
                    }
                    else
                    { 
                        putvalue(env_ASG_AudioSD_RL_ListOpState, "build-up list...");
                        shift               =FALSE;
                        direction           =FORWARD;
                        transmitpos         =FALSE;
                        indexsize           =TRUE;
                        recordaddress       =0;
                        startelement        =0;
                        elements            =3; 
    
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gReceptionList_CallBackReason  =AUDIO_RECEPTIONLIST_CALLBACKREASON_CHECKCACHE;

                        ReceptionList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;
                
                //cache-down
                case AUDIO_RECEPTIONLIST_BUILDUPCACHECACHE_DOWN:
                    if(gReceptionList_CallBackReason !=AUDIO_RECEPTIONLIST_BUILDUPCACHENOCACHE && gReceptionList_CallBackReason !=AUDIO_RECEPTIONLIST_CALLBACKREASON_CACHENEXT)
                    {
                        switch (gReceptionList_CallBackReason)
                        {
                            case AUDIO_RECEPTIONLIST_CALLBACKREASON_CHECKCACHE:
                                    
                                    //stop caching
                                    gReceptionList_cacheBuildUp      =AUDIO_RECEPTIONLIST_BUILDUPCACHENOCACHE;  //"build-up cache" finished
                                    gReceptionList_ListHandlingType  =AUDIO_RECEPTIONLIST_NOCACHE;              
                                    gReceptionList_CallBackReason    =AUDIO_RECEPTIONLIST_CALLBACKREASON_NOCALLBACK;
                                    gReceptionList_CursorAction      =AUDIO_RECEPTIONLIST_CURSORACTION_NOTHING;
                                    
                                    gReceptionList_DisplayStatus     =AUDIO_RECEPTIONLIST_DISPLAYLIST_REFRESH;
                                    
                                    putvalue(env_ASG_AudioSD_RL_ListOpState, empty_string);
                                    ReceptionList_display();
                            break;
                        }
                    }
                    else
                    { 
                        shift                   =TRUE;
                        direction               =FORWARD;
                        transmitpos             =FALSE;
                        indexsize               =TRUE;
                        recordaddress           =0;
                        for(i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++) //find last cached element
                        {   
                            if(gReceptionList_ListEntryReceptionInformation[i] ==FALSE) //abort loop
                                i =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; 
                            else
                                startelement    =gReceptionList_Pos[i];
                        }
                        elements                =3;                         
        
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gReceptionList_CallBackReason    =AUDIO_RECEPTIONLIST_CALLBACKREASON_CHECKCACHE;
                        
                        ReceptionList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;

                default:
                break;
            }//build-up cache finished
        break;
        
        /********sliding-window********/
        case AUDIO_RECEPTIONLIST_DOWN_CACHE: 
                    if (gReceptionList_CallBackReason ==AUDIO_RECEPTIONLIST_CALLBACKREASON_CHECKCACHE) //check if valid data received
                    {   
                        if(gReceptionList_ListEntryReceptionInformation[5] ==0) //No valid data in last list pos -> last list element reached, start with element 0!  
                        {    
                            shift                   =FALSE;
                            direction               =FORWARD;
                            transmitpos             =FALSE;
                            indexsize               =TRUE;
                            recordaddress           =0;
                            startelement            =0; //first element
                            elements                =1;        
                            
                            requested_startelement  =startelement;
                            mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;
                            
                            gReceptionList_CallBackReason    =AUDIO_RECEPTIONLIST_CALLBACKREASON_DISPLAYLIST; 
                            gReceptionList_cacheDown         =TRUE;

                            ReceptionList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);    
                        }
                        else
                        {
                            gReceptionList_CallBackReason =AUDIO_RECEPTIONLIST_CALLBACKREASON_DISPLAYLIST;
                            ReceptionList_ListHandling(); 
                        }    
                    }
                    else if (gReceptionList_CallBackReason ==AUDIO_RECEPTIONLIST_CALLBACKREASON_DISPLAYLIST)
                    {   
                        gReceptionList_ListHandlingType  =AUDIO_RECEPTIONLIST_NOCACHE;
                        gReceptionList_cacheDown         =FALSE;
                        gReceptionList_DisplayStatus     =AUDIO_RECEPTIONLIST_DISPLAYLIST_FIRST_ELEMENTS;
                        
                        putvalue(env_ASG_AudioSD_RL_ListOpState, empty_string);
                        ReceptionList_display();
                        gReceptionList_DisplayStatus     =AUDIO_RECEPTIONLIST_DISPLAYLIST_REFRESH;
                        gReceptionList_CallBackReason    =AUDIO_RECEPTIONLIST_CALLBACKREASON_NOCALLBACK;
                    }
                    else
                    {   
                        putvalue(env_ASG_AudioSD_RL_ListOpState, "list operating...");
                                
                        shift                   =TRUE;
                        direction               =FORWARD;
                        transmitpos             =FALSE;
                        indexsize               =TRUE;
                        recordaddress           =0;
                        startelement            =gReceptionList_Pos[5]; //last element
                        elements                =1;
                        
                        for(i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
                        {   
                            j =i+1;
                            
                            switch (i)
                            {   
                                case 0: 
                                    //buffer data of Pos '0' (local)
                                    buffer_Pos              =gReceptionList_Pos[i];
                                    buffer_Type             =gReceptionList_Type[i];
                                    buffer_Attributes       =gReceptionList_Attributes[i];
                                    buffer_Attributes_bit0  =gReceptionList_Attributes_available_Bit0[i];
                                    buffer_Attributes_bit1  =gReceptionList_Attributes_DVB_Bit1[i];
                                    buffer_Attributes_bit2  =gReceptionList_Attributes_DAB_Bit2[i];
                                    buffer_Attributes_bit3  =gReceptionList_Attributes_DAB_Bit3[i];
                                    buffer_Attributes_bit4  =gReceptionList_Attributes_DAB_Bit4[i];
                                    buffer_Attributes_bit5  =gReceptionList_Attributes_TP_Bit5[i];
                                    buffer_Attributes_bit6  =gReceptionList_Attributes_TMC_Bit6[i];
                                    buffer_Attributes_bit7  =gReceptionList_Attributes_SDARS_Bit7[i];
                                    buffer_Attributes_bit8  =gReceptionList_Attributes_DABserv_Bit8[i];
                                    buffer_Attributes_bit9  =gReceptionList_Attributes_FMOnline_Bit9[i];
                                    buffer_Attributes_bitA  =gReceptionList_Attributes_StationSelect_BitA[i];
                                    buffer_Attributes_bitB  =gReceptionList_Attributes_OnlineRadioMute_BitB[i];
                                    buffer_Attributes_bitC  =gReceptionList_Attributes_StationLinked_BitC[i];
                                    buffer_PresetID         =gReceptionList_PresetID[i];
                                    buffer_FmREG_Code       =gReceptionList_FmRegCode[i];
                                    buffer_Category         =gReceptionList_Category[i];

                                    for (k=0; k<AUDIO_RECEPTIONLIST_NAME_LENGTH;k++) //clear string
                                        buffer_Name[k] =0;                                     

                                    for(k=0;k<strlen(gReceptionList_Name[i]);k++) 
                                        buffer_Name[k]=gReceptionList_Name[i][k];
                                    
                                    for (k=0; k<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;k++) //clear string
                                        buffer_Frequency[k] =0;                                     

                                    for(k=0;k<strlen(gReceptionList_Frequency[i]);k++) 
                                        buffer_Frequency[k]=gReceptionList_Frequency[i][k];
                                    

                                    //copy data from Pos '1' to Pos '0'
                                    gReceptionList_Pos[i]                       =gReceptionList_Pos[j]; 
                                    gReceptionList_Type[i]                      =gReceptionList_Type[j];
                                    gReceptionList_Attributes[i]                =gReceptionList_Attributes[j];
                                    gReceptionList_Attributes_available_Bit0[i] =gReceptionList_Attributes_available_Bit0[j];
                                    gReceptionList_Attributes_DVB_Bit1[i]       =gReceptionList_Attributes_DVB_Bit1[j];
                                    gReceptionList_Attributes_DAB_Bit2[i]       =gReceptionList_Attributes_DAB_Bit2[j];
                                    gReceptionList_Attributes_DAB_Bit3[i]       =gReceptionList_Attributes_DAB_Bit3[j];
                                    gReceptionList_Attributes_DAB_Bit4[i]       =gReceptionList_Attributes_DAB_Bit4[j];
                                    gReceptionList_Attributes_TP_Bit5[i]        =gReceptionList_Attributes_TP_Bit5[j];
                                    gReceptionList_Attributes_TMC_Bit6[i]       =gReceptionList_Attributes_TMC_Bit6[j];
                                    gReceptionList_Attributes_SDARS_Bit7[i]     =gReceptionList_Attributes_SDARS_Bit7[j];
                                    gReceptionList_Attributes_DABserv_Bit8[i]   =gReceptionList_Attributes_DABserv_Bit8[j];
                                    gReceptionList_Attributes_FMOnline_Bit9[i]  =gReceptionList_Attributes_FMOnline_Bit9[j];
                                    gReceptionList_Attributes_StationSelect_BitA[i]  =gReceptionList_Attributes_StationSelect_BitA[j];
                                    gReceptionList_Attributes_OnlineRadioMute_BitB[i]=gReceptionList_Attributes_OnlineRadioMute_BitB[j];
                                    gReceptionList_Attributes_StationLinked_BitC[i]  =gReceptionList_Attributes_StationLinked_BitC[j];
                                    gReceptionList_PresetID[i]      =gReceptionList_PresetID[j]; 
                                    gReceptionList_FmRegCode[i]     =gReceptionList_FmRegCode[j];
                                    gReceptionList_Category[i]      =gReceptionList_Category[j];
                                
                                    for (k=0; k<AUDIO_RECEPTIONLIST_NAME_LENGTH;k++) //clear string
                                        gReceptionList_Name[i][k] =0;                                     

                                    for(k=0;k<strlen(gReceptionList_Name[j]);k++) 
                                        gReceptionList_Name[i][k]=gReceptionList_Name[j][k];

                                    for (k=0; k<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;k++) //clear string
                                        gReceptionList_Frequency[i][k] =0;                                     

                                    for(k=0;k<strlen(gReceptionList_Frequency[j]);k++) 
                                        gReceptionList_Frequency[i][k]=gReceptionList_Frequency[j][k];

                                break;
                            
                                case 5:
                                    //clear last element in list 
                                    gReceptionList_ListEntryReceptionInformation[i] =0;
                                    gReceptionList_Pos[i]                           =0;
                                    gReceptionList_Type[i]                          =0;
                                    gReceptionList_Attributes[i]                    =0;
                                    gReceptionList_Attributes_available_Bit0[i]     =0;
                                    gReceptionList_Attributes_DVB_Bit1[i]           =0;
                                    gReceptionList_Attributes_DAB_Bit2[i]           =0;
                                    gReceptionList_Attributes_DAB_Bit3[i]           =0;
                                    gReceptionList_Attributes_DAB_Bit4[i]           =0;
                                    gReceptionList_Attributes_TP_Bit5[i]            =0;
                                    gReceptionList_Attributes_TMC_Bit6[i]           =0;
                                    gReceptionList_Attributes_SDARS_Bit7[i]         =0;
                                    gReceptionList_Attributes_DABserv_Bit8[i]       =0;
                                    gReceptionList_Attributes_FMOnline_Bit9[i]      =0;
                                    gReceptionList_Attributes_StationSelect_BitA[i] =0;
                                    gReceptionList_Attributes_OnlineRadioMute_BitB[i]=0;
                                    gReceptionList_Attributes_StationLinked_BitC[i] =0;
                                    gReceptionList_PresetID[i]                      =0;
                                    gReceptionList_FmRegCode[i]                     =0;
                                    gReceptionList_Category[i]                      =0;

                                    for (k=0; k<AUDIO_RECEPTIONLIST_NAME_LENGTH;k++) //clear string
                                        gReceptionList_Name[i][k] =0;
                                    
                                    for (k=0; k<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;k++) //clear string
                                        gReceptionList_Frequency[i][k] =0;
                                                                 
                                break;
                            
                                case 8:
                                    //copy data from buffer in Pos '8'
                                    gReceptionList_Pos[i]                       =buffer_Pos; 
                                    gReceptionList_Type[i]                      =buffer_Type;
                                    gReceptionList_Attributes[i]                =buffer_Attributes;
                                    gReceptionList_Attributes_available_Bit0[i] =buffer_Attributes_bit0;
                                    gReceptionList_Attributes_DVB_Bit1[i]       =buffer_Attributes_bit1;
                                    gReceptionList_Attributes_DAB_Bit2[i]       =buffer_Attributes_bit2;
                                    gReceptionList_Attributes_DAB_Bit3[i]       =buffer_Attributes_bit3;
                                    gReceptionList_Attributes_DAB_Bit4[i]       =buffer_Attributes_bit4;
                                    gReceptionList_Attributes_TP_Bit5[i]        =buffer_Attributes_bit5;
                                    gReceptionList_Attributes_TMC_Bit6[i]       =buffer_Attributes_bit6;
                                    gReceptionList_Attributes_SDARS_Bit7[i]     =buffer_Attributes_bit7;
                                    gReceptionList_Attributes_DABserv_Bit8[i]   =buffer_Attributes_bit8;
                                    gReceptionList_Attributes_FMOnline_Bit9[i]  =buffer_Attributes_bit9;
                                    gReceptionList_Attributes_StationSelect_BitA[i]=buffer_Attributes_bitA;
                                    gReceptionList_Attributes_OnlineRadioMute_BitB[i]=buffer_Attributes_bitB;
                                    gReceptionList_Attributes_StationLinked_BitC[i]=buffer_Attributes_bitC;
                                    gReceptionList_PresetID[i]                  =buffer_PresetID;
                                    gReceptionList_FmRegCode[i]                 =buffer_FmREG_Code;
                                    gReceptionList_Category[i]                  =buffer_Category;

                                    for (k=0; k<AUDIO_RECEPTIONLIST_NAME_LENGTH;k++) //clear string
                                        gReceptionList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_Name);k++) 
                                        gReceptionList_Name[i][k]=buffer_Name[k];

                                    for (k=0; k<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;k++) //clear string
                                        gReceptionList_Frequency[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_Frequency);k++) 
                                        gReceptionList_Frequency[i][k]=buffer_Frequency[k];
                                    
                                break;
                                
                                default://other elements
                                    //copy element on other position
                                    gReceptionList_Pos[i]                       =gReceptionList_Pos[j]; 
                                    gReceptionList_Type[i]                      =gReceptionList_Type[j];
                                    gReceptionList_Attributes[i]                =gReceptionList_Attributes[j];
                                    gReceptionList_Attributes_available_Bit0[i] =gReceptionList_Attributes_available_Bit0[j];
                                    gReceptionList_Attributes_DVB_Bit1[i]       =gReceptionList_Attributes_DVB_Bit1[j]; 
                                    gReceptionList_Attributes_DAB_Bit2[i]       =gReceptionList_Attributes_DAB_Bit2[j];
                                    gReceptionList_Attributes_DAB_Bit3[i]       =gReceptionList_Attributes_DAB_Bit3[j];
                                    gReceptionList_Attributes_DAB_Bit4[i]       =gReceptionList_Attributes_DAB_Bit4[j];
                                    gReceptionList_Attributes_TP_Bit5[i]        =gReceptionList_Attributes_TP_Bit5[j];
                                    gReceptionList_Attributes_TMC_Bit6[i]       =gReceptionList_Attributes_TMC_Bit6[j];
                                    gReceptionList_Attributes_SDARS_Bit7[i]     =gReceptionList_Attributes_SDARS_Bit7[j];
                                    gReceptionList_Attributes_DABserv_Bit8[i]   =gReceptionList_Attributes_DABserv_Bit8[j];
                                    gReceptionList_Attributes_FMOnline_Bit9[i]  =gReceptionList_Attributes_FMOnline_Bit9[j];
                                    gReceptionList_Attributes_StationSelect_BitA[i]=gReceptionList_Attributes_StationSelect_BitA[j];
                                    gReceptionList_Attributes_OnlineRadioMute_BitB[i]=gReceptionList_Attributes_OnlineRadioMute_BitB[j];
                                    gReceptionList_Attributes_StationLinked_BitC[i]=gReceptionList_Attributes_StationLinked_BitC[j];
                                    gReceptionList_PresetID[i]                  =gReceptionList_PresetID[j]; 
                                    gReceptionList_FmRegCode[i]                 =gReceptionList_FmRegCode[j]; 
                                    gReceptionList_Category[i]                  =gReceptionList_Category[j];  
                                    
                                    for (k=0; k<AUDIO_RECEPTIONLIST_NAME_LENGTH;k++) //clear string
                                        gReceptionList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gReceptionList_Name[j]);k++) 
                                        gReceptionList_Name[i][k]=gReceptionList_Name[j][k];
                                        
                                    for (k=0; k<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;k++) //clear string
                                        gReceptionList_Frequency[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gReceptionList_Frequency[j]);k++) 
                                        gReceptionList_Frequency[i][k]=gReceptionList_Frequency[j][k];        
                                break;
                            } // end of switch 'i'
                        }
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        ReceptionList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);                        
                        
                        //to check, if valid data received
                        gReceptionList_CallBackReason    =AUDIO_RECEPTIONLIST_CALLBACKREASON_CHECKCACHE;
                    }
        break;

        case AUDIO_RECEPTIONLIST_UP_CACHE: 
                    if (gReceptionList_CallBackReason ==AUDIO_RECEPTIONLIST_CALLBACKREASON_CHECKCACHE) //check if valid data received
                    {   
                        if(gReceptionList_ListEntryReceptionInformation[6] ==0) //No valid data in first list pos -> last list element reached, start with element 0!  
                        {
                            shift                   =TRUE;
                            direction               =BACKWARD;
                            transmitpos             =FALSE;
                            indexsize               =TRUE;
                            recordaddress           =0;
                            startelement            =0; //Last element
                            elements                =1;        
                            
                            requested_startelement  =startelement;
                            mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                            gReceptionList_cacheUp        =TRUE;
                            gReceptionList_CallBackReason =AUDIO_RECEPTIONLIST_CALLBACKREASON_DISPLAYLIST;
                            
                            ReceptionList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                        }
                        else
                        {
                            gReceptionList_CallBackReason =AUDIO_RECEPTIONLIST_CALLBACKREASON_DISPLAYLIST;
                            ReceptionList_ListHandling();
                        }           
                    }

                    else if (gReceptionList_CallBackReason ==AUDIO_RECEPTIONLIST_CALLBACKREASON_DISPLAYLIST)
                    {   
                        gReceptionList_ListHandlingType  =AUDIO_RECEPTIONLIST_NOCACHE;
                        gReceptionList_cacheUp           =FALSE;
                        gReceptionList_DisplayStatus     =AUDIO_RECEPTIONLIST_DISPLAYLIST_FIRST_ELEMENTS;
                        
                        putvalue(env_ASG_AudioSD_RL_ListOpState, empty_string);
                        ReceptionList_display();
                        gReceptionList_DisplayStatus     =AUDIO_RECEPTIONLIST_DISPLAYLIST_REFRESH;
                        gReceptionList_CallBackReason    =AUDIO_RECEPTIONLIST_CALLBACKREASON_NOCALLBACK;
                    }

                    else
                    {           
                        putvalue(env_ASG_AudioSD_RL_ListOpState, "list operating...");

                        shift                   =TRUE;
                        direction               =BACKWARD;
                        transmitpos             =FALSE;
                        indexsize               =TRUE;
                        recordaddress           =0;
                        startelement            =gReceptionList_Pos[6]; //first element
                        elements                =1;
                    
                        for(i=AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE-1;i>=0;i--)
                        {  
                            j =i-1;
                            switch (i)
                            {   
                                case 8: 
                                    //buffer data of Pos '8' (local)
                                    buffer_Pos              =gReceptionList_Pos[i];
                                    buffer_Type             =gReceptionList_Type[i];
                                    buffer_Attributes       =gReceptionList_Attributes[i];
                                    buffer_Attributes_bit0  =gReceptionList_Attributes_available_Bit0[i];
                                    buffer_Attributes_bit1  =gReceptionList_Attributes_DVB_Bit1[i];
                                    buffer_Attributes_bit2  =gReceptionList_Attributes_DAB_Bit2[i];
                                    buffer_Attributes_bit3  =gReceptionList_Attributes_DAB_Bit3[i];
                                    buffer_Attributes_bit4  =gReceptionList_Attributes_DAB_Bit4[i];
                                    buffer_Attributes_bit5  =gReceptionList_Attributes_TP_Bit5[i];
                                    buffer_Attributes_bit6  =gReceptionList_Attributes_TMC_Bit6[i];
                                    buffer_Attributes_bit7  =gReceptionList_Attributes_SDARS_Bit7[i];
                                    buffer_Attributes_bit8  =gReceptionList_Attributes_DABserv_Bit8[i];
                                    buffer_Attributes_bit9  =gReceptionList_Attributes_FMOnline_Bit9[i];
                                    buffer_Attributes_bitA  =gReceptionList_Attributes_StationSelect_BitA[i];
                                    buffer_Attributes_bitB  =gReceptionList_Attributes_OnlineRadioMute_BitB[i];
                                    buffer_Attributes_bitC  =gReceptionList_Attributes_StationLinked_BitC[i];
                                    buffer_PresetID         =gReceptionList_PresetID[i];
                                    buffer_FmREG_Code       =gReceptionList_FmRegCode[i];
                                    buffer_Category         =gReceptionList_Category[i];                           
                                    

                                    for (k=0; k<AUDIO_RECEPTIONLIST_NAME_LENGTH;k++) //clear string
                                        buffer_Name[k] =0;                                     

                                    for(k=0;k<strlen(gReceptionList_Name[i]);k++) 
                                        buffer_Name[k]=gReceptionList_Name[i][k];

                                    for (k=0; k<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;k++) //clear string
                                        buffer_Frequency[k] =0;                                     

                                    for(k=0;k<strlen(gReceptionList_Frequency[i]);k++) 
                                        buffer_Frequency[k]=gReceptionList_Frequency[i][k];

                                    
                                    //copy data from Pos '7' to Pos '8'
                                    gReceptionList_Pos[i]                       =gReceptionList_Pos[j]; 
                                    gReceptionList_Type[i]                      =gReceptionList_Type[j];
                                    gReceptionList_Attributes[i]                =gReceptionList_Attributes[j];
                                    gReceptionList_Attributes_available_Bit0[i] =gReceptionList_Attributes_available_Bit0[j];
                                    gReceptionList_Attributes_DVB_Bit1[i]       =gReceptionList_Attributes_DVB_Bit1[j];
                                    gReceptionList_Attributes_DAB_Bit2[i]       =gReceptionList_Attributes_DAB_Bit2[j];
                                    gReceptionList_Attributes_DAB_Bit3[i]       =gReceptionList_Attributes_DAB_Bit3[j];
                                    gReceptionList_Attributes_DAB_Bit4[i]       =gReceptionList_Attributes_DAB_Bit4[j];
                                    gReceptionList_Attributes_TP_Bit5[i]        =gReceptionList_Attributes_TP_Bit5[j];
                                    gReceptionList_Attributes_TMC_Bit6[i]       =gReceptionList_Attributes_TMC_Bit6[j];
                                    gReceptionList_Attributes_SDARS_Bit7[i]     =gReceptionList_Attributes_SDARS_Bit7[j];
                                    gReceptionList_Attributes_DABserv_Bit8[i]   =gReceptionList_Attributes_DABserv_Bit8[j];
                                    gReceptionList_Attributes_FMOnline_Bit9[i]  =gReceptionList_Attributes_FMOnline_Bit9[j];
                                    gReceptionList_Attributes_StationSelect_BitA[i]=gReceptionList_Attributes_StationSelect_BitA[j];
                                    gReceptionList_Attributes_OnlineRadioMute_BitB[i]=gReceptionList_Attributes_OnlineRadioMute_BitB[j];
                                    gReceptionList_Attributes_StationLinked_BitC[i]=gReceptionList_Attributes_StationLinked_BitC[j];
                                    gReceptionList_PresetID[i]                  =gReceptionList_PresetID[j];
                                    gReceptionList_FmRegCode[i]                 =gReceptionList_FmRegCode[j];
                                    gReceptionList_Category[i]                  =gReceptionList_Category[j];

                                    for (k=0; k<AUDIO_RECEPTIONLIST_NAME_LENGTH;k++) //clear string
                                        gReceptionList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gReceptionList_Name[j]);k++) 
                                        gReceptionList_Name[i][k]=gReceptionList_Name[j][k];
                                    
                                    for (k=0; k<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;k++) //clear string
                                        gReceptionList_Frequency[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gReceptionList_Frequency[j]);k++) 
                                        gReceptionList_Frequency[i][k]=gReceptionList_Frequency[j][k];     
                                break;
                            
                                case 6: 
                                    //clear first element in list 
                                    gReceptionList_ListEntryReceptionInformation[i] =0;
                                    gReceptionList_Pos[i]                           =0;
                                    gReceptionList_Type[i]                          =0;
                                    gReceptionList_Attributes[i]                    =0;
                                    gReceptionList_Attributes_available_Bit0[i]     =0;
                                    gReceptionList_Attributes_DVB_Bit1[i]           =0;
                                    gReceptionList_Attributes_DAB_Bit2[i]           =0;
                                    gReceptionList_Attributes_DAB_Bit3[i]           =0;
                                    gReceptionList_Attributes_DAB_Bit4[i]           =0;
                                    gReceptionList_Attributes_TP_Bit5[i]            =0;
                                    gReceptionList_Attributes_TMC_Bit6[i]           =0;
                                    gReceptionList_Attributes_SDARS_Bit7[i]         =0;
                                    gReceptionList_Attributes_DABserv_Bit8[i]       =0;
                                    gReceptionList_Attributes_FMOnline_Bit9[i]      =0;
                                    gReceptionList_Attributes_StationSelect_BitA[i] =0;
                                    gReceptionList_Attributes_OnlineRadioMute_BitB[i]=0;
                                    gReceptionList_Attributes_StationLinked_BitC[i] =0;
                                    gReceptionList_PresetID[i]                      =0;
                                    gReceptionList_FmRegCode[i]                     =0;
                                    gReceptionList_Category[i]                      =0;
                            
                                    for (k=0; k<AUDIO_RECEPTIONLIST_NAME_LENGTH;k++) //clear string
                                        gReceptionList_Name[i][k] =0;
                                    
                                    for (k=0; k<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;k++) //clear string
                                        gReceptionList_Frequency[i][k] =0;
                                                                            
                                break;
                            
                                case 0: 
                                    //copy data from buffer in Pos '0'
                                    gReceptionList_Pos[i]                       =buffer_Pos; 
                                    gReceptionList_Type[i]                      =buffer_Type;
                                    gReceptionList_Attributes[i]                =buffer_Attributes;
                                    gReceptionList_Attributes_available_Bit0[i] =buffer_Attributes_bit0;
                                    gReceptionList_Attributes_DVB_Bit1[i]       =buffer_Attributes_bit1;
                                    gReceptionList_Attributes_DAB_Bit2[i]       =buffer_Attributes_bit2;
                                    gReceptionList_Attributes_DAB_Bit3[i]       =buffer_Attributes_bit3;
                                    gReceptionList_Attributes_DAB_Bit4[i]       =buffer_Attributes_bit4;
                                    gReceptionList_Attributes_TP_Bit5[i]        =buffer_Attributes_bit5;
                                    gReceptionList_Attributes_TMC_Bit6[i]       =buffer_Attributes_bit6;
                                    gReceptionList_Attributes_SDARS_Bit7[i]     =buffer_Attributes_bit7;
                                    gReceptionList_Attributes_DABserv_Bit8[i]   =buffer_Attributes_bit8;
                                    gReceptionList_Attributes_FMOnline_Bit9[i]  =buffer_Attributes_bit9;
                                    gReceptionList_Attributes_StationSelect_BitA[i]  =buffer_Attributes_bitA;
                                    gReceptionList_Attributes_OnlineRadioMute_BitB[i]  =buffer_Attributes_bitB;
                                    gReceptionList_Attributes_StationLinked_BitC[i]  =buffer_Attributes_bitC;
                                    gReceptionList_PresetID[i]                  =buffer_PresetID;
                                    gReceptionList_FmRegCode[i]                 =buffer_FmREG_Code;
                                    gReceptionList_Category[i]                  =buffer_Category;

                                    for (k=0; k<AUDIO_RECEPTIONLIST_NAME_LENGTH;k++) //clear string
                                        gReceptionList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_Name);k++) 
                                        gReceptionList_Name[i][k]=buffer_Name[k];

                                    for (k=0; k<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;k++) //clear string
                                        gReceptionList_Frequency[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_Frequency);k++) 
                                        gReceptionList_Frequency[i][k]=buffer_Frequency[k];
                                break;
                                
                                default: //other elements
                                    //copy element on other position
                                    gReceptionList_Pos[i]                       =gReceptionList_Pos[j]; 
                                    gReceptionList_Type[i]                      =gReceptionList_Type[j];
                                    gReceptionList_Attributes[i]                =gReceptionList_Attributes[j];
                                    gReceptionList_Attributes_available_Bit0[i] =gReceptionList_Attributes_available_Bit0[j];
                                    gReceptionList_Attributes_DVB_Bit1[i]       =gReceptionList_Attributes_DVB_Bit1[j];
                                    gReceptionList_Attributes_DAB_Bit2[i]       =gReceptionList_Attributes_DAB_Bit2[j];
                                    gReceptionList_Attributes_DAB_Bit3[i]       =gReceptionList_Attributes_DAB_Bit3[j];
                                    gReceptionList_Attributes_DAB_Bit4[i]       =gReceptionList_Attributes_DAB_Bit4[j];
                                    gReceptionList_Attributes_TP_Bit5[i]        =gReceptionList_Attributes_TP_Bit5[j];
                                    gReceptionList_Attributes_TMC_Bit6[i]       =gReceptionList_Attributes_TMC_Bit6[j];
                                    gReceptionList_Attributes_SDARS_Bit7[i]     =gReceptionList_Attributes_SDARS_Bit7[j];
                                    gReceptionList_Attributes_DABserv_Bit8[i]   =gReceptionList_Attributes_DABserv_Bit8[j];
                                    gReceptionList_Attributes_FMOnline_Bit9[i]  =gReceptionList_Attributes_FMOnline_Bit9[j];
                                    gReceptionList_Attributes_StationSelect_BitA[i]=gReceptionList_Attributes_StationSelect_BitA[j];
                                    gReceptionList_Attributes_OnlineRadioMute_BitB[i]=gReceptionList_Attributes_OnlineRadioMute_BitB[j];
                                    gReceptionList_Attributes_StationLinked_BitC[i]=gReceptionList_Attributes_StationLinked_BitC[j];
                                    gReceptionList_PresetID[i]                  =gReceptionList_PresetID[j];
                                    gReceptionList_FmRegCode[i]                 =gReceptionList_FmRegCode[j];
                                    gReceptionList_Category[i]                  =gReceptionList_Category[j];

                                    for (k=0; k<AUDIO_RECEPTIONLIST_NAME_LENGTH;k++) //clear string
                                        gReceptionList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gReceptionList_Name[j]);k++) 
                                        gReceptionList_Name[i][k]=gReceptionList_Name[j][k];
                                    
                                    for (k=0; k<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;k++) //clear string
                                        gReceptionList_Frequency[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gReceptionList_Frequency[j]);k++) 
                                        gReceptionList_Frequency[i][k]=gReceptionList_Frequency[j][k];
                                    
                                break;
                            } // end of switch 'i'
                        }
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        ReceptionList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);                        
                        
                        //to check, if valid data received
                        gReceptionList_CallBackReason    =AUDIO_RECEPTIONLIST_CALLBACKREASON_CHECKCACHE;
                    }
        break;

        default:
        break;
    } //end of switch 'type of cache handling' 
}

ReceptionList_display()
{   
    int Element_1 =0, Element_2 =1, Element_3 =2;

    if(POWER_ON==gASG_PowerOnOff && getvalue(env_ASG_AudioSD_RL_OnOff))
	{   
        /******'sliding window' not active******/         
        if(gReceptionList_DisplayStatus ==AUDIO_RECEPTIONLIST_DISPLAYLIST_SEARCH_ELEMENTS)
        {
            //1. Element              
            if(gReceptionList_CursorAction ==AUDIO_RECEPTIONLIST_CURSORACTION_DOWN)
                Element_1 =ReceptionList_GetNextCachedElement(gReceptionList_LastFirstElement, AUDIO_RECEPTIONLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);
            
            else if(gReceptionList_CursorAction ==AUDIO_RECEPTIONLIST_CURSORACTION_UP)            
                Element_1 =ReceptionList_GetNextCachedElement(gReceptionList_LastFirstElement, AUDIO_RECEPTIONLIST_DISPLAYLIST_FIND_PREVIUOS_ELEMENT);

            //Pos
            putvalue(env_ASG_AudioSD_RL_pos_0, gReceptionList_Pos[Element_1]);               
            
            //Type
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1|| gReceptionList_recordaddress ==2 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Type_0, gReceptionList_Type[Element_1]);

                if(gReceptionList_Type[Element_1] <0x10)
                    putvalue(env_ASG_AudioSD_RL_Type_s_0,gReceptionList_Type_s[gReceptionList_Type[Element_1]]);
                else
                    putvalue(env_ASG_AudioSD_RL_Type_s_0,gstring_reserved);
            }

            //Attributes
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1|| gReceptionList_recordaddress ==2|| gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Attr_bit0_0, gReceptionList_Attributes_available_Bit0[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit0_0,gReceptionList_Attributes_available_Bit0_s[gReceptionList_Attributes_available_Bit0[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit1_0, gReceptionList_Attributes_DVB_Bit1[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit1_0,gReceptionList_Attributes_DVB_Bit1_s[gReceptionList_Attributes_available_Bit0[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit2_0, gReceptionList_Attributes_DAB_Bit2[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit2_0,gReceptionList_Attributes_DAB_Bit2_s[gReceptionList_Attributes_DAB_Bit2[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit3_0, gReceptionList_Attributes_DAB_Bit3[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit3_0,gReceptionList_Attributes_DAB_Bit3_s[gReceptionList_Attributes_DAB_Bit3[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit4_0, gReceptionList_Attributes_DAB_Bit4[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit4_0,gReceptionList_Attributes_DAB_Bit4_s[gReceptionList_Attributes_DAB_Bit4[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit5_0, gReceptionList_Attributes_TP_Bit5[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit5_0,gReceptionList_Attributes_TP_Bit5_s[gReceptionList_Attributes_TP_Bit5[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit6_0, gReceptionList_Attributes_TMC_Bit6[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit6_0,gReceptionList_Attributes_TMC_Bit6_s[gReceptionList_Attributes_TMC_Bit6[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit7_0, gReceptionList_Attributes_SDARS_Bit7[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit7_0,gReceptionList_Attributes_SDARS_Bit7_s[gReceptionList_Attributes_SDARS_Bit7[Element_1]]);


                putvalue(env_ASG_AudioSD_RL_Attr_bit8_0, gReceptionList_Attributes_DABserv_Bit8[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit8_0,gReceptionList_Attributes_DABserv_Bit8_s[gReceptionList_Attributes_DABserv_Bit8[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit9_0, gReceptionList_Attributes_FMOnline_Bit9[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit9_0,gReceptionList_Attributes_FMOnline_Bit9_s[gReceptionList_Attributes_FMOnline_Bit9[Element_1]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitA_0, gReceptionList_Attributes_StationSelect_BitA[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitA_0,gReceptionList_Attributes_StationSelect_BitA_s[gReceptionList_Attributes_StationSelect_BitA[Element_1]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitB_0, gReceptionList_Attributes_OnlineRadioMute_BitB[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitB_0,gReceptionList_Attributes_OnlineRadioMute_BitB_s[gReceptionList_Attributes_OnlineRadioMute_BitB[Element_1]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitC_0, gReceptionList_Attributes_StationLinked_BitC[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitC_0,gReceptionList_Attributes_StationLinked_BitC_s[gReceptionList_Attributes_StationLinked_BitC[Element_1]]);
            }

            //PresetID
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_RL_PrID_0,gReceptionList_PresetID[Element_1]);
            
            //FmREG_Code
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_RL_FmReg_0,gReceptionList_FmRegCode[Element_1]);

            //Category
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1 || gReceptionList_recordaddress ==3 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Cat_0, gReceptionList_Category[Element_1]);

                if(gReceptionList_Type[Element_1] <0x38)
                    putvalue(env_ASG_AudioSD_RL_Cat_s_0,gReceptionList_Category_s[gReceptionList_Category[Element_1]]);
                else
                    putvalue(env_ASG_AudioSD_RL_Cat_s_0,gstring_reserved);
            }

            //Name
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1 || gReceptionList_recordaddress ==3 || gReceptionList_recordaddress ==4 || gReceptionList_recordaddress ==6)
                putvalue(env_ASG_AudioSD_RL_Name_s_0,gReceptionList_Name[Element_1]);
            
