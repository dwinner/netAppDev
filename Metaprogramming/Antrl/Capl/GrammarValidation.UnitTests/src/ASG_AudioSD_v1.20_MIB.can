                    putvalue(env_ASG_AudioSD_MB_FS_s_bit0_1,gMediaBrowser_FileState_emptyFolder_Bit0_s[gMediaBrowser_FileState_emptyFolder_Bit0[Element_2]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit1_1, gMediaBrowser_FileState_DRM_Bit1[Element_2]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit1_1,gMediaBrowser_FileState_DRM_Bit1_s[gMediaBrowser_FileState_DRM_Bit1[Element_2]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit2_1, gMediaBrowser_FileState_FileCorrupted_Bit2[Element_2]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit2_1,gMediaBrowser_FileState_FileCorrupted_Bit2_s[gMediaBrowser_FileState_FileCorrupted_Bit2[Element_2]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit3_1, gMediaBrowser_FileState_DeadLink_Bit3[Element_2]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit3_1,gMediaBrowser_FileState_DeadLink_Bit3_s[gMediaBrowser_FileState_DeadLink_Bit3[Element_2]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit4_1, gMediaBrowser_FileState_ImportFinished_Bit4[Element_2]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit4_1,gMediaBrowser_FileState_ImportFinished_Bit4_s[gMediaBrowser_FileState_ImportFinished_Bit4[Element_2]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit5_1, gMediaBrowser_FileState_ImportPending_Bit5[Element_2]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit5_1,gMediaBrowser_FileState_ImportPending_Bit5_s[gMediaBrowser_FileState_ImportPending_Bit5[Element_2]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit6_1, gMediaBrowser_FileState_ImportPlayable_Bit6[Element_2]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit6_1,gMediaBrowser_FileState_ImportPlayable_Bit6_s[gMediaBrowser_FileState_ImportPlayable_Bit6[Element_2]]);
                }

                //FileName
                if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==2)
                    putvalue(env_ASG_AudioSD_MB_FileName_s_1,gMediaBrowser_FileName[Element_2]);
            }

            //3. Element    
            if(gMediaBrowser_ListEntryReceptionInformation [2] ==TRUE && getvalue(env_ASG_AudioSD_MB_OnOff))
            {
                Element_3 =2;
                
                //Pos
                putvalue(env_ASG_AudioSD_MB_pos_2, gMediaBrowser_Pos[Element_3]);               
            
                //FileType
                if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_MB_FileType_2, gMediaBrowser_FileType[Element_3]);

                    if(gMediaBrowser_FileType[Element_3] <0x67)
                        putvalue(env_ASG_AudioSD_MB_FileType_s_2,gMediaBrowser_FileType_s[gMediaBrowser_FileType[Element_3]]);
                    else if (gMediaBrowser_FileType[Element_3] ==0xFF)
                        putvalue(env_ASG_AudioSD_MB_FileType_s_2,gstring_not_supported);
                    else
                        putvalue(env_ASG_AudioSD_MB_FileType_s_2,gstring_reserved);
                }

                //FileState
                if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_MB_FS_bit0_2, gMediaBrowser_FileState_emptyFolder_Bit0[Element_3]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit0_2,gMediaBrowser_FileState_emptyFolder_Bit0_s[gMediaBrowser_FileState_emptyFolder_Bit0[Element_3]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit1_2, gMediaBrowser_FileState_DRM_Bit1[Element_3]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit1_2,gMediaBrowser_FileState_DRM_Bit1_s[gMediaBrowser_FileState_DRM_Bit1[Element_3]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit2_2, gMediaBrowser_FileState_FileCorrupted_Bit2[Element_3]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit2_2,gMediaBrowser_FileState_FileCorrupted_Bit2_s[gMediaBrowser_FileState_FileCorrupted_Bit2[Element_3]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit3_2, gMediaBrowser_FileState_DeadLink_Bit3[Element_3]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit3_2,gMediaBrowser_FileState_DeadLink_Bit3_s[gMediaBrowser_FileState_DeadLink_Bit3[Element_3]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit4_2, gMediaBrowser_FileState_ImportFinished_Bit4[Element_3]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit4_2,gMediaBrowser_FileState_ImportFinished_Bit4_s[gMediaBrowser_FileState_ImportFinished_Bit4[Element_3]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit5_2, gMediaBrowser_FileState_ImportPending_Bit5[Element_3]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit5_2,gMediaBrowser_FileState_ImportPending_Bit5_s[gMediaBrowser_FileState_ImportPending_Bit5[Element_3]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit6_2, gMediaBrowser_FileState_ImportPlayable_Bit6[Element_3]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit6_2,gMediaBrowser_FileState_ImportPlayable_Bit6_s[gMediaBrowser_FileState_ImportPlayable_Bit6[Element_3]]);
                }

                //FileName
                if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==2)
                    putvalue(env_ASG_AudioSD_MB_FileName_s_2,gMediaBrowser_FileName[Element_3]);     
            }
        }
        
        else if (gMediaBrowser_DisplayStatus ==AUDIO_MEDIABROWSER_DISPLAYLIST_REFRESH)
        {               
            //1. Element
            if(gMediaBrowser_SlidingWindow_State ==AUDIO_MEDIABROWSER_SLIDINGWINDOW_NOTACTIVE)
                Element_1 =gMediaBrowser_LastFirstElement; 
            else
                Element_1 =0;

            if(gMediaBrowser_ListEntryReceptionInformation[Element_1])
            {
                //Pos
                putvalue(env_ASG_AudioSD_MB_pos_0, gMediaBrowser_Pos[Element_1]);               
            
                //FileType
                if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_MB_FileType_0, gMediaBrowser_FileType[Element_1]);

                    if(gMediaBrowser_FileType[Element_1] <0x67)
                        putvalue(env_ASG_AudioSD_MB_FileType_s_0,gMediaBrowser_FileType_s[gMediaBrowser_FileType[Element_1]]);
                    else if (gMediaBrowser_FileType[Element_1] ==0xFF)
                        putvalue(env_ASG_AudioSD_MB_FileType_s_0,gstring_not_supported);
                    else
                        putvalue(env_ASG_AudioSD_MB_FileType_s_0,gstring_reserved);
                }

                //FileState
                if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_MB_FS_bit0_0, gMediaBrowser_FileState_emptyFolder_Bit0[Element_1]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit0_0,gMediaBrowser_FileState_emptyFolder_Bit0_s[gMediaBrowser_FileState_emptyFolder_Bit0[Element_1]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit1_0, gMediaBrowser_FileState_DRM_Bit1[Element_1]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit1_0,gMediaBrowser_FileState_DRM_Bit1_s[gMediaBrowser_FileState_DRM_Bit1[Element_1]]);
    
                    putvalue(env_ASG_AudioSD_MB_FS_bit2_0, gMediaBrowser_FileState_FileCorrupted_Bit2[Element_1]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit2_0,gMediaBrowser_FileState_FileCorrupted_Bit2_s[gMediaBrowser_FileState_FileCorrupted_Bit2[Element_1]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit3_0, gMediaBrowser_FileState_DeadLink_Bit3[Element_1]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit3_0,gMediaBrowser_FileState_DeadLink_Bit3_s[gMediaBrowser_FileState_DeadLink_Bit3[Element_1]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit4_0, gMediaBrowser_FileState_ImportFinished_Bit4[Element_1]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit4_0,gMediaBrowser_FileState_ImportFinished_Bit4_s[gMediaBrowser_FileState_ImportFinished_Bit4[Element_1]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit5_0, gMediaBrowser_FileState_ImportPending_Bit5[Element_1]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit5_0,gMediaBrowser_FileState_ImportPending_Bit5_s[gMediaBrowser_FileState_ImportPending_Bit5[Element_1]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit6_0, gMediaBrowser_FileState_ImportPlayable_Bit6[Element_1]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit6_0,gMediaBrowser_FileState_ImportPlayable_Bit6_s[gMediaBrowser_FileState_ImportPlayable_Bit6[Element_1]]);
                }

                //FileName
                if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==2)
                    putvalue(env_ASG_AudioSD_MB_FileName_s_0,gMediaBrowser_FileName[Element_1]);
            }

            //2. Element             
            if(gMediaBrowser_SlidingWindow_State ==AUDIO_MEDIABROWSER_SLIDINGWINDOW_NOTACTIVE)
                Element_2 =MediaBrowser_GetNextCachedElement(Element_1, AUDIO_MEDIABROWSER_DISPLAYLIST_FIND_NEXT_ELEMENT);
            else
                Element_2 =1;

            if(gMediaBrowser_ListEntryReceptionInformation[Element_2])
            {
                //Pos
                putvalue(env_ASG_AudioSD_MB_pos_1, gMediaBrowser_Pos[Element_2]);               
            
                //FileType
                if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_MB_FileType_1, gMediaBrowser_FileType[Element_2]);

                    if(gMediaBrowser_FileType[Element_2] <0x67)
                        putvalue(env_ASG_AudioSD_MB_FileType_s_1,gMediaBrowser_FileType_s[gMediaBrowser_FileType[Element_2]]);
                    
                    else if (gMediaBrowser_FileType[Element_2] ==0xFF)
                        putvalue(env_ASG_AudioSD_MB_FileType_s_1,gstring_not_supported);
                    
                    else
                        putvalue(env_ASG_AudioSD_MB_FileType_s_1,gstring_reserved);
                }

                //FileState
                if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_MB_FS_bit0_1, gMediaBrowser_FileState_emptyFolder_Bit0[Element_2]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit0_1,gMediaBrowser_FileState_emptyFolder_Bit0_s[gMediaBrowser_FileState_emptyFolder_Bit0[Element_2]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit1_1, gMediaBrowser_FileState_DRM_Bit1[Element_2]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit1_1,gMediaBrowser_FileState_DRM_Bit1_s[gMediaBrowser_FileState_DRM_Bit1[Element_2]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit2_1, gMediaBrowser_FileState_FileCorrupted_Bit2[Element_2]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit2_1,gMediaBrowser_FileState_FileCorrupted_Bit2_s[gMediaBrowser_FileState_FileCorrupted_Bit2[Element_2]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit3_1, gMediaBrowser_FileState_DeadLink_Bit3[Element_2]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit3_1,gMediaBrowser_FileState_DeadLink_Bit3_s[gMediaBrowser_FileState_DeadLink_Bit3[Element_2]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit4_1, gMediaBrowser_FileState_ImportFinished_Bit4[Element_2]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit4_1,gMediaBrowser_FileState_ImportFinished_Bit4_s[gMediaBrowser_FileState_ImportFinished_Bit4[Element_2]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit5_1, gMediaBrowser_FileState_ImportPending_Bit5[Element_2]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit5_1,gMediaBrowser_FileState_ImportPending_Bit5_s[gMediaBrowser_FileState_ImportPending_Bit5[Element_2]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit6_1, gMediaBrowser_FileState_ImportPlayable_Bit6[Element_2]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit6_1,gMediaBrowser_FileState_ImportPlayable_Bit6_s[gMediaBrowser_FileState_ImportPlayable_Bit6[Element_2]]);
                }

                //FileName
                if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==2)
                    putvalue(env_ASG_AudioSD_MB_FileName_s_1,gMediaBrowser_FileName[Element_2]);
            }

            //3. Element          
            if(gMediaBrowser_SlidingWindow_State ==AUDIO_MEDIABROWSER_SLIDINGWINDOW_NOTACTIVE)
                Element_3 =MediaBrowser_GetNextCachedElement(Element_2, AUDIO_MEDIABROWSER_DISPLAYLIST_FIND_NEXT_ELEMENT);
            else
                Element_3 =2;

            if(gMediaBrowser_ListEntryReceptionInformation[Element_3])
            {    
                //Pos
                putvalue(env_ASG_AudioSD_MB_pos_2, gMediaBrowser_Pos[Element_3]);               
            
                //FileType
                if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_MB_FileType_2, gMediaBrowser_FileType[Element_3]);

                    if(gMediaBrowser_FileType[Element_3] <0x67)
                        putvalue(env_ASG_AudioSD_MB_FileType_s_2,gMediaBrowser_FileType_s[gMediaBrowser_FileType[Element_3]]);
                    else if (gMediaBrowser_FileType[Element_3] ==0xFF)
                        putvalue(env_ASG_AudioSD_MB_FileType_s_2,gstring_not_supported);
                    else
                        putvalue(env_ASG_AudioSD_MB_FileType_s_2,gstring_reserved);
                }

                //FileState
                if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_MB_FS_bit0_2, gMediaBrowser_FileState_emptyFolder_Bit0[Element_3]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit0_2,gMediaBrowser_FileState_emptyFolder_Bit0_s[gMediaBrowser_FileState_emptyFolder_Bit0[Element_3]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit1_2, gMediaBrowser_FileState_DRM_Bit1[Element_3]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit1_2,gMediaBrowser_FileState_DRM_Bit1_s[gMediaBrowser_FileState_DRM_Bit1[Element_3]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit2_2, gMediaBrowser_FileState_FileCorrupted_Bit2[Element_3]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit2_2,gMediaBrowser_FileState_FileCorrupted_Bit2_s[gMediaBrowser_FileState_FileCorrupted_Bit2[Element_3]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit3_2, gMediaBrowser_FileState_DeadLink_Bit3[Element_3]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit3_2,gMediaBrowser_FileState_DeadLink_Bit3_s[gMediaBrowser_FileState_DeadLink_Bit3[Element_3]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit4_2, gMediaBrowser_FileState_ImportFinished_Bit4[Element_3]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit4_2,gMediaBrowser_FileState_ImportFinished_Bit4_s[gMediaBrowser_FileState_ImportFinished_Bit4[Element_3]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit5_2, gMediaBrowser_FileState_ImportPending_Bit5[Element_3]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit5_2,gMediaBrowser_FileState_ImportPending_Bit5_s[gMediaBrowser_FileState_ImportPending_Bit5[Element_3]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit6_2, gMediaBrowser_FileState_ImportPlayable_Bit6[Element_3]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit6_2,gMediaBrowser_FileState_ImportPlayable_Bit6_s[gMediaBrowser_FileState_ImportPlayable_Bit6[Element_3]]);
                }

                //FileName
                if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==2)
                    putvalue(env_ASG_AudioSD_MB_FileName_s_2,gMediaBrowser_FileName[Element_3]);
            }
        }
    }
}

MediaBrowser_ListHandling () //for sliding window concept, list handling and 'build-up' list...
{
    byte mode, shift, direction, transmitpos, indexsize, recordaddress, buffer_FileType, buffer_ReceptionInformation, buffer_FileState_bit0, buffer_FileState_bit1, buffer_FileState_bit2, buffer_FileState_bit3, buffer_FileState_bit4, buffer_FileState_bit5, buffer_FileState_bit6;
    word requested_startelement, startelement, elements, buffer_Pos, buffer_FileState;
    char buffer_FileName[AUDIO_MEDIABROWSER_FILENAME_LENGTH];
    int i,j,k;
    
    // Init local variables. 
    mode                        =0;
    shift                       =0;
    direction                   =0;
    transmitpos                 =0;
    indexsize                   =0;
    recordaddress               =0;
    requested_startelement      =0;
    startelement                =0;
    elements                    =0;
    i                           =0;
    j                           =0;
    k                           =0;
    buffer_Pos                  =0;
    buffer_FileType             =0;
    buffer_ReceptionInformation =0;
    buffer_FileState            =0;
    buffer_FileState_bit0       =0;
    buffer_FileState_bit1       =0;
    buffer_FileState_bit2       =0;
    buffer_FileState_bit3       =0;
    buffer_FileState_bit4       =0;
    buffer_FileState_bit5       =0;
    buffer_FileState_bit6       =0;
    
    /***build-up complete cache***/

    switch (gMediaBrowser_ListHandlingType)
    {
        case AUDIO_MEDIABROWSER_BUILDUPCACHE:
             
            switch (gMediaBrowser_cacheBuildUp)
            {   
                //cache-up  
                case AUDIO_MEDIABROWSER_BUILDUPCACHECACHE_UP:  
                    if(gMediaBrowser_CallBackReason !=AUDIO_MEDIABROWSER_BUILDUPCACHENOCACHE && gMediaBrowser_CallBackReason !=AUDIO_MEDIABROWSER_CALLBACKREASON_CACHENEXT)
                    {
                        switch (gMediaBrowser_CallBackReason)
                        {
                            case AUDIO_MEDIABROWSER_CALLBACKREASON_CHECKCACHE:

                                    if(gMediaBrowser_ListEntryReceptionInformation[2] ==TRUE) //cache-down required?
                                    {            
                                        gMediaBrowser_cacheBuildUp      =AUDIO_MEDIABROWSER_BUILDUPCACHECACHE_DOWN;      //next step: build-up upper cache
                                        gMediaBrowser_CallBackReason    =AUDIO_MEDIABROWSER_CALLBACKREASON_CACHENEXT;    
                                        
                                        
                                        MediaBrowser_ListHandling ();
                                    }
                                    else //stop caching
                                    {   
                                        gMediaBrowser_cacheBuildUp      =AUDIO_MEDIABROWSER_BUILDUPCACHENOCACHE;  //"build-up cache" finished
                                        gMediaBrowser_ListHandlingType  =AUDIO_MEDIABROWSER_NOCACHE;              
                                        gMediaBrowser_CallBackReason    =AUDIO_MEDIABROWSER_CALLBACKREASON_NOCALLBACK; 
                                        gMediaBrowser_CursorAction      =AUDIO_MEDIABROWSER_CURSORACTION_NOTHING;
                                        
                                        putvalue(env_ASG_AudioSD_MB_ListOpState, empty_string);
                                        MediaBrowser_display();
                                    }
                            break;
                        }
                    }
                    else
                    {   
                        shift               =TRUE;
                        direction           =BACKWARD;
                        transmitpos         =FALSE;
                        indexsize           =TRUE;
                        recordaddress       =0;
                        startelement        =0;
                        elements            =3;
                
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gMediaBrowser_CallBackReason  =AUDIO_MEDIABROWSER_CALLBACKREASON_CHECKCACHE;

                        MediaBrowser_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;
                
                //cache "window"
                case AUDIO_MEDIABROWSER_BUILDUPCACHECACHE_WINDOW: 
                    if(gMediaBrowser_CallBackReason !=AUDIO_MEDIABROWSER_BUILDUPCACHENOCACHE && gMediaBrowser_CallBackReason !=AUDIO_MEDIABROWSER_CALLBACKREASON_CACHENEXT)
                    {   
                        switch (gMediaBrowser_CallBackReason)
                        {
                            case AUDIO_MEDIABROWSER_CALLBACKREASON_CHECKCACHE:
                                                 
                                    gMediaBrowser_cacheBuildUp      =AUDIO_MEDIABROWSER_BUILDUPCACHECACHE_UP;      //next step: build-up upper cache
                                    gMediaBrowser_CallBackReason    =AUDIO_MEDIABROWSER_CALLBACKREASON_CACHENEXT;    
                                    
                                    MediaBrowser_ListHandling ();
                            break;
                        }
                    }
                    else
                    { 
                        putvalue(env_ASG_AudioSD_MB_ListOpState, "build-up list...");
                        shift               =FALSE;
                        direction           =FORWARD;
                        transmitpos         =FALSE;
                        indexsize           =TRUE;
                        recordaddress       =0;
                        startelement        =0;
                        elements            =3; 
    
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gMediaBrowser_CallBackReason  =AUDIO_MEDIABROWSER_CALLBACKREASON_CHECKCACHE;

                        MediaBrowser_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;
                
                //cache-down
                case AUDIO_MEDIABROWSER_BUILDUPCACHECACHE_DOWN:
                    if(gMediaBrowser_CallBackReason !=AUDIO_MEDIABROWSER_BUILDUPCACHENOCACHE && gMediaBrowser_CallBackReason !=AUDIO_MEDIABROWSER_CALLBACKREASON_CACHENEXT)
                    {
                        switch (gMediaBrowser_CallBackReason)
                        {
                            case AUDIO_MEDIABROWSER_CALLBACKREASON_CHECKCACHE:
                                    
                                    //stop caching
                                    gMediaBrowser_cacheBuildUp      =AUDIO_MEDIABROWSER_BUILDUPCACHENOCACHE;  //"build-up cache" finished
                                    gMediaBrowser_ListHandlingType  =AUDIO_MEDIABROWSER_NOCACHE;              
                                    gMediaBrowser_CallBackReason    =AUDIO_MEDIABROWSER_CALLBACKREASON_NOCALLBACK;
                                    gMediaBrowser_CursorAction      =AUDIO_MEDIABROWSER_CURSORACTION_NOTHING;
                                    
                                    gMediaBrowser_DisplayStatus     =AUDIO_MEDIABROWSER_DISPLAYLIST_REFRESH;
                                    
                                    putvalue(env_ASG_AudioSD_MB_ListOpState, empty_string);
                                    MediaBrowser_display();
                            break;
                        }
                    }
                    else
                    { 
                        shift                   =TRUE;
                        direction               =FORWARD;
                        transmitpos             =FALSE;
                        indexsize               =TRUE;
                        recordaddress           =0;
                        for(i=0;i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; i++) //find last cached element
                        {   
                            if(gMediaBrowser_ListEntryReceptionInformation[i] ==FALSE) //abort loop
                                i =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; 
                            else
                                startelement    =gMediaBrowser_Pos[i];
                        }
                        elements                =3;                         
        
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gMediaBrowser_CallBackReason    =AUDIO_MEDIABROWSER_CALLBACKREASON_CHECKCACHE;
                        
                        MediaBrowser_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;

                default:
                break;
            }//build-up cache finished
        break;
        
        /********sliding-window********/
        case AUDIO_MEDIABROWSER_DOWN_CACHE: 
                    if (gMediaBrowser_CallBackReason ==AUDIO_MEDIABROWSER_CALLBACKREASON_CHECKCACHE) //check if valid data received
                    {   
                        if(gMediaBrowser_ListEntryReceptionInformation[5] ==0) //No valid data in last list pos -> last list element reached, start with element 0!  
                        {    
                            shift                   =FALSE;
                            direction               =FORWARD;
                            transmitpos             =FALSE;
                            indexsize               =TRUE;
                            recordaddress           =0;
                            startelement            =0; //first element
                            elements                =1;        
                            
                            requested_startelement  =startelement;
                            mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;
                            
                            gMediaBrowser_CallBackReason    =AUDIO_MEDIABROWSER_CALLBACKREASON_DISPLAYLIST; 
                            gMediaBrowser_cacheDown         =TRUE;

                            MediaBrowser_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);    
                        }
                        else
                        {
                            gMediaBrowser_CallBackReason =AUDIO_MEDIABROWSER_CALLBACKREASON_DISPLAYLIST;
                            MediaBrowser_ListHandling(); 
                        }    
                    }
                    else if (gMediaBrowser_CallBackReason ==AUDIO_MEDIABROWSER_CALLBACKREASON_DISPLAYLIST)
                    {   
                        gMediaBrowser_ListHandlingType  =AUDIO_MEDIABROWSER_NOCACHE;
                        gMediaBrowser_cacheDown         =FALSE;
                        gMediaBrowser_DisplayStatus     =AUDIO_MEDIABROWSER_DISPLAYLIST_FIRST_ELEMENTS;
                        
                        putvalue(env_ASG_AudioSD_MB_ListOpState, empty_string);
                        MediaBrowser_display();
                        gMediaBrowser_DisplayStatus     =AUDIO_MEDIABROWSER_DISPLAYLIST_REFRESH;
                        gMediaBrowser_CallBackReason    =AUDIO_MEDIABROWSER_CALLBACKREASON_NOCALLBACK;
                    }
                    else
                    {   
                        putvalue(env_ASG_AudioSD_MB_ListOpState, "list operating...");
                                
                        shift                   =TRUE;
                        direction               =FORWARD;
                        transmitpos             =FALSE;
                        indexsize               =TRUE;
                        recordaddress           =0;
                        startelement            =gMediaBrowser_Pos[5]; //last element
                        elements                =1;
                        
                        for(i=0;i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;i++)
                        {   
                            j =i+1;
                            
                            switch (i)
                            {   
                                case 0: 
                                    //buffer data of Pos '0' (local)
                                    buffer_Pos              =gMediaBrowser_Pos[i];
                                    buffer_FileType         =gMediaBrowser_FileType[i];
                                    buffer_FileState        =gMediaBrowser_FileState[i];
                                    buffer_FileState_bit0   =gMediaBrowser_FileState_emptyFolder_Bit0[i];
                                    buffer_FileState_bit1   =gMediaBrowser_FileState_DRM_Bit1[i];
                                    buffer_FileState_bit2   =gMediaBrowser_FileState_FileCorrupted_Bit2[i];
                                    buffer_FileState_bit3   =gMediaBrowser_FileState_DeadLink_Bit3[i];
                                    buffer_FileState_bit4   =gMediaBrowser_FileState_ImportFinished_Bit4[i];
                                    buffer_FileState_bit5   =gMediaBrowser_FileState_ImportPending_Bit5[i];
                                    buffer_FileState_bit6   =gMediaBrowser_FileState_ImportPlayable_Bit6[i];

                                    for (k=0; k<AUDIO_MEDIABROWSER_FILENAME_LENGTH;k++) //clear string
                                        buffer_FileName[k] =0;                                     

                                    for(k=0;k<strlen(gMediaBrowser_FileName[i]);k++) 
                                        buffer_FileName[k]=gMediaBrowser_FileName[i][k];
                                    
                                    
                                    //copy data from Pos '1' to Pos '0'
                                    gMediaBrowser_Pos[i]                            =gMediaBrowser_Pos[j]; 
                                    gMediaBrowser_FileType[i]                       =gMediaBrowser_FileType[j];
                                    gMediaBrowser_FileState[i]                      =gMediaBrowser_FileState[j];
                                    gMediaBrowser_FileState_emptyFolder_Bit0[i]     =gMediaBrowser_FileState_emptyFolder_Bit0[j];
                                    gMediaBrowser_FileState_DRM_Bit1[i]             =gMediaBrowser_FileState_DRM_Bit1[j];
                                    gMediaBrowser_FileState_FileCorrupted_Bit2[i]   =gMediaBrowser_FileState_FileCorrupted_Bit2[j];
                                    gMediaBrowser_FileState_DeadLink_Bit3[i]        =gMediaBrowser_FileState_DeadLink_Bit3[j];
                                    gMediaBrowser_FileState_ImportFinished_Bit4[i]  =gMediaBrowser_FileState_ImportFinished_Bit4[j];
                                    gMediaBrowser_FileState_ImportPending_Bit5[i]   =gMediaBrowser_FileState_ImportPending_Bit5[j];
                                    gMediaBrowser_FileState_ImportPlayable_Bit6[i]  =gMediaBrowser_FileState_ImportPlayable_Bit6[j];
                               
                                    for (k=0; k<AUDIO_MEDIABROWSER_FILENAME_LENGTH;k++) //clear string
                                        gMediaBrowser_FileName[i][k] =0;                                     

                                    for(k=0;k<strlen(gMediaBrowser_FileName[j]);k++) 
                                        gMediaBrowser_FileName[i][k]=gMediaBrowser_FileName[j][k];

                                break;
                            
                                case 5:
                                    //clear last element in list 
                                    gMediaBrowser_ListEntryReceptionInformation[i]  =0;
                                    gMediaBrowser_Pos[i]                            =0;
                                    gMediaBrowser_FileType[i]                       =0;
                                    gMediaBrowser_FileState[i]                      =0;
                                    gMediaBrowser_FileState_emptyFolder_Bit0[i]     =0;
                                    gMediaBrowser_FileState_DRM_Bit1[i]             =0;
                                    gMediaBrowser_FileState_FileCorrupted_Bit2[i]   =0;
                                    gMediaBrowser_FileState_DeadLink_Bit3[i]        =0;
                                    gMediaBrowser_FileState_ImportFinished_Bit4[i]  =0;
                                    gMediaBrowser_FileState_ImportPending_Bit5[i]   =0;
                                    gMediaBrowser_FileState_ImportPlayable_Bit6[i]  =0;

                                    for (k=0; k<AUDIO_MEDIABROWSER_FILENAME_LENGTH;k++) //clear string
                                        gMediaBrowser_FileName[i][k] =0;
                                                                 
                                break;
                            
                                case 8:
                                    //copy data from buffer in Pos '8'
                                    gMediaBrowser_Pos[i]                            =buffer_Pos; 
                                    gMediaBrowser_FileType[i]                       =buffer_FileType;
                                    gMediaBrowser_FileState[i]                      =buffer_FileState;
                                    gMediaBrowser_FileState_emptyFolder_Bit0[i]     =buffer_FileState_bit0;
                                    gMediaBrowser_FileState_DRM_Bit1[i]             =buffer_FileState_bit1;
                                    gMediaBrowser_FileState_FileCorrupted_Bit2[i]   =buffer_FileState_bit2;
                                    gMediaBrowser_FileState_DeadLink_Bit3[i]        =buffer_FileState_bit3;
                                    gMediaBrowser_FileState_ImportFinished_Bit4[i]  =buffer_FileState_bit4;
                                    gMediaBrowser_FileState_ImportPending_Bit5[i]   =buffer_FileState_bit5;
                                    gMediaBrowser_FileState_ImportPlayable_Bit6[i]  =buffer_FileState_bit6;

                                    for (k=0; k<AUDIO_MEDIABROWSER_FILENAME_LENGTH;k++) //clear string
                                        gMediaBrowser_FileName[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_FileName);k++) 
                                        gMediaBrowser_FileName[i][k]=buffer_FileName[k];
                                    
                                break;
                                
                                default://other elements
                                    //copy element on other position
                                    gMediaBrowser_Pos[i]                            =gMediaBrowser_Pos[j]; 
                                    gMediaBrowser_FileType[i]                       =gMediaBrowser_FileType[j];
                                    gMediaBrowser_FileState[i]                      =gMediaBrowser_FileState[j];
                                    gMediaBrowser_FileState_emptyFolder_Bit0[i]     =gMediaBrowser_FileState_emptyFolder_Bit0[j];
                                    gMediaBrowser_FileState_DRM_Bit1[i]             =gMediaBrowser_FileState_DRM_Bit1[j]; 
                                    gMediaBrowser_FileState_FileCorrupted_Bit2[i]   =gMediaBrowser_FileState_FileCorrupted_Bit2[j];
                                    gMediaBrowser_FileState_DeadLink_Bit3[i]        =gMediaBrowser_FileState_DeadLink_Bit3[j];
                                    gMediaBrowser_FileState_ImportFinished_Bit4[i]  =gMediaBrowser_FileState_ImportFinished_Bit4[j];
                                    gMediaBrowser_FileState_ImportPending_Bit5[i]   =gMediaBrowser_FileState_ImportPending_Bit5[j];
                                    gMediaBrowser_FileState_ImportPlayable_Bit6[i]  =gMediaBrowser_FileState_ImportPlayable_Bit6[j];
                                    
                                    for (k=0; k<AUDIO_MEDIABROWSER_FILENAME_LENGTH;k++) //clear string
                                        gMediaBrowser_FileName[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gMediaBrowser_FileName[j]);k++) 
                                        gMediaBrowser_FileName[i][k]=gMediaBrowser_FileName[j][k];

                                break;
                            } // end of switch 'i'
                        }
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        MediaBrowser_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);                        
                        
                        //to check, if valid data received
                        gMediaBrowser_CallBackReason    =AUDIO_MEDIABROWSER_CALLBACKREASON_CHECKCACHE;
                    }
        break;

        case AUDIO_MEDIABROWSER_UP_CACHE: 
                    if (gMediaBrowser_CallBackReason ==AUDIO_MEDIABROWSER_CALLBACKREASON_CHECKCACHE) //check if valid data received
                    {   
                        if(gMediaBrowser_ListEntryReceptionInformation[6] ==0) //No valid data in first list pos -> last list element reached, start with element 0!  
                        {
                            shift                   =TRUE;
                            direction               =BACKWARD;
                            transmitpos             =FALSE;
                            indexsize               =TRUE;
                            recordaddress           =0;
                            startelement            =0; //Last element
                            elements                =1;        
                            
                            requested_startelement  =startelement;
                            mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                            gMediaBrowser_cacheUp        =TRUE;
                            gMediaBrowser_CallBackReason =AUDIO_MEDIABROWSER_CALLBACKREASON_DISPLAYLIST;
                            
                            MediaBrowser_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                        }
                        else
                        {
                            gMediaBrowser_CallBackReason =AUDIO_MEDIABROWSER_CALLBACKREASON_DISPLAYLIST;
                            MediaBrowser_ListHandling();
                        }           
                    }

                    else if (gMediaBrowser_CallBackReason ==AUDIO_MEDIABROWSER_CALLBACKREASON_DISPLAYLIST)
                    {   
                        gMediaBrowser_ListHandlingType  =AUDIO_MEDIABROWSER_NOCACHE;
                        gMediaBrowser_cacheUp           =FALSE;
                        gMediaBrowser_DisplayStatus     =AUDIO_MEDIABROWSER_DISPLAYLIST_FIRST_ELEMENTS;
                        
                        putvalue(env_ASG_AudioSD_MB_ListOpState, empty_string);
                        MediaBrowser_display();
                        gMediaBrowser_DisplayStatus     =AUDIO_MEDIABROWSER_DISPLAYLIST_REFRESH;
                        gMediaBrowser_CallBackReason    =AUDIO_MEDIABROWSER_CALLBACKREASON_NOCALLBACK;
                    }

                    else
                    {           
                        putvalue(env_ASG_AudioSD_MB_ListOpState, "list operating...");

                        shift                   =TRUE;
                        direction               =BACKWARD;
                        transmitpos             =FALSE;
                        indexsize               =TRUE;
                        recordaddress           =0;
                        startelement            =gMediaBrowser_Pos[6]; //first element
                        elements                =1;
                    
                        for(i=AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE-1;i>=0;i--)
                        {  
                            j =i-1;
                            switch (i)
                            {   
                                case 8: 
                                    //buffer data of Pos '8' (local)
                                    buffer_Pos              =gMediaBrowser_Pos[i];
                                    buffer_FileType         =gMediaBrowser_FileType[i];
                                    buffer_FileState        =gMediaBrowser_FileState[i];
                                    buffer_FileState_bit0   =gMediaBrowser_FileState_emptyFolder_Bit0[i];
                                    buffer_FileState_bit1   =gMediaBrowser_FileState_DRM_Bit1[i];
                                    buffer_FileState_bit2   =gMediaBrowser_FileState_FileCorrupted_Bit2[i];
                                    buffer_FileState_bit3   =gMediaBrowser_FileState_DeadLink_Bit3[i];
                                    buffer_FileState_bit4   =gMediaBrowser_FileState_ImportFinished_Bit4[i];
                                    buffer_FileState_bit5   =gMediaBrowser_FileState_ImportPending_Bit5[i];
                                    buffer_FileState_bit6   =gMediaBrowser_FileState_ImportPlayable_Bit6[i];

                                    for (k=0; k<AUDIO_MEDIABROWSER_FILENAME_LENGTH;k++) //clear string
                                        buffer_FileName[k] =0;                                     

                                    for(k=0;k<strlen(gMediaBrowser_FileName[i]);k++) 
                                        buffer_FileName[k]=gMediaBrowser_FileName[i][k];

                                    //copy data from Pos '7' to Pos '8'
                                    gMediaBrowser_Pos[i]                            =gMediaBrowser_Pos[j]; 
                                    gMediaBrowser_FileType[i]                       =gMediaBrowser_FileType[j];
                                    gMediaBrowser_FileState[i]                      =gMediaBrowser_FileState[j];
                                    gMediaBrowser_FileState_emptyFolder_Bit0[i]     =gMediaBrowser_FileState_emptyFolder_Bit0[j];
                                    gMediaBrowser_FileState_DRM_Bit1[i]             =gMediaBrowser_FileState_DRM_Bit1[j];
                                    gMediaBrowser_FileState_FileCorrupted_Bit2[i]   =gMediaBrowser_FileState_FileCorrupted_Bit2[j];
                                    gMediaBrowser_FileState_DeadLink_Bit3[i]        =gMediaBrowser_FileState_DeadLink_Bit3[j];
                                    gMediaBrowser_FileState_ImportFinished_Bit4[i]  =gMediaBrowser_FileState_ImportFinished_Bit4[j];
                                    gMediaBrowser_FileState_ImportPending_Bit5[i]   =gMediaBrowser_FileState_ImportPending_Bit5[j];
                                    gMediaBrowser_FileState_ImportPlayable_Bit6[i]  =gMediaBrowser_FileState_ImportPlayable_Bit6[j];

                                    for (k=0; k<AUDIO_MEDIABROWSER_FILENAME_LENGTH;k++) //clear string
                                        gMediaBrowser_FileName[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gMediaBrowser_FileName[j]);k++) 
                                        gMediaBrowser_FileName[i][k]=gMediaBrowser_FileName[j][k];
                                    
                                break;
                            
                                case 6: 
                                    //clear first element in list 
                                    gMediaBrowser_ListEntryReceptionInformation[i]  =0;
                                    gMediaBrowser_Pos[i]                            =0;
                                    gMediaBrowser_FileType[i]                           =0;
                                    gMediaBrowser_FileState[i]                      =0;
                                    gMediaBrowser_FileState_emptyFolder_Bit0[i]     =0;
                                    gMediaBrowser_FileState_DRM_Bit1[i]             =0;
                                    gMediaBrowser_FileState_FileCorrupted_Bit2[i]   =0;
                                    gMediaBrowser_FileState_DeadLink_Bit3[i]        =0;
                                    gMediaBrowser_FileState_ImportFinished_Bit4[i]  =0;
                                    gMediaBrowser_FileState_ImportPending_Bit5[i]   =0;
                                    gMediaBrowser_FileState_ImportPlayable_Bit6[i]  =0;
                                                                
                                    for (k=0; k<AUDIO_MEDIABROWSER_FILENAME_LENGTH;k++) //clear string
                                        gMediaBrowser_FileName[i][k] =0;
                                                                            
                                break;
                            
                                case 0: 
                                    //copy data from buffer in Pos '0'
                                    gMediaBrowser_Pos[i]                            =buffer_Pos; 
                                    gMediaBrowser_FileType[i]                       =buffer_FileType;
                                    gMediaBrowser_FileState[i]                      =buffer_FileState;
                                    gMediaBrowser_FileState_emptyFolder_Bit0[i]     =buffer_FileState_bit0;
                                    gMediaBrowser_FileState_DRM_Bit1[i]             =buffer_FileState_bit1;
                                    gMediaBrowser_FileState_FileCorrupted_Bit2[i]   =buffer_FileState_bit2;
                                    gMediaBrowser_FileState_DeadLink_Bit3[i]        =buffer_FileState_bit3;
                                    gMediaBrowser_FileState_ImportFinished_Bit4[i]  =buffer_FileState_bit4;
                                    gMediaBrowser_FileState_ImportPending_Bit5[i]   =buffer_FileState_bit5;
                                    gMediaBrowser_FileState_ImportPlayable_Bit6[i]  =buffer_FileState_bit6;
                                    
                                    for (k=0; k<AUDIO_MEDIABROWSER_FILENAME_LENGTH;k++) //clear string
                                        gMediaBrowser_FileName[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_FileName);k++) 
                                        gMediaBrowser_FileName[i][k]=buffer_FileName[k];

                                break;
                                
                                default: //other elements
                                    //copy element on other position
                                    gMediaBrowser_Pos[i]                            =gMediaBrowser_Pos[j]; 
                                    gMediaBrowser_FileType[i]                       =gMediaBrowser_FileType[j];
                                    gMediaBrowser_FileState[i]                      =gMediaBrowser_FileState[j];
                                    gMediaBrowser_FileState_emptyFolder_Bit0[i]     =gMediaBrowser_FileState_emptyFolder_Bit0[j];
                                    gMediaBrowser_FileState_DRM_Bit1[i]             =gMediaBrowser_FileState_DRM_Bit1[j];
                                    gMediaBrowser_FileState_FileCorrupted_Bit2[i]   =gMediaBrowser_FileState_FileCorrupted_Bit2[j];
                                    gMediaBrowser_FileState_DeadLink_Bit3[i]        =gMediaBrowser_FileState_DeadLink_Bit3[j];
                                    gMediaBrowser_FileState_ImportFinished_Bit4[i]  =gMediaBrowser_FileState_ImportFinished_Bit4[j];
                                    gMediaBrowser_FileState_ImportPending_Bit5[i]   =gMediaBrowser_FileState_ImportPending_Bit5[j];
                                    gMediaBrowser_FileState_ImportPlayable_Bit6[i]  =gMediaBrowser_FileState_ImportPlayable_Bit6[j];

                                    for (k=0; k<AUDIO_MEDIABROWSER_FILENAME_LENGTH;k++) //clear string
                                        gMediaBrowser_FileName[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gMediaBrowser_FileName[j]);k++) 
                                        gMediaBrowser_FileName[i][k]=gMediaBrowser_FileName[j][k];
                                    
                                break;
                            } // end of switch 'i'
                        }
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        MediaBrowser_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);                        
                        
                        //to check, if valid data received
                        gMediaBrowser_CallBackReason    =AUDIO_MEDIABROWSER_CALLBACKREASON_CHECKCACHE;
                    }
        break;

        default:
        break;
    } //end of switch 'type of cache handling' 
}

on envVar env_ASG_AudioSD_MB_GetArray
{
    byte mode, shift, direction, transmitpos, indexsize,recordaddress;
    word requested_startelement, startelement, elements;

    // Init local variables. 
    mode                    =0;
    shift                   =0;
    direction               =0;
    transmitpos             =0;
    indexsize               =0;
    recordaddress           =0;
    requested_startelement  =0;
    startelement            =0;
    elements                =0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gMediaBrowser_ListHandlingType ==AUDIO_MEDIABROWSER_NOCACHE)
	{
        gMediaBrowser_ASGID            =getvalue(env_ASG_AudioSD_MB_ASGID);
        gMediaBrowser_TAID             =getvalue(env_ASG_AudioSD_MB_TAID);
        gMediaBrowser_ActiveListPos    =getvalue(env_ASG_AudioSD_MB_ActiveListPos);

        shift                           =getvalue(env_ASG_AudioSD_MB_AH_shift);
        direction                       =getvalue(env_ASG_AudioSD_MB_AH_dir);
        transmitpos                     =getvalue(env_ASG_AudioSD_MB_AH_PosTrans);
        indexsize                       =getvalue(env_ASG_AudioSD_MB_AH_IS);
        recordaddress                   =getvalue(env_ASG_AudioSD_MB_AH_RA);
        startelement                    =getvalue(env_ASG_AudioSD_MB_AH_start);
        elements                        =getvalue(env_ASG_AudioSD_MB_AH_elements);
        
        requested_startelement  =startelement;
        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

        MediaBrowser_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
    }
}

on envVar env_ASG_AudioSD_MB_OnOff
{
    int i =0, j =0;
    if(POWER_ON==gASG_PowerOnOff)
	{   
        if(getvalue(this))
        {
            gMediaBrowser_ListHandlingType      =AUDIO_MEDIABROWSER_BUILDUPCACHE;             //build-up complete cache...
            gMediaBrowser_cacheBuildUp          =AUDIO_MEDIABROWSER_BUILDUPCACHECACHE_WINDOW; //...and start with area "window"            
        
            MediaBrowser_ListHandling ();
        }
        else
        {
            gMediaBrowser_SlidingWindow_State   =AUDIO_MEDIABROWSER_SLIDINGWINDOW_NOTACTIVE;
            gMediaBrowser_ListHandlingType      =AUDIO_MEDIABROWSER_NOCACHE;
            gMediaBrowser_cacheBuildUp          =AUDIO_MEDIABROWSER_BUILDUPCACHENOCACHE;
            gMediaBrowser_CallBackReason        =AUDIO_MEDIABROWSER_CALLBACKREASON_NOCALLBACK;

            gMediaBrowser_cacheDown             =FALSE;
            gMediaBrowser_cacheUp               =FALSE;
            gMediaBrowser_LastFirstElement      =0;

            gMediaBrowser_recordaddress         =0;
            gMediaBrowser_transmitpos           =1;
            gMediaBrowser_CursorAction          =AUDIO_MEDIABROWSER_CURSORACTION_NOTHING;
            gMediaBrowser_DisplayStatus         =AUDIO_MEDIABROWSER_DISPLAYLIST_FIRST_ELEMENTS;
            
            for(j=0; j<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE; j++)
            {     
                gMediaBrowser_Pos[j]                            =0;
                gMediaBrowser_FileType[j]                       =0;
                gMediaBrowser_FileState_emptyFolder_Bit0[j]     =0;
                gMediaBrowser_FileState_DRM_Bit1[j]             =0;
                gMediaBrowser_FileState_FileCorrupted_Bit2[j]   =0;
                gMediaBrowser_FileState_DeadLink_Bit3[j]        =0;
                gMediaBrowser_FileState_ImportFinished_Bit4[j]  =0;
                gMediaBrowser_FileState_ImportPending_Bit5[j]   =0;
                gMediaBrowser_FileState_ImportPlayable_Bit6[j]  =0;
                gMediaBrowser_FileState[j]                      =0;
                gMediaBrowser_ListEntryReceptionInformation[j]  =0;

                for(i=0;i<AUDIO_MEDIABROWSER_FILENAME_LENGTH;i++)
			        gMediaBrowser_FileName[j][i] =0;
            }
            putvalue(env_ASG_AudioSD_MB_pos_0, 0);
            putvalue(env_ASG_AudioSD_MB_pos_1, 0);
            putvalue(env_ASG_AudioSD_MB_pos_2, 0);
    
            putvalue(env_ASG_AudioSD_MB_FileType_0, 0);
            putvalue(env_ASG_AudioSD_MB_FileType_1, 0);
            putvalue(env_ASG_AudioSD_MB_FileType_2, 0);

            putvalue(env_ASG_AudioSD_MB_FileType_s_0,empty_string);
            putvalue(env_ASG_AudioSD_MB_FileType_s_1,empty_string);
            putvalue(env_ASG_AudioSD_MB_FileType_s_2,empty_string);

            putvalue(env_ASG_AudioSD_MB_FS_bit0_0, 0);
            putvalue(env_ASG_AudioSD_MB_FS_bit0_1, 0);
            putvalue(env_ASG_AudioSD_MB_FS_bit0_2, 0);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit0_0, empty_string);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit0_1, empty_string);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit0_2, empty_string);

            putvalue(env_ASG_AudioSD_MB_FS_bit1_0, 0);
            putvalue(env_ASG_AudioSD_MB_FS_bit1_1, 0);
            putvalue(env_ASG_AudioSD_MB_FS_bit1_2, 0);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit1_0, empty_string);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit1_1, empty_string);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit1_2, empty_string);

            putvalue(env_ASG_AudioSD_MB_FS_bit2_0, 0);
            putvalue(env_ASG_AudioSD_MB_FS_bit2_1, 0);
            putvalue(env_ASG_AudioSD_MB_FS_bit2_2, 0);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit2_0, empty_string);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit2_1, empty_string);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit2_2, empty_string);

            putvalue(env_ASG_AudioSD_MB_FS_bit3_0, 0);
            putvalue(env_ASG_AudioSD_MB_FS_bit3_1, 0);
            putvalue(env_ASG_AudioSD_MB_FS_bit3_2, 0);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit3_0, empty_string);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit3_1, empty_string);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit3_2, empty_string);

            putvalue(env_ASG_AudioSD_MB_FS_bit4_0, 0);
            putvalue(env_ASG_AudioSD_MB_FS_bit4_1, 0);
            putvalue(env_ASG_AudioSD_MB_FS_bit4_2, 0);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit4_0, empty_string);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit4_1, empty_string);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit4_2, empty_string);

            putvalue(env_ASG_AudioSD_MB_FS_bit5_0, 0);
            putvalue(env_ASG_AudioSD_MB_FS_bit5_1, 0);
            putvalue(env_ASG_AudioSD_MB_FS_bit5_2, 0);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit5_0, empty_string);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit5_1, empty_string);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit5_2, empty_string);

            putvalue(env_ASG_AudioSD_MB_FS_bit6_0, 0);
            putvalue(env_ASG_AudioSD_MB_FS_bit6_1, 0);
            putvalue(env_ASG_AudioSD_MB_FS_bit6_2, 0);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit6_0, empty_string);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit6_1, empty_string);
            putvalue(env_ASG_AudioSD_MB_FS_s_bit6_2, empty_string);
           
            putvalue(env_ASG_AudioSD_MB_FileName_s_0, empty_string);
            putvalue(env_ASG_AudioSD_MB_FileName_s_1, empty_string);
            putvalue(env_ASG_AudioSD_MB_FileName_s_2, empty_string);
            
        }
    }
}   

on envVar env_ASG_AudioSD_MB_down
{
    int i=0, j=0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gMediaBrowser_ListHandlingType ==AUDIO_MEDIABROWSER_NOCACHE)
	{      
        gMediaBrowser_CursorAction =AUDIO_MEDIABROWSER_CURSORACTION_DOWN;
        
        if(gMediaBrowser_SlidingWindow_State ==AUDIO_MEDIABROWSER_SLIDINGWINDOW_ACTIVE)
        {   
            gMediaBrowser_ListHandlingType  =AUDIO_MEDIABROWSER_DOWN_CACHE;
            gMediaBrowser_DisplayStatus     =AUDIO_MEDIABROWSER_DISPLAYLIST_FIRST_ELEMENTS;
            gMediaBrowser_CursorAction      =AUDIO_MEDIABROWSER_CURSORACTION_NOTHING;
            
            MediaBrowser_ListHandling ();
        }
        else if(gMediaBrowser_SlidingWindow_State ==AUDIO_MEDIABROWSER_SLIDINGWINDOW_NOTACTIVE)
        {
            gMediaBrowser_DisplayStatus     =AUDIO_MEDIABROWSER_DISPLAYLIST_SEARCH_ELEMENTS;
            gMediaBrowser_CursorAction      =AUDIO_MEDIABROWSER_CURSORACTION_DOWN;

            MediaBrowser_display();

            //reset values
            gMediaBrowser_DisplayStatus     =AUDIO_MEDIABROWSER_DISPLAYLIST_REFRESH;
            gMediaBrowser_CursorAction      =AUDIO_MEDIABROWSER_CURSORACTION_NOTHING;
        }
    }
}

on envVar env_ASG_AudioSD_MB_up
{
    int i=0, j=0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gMediaBrowser_ListHandlingType ==AUDIO_MEDIABROWSER_NOCACHE)
	{   
        gMediaBrowser_CursorAction =AUDIO_MEDIABROWSER_CURSORACTION_UP;

        if(gMediaBrowser_SlidingWindow_State ==AUDIO_MEDIABROWSER_SLIDINGWINDOW_ACTIVE)
        {  
            gMediaBrowser_ListHandlingType  =AUDIO_MEDIABROWSER_UP_CACHE;
            gMediaBrowser_DisplayStatus     =AUDIO_MEDIABROWSER_DISPLAYLIST_FIRST_ELEMENTS;
            gMediaBrowser_CursorAction      =AUDIO_MEDIABROWSER_CURSORACTION_NOTHING;
            
            MediaBrowser_ListHandling ();
        }
        else if(gMediaBrowser_SlidingWindow_State ==AUDIO_MEDIABROWSER_SLIDINGWINDOW_NOTACTIVE)
        {
            gMediaBrowser_DisplayStatus     =AUDIO_MEDIABROWSER_DISPLAYLIST_SEARCH_ELEMENTS;
            gMediaBrowser_CursorAction      =AUDIO_MEDIABROWSER_CURSORACTION_UP;

            MediaBrowser_ListHandling();
            
            MediaBrowser_display();

            //reset values
            gMediaBrowser_DisplayStatus     =AUDIO_MEDIABROWSER_DISPLAYLIST_REFRESH;
            gMediaBrowser_CursorAction      =AUDIO_MEDIABROWSER_CURSORACTION_NOTHING;
        }    
    }
}

on timer ASGCapa_startTimer
{
    ASGCapabilities_Request(DataSetGet_REQ);
}

on envVar env_ASG_AudioSD_FSGSetup_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        FSG_Setup_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_SDSState_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        SDSState_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_InfoSt_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        InfoStates_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_ASGCap_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        ASGCapabilities_Request(DataGet_REQ);
    
}

on envVar env_ASG_AudioSD_CSI_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        CurrentStationInfo_Request(DataGet_REQ);   
}

on envVar env_ASG_AudioSD_CSH_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        CurrentStationHandle_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_AS_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        activeSource_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_SrcSt_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        SourceState_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_ASName_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        activeSourceName_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_CurrVol_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        currentVolume_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_Mute_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        Mute_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_GIS_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        GeneralInfoSwitches_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_TPMemInfo_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        TPMemoInfo_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_PrefList_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        PreferredList_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_RecListTy_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        ReceptionListType_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_MePath_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        MediaPath_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_MeBrLevel_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        MediaBrowserFolderLevel_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_AnInf_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        AnnouncementInfo_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_FSGOpState_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        FSG_OperationState_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_FctSyn_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        FunctionSynchronisation_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_FctList_get
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
        FunctionList_Request(DataGet_REQ);
}

on envVar env_ASG_AudioSD_open_Prop_5
{

    openPanel("ASG_Property_DF41"); 


}

on sysvar sysvar::ASG_AudioSD::MeImSe_InID
{
}

on sysvar sysvar::ASG_AudioSD::MeImSe_ST
{
    if(@sysvar::ASG_AudioSD::MeImSe_ST <0x24 || !temp3)
       gMIS_STact = @sysvar::ASG_AudioSD::MeImSe_ST;
    if(@sysvar::ASG_AudioSD::MeImSe_ST ==255 || !temp3)
       gMIS_STact = @sysvar::ASG_AudioSD::MeImSe_ST;
       temp3 =0;
    if(@sysvar::ASG_AudioSD::MeImSe_SThex != gMIS_STact)
        @sysvar::ASG_AudioSD::MeImSe_SThex =@sysvar::ASG_AudioSD::MeImSe_ST;

}

on sysvar sysvar::ASG_AudioSD::MeImSe_State0
{
    if(@sysvar::ASG_AudioSD::MeImSe_State0 == 1)
        @sysvar::ASG_AudioSD::MeImSe_State1 == 0;
}

on sysvar sysvar::ASG_AudioSD::MeImSe_State1
{
    if(@sysvar::ASG_AudioSD::MeImSe_State1 == 1)
        @sysvar::ASG_AudioSD::MeImSe_State0 == 0;
}

on sysvar sysvar::ASG_AudioSD::MeImSe_Get
{
}

on sysvar sysvar::ASG_AudioSD::MeImSe_SThex
{

    if(@sysvar::ASG_AudioSD::MeImSe_SThex >0x24 && @sysvar::ASG_AudioSD::MeImSe_SThex != 255)
       {
        gMIS_STact =@sysvar::ASG_AudioSD::MeImSe_SThex;
        temp3 =1;
        @sysvar::ASG_AudioSD::MeImSe_ST = @sysvar::ASG_AudioSD::MeImSe_SThex;
       }
       else
       {
        if(@sysvar::ASG_AudioSD::MeImSe_SThex != gMIS_STact)
            @sysvar::ASG_AudioSD::MeImSe_ST =@sysvar::ASG_AudioSD::MeImSe_SThex;
       }
}

on sysvar sysvar::ASG_AudioSD::CuDoSt_Get
{
}

on sysvar sysvar::ASG_AudioSD::CuStHa2_Get
{
}

on sysvar sysvar::ASG_AudioSD::CuVoEx_Get
{
}

on sysvar sysvar::ASG_AudioSD::OnMuSt_Get
{
}

on sysvar sysvar::ASG_AudioSD::CuVoEx_CVT
{
    if(@sysvar::ASG_AudioSD::CuVoEx_CVT <0x0D || !temp1)
       gCVE_CVTact = @sysvar::ASG_AudioSD::CuVoEx_CVT;
    if(@sysvar::ASG_AudioSD::CuVoEx_CVT ==0x10 || !temp1 || @sysvar::ASG_AudioSD::CuVoEx_CVT ==0x11)
       gCVE_CVTact = @sysvar::ASG_AudioSD::CuVoEx_CVT;
       temp1 =0;
    if(@sysvar::ASG_AudioSD::CuVoEx_CVThex != gCVE_CVTact)
        @sysvar::ASG_AudioSD::CuVoEx_CVThex =@sysvar::ASG_AudioSD::CuVoEx_CVT;
}

on sysvar sysvar::ASG_AudioSD::CuVoEx_CVThex
{
    if(@sysvar::ASG_AudioSD::CuVoEx_CVThex >0x0D && @sysvar::ASG_AudioSD::CuVoEx_CVThex != 0x10 && @sysvar::ASG_AudioSD::CuVoEx_CVThex != 0x11)
       {
        gCVE_CVTact =@sysvar::ASG_AudioSD::CuVoEx_CVThex;
        temp1 =1;
        @sysvar::ASG_AudioSD::CuVoEx_CVT = @sysvar::ASG_AudioSD::CuVoEx_CVThex;
       }
       else
       {
        if(@sysvar::ASG_AudioSD::CuVoEx_CVThex != gCVE_CVTact)
            @sysvar::ASG_AudioSD::CuVoEx_CVT =@sysvar::ASG_AudioSD::CuVoEx_CVThex;
       }
}

on sysvar sysvar::ASG_AudioSD::CuVoEx_VolS0
{
    if(@sysvar::ASG_AudioSD::CuVoEx_VolS0==1)
        @sysvar::ASG_AudioSD::CuVoEx_VolS1 = 0;
}

on sysvar sysvar::ASG_AudioSD::CuVoEx_VolS1
{
    if(@sysvar::ASG_AudioSD::CuVoEx_VolS1==1)
        @sysvar::ASG_AudioSD::CuVoEx_VolS0 = 0;

}

on sysvar sysvar::ASG_AudioSD::CuDoSt_CuDoSt
{
    if(@sysvar::ASG_AudioSD::CuDoSt_CuDoSt <4 || !temp2)
       gCDS_CDSact = @sysvar::ASG_AudioSD::CuDoSt_CuDoSt;
    temp2 =0;
    if(@sysvar::ASG_AudioSD::CuDoSt_CuDoSthex != gCDS_CDSact)
        @sysvar::ASG_AudioSD::CuDoSt_CuDoSthex =@sysvar::ASG_AudioSD::CuDoSt_CuDoSt;
}

on sysvar sysvar::ASG_AudioSD::CuDoSt_CuDoSthex
{
    if(@sysvar::ASG_AudioSD::CuDoSt_CuDoSthex >3)
       {
        gCDS_CDSact =@sysvar::ASG_AudioSD::CuDoSt_CuDoSthex;
        temp2 =1;
        @sysvar::ASG_AudioSD::CuDoSt_CuDoSt = @sysvar::ASG_AudioSD::CuDoSt_CuDoSthex;
       }
       else
       {
        if(@sysvar::ASG_AudioSD::CuDoSt_CuDoSthex != gCDS_CDSact)
            @sysvar::ASG_AudioSD::CuDoSt_CuDoSt =@sysvar::ASG_AudioSD::CuDoSt_CuDoSthex;
       }
}

on sysvar sysvar::ASG_AudioSD::OnMuSt_State
{
    if(@sysvar::ASG_AudioSD::OnMuSt_State <0x25 || !temp4)
       gOMS_Sact = @sysvar::ASG_AudioSD::OnMuSt_State;
    temp4 =0;
    if(@sysvar::ASG_AudioSD::OnMuSt_Statehex != gOMS_Sact)
        @sysvar::ASG_AudioSD::OnMuSt_Statehex =@sysvar::ASG_AudioSD::OnMuSt_State;
}

on sysvar sysvar::ASG_AudioSD::OnMuSt_Statehex
{
    if(@sysvar::ASG_AudioSD::OnMuSt_Statehex >0x24)
       {
        gOMS_Sact =@sysvar::ASG_AudioSD::OnMuSt_Statehex;
        temp4 =1;
        @sysvar::ASG_AudioSD::OnMuSt_State = @sysvar::ASG_AudioSD::OnMuSt_Statehex;
       }
       else
       {
        if(@sysvar::ASG_AudioSD::OnMuSt_Statehex != gOMS_Sact)
            @sysvar::ASG_AudioSD::OnMuSt_State =@sysvar::ASG_AudioSD::OnMuSt_Statehex;
       }
}

MediaImportState_Indication (dword Indication_array [], int datalength)
{

		switch (gBAP_Indication[2])
		{
			case Data_IND:
          @sysvar::ASG_AudioSD::MeImSe_State0 = 0;
          @sysvar::ASG_AudioSD::MeImSe_State1 = 0;
          //get data
	        @sysvar::ASG_AudioSD::MeImSe_SThex  = Indication_array[3];
          @sysvar::ASG_AudioSD::MeImSe_InID   = Indication_array[4];
          @sysvar::ASG_AudioSD::MeImSe_State1 = Indication_array[5];         
          if( Indication_array[5] == 0)
          {
              @sysvar::ASG_AudioSD::MeImSe_State0 = 1;
          }
          @sysvar::ASG_AudioSD::MeImSe_Progress = Indication_array[6];      
      break;
      case Error_IND:
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaImportState_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaImportState_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaImportState_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD MediaImportState_Indication: Application-Error: 0x%x", Indication_array[3]);	
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD MediaImportState_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
		}
}

MediaImportState_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	            //LSG-ID
	requestarray[1] =FctID_MediaImportState;	//Fct.-ID
	requestarray[2] =request;                   //request type
	
    switch(request)
	{
		case DataGet_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD MediaImportState_Request: invalid request %d", request);
		break;
	}
}

CurrentVolumeExtended_Indication (dword Indication_array [], int datalength)
{
		switch (gBAP_Indication[2])
		{
			case Data_IND:
                
                //get data
				@sysvar::ASG_AudioSD::CuVoEx_CVThex =Indication_array[3];
                @sysvar::ASG_AudioSD::CuVoEx_VolS1  =Indication_array[4];         
                if(Indication_array[4] == 0)
                    @sysvar::ASG_AudioSD::CuVoEx_VolS0 = 1;
                @sysvar::ASG_AudioSD::CuVoEx_MaxVol =Indication_array[5];
                @sysvar::ASG_AudioSD::CuVoEx_GenVol =Indication_array[6];



            break;
			
            case Error_IND:
					
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentVolumeExtended_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentVolumeExtended_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentVolumeExtended_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentVolumeExtended_Indication: Application-Error: 0x%x", Indication_array[3]);
				
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD CurrentVolumeExtended_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
		}
}

CurrentVolumeExtended_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	            //LSG-ID
	requestarray[1] =FctID_CurrentVolumeExtended;	    //Fct.-ID
	requestarray[2] =request;                   //request type
	
    switch(request)
	{
		case DataGet_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentVolumeExtended_Request: invalid request %d", request);
		break;
	}
}

CustomerDownloadState_Indication (dword Indication_array [], int datalength)
{

		switch (gBAP_Indication[2])
		{
			case Data_IND:
          //get data
	        @sysvar::ASG_AudioSD::CuDoSt_CuDoSthex  = Indication_array[3];
          @sysvar::ASG_AudioSD::CuDoSt_PCD        = Indication_array[4];
      break;

      case Error_IND:	
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CustomerDownloadState_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CustomerDownloadState_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CustomerDownloadState_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD CustomerDownloadState_Indication: Application-Error: 0x%x", Indication_array[3]);
				
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD CustomerDownloadState_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
		}
}

OnlineMusic_State_Indication (dword Indication_array [], int datalength)
{

		switch (gBAP_Indication[2])
		{
			case Data_IND:

                //get data
				@sysvar::ASG_AudioSD::OnMuSt_Statehex  = Indication_array[3];
                @sysvar::ASG_AudioSD::OnMuSt_BuLvl   = Indication_array[4];

            break;
			
            case Error_IND:
					
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD OnlineMusic_State_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD OnlineMusic_State_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD OnlineMusic_State_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD OnlineMusic_State_Indication: Application-Error: 0x%x", Indication_array[3]);
				
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD OnlineMusic_State_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
		}
}

CommonList_Indication (dword Indication_array [], int datalength)
{
    byte mode, direction, shift, recordaddress, indexsize, current_element, transmitpos, length, CacheElements, StartElementInCache;
    word  startelement, elements, startelement_check, Offset =0;
    int i =0, j=0;

    // Init local variables
    Offset                  =0;
    mode                    =0;
    direction               =0;
    shift                   =0;
    recordaddress           =0;
    startelement            =0;
    elements                =0;
    current_element         =0;
    transmitpos             =0;
    length                  =0;
    startelement_check      =0;
    StartElementInCache     =FALSE;
    CacheElements           =FALSE;

    
		switch (gBAP_Indication[2])
		{
			case Data_IND:
				//get data
                gCommonList_ASGID =(Indication_array[3] &0xF0) /0x10;
                gCommonList_TAID  =Indication_array[3] &0x0F;
                
                gCommonList_TotalNumListElements =Indication_array[4];
                gCommonList_TotalNumListElements +=(Indication_array[5] *0x100);
                              
                /***ArrayHeader***/
                mode            =(Indication_array[6] &0xF0) /0x10;
                recordaddress   =Indication_array[6] &0x0F;
                Offset =7;
                
                // decode "mode-byte"
                shift       =mode &0x01;
                direction   =(mode &0x02)/0x02;
                transmitpos =(mode &0x04)/0x04;
                indexsize   =(mode &0x08)/0x08; 

                if (indexsize)
                {   
                    startelement =Indication_array[Offset];
                    Offset++;
                    startelement +=(Indication_array[Offset] *0x100);
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                    elements +=(Indication_array[Offset] *0x100);
                    Offset++;
                }
                else
                {   
                    startelement =Indication_array[Offset];
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                }           
            
                if(startelement !=0)
                {
                    for (i=0;i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(startelement ==gCommonList_Pos[i])  
                            i =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;              
                    }
                }

                switch (recordaddress)
                {
                    case 0: //recordaddress =0 -> SourceType, Attributes, PresetID, Category, Name, Frequency

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gCommonList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gCommonList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gCommonList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gCommonList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_COMMONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gCommonList_ListHandlingType !=AUDIO_COMMONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }
                                    Offset= CommonList_IndicationCopyElement_SourceType (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Attributes (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_PresetID   (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Category   (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Name       (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Frequency  (CacheElements, current_element, Offset, Indication_array);                                                                                                                                                


                                    if(CacheElements ==TRUE)                                    
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gCommonList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_COMMONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element alredy exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gCommonList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    Offset= CommonList_IndicationCopyElement_SourceType (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Attributes (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_PresetID   (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Category   (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Name       (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Frequency  (CacheElements, current_element, Offset, Indication_array);                                                                                                                                                
                                  
                                    if(CacheElements ==TRUE)                                   
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0 ends

                     case 1: //recordaddress =1 -> SourceType, Attributes, PresetID, Category, Name
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gCommonList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gCommonList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gCommonList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gCommonList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gCommonList_ListHandlingType !=AUDIO_COMMONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }


                                    Offset= CommonList_IndicationCopyElement_SourceType (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Attributes (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_PresetID   (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Category   (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Name       (CacheElements, current_element, Offset, Indication_array);

                                    if(CacheElements ==TRUE)                                    
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gCommonList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_COMMONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element alredy exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gCommonList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    Offset= CommonList_IndicationCopyElement_SourceType (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Attributes (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_PresetID   (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Category   (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Name       (CacheElements, current_element, Offset, Indication_array);
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break;         //recordaddress =1 ends

                     case 2: //recordaddress =2 -> Name
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gCommonList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gCommonList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gCommonList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gCommonList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_COMMONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gCommonList_ListHandlingType !=AUDIO_COMMONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }


                                    Offset= CommonList_IndicationCopyElement_Name       (CacheElements, current_element, Offset, Indication_array);


                                    if(CacheElements ==TRUE)                                    
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gCommonList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE)
                                    {
                                        CacheElements =TRUE;
                                        //if element alredy exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gCommonList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    

                                    Offset= CommonList_IndicationCopyElement_Name       (CacheElements, current_element, Offset, Indication_array);
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break;         //recordaddress =2 ends

                     case 3: //recordaddress =3 -> Attributes, Frequency

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gCommonList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gCommonList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gCommonList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gCommonList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_COMMONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gCommonList_ListHandlingType !=AUDIO_COMMONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }

                                    Offset= CommonList_IndicationCopyElement_Attributes (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Frequency  (CacheElements, current_element, Offset, Indication_array);                                                                                                                                                

                                    if(CacheElements ==TRUE)                                    
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gCommonList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_COMMONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element alredy exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gCommonList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    Offset= CommonList_IndicationCopyElement_Attributes (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Frequency  (CacheElements, current_element, Offset, Indication_array);                                                                                                                                                
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break;         //recordaddress =3 ends

                     case 15: //recordaddress =15 -> Pos
 
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gCommonList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gCommonList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gCommonList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gCommonList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_COMMONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gCommonList_ListHandlingType !=AUDIO_COMMONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }


                                    Offset= CommonList_IndicationCopyElement_Pos  (CacheElements, current_element, Offset, Indication_array);


                                    if(CacheElements ==TRUE)                                    
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gCommonList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_COMMONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element alredy exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gCommonList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    

                                    Offset= CommonList_IndicationCopyElement_Pos  (CacheElements, current_element, Offset, Indication_array);
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break;         //recordaddress =15 ends
                    
                }
                                   
                //Panel
                @sysvar::ASG_AudioSD::ComList_ASG_ID = gCommonList_ASGID;
                @sysvar::ASG_AudioSD::ComList_TAID = gCommonList_TAID;
                @sysvar::ASG_AudioSD::ComList_TNLE = gCommonList_TotalNumListElements;
             //   @sysvar::naviSD_ASG::POI_List_RecordAdd =recordaddress;
             //   @sysvar::naviSD_ASG::POI_List_transmitPos_APNT =transmitpos;             
			break;



//----------------------------------------------------------------------------------------------------------
//----------------------------------------------------------------------------------------------------------
//----------------------------------------------------------------------------------------------------------
//----------------------------------------------------------------------------------------------------------
//----------------------------------------------------------------------------------------------------------
//----------------------------------------------------------------------------------------------------------
//----------------------------------------------------------------------------------------------------------
//----------------------------------------------------------------------------------------------------------
//----------------------------------------------------------------------------------------------------------
//----------------------------------------------------------------------------------------------------------
//----------------------------------------------------------------------------------------------------------
//----------------------------------------------------------------------------------------------------------
//----------------------------------------------------------------------------------------------------------
//----------------------------------------------------------------------------------------------------------



            case Changed_IND:
                //get data      
                /***ArrayHeader***/
                mode            =(Indication_array[3] &0xF0) /0x10;
                recordaddress   =Indication_array[3] &0x0F;
                Offset =4;
                
                // decode "mode-byte"
                shift       =mode &0x01;
                direction   =(mode &0x02)/0x02;
                transmitpos =(mode &0x04)/0x04;
                indexsize   =(mode &0x08)/0x08; 

                if (indexsize)
                {   
                    startelement =Indication_array[Offset];
                    Offset++;
                    startelement +=(Indication_array[Offset] *0x100);
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                    elements +=(Indication_array[Offset] *0x100);
                    Offset++;
                }
                else
                {   
                    startelement =Indication_array[Offset];
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                }  

                if(startelement ==0 && shift==0 && transmitpos==0 && recordaddress==0 && elements==0xFFFF) //check 'full range update'?
                {
                sysSetVariableString(sysvar::ASG_AudioSD::ComList_FRUreseved,"FRU reseved");
                
                }
                else if (datalength>8)
                {
                    if(startelement !=0)
                {
                    for (i=0;i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(startelement ==gCommonList_Pos[i])  
                            i =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;              
                    }
                }

                switch (recordaddress)
                {
                    case 0: //recordaddress =0 -> complete record

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gCommonList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gCommonList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gCommonList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gCommonList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_COMMONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gCommonList_ListHandlingType !=AUDIO_COMMONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }

                                    Offset= CommonList_IndicationCopyElement_SourceType (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Attributes (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_PresetID   (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Category   (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Name       (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Frequency  (CacheElements, current_element, Offset, Indication_array);                                                                                                                                                


                                    if(CacheElements ==TRUE)                                    
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gCommonList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_COMMONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element alredy exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gCommonList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }

                                    Offset= CommonList_IndicationCopyElement_SourceType (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Attributes (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_PresetID   (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Category   (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Name       (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Frequency  (CacheElements, current_element, Offset, Indication_array);                                                                                                                                                

                                    if(CacheElements ==TRUE)                                   
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0 ends

                     case 1: //recordaddress =1 -> SourceType, Attributes, PresetID, Category, Name
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gCommonList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gCommonList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gCommonList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gCommonList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_COMMONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gCommonList_ListHandlingType !=AUDIO_COMMONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }

                                    Offset= CommonList_IndicationCopyElement_SourceType (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Attributes (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_PresetID   (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Category   (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Name       (CacheElements, current_element, Offset, Indication_array);


                                    if(CacheElements ==TRUE)                                    
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gCommonList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_COMMONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element alredy exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gCommonList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    Offset= CommonList_IndicationCopyElement_SourceType (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Attributes (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_PresetID   (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Category   (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Name       (CacheElements, current_element, Offset, Indication_array);

                                    
                                    if(CacheElements ==TRUE)                                   
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break;         //recordaddress =1 ends

                     case 2: //recordaddress =2 -> Distance, Unit
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gCommonList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gCommonList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gCommonList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gCommonList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_COMMONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gCommonList_ListHandlingType !=AUDIO_COMMONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }


                                    Offset= CommonList_IndicationCopyElement_Name       (CacheElements, current_element, Offset, Indication_array);


                                    if(CacheElements ==TRUE)                                  
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gCommonList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_COMMONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element alredy exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gCommonList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    Offset= CommonList_IndicationCopyElement_Name       (CacheElements, current_element, Offset, Indication_array);
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break;         //recordaddress =2 ends

                     case 3: //recordaddress =3 -> Attributes, Frequency
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gCommonList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gCommonList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gCommonList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gCommonList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_COMMONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gCommonList_ListHandlingType !=AUDIO_COMMONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }


                                    Offset= CommonList_IndicationCopyElement_Attributes (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Frequency  (CacheElements, current_element, Offset, Indication_array);                                                                                                                                                

                                    if(CacheElements ==TRUE)                                    
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gCommonList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_COMMONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element alredy exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gCommonList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    Offset= CommonList_IndicationCopyElement_Attributes (CacheElements, current_element, Offset, Indication_array);
                                    Offset= CommonList_IndicationCopyElement_Frequency  (CacheElements, current_element, Offset, Indication_array);                                                                                                                                                
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break;         //recordaddress =3 ends

                     case 15: //recordaddress =15 -> Pos
 
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gCommonList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gCommonList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gCommonList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gCommonList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_COMMONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gCommonList_Pos[i] && gCommonList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gCommonList_ListHandlingType !=AUDIO_COMMONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }


                                    Offset= CommonList_IndicationCopyElement_Pos  (CacheElements, current_element, Offset, Indication_array);


                                    if(CacheElements ==TRUE)                                    
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gCommonList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =CommonList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_COMMONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element alredy exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gCommonList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gCommonList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gCommonList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    Offset= CommonList_IndicationCopyElement_Pos  (CacheElements, current_element, Offset, Indication_array); 
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gCommonList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =CommonList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break;         //recordaddress =15 ends
                    
                }
                }
            break;
			
            case Error_IND:
					
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CommonList_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30 && Indication_array[3] !=0)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CommonList_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40 && Indication_array[3] !=0)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CommonList_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD CommonList_Indication: Application-Error: 0x%x", Indication_array[3]);
				
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD CommonList_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
		}

    //for "sliding window concept" TODO: noch zu implementieren "sliding window für ASG"
 /*   if(gPOIList_TotalNumListElements<=NAV_POILIST_ASGCACHE_MAX_SIZE)
        gPOIList_SlidingWindow_State =NAV_POILIST_SLIDINGWINDOW_NOTACTIVE;
    else
        gPOIList_SlidingWindow_State =NAV_POILIST_SLIDINGWINDOW_ACTIVE;

    if (gPOIList_CallBackReason !=NAV_POILIST_CALLBACKREASON_NOCALLBACK)
        POIList_ListHandling ();
    else
        POIList_display();
*/}

CurrentStation_Handle2_Indication (dword Indication_array [], int datalength)
{

		switch (gBAP_Indication[2])
		{
			case Data_IND:

                //get data
        				@sysvar::ASG_AudioSD::CuStHa2_CoListhex  = Indication_array[3];
        				@sysvar::ASG_AudioSD::CuStHa2_CoListhex  += Indication_array[4] *0x100;
                @sysvar::ASG_AudioSD::CuStHa2_CoListAbPohex   = Indication_array[5];
                @sysvar::ASG_AudioSD::CuStHa2_CoListAbPohex   += Indication_array[6] *0x100;
                @sysvar::ASG_AudioSD::CuStHa2_LSListhex = Indication_array[7];
                @sysvar::ASG_AudioSD::CuStHa2_LSListAbPohex = Indication_array[8];

            break;
			
            case Error_IND:
					
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStation_Handle2_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStation_Handle2_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStation_Handle2_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStation_Handle2_Indication: Application-Error: 0x%x", Indication_array[3]);
				
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD CurrentStation_Handle2_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
		}
}

CustomerDownloadState_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	            //LSG-ID
	requestarray[1] =FctID_CustomerDownloadState;	//Fct.-ID
	requestarray[2] =request;                   //request type
	
    switch(request)
	{
		case DataGet_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD CustomerDownloadState_Request: invalid request %d", request);
		break;
	}
}

OnlineMusic_State_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	            //LSG-ID
	requestarray[1] =FctID_OnlineMusic_State;	//Fct.-ID
	requestarray[2] =request;                   //request type
	
    switch(request)
	{
		case DataGet_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD OnlineMusic_State_Request: invalid request %d", request);
		break;
	}
}

CurrentStation_Handle2_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	            //LSG-ID
	requestarray[1] =FctID_CurrentStation_Handle2;	//Fct.-ID
	requestarray[2] =request;                   //request type
	
    switch(request)
	{
		case DataGet_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD CurrentStation_Handle2_Request: invalid request %d", request);
		break;
	}
}

on sysvar sysvar::ASG_AudioSD::SwRaMe_SwRaMeRe
{
    if(@sysvar::ASG_AudioSD::SwRaMe_SwRaMeRe <5 || !tempSwRaMe2)
       gSwRaMe_SwRaMeReAct = @sysvar::ASG_AudioSD::SwRaMe_SwRaMeRe;
    tempSwRaMe2 =0;
    if(@sysvar::ASG_AudioSD::SwRaMe_SwRaMeRehex != gSwRaMe_SwRaMeReAct)
        @sysvar::ASG_AudioSD::SwRaMe_SwRaMeRehex =@sysvar::ASG_AudioSD::SwRaMe_SwRaMeRe;
}

on sysvar sysvar::ASG_AudioSD::SwRaMe_SwRaMeRehex
{
    if(@sysvar::ASG_AudioSD::SwRaMe_SwRaMeRehex >5)
       {
        gSwRaMe_SwRaMeReAct =@sysvar::ASG_AudioSD::SwRaMe_SwRaMeRehex;
        tempSwRaMe2 =1;
        @sysvar::ASG_AudioSD::SwRaMe_SwRaMeRe =6;
       }
       else
       {
        if(@sysvar::ASG_AudioSD::SwRaMe_SwRaMeRehex != gSwRaMe_SwRaMeReAct)
            @sysvar::ASG_AudioSD::SwRaMe_SwRaMeRe =@sysvar::ASG_AudioSD::SwRaMe_SwRaMeRehex;
       }

}

on sysvar sysvar::ASG_AudioSD::SwRaMe_Source
{
    if(@sysvar::ASG_AudioSD::SwRaMe_Source <6 || !tempSwRaMe1)
       gSwRaMe_SourceAct = @sysvar::ASG_AudioSD::SwRaMe_Source;
    tempSwRaMe1 =0;
    if(@sysvar::ASG_AudioSD::SwRaMe_Sourcehex != gSwRaMe_SourceAct)
        @sysvar::ASG_AudioSD::SwRaMe_Sourcehex =@sysvar::ASG_AudioSD::SwRaMe_Source;
}

on sysvar sysvar::ASG_AudioSD::SwRaMe_Sourcehex
{
    if(@sysvar::ASG_AudioSD::SwRaMe_Sourcehex >6)
       {
        gSwRaMe_SourceAct =@sysvar::ASG_AudioSD::SwRaMe_Sourcehex;
        tempSwRaMe1 =1;
        @sysvar::ASG_AudioSD::SwRaMe_Source =7;
       }
       else
       {
        if(@sysvar::ASG_AudioSD::SwRaMe_Sourcehex != gSwRaMe_SourceAct)
            @sysvar::ASG_AudioSD::SwRaMe_Source =@sysvar::ASG_AudioSD::SwRaMe_Sourcehex;
       }

}

on sysvar sysvar::ASG_AudioSD::SwRaMe_Abort
{
    if(@sysvar::ASG_AudioSD::SwRaMe_Abort)
        SwitchRadioMedia_Request(AbortResult_REQ);
}

on sysvar sysvar::ASG_AudioSD::SwRaMe_StartResult
{
    if(@sysvar::ASG_AudioSD::SwRaMe_StartResult)
        SwitchRadioMedia_Request(StartResult_REQ);
}

SwitchRadioMedia_Indication(dword Indication_array [], int datalength)
{
	switch (gBAP_Indication[2])
	{
		case Processing_IND:
		break;
		case Result_IND:
                @sysvar::ASG_AudioSD::SwRaMe_SwRaMeRehex = Indication_array[3];            
		break;
		case Error_IND:
				
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD SwitchRadioMedia_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30 && Indication_array[3] !=0)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD SwitchRadioMedia_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40 && Indication_array[3] !=0)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD SwitchRadioMedia_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
				{	
                    writelineEx(gError_Trace, 0, "ASG-AudioSD SwitchRadioMedia_Indication: Application-Error: 0x%x", Indication_array[3]);

                }
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD SwitchRadioMedia_Indication:: unknown indication %d", gBAP_Indication[2]);
		break;
	}
}

SwitchRadioMedia_Request (byte request)
{
    int i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init lokal variables
	for(i=0;i<BAP_BUFFER_SIZE;i++)
		requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	    //LSG-ID
	requestarray[1] =FctID_SwitchRadioMedia; //Fct.-ID
	requestarray[2] =request;

	switch(request)
	{
		case StartResult_REQ:
        			
		    requestarray[3] = @sysvar::ASG_AudioSD::SwRaMe_Sourcehex;					
            set_status_requestbuffer (requestarray, 4, Bap_UInt8);
		break;          
               
        case AbortResult_REQ:

			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
		default://error
			writelineEx(gError_Trace, 0,"ASG-AudioSD SwitchRadioMedia_Request: unknown request %d", request);
		break;
	}
}

on envVar env_ASG_AudioSD_Method2
{
if(getvalue(this))
    openPanel("Method_2_AudioSD_ASG");


}

CommonList_Request(byte request, byte mode, byte recordaddress, word requested_startelement, word startelement, word elements)
{   
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];
    byte Offset;
    word indexsize;

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;
    
    indexsize   =0;
    Offset      =0;

    // decode "mode-byte"
    indexsize   =(mode &0x08)/0x08; 

    // Handle request.
    requestarray[0] =LSG_AudioSD;	    //LSG-ID
	requestarray[1] =FctID_CommonList;	//Fct.-ID
	requestarray[2] =request;           //request type

    switch(request)
	{
        case DataGet_REQ:              
                requestarray[3] =((gCommonList_ASGID *0x10) &0xF0) +(gCommonList_TAID &0x0F);
 
                
                /***ArrayHeader***/
			    requestarray[4] =((mode *0x10) &0xF0) +(recordaddress &0x0F);          
                Offset =5;

                if(indexsize)
                {
                    requestarray[Offset] =requested_startelement &0x00FF;
                    Offset++;
                    requestarray[Offset] =(requested_startelement &0xFF00) /0x100;
                    Offset++;  

                    requestarray[Offset] =elements &0x00FF;
                    Offset++;
                    requestarray[Offset] =(elements &0xFF00) /0x100;
                    Offset++;       
                    //writeEX(gBAP_Trace, 0, "ASG_Request_indexSize_16bit %x",indexsize); //debug
                }
                else
                {
                    requestarray[Offset] =requested_startelement;
                    Offset++;

                    requestarray[Offset] =elements;
                    Offset++;
                    //writeEX(gBAP_Trace, 0, "ASG_Request_indexSize_8bit %x",indexsize); //debug
                }
            
            set_status_requestbuffer (requestarray, Offset, Bap_ByteSequence);
            sysSetVariableString(sysvar::ASG_AudioSD::ComList_FRUreseved," ");
         break;

        default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD CommonList_Request: invalid request %d", request);
		break;
    }
}

on envVar env_ASG_AudioSD_CommomList
{
if(getvalue(this))
    openPanel("CommonList_ASG");
}

on sysvar sysvar::ASG_AudioSD::ComList_direction_b
{
    if (@sysvar::ASG_AudioSD::ComList_direction_b)
        @sysvar::ASG_AudioSD::ComList_direction_f =0;
}

on sysvar sysvar::ASG_AudioSD::ComList_direction_f
{
    if (@sysvar::ASG_AudioSD::ComList_direction_f)
        @sysvar::ASG_AudioSD::ComList_direction_b =0;
}

on sysvar sysvar::ASG_AudioSD::ComList_GetArray
{
    byte mode, shift, direction, transmitpos, indexsize,recordaddress;
    word requested_startelement, startelement, elements;
    
    // Init local variables. 
    mode                    =0;
    shift                   =0;
    direction               =0;
    transmitpos             =0;
    indexsize               =0;
    recordaddress           =0;
    requested_startelement  =0;
    startelement            =0;
    elements                =0;

    if(POWER_ON==gASG_PowerOnOff && @sysvar::ASG_AudioSD::ComList_GetArray && gCommonList_ListHandlingType ==AUDIO_COMMONLIST_NOCACHE)
	{
        gCommonList_ASGID               =@sysvar::ASG_AudioSD::ComList_ASG_ID;
        gCommonList_TAID                =@sysvar::ASG_AudioSD::ComList_TAID;
        shift                           =@sysvar::ASG_AudioSD::ComList_shift_1;
        direction                       =@sysvar::ASG_AudioSD::ComList_direction_b;
        transmitpos                     =@sysvar::ASG_AudioSD::ComList_transmitPos_1;
        indexsize                       =@sysvar::ASG_AudioSD::ComList_indexSize_16bit;
        recordaddress                   =@sysvar::ASG_AudioSD::ComList_recordaddress;
        startelement                    =@sysvar::ASG_AudioSD::ComList_start;
        elements                        =@sysvar::ASG_AudioSD::ComList_elements;
        
        requested_startelement  =startelement;
        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;
        //writeEX(gBAP_Trace, 0, "GetArray_indexSize %x",indexsize); //debug
        CommonList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
    }
}

on sysvar sysvar::ASG_AudioSD::ComList_indexSize_8bit
{
    if (@sysvar::ASG_AudioSD::ComList_indexSize_8bit)
        @sysvar::ASG_AudioSD::ComList_indexSize_16bit =0;
}

on sysvar sysvar::ASG_AudioSD::ComList_indexSize_16bit
{
    if (@sysvar::ASG_AudioSD::ComList_indexSize_16bit)
        @sysvar::ASG_AudioSD::ComList_indexSize_8bit =0;
}

on sysvar sysvar::ASG_AudioSD::ComList_shift_0
{
    if (@sysvar::ASG_AudioSD::ComList_shift_0)
        @sysvar::ASG_AudioSD::ComList_shift_1 =0;
}

on sysvar sysvar::ASG_AudioSD::ComList_shift_1
{
    if (@sysvar::ASG_AudioSD::ComList_shift_1)
        @sysvar::ASG_AudioSD::ComList_shift_0 =0;
}

on sysvar sysvar::ASG_AudioSD::ComList_transmitPos_0
{
    if (@sysvar::ASG_AudioSD::ComList_transmitPos_0)
        @sysvar::ASG_AudioSD::ComList_transmitPos_1 =0;
}

on sysvar sysvar::ASG_AudioSD::ComList_transmitPos_1
{
    if (@sysvar::ASG_AudioSD::ComList_transmitPos_1)
        @sysvar::ASG_AudioSD::ComList_transmitPos_0 =0;
}

int CommonListGetNextCachedElement (int currentElement,byte direction)
{
    int i=0, nextElement=0;

    switch (direction)
    {
        case AUDIO_COMMONLIST_DISPLAYLIST_FIND_NEXT_ELEMENT:                
                nextElement = ++currentElement;

                if (nextElement<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE) //start at next element, if next element is not >8
                {
                    for(i =nextElement; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i= AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;
                        }
                        else
                            nextElement =0;
                    }
                }
                else    //start at first element
                {
                    nextElement =0;

                    for(i =nextElement; i<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE;
                        }   
                    }
                }
        break;

        case AUDIO_COMMONLIST_DISPLAYLIST_FIND_PREVIUOS_ELEMENT:
                nextElement = --currentElement;
                if (nextElement ==0 && gCommonList_ListEntryReceptionInformation[nextElement] ==TRUE)
                    nextElement =0;
                else if (nextElement>0) 
                {
                    for(i =nextElement; i>0; i--)
                    {
                        if(gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =0;
                        }
                        else
                            nextElement =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE-1;
                    }
                }    
                else    //start at last element
                {
                    nextElement =AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE-1;

                    for(i =nextElement; i>0; i--)
                    {
                        if(gCommonList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =0;
                        }
                        else if(gCommonList_ListEntryReceptionInformation[0] ==TRUE)
                            nextElement =0;          
                    }
                }
        break;

        default:
        break;
    }
    return(nextElement);
}

int CommonList_GetNextLineInCache (int currentElement,byte direction)
{
    int i=0, nextElement=0;
    
    switch (direction)
    {
        case FORWARD:
                           
                if(currentElement<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE-1 && currentElement !=5) 
                    nextElement = ++currentElement;  
                
                else if (currentElement ==8)            
                    nextElement =0;
                else
                    nextElement =AUDIO_COMMONLIST_NO_NEXT_POSITION;
        break;

        case BACKWARD:
                if(currentElement<AUDIO_COMMONLIST_ASGCACHE_MAX_SIZE && currentElement !=0 && currentElement !=6) 
                    nextElement =--currentElement;
                
                else if (currentElement ==0)            
                    nextElement =8;
                
                else
                    nextElement =AUDIO_COMMONLIST_NO_NEXT_POSITION;
        break;

        default:
        break;
    }

    return(nextElement);
}

word CommonList_IndicationCopyElement_SourceType (byte CacheElements, byte current_element, word Offset, dword Indication_array[])
{
    //Direction Symbolic
    if(CacheElements ==TRUE)
      gCommonList_SourceType[current_element] =Indication_array[Offset];
      Offset++;
    return Offset;
}

word CommonList_IndicationCopyElement_Attributes (byte CacheElements, byte current_element, word Offset, dword Indication_array[])
{
    //Attributes
    if(CacheElements ==TRUE)
      {
        gCommonList_Attributes[current_element] =Indication_array[Offset];
        Offset++;
        gCommonList_Attributes[current_element] +=Indication_array[Offset]*0x100;
        Offset++;
      }
    return Offset;
}      

word CommonList_IndicationCopyElement_PresetID (byte CacheElements, byte current_element, word Offset, dword Indication_array[])
{
    //Direction Symbolic
    if(CacheElements ==TRUE)
      gCommonList_PresetID[current_element] =Indication_array[Offset];
      Offset++;
    return Offset;
}

word CommonList_IndicationCopyElement_Category (byte CacheElements, byte current_element, word Offset, dword Indication_array[])
{
    //Direction Symbolic
    if(CacheElements ==TRUE)
      gCommonList_Category[current_element] =Indication_array[Offset];
      Offset++;
    return Offset;
}

word CommonList_IndicationCopyElement_Name  (byte CacheElements, byte current_element, word Offset, dword Indication_array[])
{
byte length;
int i;
  //City
    if(CacheElements ==TRUE)
    {
        for(i=0; i<AUDIO_ASG_COMMONLIST_NAME_LENGTH;i++) //clear
	        gCommonList_ASG_Name[current_element][i] =0; 
    }
    length =Indication_array[Offset];
    Offset++;
    for(i=0; i<length;i++) //copy data
    {   
        if(CacheElements ==TRUE)
            gCommonList_ASG_Name[current_element][i] =Indication_array[Offset];
        Offset++;
    }

    return Offset;
}

word CommonList_IndicationCopyElement_Frequency  (byte CacheElements, byte current_element, word Offset, dword Indication_array[])
{
byte length;
int i;
  //City
    if(CacheElements ==TRUE)
    {
        for(i=0; i<AUDIO_ASG_COMMONLIST_FREQUENCY_LENGTH;i++) //clear
	        gCommonList_ASG_Frequency[current_element][i] =0; 
    }
    length =Indication_array[Offset];
    Offset++;
    for(i=0; i<length;i++) //copy data
    {   
        if(CacheElements ==TRUE)
            gCommonList_ASG_Frequency[current_element][i] =Indication_array[Offset];
        Offset++;
    }

    return Offset;
}

word CommonList_IndicationCopyElement_Pos (byte CacheElements, byte current_element, word Offset, dword Indication_array[])
{

    //Pos
    if(CacheElements ==TRUE)
      gCommonList_Pos[current_element] =Indication_array[Offset];
      Offset++;
    return Offset;
}

on message BAP_only_MQB_MLBevo_v119::BAP_Audio_FSG_01
{
    int i, error;
    byte RX_Data[8];		//received CAN-DATA
    dword RX_Header[3];		//received CAN-Header

    RX_Header[0]=this.CAN; 
    RX_Header[1]=this.ID; 
    RX_Header[2]=this.DLC; // received length
	
	// extract CAN data    																	
	for (i=0; i<this.DLC; i++) 														
	    RX_Data[i]=this.byte(i);		  
	        
	//send recieved CAN-data with CAN-header to BAP-DLL
	error =Bap180_CAN_SetRxDat(NODE_INDEX,RX_Header,RX_Data);	
	if(error !=0)
	    write("ASG-AudioSD: BAP_CAN_SetRxData: %d", error);   

}

on message BAP_Audio_FSG_02
{
    int i, error;
    byte RX_Data[8];		//received CAN-DATA
    dword RX_Header[3];		//received CAN-Header

    RX_Header[0]=this.CAN; 
    RX_Header[1]=this.ID; 
    RX_Header[2]=this.DLC; // received length
	
	// extract CAN data    																	
	for (i=0; i<this.DLC; i++) 														
	    RX_Data[i]=this.byte(i);		  
	        
	//send recieved CAN-data with CAN-header to BAP-DLL
	error =Bap180_CAN_SetRxDat(NODE_INDEX,RX_Header,RX_Data);	
	if(error !=0)
	    write("ASG-AudioSD: BAP_CAN_SetRxData: %d", error);  
        
}

on envVar env_ASG_AudioSD_SDSState_setGet
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
	{
        gSDS_State_state =getvalue(env_ASG_AudioSD_SDSState_State);

        SDSState_Request(DataSetGet_REQ);
    }
}

on envVar env_ASG_AudioSD_PrefList_setGet
{
    if(gASG_PowerOnOff ==POWER_ON && getvalue(this))
	{
        PreferredList_Request(DataSetGet_REQ);
    }
}

void SiriusAlertList_Request(byte request, byte mode, byte recordaddress, word requested_startelement, word startelement, word elements)
{   
    int  i;
    dword requestarray [BAP_BUFFER_SIZE], Offset;
    word indexsize;

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;
    
    indexsize   =0;
    Offset      =0;

    // decode "mode-byte"
    indexsize   =(mode &0x08)/0x08; 

    // Handle request.
    requestarray[0] =LSG_AudioSD;	        //LSG-ID
	requestarray[1] =FctID_SiriusAlertList;	//Fct.-ID
	requestarray[2] =request;               //request type

    switch(request)
	{
        case DataGet_REQ:              
                requestarray[3] =((gSiriusAlertList_ASGID *0x10) &0xF0) +(gSiriusAlertList_TAID &0x0F);
                
                /***ArrayHeader***/
			          requestarray[4] =((mode *0x10) &0xF0) +(recordaddress &0x0F);          
                Offset =5;

                if(indexsize)
                {
                    requestarray[Offset] =requested_startelement &0x00FF;
                    Offset++;
                    requestarray[Offset] =(requested_startelement &0xFF00) /0x100;
                    Offset++;  

                    requestarray[Offset] =elements &0x00FF;
                    Offset++;
                    requestarray[Offset] =(elements &0xFF00) /0x100;
                    Offset++;       
                }
                else
                {
                    requestarray[Offset] =requested_startelement;
                    Offset++;

                    requestarray[Offset] =elements;
                    Offset++;
                }
            
            set_status_requestbuffer (requestarray, Offset, Bap_ByteSequence);
         break;

        default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD ReceptionList_Request: invalid request %d", request);
		break;
    }
}

void SiriusAlertList_Indication (dword Indication_array [], int datalength)
{
    byte mode, direction, shift, recordaddress, indexsize, current_element, transmitpos, length, CacheElements, StartElementInCache;
    word  startelement, elements, startelement_check, Offset =0;
    int i =0, j=0;

    // Init local variables
    mode                    =0;
    direction               =0;
    shift                   =0;
    recordaddress           =0;
    startelement            =0;
    elements                =0;
    current_element         =0;
    transmitpos             =0;
    length                  =0;
    startelement_check      =0;
    StartElementInCache     =FALSE;
    CacheElements           =FALSE;
    
		switch (gBAP_Indication[2])
		{
			case Data_IND:
				//get data
                gSiriusAlertList_ASGID =(Indication_array[3] &0xF0) /0x10;
                gSiriusAlertList_TAID  =Indication_array[3] &0x0F;           

                gSiriusAlertList_TotalNumListElements =Indication_array[4];
                gSiriusAlertList_TotalNumListElements +=(Indication_array[5] *0x100);
              
                /***ArrayHeader***/
                mode            =(Indication_array[6] &0xF0) /0x10;
                recordaddress   =Indication_array[6] &0x0F;
                Offset =7;
                
                // decode "mode-byte"
                shift       =mode &0x01;
                direction   =(mode &0x02)/0x02;
                transmitpos =(mode &0x04)/0x04;
                indexsize   =(mode &0x08)/0x08; 

                if (indexsize)
                {   
                    startelement =Indication_array[Offset];
                    Offset++;
                    startelement +=(Indication_array[Offset] *0x100);
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                    elements +=(Indication_array[Offset] *0x100);
                    Offset++;
                }
                else
                {   
                    startelement =Indication_array[Offset];
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                }           
            
                if(startelement !=0)
                {
                    for (i=0;i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(startelement ==gSiriusAlertList_Pos[i])  
                            i =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;              
                    }
                }

                switch (recordaddress)
                {
                    case 0: //recordaddress =0 -> complete record

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSiriusAlertList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSiriusAlertList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSiriusAlertList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSiriusAlertList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSiriusAlertList_ListHandlingType !=AUDIO_SIRIUSALERTLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;i++) //clear
			                                    gSiriusAlertList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //AlertType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_AlertType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //AlertName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                gSiriusAlertList_AlertName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_AlertName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Extension
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_EXTENSION_LENGTH;i++) //clear
			                                gSiriusAlertList_Extension[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Extension[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    
                                    if(CacheElements ==TRUE)                                    
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSiriusAlertList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSiriusAlertList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;i++) //clear
			                                    gSiriusAlertList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //AlertType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_AlertType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //AlertName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                gSiriusAlertList_AlertName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_AlertName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Extension
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_EXTENSION_LENGTH;i++) //clear
			                                gSiriusAlertList_Extension[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Extension[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0 ends
                    
                    case 1: //recordaddress =1 -> Attributes, PresetID, Name, Frequency

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSiriusAlertList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSiriusAlertList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSiriusAlertList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSiriusAlertList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSiriusAlertList_ListHandlingType !=AUDIO_SIRIUSALERTLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;i++) //clear
			                                    gSiriusAlertList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                    
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSiriusAlertList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSiriusAlertList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;i++) //clear
			                                    gSiriusAlertList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =1 ends
                    
                    case 2: //recordaddress =2 -> Attributes, PresetID, Name

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSiriusAlertList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSiriusAlertList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSiriusAlertList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSiriusAlertList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSiriusAlertList_ListHandlingType !=AUDIO_SIRIUSALERTLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSiriusAlertList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSiriusAlertList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =2 ends
                    
                    case 3: //recordaddress =3 -> Name

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSiriusAlertList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSiriusAlertList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSiriusAlertList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSiriusAlertList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSiriusAlertList_ListHandlingType !=AUDIO_SIRIUSALERTLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSiriusAlertList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSiriusAlertList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =3 ends
                    
                    case 4: //recordaddress =4 -> Attributes, Frequency

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSiriusAlertList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSiriusAlertList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSiriusAlertList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSiriusAlertList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSiriusAlertList_ListHandlingType !=AUDIO_SIRIUSALERTLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;i++) //clear
			                                    gSiriusAlertList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                    
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSiriusAlertList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSiriusAlertList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;i++) //clear
			                                    gSiriusAlertList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =4 ends
                        
                    case 5: //recordaddress =5 -> Attributes, PresetID, Name, Frequency, AlertType, AlertName

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSiriusAlertList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSiriusAlertList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSiriusAlertList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSiriusAlertList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSiriusAlertList_ListHandlingType !=AUDIO_SIRIUSALERTLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;i++) //clear
			                                    gSiriusAlertList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //AlertType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_AlertType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //AlertName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                gSiriusAlertList_AlertName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_AlertName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSiriusAlertList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSiriusAlertList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;i++) //clear
			                                    gSiriusAlertList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //AlertType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_AlertType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //AlertName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                gSiriusAlertList_AlertName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_AlertName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =5 ends                    
                        
                    case 15: //recordaddress =0xf -> Pos

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSiriusAlertList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSiriusAlertList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSiriusAlertList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSiriusAlertList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSiriusAlertList_ListHandlingType !=AUDIO_SIRIUSALERTLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                    
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSiriusAlertList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gSiriusAlertList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0xf ends
                }
                                   
                //Panel
                putvalue(env_ASG_AudioSD_SAL_ASGID, gSiriusAlertList_ASGID);
                putvalue(env_ASG_AudioSD_SAL_TAID, gSiriusAlertList_TAID);
                putvalue(env_ASG_AudioSD_SAL_TotalNumLE, gSiriusAlertList_TotalNumListElements);

                gSiriusAlertList_recordaddress =recordaddress;
                gSiriusAlertList_transmitpos   =transmitpos;             
            
			break;

            case Changed_IND:            
              
                /***ArrayHeader***/
                mode            =(Indication_array[3] &0xF0) /0x10;
                recordaddress   =Indication_array[3] &0x0F;
                Offset =4;
                
                // decode "mode-byte"
                shift       =mode &0x01;
                direction   =(mode &0x02)/0x02;
                transmitpos =(mode &0x04)/0x04;
                indexsize   =(mode &0x08)/0x08; 

                if (indexsize)
                {   
                    startelement =Indication_array[Offset];
                    Offset++;
                    startelement +=(Indication_array[Offset] *0x100);
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                    elements +=(Indication_array[Offset] *0x100);
                    Offset++;
                }
                else
                {   
                    startelement =Indication_array[Offset];
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                }           
            
                if(startelement ==0 && shift==0 && transmitpos==0 && recordaddress==0 && elements==65535) //check 'full range update'?
                {
                    putvalue(env_ASG_AudioSD_SAL_OnOff, FALSE);
                    //putvalue(env_ASG_AudioSD_SAL_ListOpState, "'full range update' received");
                }
                else if (datalength>11)
                {
                if(startelement !=0)
                {
                    for (i=0;i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(startelement ==gSiriusAlertList_Pos[i])  
                            i =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;              
                    }
                }

                switch (recordaddress)
                {
                    case 0: //recordaddress =0 -> complete record

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSiriusAlertList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSiriusAlertList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSiriusAlertList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSiriusAlertList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSiriusAlertList_ListHandlingType !=AUDIO_SIRIUSALERTLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;i++) //clear
			                                    gSiriusAlertList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //AlertType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_AlertType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //AlertName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                gSiriusAlertList_AlertName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_AlertName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Extension
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_EXTENSION_LENGTH;i++) //clear
			                                gSiriusAlertList_Extension[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Extension[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    
                                    if(CacheElements ==TRUE)                                    
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSiriusAlertList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSiriusAlertList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;i++) //clear
			                                    gSiriusAlertList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //AlertType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_AlertType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //AlertName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                gSiriusAlertList_AlertName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_AlertName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Extension
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_EXTENSION_LENGTH;i++) //clear
			                                gSiriusAlertList_Extension[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Extension[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0 ends
                    
                    case 1: //recordaddress =1 -> Attributes, PresetID, Name, Frequency

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSiriusAlertList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSiriusAlertList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSiriusAlertList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSiriusAlertList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSiriusAlertList_ListHandlingType !=AUDIO_SIRIUSALERTLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;i++) //clear
			                                    gSiriusAlertList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                    
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSiriusAlertList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSiriusAlertList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_FREQUENCY_LENGTH;i++) //clear
			                                    gSiriusAlertList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =1 ends
                    
                    case 2: //recordaddress =2 -> Attributes, PresetID, Name

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSiriusAlertList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSiriusAlertList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSiriusAlertList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSiriusAlertList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSiriusAlertList_ListHandlingType !=AUDIO_SIRIUSALERTLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSiriusAlertList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSiriusAlertList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gSiriusAlertList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gSiriusAlertList_Attributes_Bit0[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x01);
                                        gSiriusAlertList_Attributes_Bit1[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x02) /0x02;
                                        gSiriusAlertList_Attributes_Bit2[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x04) /0x04; 
                                        gSiriusAlertList_Attributes_Bit3[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x08) /0x08;
                                        gSiriusAlertList_Attributes_Bit4[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x10) /0x10;
                                        gSiriusAlertList_Attributes_Bit5[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x20) /0x20;
                                        gSiriusAlertList_Attributes_Bit6[current_element]    =(gSiriusAlertList_Attributes[current_element] &0x40) /0x40;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSiriusAlertList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gSiriusAlertList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SiriusAlertList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =2 ends
                    
                    case 3: //recordaddress =3 -> Name

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSiriusAlertList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSiriusAlertList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SiriusAlertList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSiriusAlertList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSiriusAlertList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SIRIUSALERTLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SIRIUSALERTLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSiriusAlertList_Pos[i] && gSiriusAlertList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSiriusAlertList_ListHandlingType !=AUDIO_SIRIUSALERTLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSiriusAlertList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSiriusAlertList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SIRIUSALERTLIST_NAME_LENGTH;i++) //clear
			                                    gSiriusAlertList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSiriusAlertList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

