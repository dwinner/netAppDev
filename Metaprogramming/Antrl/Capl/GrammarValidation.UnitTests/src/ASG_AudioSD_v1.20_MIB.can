                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_LSL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element    
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;         
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gLSL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_LSL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_LSL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gLSL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gLSL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =3 ends  
        case 15: //recordaddress =15 -> POS 
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element       
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
    		    {
              current_element =AUDIO_LSL_ASGCACHE_MAX_SIZE-1; //NAV_VIDEOSTREAMS_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement;
              if (shift ==TRUE) //startelement is next element
                current_element++;
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element       
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_LSL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gLSL_Pos[i] && gLSL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gLSL_ListHandlingType !=AUDIO_LSL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gLSL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gLSL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =15 ends    
        }
      }
    break;            
    case Error_IND:	
			if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
				writelineEx(gError_Trace, 0, "ASG-AudioSD LastStationList_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
			else if(Indication_array[3]<0x30 && Indication_array[3] !=0)			//BPL-error
				writelineEx(gError_Trace, 0, "ASG-AudioSD LastStationList_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
			else if(Indication_array[3]<0x40 && Indication_array[3] !=0)			//BAL-error
				writelineEx(gError_Trace, 0, "ASG-AudioSD LastStationList_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
			else
				writelineEx(gError_Trace, 0, "ASG-AudioSD LastStationList_Indication: Application-Error: 0x%x", Indication_array[3]);
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD LastStationList_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
	}  
}

void LastStationList_GetAttributesBits(word current_element)
{
  gLSL_Attributes_Bit0[current_element]   =gLSL_Attributes[current_element] & 0x0001;
  gLSL_Attributes_Bit1[current_element]   =gLSL_Attributes[current_element] & 0x0002 / 0x0002;
  gLSL_Attributes_Bit2[current_element]   =gLSL_Attributes[current_element] & 0x0004 / 0x0004;
  gLSL_Attributes_Bit3[current_element]   =gLSL_Attributes[current_element] & 0x0008 / 0x0008;
  gLSL_Attributes_Bit4[current_element]   =gLSL_Attributes[current_element] & 0x0010 / 0x0010;
  gLSL_Attributes_Bit5[current_element]   =gLSL_Attributes[current_element] & 0x0020 / 0x0020;
  gLSL_Attributes_Bit6[current_element]   =gLSL_Attributes[current_element] & 0x0040 / 0x0040;
  gLSL_Attributes_Bit7[current_element]   =gLSL_Attributes[current_element] & 0x0080 / 0x0080;
  gLSL_Attributes_Bit8[current_element]   =gLSL_Attributes[current_element] & 0x0100 / 0x0100;
  gLSL_Attributes_Bit9[current_element]   =gLSL_Attributes[current_element] & 0x0200 / 0x0200;
  gLSL_Attributes_Bit10[current_element]  =gLSL_Attributes[current_element] & 0x0400 / 0x0400;
  gLSL_Attributes_Bit11[current_element]  =gLSL_Attributes[current_element] & 0x0800 / 0x0800;
}

on envVar env_ASG_AudioSD_FL_GetArray
{
  byte mode, shift, direction, transmitpos, indexsize,recordaddress;
  word requested_startelement, startelement, elements;
  
  // Init local variables. 
  mode                    =0;
  shift                   =0;
  direction               =0;
  transmitpos             =0;
  indexsize               =0;
  recordaddress           =0;
  requested_startelement  =0;
  startelement            =0;
  elements                =0;

  if(POWER_ON==gASG_PowerOnOff && getvalue(this))
	{
    gFL_ASGID                  =getvalue(env_ASG_AudioSD_FL_ASGID);
    gFL_TAID                   =getvalue(env_ASG_AudioSD_FL_TAID);;
    shift                           =getvalue(env_ASG_AudioSD_FL_AH_shift);;
    direction                       =getvalue(env_ASG_AudioSD_FL_AH_dir);;
    transmitpos                     =getvalue(env_ASG_AudioSD_FL_AH_PosTrans);;
    indexsize                       =getvalue(env_ASG_AudioSD_FL_AH_IS);;
    recordaddress                   =getvalue(env_ASG_AudioSD_FL_AH_RA);;
    startelement                    =getvalue(env_ASG_AudioSD_FL_AH_start);;
    elements                        =getvalue(env_ASG_AudioSD_FL_AH_elements);;
    
    requested_startelement  =startelement;
    mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;
    //writeEX(gBAP_Trace, 0, "GetArray_indexSize %x",indexsize); //debug
    FavoriteList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
  }
}

void FavoriteList_Request(byte request, byte mode, byte recordaddress, word requested_startelement, word startelement, word elements)
{   
  int  i;
  dword requestarray [BAP_BUFFER_SIZE];
  byte Offset;
  word indexsize;

  // Init local variables. 
  for(i=0;i<BAP_BUFFER_SIZE;i++)
    requestarray [i]=0;
  
  indexsize   =0;
  Offset      =0;

  // decode "mode-byte"
  indexsize   =(mode &0x08)/0x08; 

  // Handle request.
  requestarray[0] =LSG_AudioSD;	    //LSG-ID
	requestarray[1] =FctID_FavoriteList;	//Fct.-ID
	requestarray[2] =request;           //request type

  switch(request)
	{
    case DataGet_REQ:              
      requestarray[3] =((gFL_ASGID *0x10) &0xF0) +(gFL_TAID &0x0F);      
      /***ArrayHeader***/
	    requestarray[4] =((mode *0x10) &0xF0) +(recordaddress &0x0F);          
      Offset =5;
      if(indexsize)
      {
        requestarray[Offset] =requested_startelement &0x00FF;
        Offset++;
        requestarray[Offset] =(requested_startelement &0xFF00) /0x100;
        Offset++;  
        requestarray[Offset] =elements &0x00FF;
        Offset++;
        requestarray[Offset] =(elements &0xFF00) /0x100;
        Offset++;       
        //writeEX(gBAP_Trace, 0, "ASG_Request_indexSize_16bit %x",indexsize); //debug
      }
      else
      {
        requestarray[Offset] =requested_startelement;
        Offset++;
        requestarray[Offset] =elements;
        Offset++;
        //writeEX(gBAP_Trace, 0, "ASG_Request_indexSize_8bit %x",indexsize); //debug
      }
      set_status_requestbuffer (requestarray, Offset, Bap_ByteSequence);
    break;
    default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD FavoriteList_Picture: invalid request %d", request);
		break;
  }
}

void FavoriteList_Indication(dword Indication_array [], int datalength)
{
  byte mode, direction, shift, recordaddress, transmitpos, length, indexsize, CacheElements;
  word startelement, elements, current_element;
  int i =0, j=0, Offset =0;
  
  // Init local variables
  mode                    =0;
  direction               =0;
  shift                   =0;
  recordaddress           =0;
  startelement            =0;
  elements                =0;
  current_element         =0;
  transmitpos             =0;
  length                  =0;
  CacheElements =FALSE;
  
  write("Debug: FavoriteList_Indication -> ind-type=%d",gBAP_Indication[2]);
  
	switch (gBAP_Indication[2])
	{
		case Data_IND:
		//get data
      gFL_ASGID =(Indication_array[3] &0xF0) /0x10;
      gFL_TAID  =Indication_array[3] &0x0F; 
      gFL_TotalNumListElements =Indication_array[4];
      /***ArrayHeader***/
      mode            =(Indication_array[5] &0xF0) /0x10;
      recordaddress   =Indication_array[5] &0x0F;
      startelement    =Indication_array[6];
      elements        =Indication_array[7];
      Offset =8;
      // decode "mode-byte"
      shift       =mode &0x01;
      direction   =(mode &0x02)/0x02;
      transmitpos =(mode &0x04)/0x04;
      indexsize   =(mode &0x08)/0x08;             
 
      if(startelement !=0)
      {
        for (i=0;i<AUDIO_FL_ASGCACHE_MAX_SIZE;i++)
        {
          if(startelement ==gFL_Pos[i])  
            i =AUDIO_FL_ASGCACHE_MAX_SIZE;              
        }
      }
      switch (recordaddress)
      { 
        case 1: //recordaddress =1 -> PresetIndex, Waveband, Attributes, Name, Frequency
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;             
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gFL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Attributes
                if (CacheElements ==TRUE)
                  gFL_Attributes[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gFL_Attributes[current_element] +=Indication_array[Offset] *0x100;
                Offset++;
                FavoriteList_GetAttributesBits(current_element);
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_FL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element  
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
			    	{
              current_element =AUDIO_FL_ASGCACHE_MAX_SIZE-1; //AUDIO_FL_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  } 
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gFL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Attributes
                if (CacheElements ==TRUE)
                  gFL_Attributes[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gFL_Attributes[current_element] +=Indication_array[Offset] *0x100;
                Offset++;
                FavoriteList_GetAttributesBits(current_element);
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_FL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is next element
                current_element++;
                                
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gFL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Attributes
                if (CacheElements ==TRUE)
                  gFL_Attributes[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gFL_Attributes[current_element] +=Indication_array[Offset] *0x100;
                Offset++;
                FavoriteList_GetAttributesBits(current_element);
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_FL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element    
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;         
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gFL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Attributes
                if (CacheElements ==TRUE)
                  gFL_Attributes[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gFL_Attributes[current_element] +=Indication_array[Offset] *0x100;
                Offset++;
                FavoriteList_GetAttributesBits(current_element);
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_FL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =1 ends
        case 2: //recordaddress =2 -> PresetIndex, Waveband, Name
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;             
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gFL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element  
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
			    	{
              current_element =AUDIO_FL_ASGCACHE_MAX_SIZE-1; //AUDIO_FL_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  } 
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gFL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is next element
                current_element++;
                                
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gFL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element    
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;         
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gFL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =2 ends
        case 3: //recordaddress =3 -> PresetIndex, Name, Frequency
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;             
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_FL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element  
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
			    	{
              current_element =AUDIO_FL_ASGCACHE_MAX_SIZE-1; //AUDIO_FL_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  } 
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_FL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is next element
                current_element++;
                                
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_FL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element    
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;         
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_FL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =3 ends  
        case 15: //recordaddress =15 -> POS 
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element       
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
    		    {
              current_element =AUDIO_FL_ASGCACHE_MAX_SIZE-1; //NAV_VIDEOSTREAMS_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement;
              if (shift ==TRUE) //startelement is next element
                current_element++;
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element       
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =15 ends    
      }                             
      //Panel
      putvalue(env_ASG_AudioSD_FL_ASGID, gFL_ASGID);
      putvalue(env_ASG_AudioSD_FL_TAID, gFL_TAID);
      putvalue(env_ASG_AudioSD_FL_TotalNumLE, gFL_TotalNumListElements);
      
      /*
      if (gFL_CallBackReason !=AUDIO_FL_CALLBACKREASON_NOCALLBACK)
        FL_ListHandling ();
      else
        FL_display(recordaddress, transmitpos);         
      */
		break;
    case Changed_IND:
      //get data
      /***ArrayHeader***/
      mode            =(Indication_array[3] &0xF0) /0x10;
      recordaddress   =Indication_array[3] &0x0F;
      Offset =4;
      // decode "mode-byte"
      shift       =mode &0x01;
      direction   =(mode &0x02)/0x02;
      transmitpos =(mode &0x04)/0x04;
      indexsize   =(mode &0x08)/0x08;               
      if (indexsize)
      {   
        startelement =Indication_array[Offset];
        Offset++;
        startelement +=(Indication_array[Offset] *0x100);
        Offset++;
        elements =Indication_array[Offset];
        Offset++;
        elements +=(Indication_array[Offset] *0x100);
        Offset++;
      }
      else
      {   
        startelement =Indication_array[Offset];
        Offset++;
        elements =Indication_array[Offset];
        Offset++;
      }           
      if(startelement ==0 && shift==0 && transmitpos==0 && recordaddress==0 && elements==255) //check 'full range update'?
      {
        /*
        putvalue(env_ASG_NaviSD_LG_OnOff, FALSE);
        putvalue(env_ASG_NaviSD_LG_ListOpState, "'full range update' received");
        */
      }
      else if (datalength>9)
      {
        if(startelement !=0)
        {
          for (i=0;i<AUDIO_FL_ASGCACHE_MAX_SIZE;i++)
          {
            if(startelement ==gFL_Pos[i])  
              i =AUDIO_FL_ASGCACHE_MAX_SIZE;              
          }
        }
        switch (recordaddress)
        {  
          case 1: //recordaddress =1 -> PresetIndex, Waveband, Attributes, Name, Frequency
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;             
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gFL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Attributes
                if (CacheElements ==TRUE)
                  gFL_Attributes[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gFL_Attributes[current_element] +=Indication_array[Offset] *0x100;
                Offset++;
                FavoriteList_GetAttributesBits(current_element);
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_FL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element  
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
			    	{
              current_element =AUDIO_FL_ASGCACHE_MAX_SIZE-1; //AUDIO_FL_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  } 
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gFL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Attributes
                if (CacheElements ==TRUE)
                  gFL_Attributes[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gFL_Attributes[current_element] +=Indication_array[Offset] *0x100;
                Offset++;
                FavoriteList_GetAttributesBits(current_element);
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_FL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is next element
                current_element++;
                                
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gFL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Attributes
                if (CacheElements ==TRUE)
                  gFL_Attributes[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gFL_Attributes[current_element] +=Indication_array[Offset] *0x100;
                Offset++;
                FavoriteList_GetAttributesBits(current_element);
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_FL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element    
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;         
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gFL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Attributes
                if (CacheElements ==TRUE)
                  gFL_Attributes[current_element] =Indication_array[Offset];
                Offset++;
                if (CacheElements ==TRUE)
                  gFL_Attributes[current_element] +=Indication_array[Offset] *0x100;
                Offset++;
                FavoriteList_GetAttributesBits(current_element);
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_FL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =1 ends
        case 2: //recordaddress =2 -> PresetIndex, Waveband, Name
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;             
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gFL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element  
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
			    	{
              current_element =AUDIO_FL_ASGCACHE_MAX_SIZE-1; //AUDIO_FL_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  } 
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gFL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is next element
                current_element++;
                                
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gFL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element    
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;         
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Waveband
                if (CacheElements ==TRUE)
                  gFL_Waveband[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =2 ends
        case 3: //recordaddress =3 -> PresetIndex, Name, Frequency
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;             
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_FL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element  
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
			    	{
              current_element =AUDIO_FL_ASGCACHE_MAX_SIZE-1; //AUDIO_FL_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  } 
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_FL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is next element
                current_element++;
                                
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_FL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element    
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;         
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                      gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //PresetIndex
                if (CacheElements ==TRUE)
                  gFL_PresetIndex[current_element] =Indication_array[Offset];
                Offset++;
                //Name
                for(i=0; i<AUDIO_FL_NAME_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Name[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Name[current_element][i] =Indication_array[Offset];
                  Offset++;
                } 
                //Frequency
                for(i=0; i<AUDIO_FL_FREQUENCY_LENGTH;i++) //clear
                {
                  if (CacheElements ==TRUE)
                    gFL_Frequency[current_element][i] =0; 
                }
                length =Indication_array[Offset];
                Offset++;                
                for(i=0; i<length;i++) //copy data
                {   
                  if (CacheElements ==TRUE)
                      gFL_Frequency[current_element][i] =Indication_array[Offset];
                  Offset++;
                }   
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =3 ends  
        case 15: //recordaddress =15 -> POS 
          if(0==startelement)
          {
            if(FORWARD==direction)  //forward-start
    		    {          
              current_element =startelement;
              if (shift ==TRUE) //startelement is next element
                current_element++;                 
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element       
              }   //copy data of current element finished
            }       //forward ends
            if(BACKWARD==direction && shift==TRUE)  //backward-start and shift=TRUE -> Start at last element in array
    		    {
              current_element =AUDIO_FL_ASGCACHE_MAX_SIZE-1; //NAV_VIDEOSTREAMS_ENTRIES =8, but range: 0...7!
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                     
            }       //backward ends
          }          //startelement=0 ends
          else if (startelement !=0) //startelement !=0
          {
            if(FORWARD==direction)  //forward-start
    		    {
              current_element =startelement;
              if (shift ==TRUE) //startelement is next element
                current_element++;
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element++; //go on with next element       
              }   //copy data of current element finished
            }       //forward ends
            else if(BACKWARD==direction)
            {
              current_element =startelement; 
              if (shift ==TRUE) //startelement is previous element
                current_element--;
              for (j=0; j<elements;j++) //copy elements
              {
                //check, if elements must be cached and in case find position in array
                CacheElements =FALSE;
                for (i=0; i<AUDIO_FL_ASGCACHE_MAX_SIZE; i++)
                {  
                  //if element already cached, find position in ASG-cache
                  if((transmitpos ==1) && Indication_array[Offset] ==gFL_Pos[i] && gFL_ListEntryReceptionInformation[i] ==TRUE)
                  {    
                    current_element =i; 
                    CacheElements   =TRUE;
                  }
                  //if not already cached, then store element only, if Cache is build-up!
                  else if((gFL_ListHandlingType !=AUDIO_FL_NOCACHE))
                    CacheElements   =TRUE;
                }
                //Pos
                if (transmitpos)
                {   
                  if (CacheElements ==TRUE)
                    gFL_Pos[current_element]=Indication_array[Offset];
                  Offset++;
                }
                //next element
                if (CacheElements ==TRUE)
                  gFL_ListEntryReceptionInformation [current_element] =TRUE;
                current_element--;
              }   //copy data of current element finished                                 
            }
          }          //startelement !=0 ends
        break;         //recordaddress =15 ends    
        }
      }
    break;            
    case Error_IND:	
			if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
				writelineEx(gError_Trace, 0, "ASG-AudioSD LastStationList_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
			else if(Indication_array[3]<0x30 && Indication_array[3] !=0)			//BPL-error
				writelineEx(gError_Trace, 0, "ASG-AudioSD LastStationList_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
			else if(Indication_array[3]<0x40 && Indication_array[3] !=0)			//BAL-error
				writelineEx(gError_Trace, 0, "ASG-AudioSD LastStationList_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
			else
				writelineEx(gError_Trace, 0, "ASG-AudioSD LastStationList_Indication: Application-Error: 0x%x", Indication_array[3]);
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD LastStationList_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
	}  
}

void FavoriteList_GetAttributesBits(word current_element)
{
  gFL_Attributes_Bit0[current_element]   =gFL_Attributes[current_element] & 0x0001;
  gFL_Attributes_Bit1[current_element]   =gFL_Attributes[current_element] & 0x0002 / 0x0002;
  gFL_Attributes_Bit2[current_element]   =gFL_Attributes[current_element] & 0x0004 / 0x0004;
  gFL_Attributes_Bit3[current_element]   =gFL_Attributes[current_element] & 0x0008 / 0x0008;
  gFL_Attributes_Bit4[current_element]   =gFL_Attributes[current_element] & 0x0010 / 0x0010;
  gFL_Attributes_Bit5[current_element]   =gFL_Attributes[current_element] & 0x0020 / 0x0020;
  gFL_Attributes_Bit6[current_element]   =gFL_Attributes[current_element] & 0x0040 / 0x0040;
  gFL_Attributes_Bit7[current_element]   =gFL_Attributes[current_element] & 0x0080 / 0x0080;
  gFL_Attributes_Bit8[current_element]   =gFL_Attributes[current_element] & 0x0100 / 0x0100;
  gFL_Attributes_Bit9[current_element]   =gFL_Attributes[current_element] & 0x0200 / 0x0200;
  gFL_Attributes_Bit10[current_element]  =gFL_Attributes[current_element] & 0x0400 / 0x0400;
  gFL_Attributes_Bit11[current_element]  =gFL_Attributes[current_element] & 0x0800 / 0x0800;
}
