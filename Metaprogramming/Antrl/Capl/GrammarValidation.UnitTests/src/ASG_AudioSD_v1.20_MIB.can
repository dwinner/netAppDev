            //Frequency
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_RL_Freq_s_0,gReceptionList_Frequency[Element_1]);

            gReceptionList_LastFirstElement =Element_1;
            
            
            //2. Element             
            Element_2 =ReceptionList_GetNextCachedElement(Element_1, AUDIO_RECEPTIONLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);
            
            //Pos
            putvalue(env_ASG_AudioSD_RL_pos_1, gReceptionList_Pos[Element_2]);               
            
            //Type
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1|| gReceptionList_recordaddress ==2 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Type_1, gReceptionList_Type[Element_2]);

                if(gReceptionList_Type[Element_2] <0x10)
                    putvalue(env_ASG_AudioSD_RL_Type_s_1,gReceptionList_Type_s[gReceptionList_Type[Element_2]]);
                else
                    putvalue(env_ASG_AudioSD_RL_Type_s_1,gstring_reserved);
            }

            //Attributes
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1|| gReceptionList_recordaddress ==2 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Attr_bit0_1, gReceptionList_Attributes_available_Bit0[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit0_1,gReceptionList_Attributes_available_Bit0_s[gReceptionList_Attributes_available_Bit0[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit1_1, gReceptionList_Attributes_DVB_Bit1[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit1_1,gReceptionList_Attributes_DVB_Bit1_s[gReceptionList_Attributes_available_Bit0[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit2_1, gReceptionList_Attributes_DAB_Bit2[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit2_1,gReceptionList_Attributes_DAB_Bit2_s[gReceptionList_Attributes_DAB_Bit2[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit3_1, gReceptionList_Attributes_DAB_Bit3[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit3_1,gReceptionList_Attributes_DAB_Bit3_s[gReceptionList_Attributes_DAB_Bit3[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit4_1, gReceptionList_Attributes_DAB_Bit4[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit4_1,gReceptionList_Attributes_DAB_Bit4_s[gReceptionList_Attributes_DAB_Bit4[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit5_1, gReceptionList_Attributes_TP_Bit5[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit5_1,gReceptionList_Attributes_TP_Bit5_s[gReceptionList_Attributes_TP_Bit5[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit6_1, gReceptionList_Attributes_TMC_Bit6[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit6_1,gReceptionList_Attributes_TMC_Bit6_s[gReceptionList_Attributes_TMC_Bit6[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit7_1, gReceptionList_Attributes_SDARS_Bit7[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit7_1,gReceptionList_Attributes_SDARS_Bit7_s[gReceptionList_Attributes_SDARS_Bit7[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit8_1, gReceptionList_Attributes_DABserv_Bit8[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit8_1,gReceptionList_Attributes_DABserv_Bit8_s[gReceptionList_Attributes_DABserv_Bit8[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit9_1, gReceptionList_Attributes_FMOnline_Bit9[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit9_1,gReceptionList_Attributes_FMOnline_Bit9_s[gReceptionList_Attributes_FMOnline_Bit9[Element_2]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitA_1, gReceptionList_Attributes_StationSelect_BitA[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitA_1,gReceptionList_Attributes_StationSelect_BitA_s[gReceptionList_Attributes_StationSelect_BitA[Element_2]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitB_1, gReceptionList_Attributes_OnlineRadioMute_BitB[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitB_1,gReceptionList_Attributes_OnlineRadioMute_BitB_s[gReceptionList_Attributes_OnlineRadioMute_BitB[Element_2]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitC_1, gReceptionList_Attributes_StationLinked_BitC[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitC_1,gReceptionList_Attributes_StationLinked_BitC_s[gReceptionList_Attributes_StationLinked_BitC[Element_2]]);
            }

            //PresetID
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_RL_PrID_1,gReceptionList_PresetID[Element_2]);
            
            //FmREG_Code
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_RL_FmReg_1,gReceptionList_FmRegCode[Element_2]);

            //Category
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1 || gReceptionList_recordaddress ==3 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Cat_1, gReceptionList_Category[Element_2]);

                if(gReceptionList_Type[Element_2] <0x38)
                    putvalue(env_ASG_AudioSD_RL_Cat_s_1,gReceptionList_Category_s[gReceptionList_Category[Element_2]]);
                else
                    putvalue(env_ASG_AudioSD_RL_Cat_s_1,gstring_reserved);
            }

            //Name
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1 || gReceptionList_recordaddress ==3 || gReceptionList_recordaddress ==4 || gReceptionList_recordaddress ==6)
                putvalue(env_ASG_AudioSD_RL_Name_s_1,gReceptionList_Name[Element_2]);
            
            //Frequency
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_RL_Freq_s_1,gReceptionList_Frequency[Element_2]);
             
            
            //3. Element          
            Element_3 =ReceptionList_GetNextCachedElement(Element_2, AUDIO_RECEPTIONLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);

            //Pos
            putvalue(env_ASG_AudioSD_RL_pos_2, gReceptionList_Pos[Element_3]);               
            
            //Type
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1|| gReceptionList_recordaddress ==2 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Type_2, gReceptionList_Type[Element_3]);

                if(gReceptionList_Type[Element_3] <0x10)
                    putvalue(env_ASG_AudioSD_RL_Type_s_2,gReceptionList_Type_s[gReceptionList_Type[Element_3]]);
                else
                    putvalue(env_ASG_AudioSD_RL_Type_s_2,gstring_reserved);
            }

            //Attributes
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1|| gReceptionList_recordaddress ==2 || gReceptionList_recordaddress ==6)
              {
                putvalue(env_ASG_AudioSD_RL_Attr_bit0_2, gReceptionList_Attributes_available_Bit0[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit0_2,gReceptionList_Attributes_available_Bit0_s[gReceptionList_Attributes_available_Bit0[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit1_2, gReceptionList_Attributes_DVB_Bit1[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit1_2,gReceptionList_Attributes_DVB_Bit1_s[gReceptionList_Attributes_available_Bit0[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit2_2, gReceptionList_Attributes_DAB_Bit2[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit2_2,gReceptionList_Attributes_DAB_Bit2_s[gReceptionList_Attributes_DAB_Bit2[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit3_2, gReceptionList_Attributes_DAB_Bit3[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit3_2,gReceptionList_Attributes_DAB_Bit3_s[gReceptionList_Attributes_DAB_Bit3[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit4_2, gReceptionList_Attributes_DAB_Bit4[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit4_2,gReceptionList_Attributes_DAB_Bit4_s[gReceptionList_Attributes_DAB_Bit4[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit5_2, gReceptionList_Attributes_TP_Bit5[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit5_2,gReceptionList_Attributes_TP_Bit5_s[gReceptionList_Attributes_TP_Bit5[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit6_2, gReceptionList_Attributes_TMC_Bit6[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit6_2,gReceptionList_Attributes_TMC_Bit6_s[gReceptionList_Attributes_TMC_Bit6[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit7_2, gReceptionList_Attributes_SDARS_Bit7[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit7_2,gReceptionList_Attributes_SDARS_Bit7_s[gReceptionList_Attributes_SDARS_Bit7[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit8_2, gReceptionList_Attributes_DABserv_Bit8[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit8_2,gReceptionList_Attributes_DABserv_Bit8_s[gReceptionList_Attributes_DABserv_Bit8[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit9_2, gReceptionList_Attributes_FMOnline_Bit9[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit9_2,gReceptionList_Attributes_FMOnline_Bit9_s[gReceptionList_Attributes_FMOnline_Bit9[Element_3]]);
                
                putvalue(env_ASG_AudioSD_RL_Attr_bitA_2, gReceptionList_Attributes_StationSelect_BitA[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitA_2,gReceptionList_Attributes_StationSelect_BitA_s[gReceptionList_Attributes_StationSelect_BitA[Element_3]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitB_2, gReceptionList_Attributes_OnlineRadioMute_BitB[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitB_2,gReceptionList_Attributes_OnlineRadioMute_BitB_s[gReceptionList_Attributes_OnlineRadioMute_BitB[Element_3]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitC_2, gReceptionList_Attributes_StationLinked_BitC[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitC_2,gReceptionList_Attributes_StationLinked_BitC_s[gReceptionList_Attributes_StationLinked_BitC[Element_3]]);
            }

            //PresetID
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_RL_PrID_2,gReceptionList_PresetID[Element_3]);
            
            //FmREG_Code
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_RL_FmReg_2,gReceptionList_FmRegCode[Element_3]);

            //Category
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1 || gReceptionList_recordaddress ==3 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Cat_2, gReceptionList_Category[Element_3]);

                if(gReceptionList_Type[Element_3] <0x38)
                    putvalue(env_ASG_AudioSD_RL_Cat_s_2,gReceptionList_Category_s[gReceptionList_Category[Element_3]]);
                else
                    putvalue(env_ASG_AudioSD_RL_Cat_s_2,gstring_reserved);
            }

            //Name
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1 || gReceptionList_recordaddress ==3 || gReceptionList_recordaddress ==4 || gReceptionList_recordaddress ==6)
                putvalue(env_ASG_AudioSD_RL_Name_s_2,gReceptionList_Name[Element_3]);
            
            //Frequency
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_RL_Freq_s_2,gReceptionList_Frequency[Element_3]);         
        }

        /******'sliding Window' active or 'build-up List'******/
        else if(gReceptionList_DisplayStatus ==AUDIO_RECEPTIONLIST_DISPLAYLIST_FIRST_ELEMENTS) 
        {
            //1. Element    
            if(gReceptionList_ListEntryReceptionInformation [0] ==TRUE && getvalue(env_ASG_AudioSD_RL_OnOff))
            {   
                Element_1 =0;
                
            //Pos
            if (gReceptionList_transmitpos)
                putvalue(env_ASG_AudioSD_RL_pos_0, gReceptionList_Pos[Element_1]);               
            
            //Type
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1|| gReceptionList_recordaddress ==2 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Type_0, gReceptionList_Type[Element_1]);

                if(gReceptionList_Type[Element_1] <0x10)
                    putvalue(env_ASG_AudioSD_RL_Type_s_0,gReceptionList_Type_s[gReceptionList_Type[Element_1]]);
                else
                    putvalue(env_ASG_AudioSD_RL_Type_s_0,gstring_reserved);
            }

            //Attributes
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1|| gReceptionList_recordaddress ==2 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Attr_bit0_0, gReceptionList_Attributes_available_Bit0[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit0_0,gReceptionList_Attributes_available_Bit0_s[gReceptionList_Attributes_available_Bit0[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit1_0, gReceptionList_Attributes_DVB_Bit1[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit1_0,gReceptionList_Attributes_DVB_Bit1_s[gReceptionList_Attributes_available_Bit0[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit2_0, gReceptionList_Attributes_DAB_Bit2[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit2_0,gReceptionList_Attributes_DAB_Bit2_s[gReceptionList_Attributes_DAB_Bit2[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit3_0, gReceptionList_Attributes_DAB_Bit3[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit3_0,gReceptionList_Attributes_DAB_Bit3_s[gReceptionList_Attributes_DAB_Bit3[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit4_0, gReceptionList_Attributes_DAB_Bit4[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit4_0,gReceptionList_Attributes_DAB_Bit4_s[gReceptionList_Attributes_DAB_Bit4[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit5_0, gReceptionList_Attributes_TP_Bit5[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit5_0,gReceptionList_Attributes_TP_Bit5_s[gReceptionList_Attributes_TP_Bit5[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit6_0, gReceptionList_Attributes_TMC_Bit6[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit6_0,gReceptionList_Attributes_TMC_Bit6_s[gReceptionList_Attributes_TMC_Bit6[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit7_0, gReceptionList_Attributes_SDARS_Bit7[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit7_0,gReceptionList_Attributes_SDARS_Bit7_s[gReceptionList_Attributes_SDARS_Bit7[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit8_0, gReceptionList_Attributes_DABserv_Bit8[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit8_0,gReceptionList_Attributes_DABserv_Bit8_s[gReceptionList_Attributes_DABserv_Bit8[Element_1]]);
                
                putvalue(env_ASG_AudioSD_RL_Attr_bit9_0, gReceptionList_Attributes_FMOnline_Bit9[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit9_0,gReceptionList_Attributes_FMOnline_Bit9_s[gReceptionList_Attributes_FMOnline_Bit9[Element_1]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitA_0, gReceptionList_Attributes_StationSelect_BitA[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitA_0,gReceptionList_Attributes_StationSelect_BitA_s[gReceptionList_Attributes_StationSelect_BitA[Element_1]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitB_0, gReceptionList_Attributes_OnlineRadioMute_BitB[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitB_0,gReceptionList_Attributes_OnlineRadioMute_BitB_s[gReceptionList_Attributes_OnlineRadioMute_BitB[Element_1]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitC_0, gReceptionList_Attributes_StationLinked_BitC[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitC_0,gReceptionList_Attributes_StationLinked_BitC_s[gReceptionList_Attributes_StationLinked_BitC[Element_1]]);

            }

            //PresetID
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_RL_PrID_0,gReceptionList_PresetID[Element_1]);
            
            //FmREG_Code
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_RL_FmReg_0,gReceptionList_FmRegCode[Element_1]);

            //Category
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1 || gReceptionList_recordaddress ==3 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Cat_0, gReceptionList_Category[Element_1]);

                if(gReceptionList_Type[Element_1] <0x38)
                    putvalue(env_ASG_AudioSD_RL_Cat_s_0,gReceptionList_Category_s[gReceptionList_Category[Element_1]]);
                else
                    putvalue(env_ASG_AudioSD_RL_Cat_s_0,gstring_reserved);
            }

            //Name
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1 || gReceptionList_recordaddress ==3 || gReceptionList_recordaddress ==4 || gReceptionList_recordaddress ==6)
                putvalue(env_ASG_AudioSD_RL_Name_s_0,gReceptionList_Name[Element_1]);
            
            //Frequency
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_RL_Freq_s_0,gReceptionList_Frequency[Element_1]);
                
                gReceptionList_LastFirstElement =0;
             }

            
            //2. Element    
            if(gReceptionList_ListEntryReceptionInformation [1] ==TRUE && getvalue(env_ASG_AudioSD_RL_OnOff))
            {
                Element_2 =1;
            //Pos
            if (gReceptionList_transmitpos)        
                putvalue(env_ASG_AudioSD_RL_pos_1, gReceptionList_Pos[Element_2]);               
            
            //Type
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1|| gReceptionList_recordaddress ==2 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Type_1, gReceptionList_Type[Element_2]);

                if(gReceptionList_Type[Element_2] <0x10)
                    putvalue(env_ASG_AudioSD_RL_Type_s_1,gReceptionList_Type_s[gReceptionList_Type[Element_2]]);
                else
                    putvalue(env_ASG_AudioSD_RL_Type_s_1,gstring_reserved);
            }

            //Attributes
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1|| gReceptionList_recordaddress ==2 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Attr_bit0_1, gReceptionList_Attributes_available_Bit0[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit0_1,gReceptionList_Attributes_available_Bit0_s[gReceptionList_Attributes_available_Bit0[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit1_1, gReceptionList_Attributes_DVB_Bit1[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit1_1,gReceptionList_Attributes_DVB_Bit1_s[gReceptionList_Attributes_available_Bit0[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit2_1, gReceptionList_Attributes_DAB_Bit2[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit2_1,gReceptionList_Attributes_DAB_Bit2_s[gReceptionList_Attributes_DAB_Bit2[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit3_1, gReceptionList_Attributes_DAB_Bit3[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit3_1,gReceptionList_Attributes_DAB_Bit3_s[gReceptionList_Attributes_DAB_Bit3[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit4_1, gReceptionList_Attributes_DAB_Bit4[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit4_1,gReceptionList_Attributes_DAB_Bit4_s[gReceptionList_Attributes_DAB_Bit4[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit5_1, gReceptionList_Attributes_TP_Bit5[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit5_1,gReceptionList_Attributes_TP_Bit5_s[gReceptionList_Attributes_TP_Bit5[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit6_1, gReceptionList_Attributes_TMC_Bit6[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit6_1,gReceptionList_Attributes_TMC_Bit6_s[gReceptionList_Attributes_TMC_Bit6[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit7_1, gReceptionList_Attributes_SDARS_Bit7[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit7_1,gReceptionList_Attributes_SDARS_Bit7_s[gReceptionList_Attributes_SDARS_Bit7[Element_2]]);
                
                putvalue(env_ASG_AudioSD_RL_Attr_bit8_1, gReceptionList_Attributes_DABserv_Bit8[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit8_1,gReceptionList_Attributes_DABserv_Bit8_s[gReceptionList_Attributes_DABserv_Bit8[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit9_1, gReceptionList_Attributes_FMOnline_Bit9[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit9_1,gReceptionList_Attributes_FMOnline_Bit9_s[gReceptionList_Attributes_FMOnline_Bit9[Element_2]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitA_1, gReceptionList_Attributes_StationSelect_BitA[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitA_1,gReceptionList_Attributes_StationSelect_BitA_s[gReceptionList_Attributes_StationSelect_BitA[Element_2]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitB_1, gReceptionList_Attributes_OnlineRadioMute_BitB[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitB_1,gReceptionList_Attributes_OnlineRadioMute_BitB_s[gReceptionList_Attributes_OnlineRadioMute_BitB[Element_2]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitC_1, gReceptionList_Attributes_StationLinked_BitC[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitC_1,gReceptionList_Attributes_StationLinked_BitC_s[gReceptionList_Attributes_StationLinked_BitC[Element_2]]);
            }

            //PresetID
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_RL_PrID_1,gReceptionList_PresetID[Element_2]);
            
            //FmREG_Code
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_RL_FmReg_1,gReceptionList_FmRegCode[Element_2]);

            //Category
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1 || gReceptionList_recordaddress ==3 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Cat_1, gReceptionList_Category[Element_2]);

                if(gReceptionList_Type[Element_2] <0x38)
                    putvalue(env_ASG_AudioSD_RL_Cat_s_1,gReceptionList_Category_s[gReceptionList_Category[Element_2]]);
                else
                    putvalue(env_ASG_AudioSD_RL_Cat_s_1,gstring_reserved);
            }

            //Name
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1 || gReceptionList_recordaddress ==3 || gReceptionList_recordaddress ==4 || gReceptionList_recordaddress ==6)
                putvalue(env_ASG_AudioSD_RL_Name_s_1,gReceptionList_Name[Element_2]);
            
            //Frequency
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_RL_Freq_s_1,gReceptionList_Frequency[Element_2]);
             }

             //3. Element    
            if(gReceptionList_ListEntryReceptionInformation [2] ==TRUE && getvalue(env_ASG_AudioSD_RL_OnOff))
            {
             Element_3 =2;
             //Pos
             if (gReceptionList_transmitpos)       
                putvalue(env_ASG_AudioSD_RL_pos_2, gReceptionList_Pos[Element_3]);               
            
            //Type
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1|| gReceptionList_recordaddress ==2 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Type_2, gReceptionList_Type[Element_3]);

                if(gReceptionList_Type[Element_3] <0x10)
                    putvalue(env_ASG_AudioSD_RL_Type_s_2,gReceptionList_Type_s[gReceptionList_Type[Element_3]]);
                else
                    putvalue(env_ASG_AudioSD_RL_Type_s_2,gstring_reserved);
            }

            //Attributes
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1|| gReceptionList_recordaddress ==2 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Attr_bit0_2, gReceptionList_Attributes_available_Bit0[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit0_2,gReceptionList_Attributes_available_Bit0_s[gReceptionList_Attributes_available_Bit0[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit1_2, gReceptionList_Attributes_DVB_Bit1[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit1_2,gReceptionList_Attributes_DVB_Bit1_s[gReceptionList_Attributes_available_Bit0[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit2_2, gReceptionList_Attributes_DAB_Bit2[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit2_2,gReceptionList_Attributes_DAB_Bit2_s[gReceptionList_Attributes_DAB_Bit2[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit3_2, gReceptionList_Attributes_DAB_Bit3[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit3_2,gReceptionList_Attributes_DAB_Bit3_s[gReceptionList_Attributes_DAB_Bit3[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit4_2, gReceptionList_Attributes_DAB_Bit4[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit4_2,gReceptionList_Attributes_DAB_Bit4_s[gReceptionList_Attributes_DAB_Bit4[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit5_2, gReceptionList_Attributes_TP_Bit5[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit5_2,gReceptionList_Attributes_TP_Bit5_s[gReceptionList_Attributes_TP_Bit5[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit6_2, gReceptionList_Attributes_TMC_Bit6[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit6_2,gReceptionList_Attributes_TMC_Bit6_s[gReceptionList_Attributes_TMC_Bit6[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit7_2, gReceptionList_Attributes_SDARS_Bit7[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit7_2,gReceptionList_Attributes_SDARS_Bit7_s[gReceptionList_Attributes_SDARS_Bit7[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit8_2, gReceptionList_Attributes_DABserv_Bit8[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit8_2,gReceptionList_Attributes_DABserv_Bit8_s[gReceptionList_Attributes_DABserv_Bit8[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit9_2, gReceptionList_Attributes_FMOnline_Bit9[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit9_2,gReceptionList_Attributes_FMOnline_Bit9_s[gReceptionList_Attributes_FMOnline_Bit9[Element_3]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitA_2, gReceptionList_Attributes_StationSelect_BitA[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitA_2,gReceptionList_Attributes_StationSelect_BitA_s[gReceptionList_Attributes_StationSelect_BitA[Element_3]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitB_2, gReceptionList_Attributes_OnlineRadioMute_BitB[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitB_2,gReceptionList_Attributes_OnlineRadioMute_BitB_s[gReceptionList_Attributes_OnlineRadioMute_BitB[Element_3]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitC_2, gReceptionList_Attributes_StationLinked_BitC[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitC_2,gReceptionList_Attributes_StationLinked_BitC_s[gReceptionList_Attributes_StationLinked_BitC[Element_3]]);

            }

            //PresetID
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_RL_PrID_2,gReceptionList_PresetID[Element_3]);
            
            //FmREG_Code
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_RL_FmReg_2,gReceptionList_FmRegCode[Element_3]);

            //Category
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1 || gReceptionList_recordaddress ==3 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Cat_2, gReceptionList_Category[Element_3]);

                if(gReceptionList_Type[Element_3] <0x38)
                    putvalue(env_ASG_AudioSD_RL_Cat_s_2,gReceptionList_Category_s[gReceptionList_Category[Element_3]]);
                else
                    putvalue(env_ASG_AudioSD_RL_Cat_s_2,gstring_reserved);
            }

            //Name
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1 || gReceptionList_recordaddress ==3 || gReceptionList_recordaddress ==4 || gReceptionList_recordaddress ==6)
                putvalue(env_ASG_AudioSD_RL_Name_s_2,gReceptionList_Name[Element_3]);
            
            //Frequency
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_RL_Freq_s_2,gReceptionList_Frequency[Element_3]);     
            }
        }
        else if (gReceptionList_DisplayStatus ==AUDIO_RECEPTIONLIST_DISPLAYLIST_REFRESH)
        {               
            //1. Element
            if(gReceptionList_SlidingWindow_State ==AUDIO_RECEPTIONLIST_SLIDINGWINDOW_NOTACTIVE)
                Element_1 =gReceptionList_LastFirstElement; 
            else
                Element_1 =0;

            if(gReceptionList_ListEntryReceptionInformation[Element_1])
            {
                //Pos
            putvalue(env_ASG_AudioSD_RL_pos_0, gReceptionList_Pos[Element_1]);               
            
            //Type
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1|| gReceptionList_recordaddress ==2 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Type_0, gReceptionList_Type[Element_1]);

                if(gReceptionList_Type[Element_1] <0x10)
                    putvalue(env_ASG_AudioSD_RL_Type_s_0,gReceptionList_Type_s[gReceptionList_Type[Element_1]]);
                else
                    putvalue(env_ASG_AudioSD_RL_Type_s_0,gstring_reserved);
            }

            //Attributes
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1|| gReceptionList_recordaddress ==2 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Attr_bit0_0, gReceptionList_Attributes_available_Bit0[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit0_0,gReceptionList_Attributes_available_Bit0_s[gReceptionList_Attributes_available_Bit0[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit1_0, gReceptionList_Attributes_DVB_Bit1[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit1_0,gReceptionList_Attributes_DVB_Bit1_s[gReceptionList_Attributes_available_Bit0[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit2_0, gReceptionList_Attributes_DAB_Bit2[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit2_0,gReceptionList_Attributes_DAB_Bit2_s[gReceptionList_Attributes_DAB_Bit2[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit3_0, gReceptionList_Attributes_DAB_Bit3[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit3_0,gReceptionList_Attributes_DAB_Bit3_s[gReceptionList_Attributes_DAB_Bit3[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit4_0, gReceptionList_Attributes_DAB_Bit4[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit4_0,gReceptionList_Attributes_DAB_Bit4_s[gReceptionList_Attributes_DAB_Bit4[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit5_0, gReceptionList_Attributes_TP_Bit5[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit5_0,gReceptionList_Attributes_TP_Bit5_s[gReceptionList_Attributes_TP_Bit5[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit6_0, gReceptionList_Attributes_TMC_Bit6[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit6_0,gReceptionList_Attributes_TMC_Bit6_s[gReceptionList_Attributes_TMC_Bit6[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit7_0, gReceptionList_Attributes_SDARS_Bit7[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit7_0,gReceptionList_Attributes_SDARS_Bit7_s[gReceptionList_Attributes_SDARS_Bit7[Element_1]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit8_0, gReceptionList_Attributes_DABserv_Bit8[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit8_0,gReceptionList_Attributes_DABserv_Bit8_s[gReceptionList_Attributes_DABserv_Bit8[Element_1]]);
                
                putvalue(env_ASG_AudioSD_RL_Attr_bit9_0, gReceptionList_Attributes_FMOnline_Bit9[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit9_0,gReceptionList_Attributes_FMOnline_Bit9_s[gReceptionList_Attributes_FMOnline_Bit9[Element_1]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitA_0, gReceptionList_Attributes_StationSelect_BitA[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitA_0,gReceptionList_Attributes_StationSelect_BitA_s[gReceptionList_Attributes_StationSelect_BitA[Element_1]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitB_0, gReceptionList_Attributes_OnlineRadioMute_BitB[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitB_0,gReceptionList_Attributes_OnlineRadioMute_BitB_s[gReceptionList_Attributes_OnlineRadioMute_BitB[Element_1]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitC_0, gReceptionList_Attributes_StationLinked_BitC[Element_1]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitC_0,gReceptionList_Attributes_StationLinked_BitC_s[gReceptionList_Attributes_StationLinked_BitC[Element_1]]);
            }

            //PresetID
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_RL_PrID_0,gReceptionList_PresetID[Element_1]);
            
            //FmREG_Code
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_RL_FmReg_0,gReceptionList_FmRegCode[Element_1]);

            //Category
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1 || gReceptionList_recordaddress ==3 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Cat_0, gReceptionList_Category[Element_1]);

                if(gReceptionList_Type[Element_1] <0x38)
                    putvalue(env_ASG_AudioSD_RL_Cat_s_0,gReceptionList_Category_s[gReceptionList_Category[Element_1]]);
                else
                    putvalue(env_ASG_AudioSD_RL_Cat_s_0,gstring_reserved);
            }

            //Name
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1 || gReceptionList_recordaddress ==3 || gReceptionList_recordaddress ==4 || gReceptionList_recordaddress ==6)
                putvalue(env_ASG_AudioSD_RL_Name_s_0,gReceptionList_Name[Element_1]);
            
            //Frequency
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_RL_Freq_s_0,gReceptionList_Frequency[Element_1]);
            }

            //2. Element             
            if(gReceptionList_SlidingWindow_State ==AUDIO_RECEPTIONLIST_SLIDINGWINDOW_NOTACTIVE)
                Element_2 =ReceptionList_GetNextCachedElement(Element_1, AUDIO_RECEPTIONLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);
            else
                Element_2 =1;

            if(gReceptionList_ListEntryReceptionInformation[Element_2])
            {
                //Pos
            putvalue(env_ASG_AudioSD_RL_pos_1, gReceptionList_Pos[Element_2]);               
            
            //Type
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1|| gReceptionList_recordaddress ==2 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Type_1, gReceptionList_Type[Element_2]);

                if(gReceptionList_Type[Element_2] <0x10)
                    putvalue(env_ASG_AudioSD_RL_Type_s_1,gReceptionList_Type_s[gReceptionList_Type[Element_2]]);
                else
                    putvalue(env_ASG_AudioSD_RL_Type_s_1,gstring_reserved);
            }

            //Attributes
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1|| gReceptionList_recordaddress ==2 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Attr_bit0_1, gReceptionList_Attributes_available_Bit0[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit0_1,gReceptionList_Attributes_available_Bit0_s[gReceptionList_Attributes_available_Bit0[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit1_1, gReceptionList_Attributes_DVB_Bit1[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit1_1,gReceptionList_Attributes_DVB_Bit1_s[gReceptionList_Attributes_available_Bit0[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit2_1, gReceptionList_Attributes_DAB_Bit2[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit2_1,gReceptionList_Attributes_DAB_Bit2_s[gReceptionList_Attributes_DAB_Bit2[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit3_1, gReceptionList_Attributes_DAB_Bit3[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit3_1,gReceptionList_Attributes_DAB_Bit3_s[gReceptionList_Attributes_DAB_Bit3[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit4_1, gReceptionList_Attributes_DAB_Bit4[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit4_1,gReceptionList_Attributes_DAB_Bit4_s[gReceptionList_Attributes_DAB_Bit4[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit5_1, gReceptionList_Attributes_TP_Bit5[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit5_1,gReceptionList_Attributes_TP_Bit5_s[gReceptionList_Attributes_TP_Bit5[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit6_1, gReceptionList_Attributes_TMC_Bit6[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit6_1,gReceptionList_Attributes_TMC_Bit6_s[gReceptionList_Attributes_TMC_Bit6[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit7_1, gReceptionList_Attributes_SDARS_Bit7[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit7_1,gReceptionList_Attributes_SDARS_Bit7_s[gReceptionList_Attributes_SDARS_Bit7[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit8_1, gReceptionList_Attributes_DABserv_Bit8[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit8_1,gReceptionList_Attributes_DABserv_Bit8_s[gReceptionList_Attributes_DABserv_Bit8[Element_2]]);
                
                putvalue(env_ASG_AudioSD_RL_Attr_bit9_1, gReceptionList_Attributes_FMOnline_Bit9[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit9_1,gReceptionList_Attributes_FMOnline_Bit9_s[gReceptionList_Attributes_FMOnline_Bit9[Element_2]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bitA_1, gReceptionList_Attributes_StationSelect_BitA[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitA_1,gReceptionList_Attributes_StationSelect_BitA_s[gReceptionList_Attributes_StationSelect_BitA[Element_2]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitB_1, gReceptionList_Attributes_OnlineRadioMute_BitB[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitB_1,gReceptionList_Attributes_OnlineRadioMute_BitB_s[gReceptionList_Attributes_OnlineRadioMute_BitB[Element_2]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitC_1, gReceptionList_Attributes_StationLinked_BitC[Element_2]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitC_1,gReceptionList_Attributes_StationLinked_BitC_s[gReceptionList_Attributes_StationLinked_BitC[Element_2]]);
            }

            //PresetID
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_RL_PrID_1,gReceptionList_PresetID[Element_2]);
            
            //FmREG_Code
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_RL_FmReg_1,gReceptionList_FmRegCode[Element_2]);

            //Category
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1 || gReceptionList_recordaddress ==3 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Cat_1, gReceptionList_Category[Element_2]);

                if(gReceptionList_Type[Element_2] <0x38)
                    putvalue(env_ASG_AudioSD_RL_Cat_s_1,gReceptionList_Category_s[gReceptionList_Category[Element_2]]);
                else
                    putvalue(env_ASG_AudioSD_RL_Cat_s_1,gstring_reserved);
            }

            //Name
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1 || gReceptionList_recordaddress ==3 || gReceptionList_recordaddress ==4 || gReceptionList_recordaddress ==6)
                putvalue(env_ASG_AudioSD_RL_Name_s_1,gReceptionList_Name[Element_2]);
            
            //Frequency
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_RL_Freq_s_1,gReceptionList_Frequency[Element_2]);
            }

            //3. Element          
            if(gReceptionList_SlidingWindow_State ==AUDIO_RECEPTIONLIST_SLIDINGWINDOW_NOTACTIVE)
                Element_3 =ReceptionList_GetNextCachedElement(Element_2, AUDIO_RECEPTIONLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);
            else
                Element_3 =2;

            if(gReceptionList_ListEntryReceptionInformation[Element_3])
            {    
                //Pos
            putvalue(env_ASG_AudioSD_RL_pos_2, gReceptionList_Pos[Element_3]);               
            
            //Type
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1|| gReceptionList_recordaddress ==2 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Type_2, gReceptionList_Type[Element_3]);

                if(gReceptionList_Type[Element_3] <0x10)
                    putvalue(env_ASG_AudioSD_RL_Type_s_2,gReceptionList_Type_s[gReceptionList_Type[Element_3]]);
                else
                    putvalue(env_ASG_AudioSD_RL_Type_s_2,gstring_reserved);
            }

            //Attributes
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1|| gReceptionList_recordaddress ==2 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Attr_bit0_2, gReceptionList_Attributes_available_Bit0[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit0_2,gReceptionList_Attributes_available_Bit0_s[gReceptionList_Attributes_available_Bit0[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit1_2, gReceptionList_Attributes_DVB_Bit1[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit1_2,gReceptionList_Attributes_DVB_Bit1_s[gReceptionList_Attributes_available_Bit0[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit2_2, gReceptionList_Attributes_DAB_Bit2[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit2_2,gReceptionList_Attributes_DAB_Bit2_s[gReceptionList_Attributes_DAB_Bit2[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit3_2, gReceptionList_Attributes_DAB_Bit3[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit3_2,gReceptionList_Attributes_DAB_Bit3_s[gReceptionList_Attributes_DAB_Bit3[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit4_2, gReceptionList_Attributes_DAB_Bit4[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit4_2,gReceptionList_Attributes_DAB_Bit4_s[gReceptionList_Attributes_DAB_Bit4[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit5_2, gReceptionList_Attributes_TP_Bit5[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit5_2,gReceptionList_Attributes_TP_Bit5_s[gReceptionList_Attributes_TP_Bit5[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit6_2, gReceptionList_Attributes_TMC_Bit6[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit6_2,gReceptionList_Attributes_TMC_Bit6_s[gReceptionList_Attributes_TMC_Bit6[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit7_2, gReceptionList_Attributes_SDARS_Bit7[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit7_2,gReceptionList_Attributes_SDARS_Bit7_s[gReceptionList_Attributes_SDARS_Bit7[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bit8_2, gReceptionList_Attributes_DABserv_Bit8[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit8_2,gReceptionList_Attributes_DABserv_Bit8_s[gReceptionList_Attributes_DABserv_Bit8[Element_3]]);
                
                putvalue(env_ASG_AudioSD_RL_Attr_bit9_2, gReceptionList_Attributes_FMOnline_Bit9[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bit9_2,gReceptionList_Attributes_FMOnline_Bit9_s[gReceptionList_Attributes_FMOnline_Bit9[Element_3]]);

                putvalue(env_ASG_AudioSD_RL_Attr_bitA_2, gReceptionList_Attributes_StationSelect_BitA[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitA_2,gReceptionList_Attributes_StationSelect_BitA_s[gReceptionList_Attributes_StationSelect_BitA[Element_3]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitB_2, gReceptionList_Attributes_OnlineRadioMute_BitB[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitB_2,gReceptionList_Attributes_OnlineRadioMute_BitB_s[gReceptionList_Attributes_OnlineRadioMute_BitB[Element_3]]);
              
                putvalue(env_ASG_AudioSD_RL_Attr_bitC_2, gReceptionList_Attributes_StationLinked_BitC[Element_3]);
                putvalue(env_ASG_AudioSD_RL_Attr_s_bitC_2,gReceptionList_Attributes_StationLinked_BitC_s[gReceptionList_Attributes_StationLinked_BitC[Element_3]]);
            }

            //PresetID
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_RL_PrID_2,gReceptionList_PresetID[Element_3]);
            
            //FmREG_Code
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_RL_FmReg_2,gReceptionList_FmRegCode[Element_3]);

            //Category
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1 || gReceptionList_recordaddress ==3 || gReceptionList_recordaddress ==6) 
            {
                putvalue(env_ASG_AudioSD_RL_Cat_2, gReceptionList_Category[Element_3]);

                if(gReceptionList_Type[Element_3] <0x38)
                    putvalue(env_ASG_AudioSD_RL_Cat_s_2,gReceptionList_Category_s[gReceptionList_Category[Element_3]]);
                else
                    putvalue(env_ASG_AudioSD_RL_Cat_s_2,gstring_reserved);
            }

            //Name
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==1 || gReceptionList_recordaddress ==3 || gReceptionList_recordaddress ==4 || gReceptionList_recordaddress ==6)
                putvalue(env_ASG_AudioSD_RL_Name_s_2,gReceptionList_Name[Element_3]);
            
            //Frequency
            if (gReceptionList_recordaddress ==0 || gReceptionList_recordaddress ==5)
                putvalue(env_ASG_AudioSD_RL_Freq_s_2,gReceptionList_Frequency[Element_3]);
            }
        }
    }
}

on envVar env_ASG_AudioSD_RL_GetArray
{
    byte mode, shift, direction, transmitpos, indexsize,recordaddress;
    word requested_startelement, startelement, elements;

    // Init local variables. 
    mode                    =0;
    shift                   =0;
    direction               =0;
    transmitpos             =0;
    indexsize               =0;
    recordaddress           =0;
    requested_startelement  =0;
    startelement            =0;
    elements                =0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gReceptionList_ListHandlingType ==AUDIO_RECEPTIONLIST_NOCACHE)
	{
        gReceptionList_ASGID            =getvalue(env_ASG_AudioSD_RL_ASGID);
        gReceptionList_TAID             =getvalue(env_ASG_AudioSD_RL_TAID);
        gReceptionList_ParentID         =getvalue(env_ASG_AudioSD_RL_ParentID);
        gReceptionList_ElementType      =getvalue(env_ASG_AudioSD_RL_ElementType);

        shift                           =getvalue(env_ASG_AudioSD_RL_AH_shift);
        direction                       =getvalue(env_ASG_AudioSD_RL_AH_dir);
        transmitpos                     =getvalue(env_ASG_AudioSD_RL_AH_PosTrans);
        indexsize                       =getvalue(env_ASG_AudioSD_RL_AH_IS);
        recordaddress                   =getvalue(env_ASG_AudioSD_RL_AH_RA);
        startelement                    =getvalue(env_ASG_AudioSD_RL_AH_start);
        elements                        =getvalue(env_ASG_AudioSD_RL_AH_elements);
        
        requested_startelement  =startelement;
        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

        ReceptionList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
    }
}

on envVar env_ASG_AudioSD_RL_OnOff
{
    int i =0, j =0;
    if(POWER_ON==gASG_PowerOnOff)
	{   
        if(getvalue(this))
        {
            gReceptionList_ListHandlingType      =AUDIO_RECEPTIONLIST_BUILDUPCACHE;             //build-up complete cache...
            gReceptionList_cacheBuildUp          =AUDIO_RECEPTIONLIST_BUILDUPCACHECACHE_WINDOW; //...and start with area "window"            
        
            ReceptionList_ListHandling ();
        }
        else
        {
            gReceptionList_SlidingWindow_State   =AUDIO_RECEPTIONLIST_SLIDINGWINDOW_NOTACTIVE;
            gReceptionList_ListHandlingType      =AUDIO_RECEPTIONLIST_NOCACHE;
            gReceptionList_cacheBuildUp          =AUDIO_RECEPTIONLIST_BUILDUPCACHENOCACHE;
            gReceptionList_CallBackReason        =AUDIO_RECEPTIONLIST_CALLBACKREASON_NOCALLBACK;

            gReceptionList_cacheDown             =FALSE;
            gReceptionList_cacheUp               =FALSE;
            gReceptionList_LastFirstElement      =0;

            gReceptionList_recordaddress         =0;
            gReceptionList_transmitpos           =1;
            gReceptionList_CursorAction          =AUDIO_RECEPTIONLIST_CURSORACTION_NOTHING;
            gReceptionList_DisplayStatus         =AUDIO_RECEPTIONLIST_DISPLAYLIST_FIRST_ELEMENTS;
            
            for(j=0; j<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; j++)
            {     
                gReceptionList_Pos[j]                            =0;
                gReceptionList_Type[j]                           =0;
                gReceptionList_Attributes_available_Bit0[j]      =0;
                gReceptionList_Attributes_DVB_Bit1[j]            =0;
                gReceptionList_Attributes_DAB_Bit2[j]            =0;
                gReceptionList_Attributes_DAB_Bit3[j]            =0;
                gReceptionList_Attributes_DAB_Bit4[j]            =0;
                gReceptionList_Attributes_TP_Bit5[j]             =0;
                gReceptionList_Attributes_TMC_Bit6[j]            =0;
                gReceptionList_Attributes_SDARS_Bit7[j]          =0;
                gReceptionList_Attributes_DABserv_Bit8[j]        =0;
                gReceptionList_Attributes_FMOnline_Bit9[j]       =0;
                gReceptionList_Attributes_StationSelect_BitA[j]  =0;
                gReceptionList_Attributes_OnlineRadioMute_BitB[j]=0;
                gReceptionList_Attributes_StationLinked_BitC[j]  =0;
                gReceptionList_Attributes[j]                     =0;
                gReceptionList_PresetID[j]                       =0;
                gReceptionList_FmRegCode[j]                      =0;
                gReceptionList_Category[j]                       =0;
                gReceptionList_ListEntryReceptionInformation[j]  =0;

                for(i=0;i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++)
			            gReceptionList_Name[j][i] =0;
                
                for(i=0;i<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;i++)
			            gReceptionList_Frequency[j][i] =0;
            }
            putvalue(env_ASG_AudioSD_RL_pos_0, 0);
            putvalue(env_ASG_AudioSD_RL_pos_1, 0);
            putvalue(env_ASG_AudioSD_RL_pos_2, 0);
    
            putvalue(env_ASG_AudioSD_RL_Type_0, 0);
            putvalue(env_ASG_AudioSD_RL_Type_1, 0);
            putvalue(env_ASG_AudioSD_RL_Type_2, 0);

            putvalue(env_ASG_AudioSD_RL_Type_s_0,empty_string);
            putvalue(env_ASG_AudioSD_RL_Type_s_1,empty_string);
            putvalue(env_ASG_AudioSD_RL_Type_s_2,empty_string);

            putvalue(env_ASG_AudioSD_RL_Attr_bit0_0, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit0_1, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit0_2, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit0_0, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit0_1, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit0_2, empty_string);

            putvalue(env_ASG_AudioSD_RL_Attr_bit1_0, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit1_1, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit1_2, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit1_0, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit1_1, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit1_2, empty_string);

            putvalue(env_ASG_AudioSD_RL_Attr_bit2_0, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit2_1, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit2_2, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit2_0, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit2_1, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit2_2, empty_string);

            putvalue(env_ASG_AudioSD_RL_Attr_bit3_0, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit3_1, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit3_2, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit3_0, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit3_1, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit3_2, empty_string);

            putvalue(env_ASG_AudioSD_RL_Attr_bit4_0, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit4_1, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit4_2, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit4_0, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit4_1, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit4_2, empty_string);

            putvalue(env_ASG_AudioSD_RL_Attr_bit5_0, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit5_1, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit5_2, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit5_0, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit5_1, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit5_2, empty_string);

            putvalue(env_ASG_AudioSD_RL_Attr_bit6_0, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit6_1, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit6_2, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit6_0, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit6_1, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit6_2, empty_string);

            putvalue(env_ASG_AudioSD_RL_Attr_bit7_0, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit7_1, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit7_2, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit7_0, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit7_1, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit7_2, empty_string);
            
            putvalue(env_ASG_AudioSD_RL_Attr_bit8_0, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit8_1, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit8_2, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit8_0, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit8_1, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit8_2, empty_string);
            
            putvalue(env_ASG_AudioSD_RL_Attr_bit9_0, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit9_1, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bit9_2, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit9_0, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit9_1, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bit9_2, empty_string);
            
            putvalue(env_ASG_AudioSD_RL_Attr_bitA_0, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bitA_1, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bitA_2, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bitA_0, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bitA_1, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bitA_2, empty_string);
            
            putvalue(env_ASG_AudioSD_RL_Attr_bitB_0, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bitB_1, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bitB_2, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bitB_0, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bitB_1, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bitB_2, empty_string);
            
            putvalue(env_ASG_AudioSD_RL_Attr_bitC_0, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bitC_1, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_bitC_2, 0);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bitC_0, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bitC_1, empty_string);
            putvalue(env_ASG_AudioSD_RL_Attr_s_bitC_2, empty_string);
            
            putvalue(env_ASG_AudioSD_RL_PrID_0, 0);
            putvalue(env_ASG_AudioSD_RL_PrID_1, 0);
            putvalue(env_ASG_AudioSD_RL_PrID_2, 0);

            putvalue(env_ASG_AudioSD_RL_FmReg_0, 0);
            putvalue(env_ASG_AudioSD_RL_FmReg_1, 0);
            putvalue(env_ASG_AudioSD_RL_FmReg_2, 0);

            putvalue(env_ASG_AudioSD_RL_Cat_0, 0);
            putvalue(env_ASG_AudioSD_RL_Cat_1, 0);
            putvalue(env_ASG_AudioSD_RL_Cat_2, 0);
            putvalue(env_ASG_AudioSD_RL_Cat_s_0, empty_string);
            putvalue(env_ASG_AudioSD_RL_Cat_s_1, empty_string);
            putvalue(env_ASG_AudioSD_RL_Cat_s_2, empty_string);

            putvalue(env_ASG_AudioSD_RL_Name_s_0, empty_string);
            putvalue(env_ASG_AudioSD_RL_Name_s_1, empty_string);
            putvalue(env_ASG_AudioSD_RL_Name_s_2, empty_string);

            putvalue(env_ASG_AudioSD_RL_Freq_s_0, empty_string);
            putvalue(env_ASG_AudioSD_RL_Freq_s_1, empty_string);
            putvalue(env_ASG_AudioSD_RL_Freq_s_2, empty_string);
            
        }
    }
}   

on envVar env_ASG_AudioSD_RL_down
{
    int i=0, j=0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gReceptionList_ListHandlingType ==AUDIO_RECEPTIONLIST_NOCACHE)
	{      
        gReceptionList_CursorAction =AUDIO_RECEPTIONLIST_CURSORACTION_DOWN;
        
        if(gReceptionList_SlidingWindow_State ==AUDIO_RECEPTIONLIST_SLIDINGWINDOW_ACTIVE)
        {   
            gReceptionList_ListHandlingType  =AUDIO_RECEPTIONLIST_DOWN_CACHE;
            gReceptionList_DisplayStatus     =AUDIO_RECEPTIONLIST_DISPLAYLIST_FIRST_ELEMENTS;
            gReceptionList_CursorAction      =AUDIO_RECEPTIONLIST_CURSORACTION_NOTHING;
            
            ReceptionList_ListHandling ();
        }
        else if(gReceptionList_SlidingWindow_State ==AUDIO_RECEPTIONLIST_SLIDINGWINDOW_NOTACTIVE)
        {
            gReceptionList_DisplayStatus     =AUDIO_RECEPTIONLIST_DISPLAYLIST_SEARCH_ELEMENTS;
            gReceptionList_CursorAction      =AUDIO_RECEPTIONLIST_CURSORACTION_DOWN;

            ReceptionList_display();

            //reset values
            gReceptionList_DisplayStatus     =AUDIO_RECEPTIONLIST_DISPLAYLIST_REFRESH;
            gReceptionList_CursorAction      =AUDIO_RECEPTIONLIST_CURSORACTION_NOTHING;
        }
    }
}

on envVar env_ASG_AudioSD_RL_up
{
    int i=0, j=0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gReceptionList_ListHandlingType ==AUDIO_RECEPTIONLIST_NOCACHE)
	{   
        gReceptionList_CursorAction =AUDIO_RECEPTIONLIST_CURSORACTION_UP;

        if(gReceptionList_SlidingWindow_State ==AUDIO_RECEPTIONLIST_SLIDINGWINDOW_ACTIVE)
        {  
            gReceptionList_ListHandlingType  =AUDIO_RECEPTIONLIST_UP_CACHE;
            gReceptionList_DisplayStatus     =AUDIO_RECEPTIONLIST_DISPLAYLIST_FIRST_ELEMENTS;
            gReceptionList_CursorAction      =AUDIO_RECEPTIONLIST_CURSORACTION_NOTHING;
            
            ReceptionList_ListHandling ();
        }
        else if(gReceptionList_SlidingWindow_State ==AUDIO_RECEPTIONLIST_SLIDINGWINDOW_NOTACTIVE)
        {
            gReceptionList_DisplayStatus     =AUDIO_RECEPTIONLIST_DISPLAYLIST_SEARCH_ELEMENTS;
            gReceptionList_CursorAction      =AUDIO_RECEPTIONLIST_CURSORACTION_UP;

            ReceptionList_ListHandling();
            
            ReceptionList_display();

            //reset values
            gReceptionList_DisplayStatus     =AUDIO_RECEPTIONLIST_DISPLAYLIST_REFRESH;
            gReceptionList_CursorAction      =AUDIO_RECEPTIONLIST_CURSORACTION_NOTHING;
        }    
    }
}

int SourceList_GetNextCachedElement (int currentElement,byte direction)
{
    int i=0, nextElement=0;

    switch (direction)
    {
        case AUDIO_SOURCELIST_DISPLAYLIST_FIND_NEXT_ELEMENT:                
                nextElement = ++currentElement;

                if (nextElement<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE) //start at next element, if next element is not >8
                {
                    for(i =nextElement; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i= AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;
                        }
                        else
                            nextElement =0;
                    }
                }
                else    //start at first element
                {
                    nextElement =0;

                    for(i =nextElement; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;
                        }   
                    }
                }
        break;

        case AUDIO_SOURCELIST_DISPLAYLIST_FIND_PREVIUOS_ELEMENT:
                nextElement = --currentElement;
                if (nextElement ==0 && gSourceList_ListEntryReceptionInformation[nextElement] ==TRUE)
                    nextElement =0;
                else if (nextElement>0) 
                {
                    for(i =nextElement; i>0; i--)
                    {
                        if(gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =0;
                        }
                        else
                            nextElement =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE-1;
                    }
                }    
                else    //start at last element
                {
                    nextElement =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE-1;

                    for(i =nextElement; i>0; i--)
                    {
                        if(gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =0;
                        }
                        else if(gSourceList_ListEntryReceptionInformation[0] ==TRUE)
                            nextElement =0;          
                    }
                }
        break;

        default:
        break;
    }
    return(nextElement);
}

int SourceList_GetNextLineInCache (int currentElement,byte direction)
{
    int i=0, nextElement=0;

    switch (direction)
    {
        case FORWARD:
                           
                if(currentElement<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE-1 && currentElement !=5) 
                    nextElement = ++currentElement;  
                
                else if (currentElement ==8)            
                    nextElement =0;
                else
                    nextElement =AUDIO_SOURCELIST_NO_NEXT_POSITION;
        break;

        case BACKWARD:
                if(currentElement<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE && currentElement !=0 && currentElement !=6) 
                    nextElement =--currentElement;
                
                else if (currentElement ==0)            
                    nextElement =8;
                
                else
                    nextElement =AUDIO_SOURCELIST_NO_NEXT_POSITION;
        break;

        default:
        break;
    }
    return(nextElement);
}

SourceList_ListHandling () //for sliding window concept, list handling and 'build-up' list...
{
    byte mode, shift, direction, transmitpos, indexsize, recordaddress, buffer_SourceType, buffer_InstanceID, buffer_MediaType, buffer_Attributes, buffer_Attributes_bit0, buffer_Attributes_bit1, buffer_Attributes_bit2, buffer_Attributes_bit3, buffer_Attributes_bit4, buffer_Attributes_bit5, buffer_Attributes_bit6, buffer_ReceptionInformation;
    word requested_startelement, startelement, elements, buffer_Pos ;
    char buffer_Name[AUDIO_SOURCELIST_NAME_LENGTH];
    int i,j,k;
    
    // Init local variables. 
    mode                        =0;
    shift                       =0;
    direction                   =0;
    transmitpos                 =0;
    indexsize                   =0;
    recordaddress               =0;
    requested_startelement      =0;
    startelement                =0;
    elements                    =0;
    i                           =0;
    j                           =0;
    k                           =0;
    buffer_Pos                  =0;
    buffer_SourceType           =0;
    buffer_InstanceID           =0;
    buffer_MediaType            =0;
    buffer_ReceptionInformation =0;
    buffer_Attributes           =0;
    buffer_Attributes_bit0      =0;
    buffer_Attributes_bit1      =0;
    buffer_Attributes_bit2      =0;
    buffer_Attributes_bit3      =0;
    buffer_Attributes_bit4      =0;
    buffer_Attributes_bit5      =0;
    
    /***build-up complete cache***/

    switch (gSourceList_ListHandlingType)
    {
        case AUDIO_SOURCELIST_BUILDUPCACHE:
             
            switch (gSourceList_cacheBuildUp)
            {   
                //cache-up  
                case AUDIO_SOURCELIST_BUILDUPCACHECACHE_UP:  
                    if(gSourceList_CallBackReason !=AUDIO_SOURCELIST_BUILDUPCACHENOCACHE && gSourceList_CallBackReason !=AUDIO_SOURCELIST_CALLBACKREASON_CACHENEXT)
                    {
                        switch (gSourceList_CallBackReason)
                        {
                            case AUDIO_SOURCELIST_CALLBACKREASON_CHECKCACHE:

                                    if(gSourceList_ListEntryReceptionInformation[2] ==TRUE) //cache-down required?
                                    {            
                                        gSourceList_cacheBuildUp      =AUDIO_SOURCELIST_BUILDUPCACHECACHE_DOWN;      //next step: build-up upper cache
                                        gSourceList_CallBackReason    =AUDIO_SOURCELIST_CALLBACKREASON_CACHENEXT;    
                                        
                                        
                                        SourceList_ListHandling ();
                                    }
                                    else //stop caching
                                    {   
                                        gSourceList_cacheBuildUp      =AUDIO_SOURCELIST_BUILDUPCACHENOCACHE;  //"build-up cache" finished
                                        gSourceList_ListHandlingType  =AUDIO_SOURCELIST_NOCACHE;              
                                        gSourceList_CallBackReason    =AUDIO_SOURCELIST_CALLBACKREASON_NOCALLBACK; 
                                        gSourceList_CursorAction      =AUDIO_SOURCELIST_CURSORACTION_NOTHING;
                                        
                                        putvalue(env_ASG_AudioSD_SL_ListOpState, empty_string);
                                        SourceList_display();
                                    }
                            break;
                        }
                    }
                    else
                    {   
                        shift               =TRUE;
                        direction           =BACKWARD;
                        transmitpos         =FALSE;
                        indexsize           =TRUE;
                        recordaddress       =0;
                        startelement        =0;
                        elements            =3;
                
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gSourceList_CallBackReason  =AUDIO_SOURCELIST_CALLBACKREASON_CHECKCACHE;

                        SourceList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;
                
                //cache "window"
                case AUDIO_SOURCELIST_BUILDUPCACHECACHE_WINDOW: 
                    if(gSourceList_CallBackReason !=AUDIO_SOURCELIST_BUILDUPCACHENOCACHE && gSourceList_CallBackReason !=AUDIO_SOURCELIST_CALLBACKREASON_CACHENEXT)
                    {   
                        switch (gSourceList_CallBackReason)
                        {
                            case AUDIO_SOURCELIST_CALLBACKREASON_CHECKCACHE:
                                                 
                                    gSourceList_cacheBuildUp      =AUDIO_SOURCELIST_BUILDUPCACHECACHE_UP;      //next step: build-up upper cache
                                    gSourceList_CallBackReason    =AUDIO_SOURCELIST_CALLBACKREASON_CACHENEXT;    
                                    
                                    SourceList_ListHandling ();
                            break;
                        }
                    }
                    else
                    { 
                        putvalue(env_ASG_AudioSD_SL_ListOpState, "build-up list...");
                        shift               =FALSE;
                        direction           =FORWARD;
                        transmitpos         =FALSE;
                        indexsize           =TRUE;
                        recordaddress       =0;
                        startelement        =0;
                        elements            =3; 
    
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gSourceList_CallBackReason  =AUDIO_SOURCELIST_CALLBACKREASON_CHECKCACHE;

                        SourceList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;
                
                //cache-down
                case AUDIO_SOURCELIST_BUILDUPCACHECACHE_DOWN:
                    if(gSourceList_CallBackReason !=AUDIO_SOURCELIST_BUILDUPCACHENOCACHE && gSourceList_CallBackReason !=AUDIO_SOURCELIST_CALLBACKREASON_CACHENEXT)
                    {
                        switch (gSourceList_CallBackReason)
                        {
                            case AUDIO_SOURCELIST_CALLBACKREASON_CHECKCACHE:
                                    
                                    //stop caching
                                    gSourceList_cacheBuildUp      =AUDIO_SOURCELIST_BUILDUPCACHENOCACHE;  //"build-up cache" finished
                                    gSourceList_ListHandlingType  =AUDIO_SOURCELIST_NOCACHE;              
                                    gSourceList_CallBackReason    =AUDIO_SOURCELIST_CALLBACKREASON_NOCALLBACK;
                                    gSourceList_CursorAction      =AUDIO_SOURCELIST_CURSORACTION_NOTHING;
                                    
                                    gSourceList_DisplayStatus     =AUDIO_SOURCELIST_DISPLAYLIST_REFRESH;
                                    
                                    putvalue(env_ASG_AudioSD_SL_ListOpState, empty_string);
                                    
                                    SourceList_display();
                            break;
                        }
                    }
                    else
                    { 
                        shift                   =TRUE;
                        direction               =FORWARD;
                        transmitpos             =FALSE;
                        indexsize               =TRUE;
                        recordaddress           =0;
                        for(i=0;i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++) //find last cached element
                        {   
                            if(gSourceList_ListEntryReceptionInformation[i] ==FALSE) //abort loop
                                i =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; 
                            else
                                startelement    =gSourceList_Pos[i];
                        }
                        elements                =3;                         
        
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gSourceList_CallBackReason    =AUDIO_SOURCELIST_CALLBACKREASON_CHECKCACHE;
                        
                        SourceList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;

                default:
                break;
            }//build-up cache finished
        break;
        
        /********sliding-window********/
        case AUDIO_SOURCELIST_DOWN_CACHE: 
                    if (gSourceList_CallBackReason ==AUDIO_SOURCELIST_CALLBACKREASON_CHECKCACHE) //check if valid data received
                    {   
                        if(gSourceList_ListEntryReceptionInformation[5] ==0) //No valid data in last list pos -> last list element reached, start with element 0!  
                        {    
                            shift                   =FALSE;
                            direction               =FORWARD;
                            transmitpos             =FALSE;
                            indexsize               =TRUE;
                            recordaddress           =0;
                            startelement            =0; //first element
                            elements                =1;        
                            
                            requested_startelement  =startelement;
                            mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;
                            
                            gSourceList_CallBackReason    =AUDIO_SOURCELIST_CALLBACKREASON_DISPLAYLIST; 
                            gSourceList_cacheDown         =TRUE;

                            SourceList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);    
                        }
                        else
                        {
                            gSourceList_CallBackReason =AUDIO_SOURCELIST_CALLBACKREASON_DISPLAYLIST;
                            SourceList_ListHandling(); 
                        }    
                    }
                    else if (gSourceList_CallBackReason ==AUDIO_SOURCELIST_CALLBACKREASON_DISPLAYLIST)
                    {   
                        gSourceList_ListHandlingType  =AUDIO_SOURCELIST_NOCACHE;
                        gSourceList_cacheDown         =FALSE;
                        gSourceList_DisplayStatus     =AUDIO_SOURCELIST_DISPLAYLIST_FIRST_ELEMENTS;
                        
                        putvalue(env_ASG_AudioSD_SL_ListOpState, empty_string);
                        SourceList_display();
                        gSourceList_DisplayStatus     =AUDIO_SOURCELIST_DISPLAYLIST_REFRESH;
                        gSourceList_CallBackReason    =AUDIO_SOURCELIST_CALLBACKREASON_NOCALLBACK;
                    }
                    else
                    {   
                        putvalue(env_ASG_AudioSD_SL_ListOpState, "list operating...");
                                
                        shift                   =TRUE;
                        direction               =FORWARD;
                        transmitpos             =FALSE;
                        indexsize               =TRUE;
                        recordaddress           =0;
                        startelement            =gSourceList_Pos[5]; //last element
                        elements                =1;
                        
                        for(i=0;i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;i++)
                        {   
                            j =i+1;
                            
                            switch (i)
                            {   
                                case 0: 
                                    //buffer data of Pos '0' (local)
                                    buffer_Pos              =gSourceList_Pos[i];
                                    buffer_SourceType       =gSourceList_SourceType[i];
                                    buffer_InstanceID       =gSourceList_InstanceID[i];
                                    buffer_MediaType        =gSourceList_MediaType[i];
                                    buffer_Attributes       =gSourceList_Attributes[i];
                                    buffer_Attributes_bit0  =gSourceList_Attributes_BuiltIn_Bit0[i];
                                    buffer_Attributes_bit1  =gSourceList_Attributes_MediaError_Bit1[i];
                                    buffer_Attributes_bit2  =gSourceList_Attributes_MediaPlay_Bit2[i];
                                    buffer_Attributes_bit3  =gSourceList_Attributes_MediaRead_Bit3[i];
                                    buffer_Attributes_bit4  =gSourceList_Attributes_MediaLoad_Bit4[i];
                                    buffer_Attributes_bit5  =gSourceList_Attributes_ImportRun_Bit5[i];
                                    buffer_Attributes_bit6  =gSourceList_Attributes_MediaSupp_Bit6[i];

                                    for (k=0; k<AUDIO_SOURCELIST_NAME_LENGTH;k++) //clear string
                                        buffer_Name[k] =0;                                     

                                    for(k=0;k<strlen(gSourceList_Name[i]);k++) 
                                        buffer_Name[k]=gSourceList_Name[i][k];

                                    //copy data from Pos '1' to Pos '0'
                                    gSourceList_Pos[i]                          =gSourceList_Pos[j]; 
                                    gSourceList_SourceType[i]                   =gSourceList_SourceType[j];
                                    gSourceList_InstanceID[i]                   =gSourceList_InstanceID[j];
                                    gSourceList_MediaType[i]                    =gSourceList_MediaType[j]; 
                                    gSourceList_Attributes[i]                   =gSourceList_Attributes[j];
                                    gSourceList_Attributes_BuiltIn_Bit0[i]      =gSourceList_Attributes_BuiltIn_Bit0[j];
                                    gSourceList_Attributes_MediaError_Bit1[i]   =gSourceList_Attributes_MediaError_Bit1[j];
                                    gSourceList_Attributes_MediaPlay_Bit2[i]    =gSourceList_Attributes_MediaPlay_Bit2[j];
                                    gSourceList_Attributes_MediaRead_Bit3[i]    =gSourceList_Attributes_MediaRead_Bit3[j];
                                    gSourceList_Attributes_MediaLoad_Bit4[i]    =gSourceList_Attributes_MediaLoad_Bit4[j];
                                    gSourceList_Attributes_ImportRun_Bit5[i]    =gSourceList_Attributes_ImportRun_Bit5[j]; 
                                    gSourceList_Attributes_MediaSupp_Bit6[i]    =gSourceList_Attributes_MediaSupp_Bit6[j]; 
                                
                                    for (k=0; k<AUDIO_SOURCELIST_NAME_LENGTH;k++) //clear string
                                        gSourceList_Name[i][k] =0;                                     

                                    for(k=0;k<strlen(gSourceList_Name[j]);k++) 
                                        gSourceList_Name[i][k]=gSourceList_Name[j][k];

                                break;
                            
                                case 5:
                                    //clear last element in list 
                                    gSourceList_ListEntryReceptionInformation[i]    =0;
                                    gSourceList_Pos[i]                              =0;
                                    gSourceList_SourceType[i]                       =0;
                                    gSourceList_InstanceID[i]                       =0;
                                    gSourceList_MediaType[i]                        =0;
                                    gSourceList_Attributes[i]                       =0;
                                    gSourceList_Attributes_BuiltIn_Bit0[i]          =0;
                                    gSourceList_Attributes_MediaError_Bit1[i]       =0;
                                    gSourceList_Attributes_MediaPlay_Bit2[i]        =0;
                                    gSourceList_Attributes_MediaRead_Bit3[i]        =0;
                                    gSourceList_Attributes_MediaLoad_Bit4[i]        =0;
                                    gSourceList_Attributes_ImportRun_Bit5[i]        =0;
                                    gSourceList_Attributes_MediaSupp_Bit6[i]        =0;
                                    
                                    for (k=0; k<AUDIO_SOURCELIST_NAME_LENGTH;k++) //clear string
                                        gSourceList_Name[i][k] =0;
                                                                 
                                break;
                            
                                case 8:
                                    //copy data from buffer in Pos '8'
                                    gSourceList_Pos[i]                          =buffer_Pos; 
                                    gSourceList_SourceType[i]                   =buffer_SourceType;
                                    gSourceList_InstanceID[i]                   =buffer_InstanceID;
                                    gSourceList_MediaType[i]                    =buffer_MediaType;
                                    gSourceList_Attributes[i]                   =buffer_Attributes;
                                    gSourceList_Attributes_BuiltIn_Bit0[i]      =buffer_Attributes_bit0;
                                    gSourceList_Attributes_MediaError_Bit1[i]   =buffer_Attributes_bit1;
                                    gSourceList_Attributes_MediaPlay_Bit2[i]    =buffer_Attributes_bit2;
                                    gSourceList_Attributes_MediaRead_Bit3[i]    =buffer_Attributes_bit3;
                                    gSourceList_Attributes_MediaLoad_Bit4[i]    =buffer_Attributes_bit4;
                                    gSourceList_Attributes_ImportRun_Bit5[i]    =buffer_Attributes_bit5;
                                    gSourceList_Attributes_MediaSupp_Bit6[i]    =buffer_Attributes_bit6;
                                                                        
                                    for (k=0; k<AUDIO_SOURCELIST_NAME_LENGTH;k++) //clear string
                                        gSourceList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_Name);k++) 
                                        gSourceList_Name[i][k]=buffer_Name[k];

                                break;
                                
                                default://other elements
                                    //copy element on other position
                                    gSourceList_Pos[i]                          =gSourceList_Pos[j]; 
                                    gSourceList_SourceType[i]                   =gSourceList_SourceType[j];
                                    gSourceList_InstanceID[i]                   =gSourceList_InstanceID[j];
                                    gSourceList_MediaType[i]                    =gSourceList_MediaType[j];
                                    gSourceList_Attributes[i]                   =gSourceList_Attributes[j];
                                    gSourceList_Attributes_BuiltIn_Bit0[i]      =gSourceList_Attributes_BuiltIn_Bit0[j];
                                    gSourceList_Attributes_MediaError_Bit1[i]   =gSourceList_Attributes_MediaError_Bit1[j]; 
                                    gSourceList_Attributes_MediaPlay_Bit2[i]    =gSourceList_Attributes_MediaPlay_Bit2[j];
                                    gSourceList_Attributes_MediaRead_Bit3[i]    =gSourceList_Attributes_MediaRead_Bit3[j];
                                    gSourceList_Attributes_MediaLoad_Bit4[i]    =gSourceList_Attributes_MediaLoad_Bit4[j];
                                    gSourceList_Attributes_ImportRun_Bit5[i]    =gSourceList_Attributes_ImportRun_Bit5[j];
                                    gSourceList_Attributes_MediaSupp_Bit6[i]    =gSourceList_Attributes_MediaSupp_Bit6[j];
                                 
                                    for (k=0; k<AUDIO_SOURCELIST_NAME_LENGTH;k++) //clear string
                                        gSourceList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gSourceList_Name[j]);k++) 
                                        gSourceList_Name[i][k]=gSourceList_Name[j][k];
                                        
                                break;
                            } // end of switch 'i'
                        }
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        SourceList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);                        
                        
                        //to check, if valid data received
                        gSourceList_CallBackReason    =AUDIO_SOURCELIST_CALLBACKREASON_CHECKCACHE;
                    }
        break;

        case AUDIO_SOURCELIST_UP_CACHE: 
                    if (gSourceList_CallBackReason ==AUDIO_SOURCELIST_CALLBACKREASON_CHECKCACHE) //check if valid data received
                    {   
                        if(gSourceList_ListEntryReceptionInformation[6] ==0) //No valid data in first list pos -> last list element reached, start with element 0!  
                        {
                            shift                   =TRUE;
                            direction               =BACKWARD;
                            transmitpos             =FALSE;
                            indexsize               =TRUE;
                            recordaddress           =0;
                            startelement            =0; //Last element
                            elements                =1;        
                            
                            requested_startelement  =startelement;
                            mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                            gSourceList_cacheUp        =TRUE;
                            gSourceList_CallBackReason =AUDIO_SOURCELIST_CALLBACKREASON_DISPLAYLIST;
                            
                            SourceList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                        }
                        else
                        {
                            gSourceList_CallBackReason =AUDIO_SOURCELIST_CALLBACKREASON_DISPLAYLIST;
                            SourceList_ListHandling();
                        }           
                    }

                    else if (gSourceList_CallBackReason ==AUDIO_SOURCELIST_CALLBACKREASON_DISPLAYLIST)
                    {   
                        gSourceList_ListHandlingType  =AUDIO_SOURCELIST_NOCACHE;
                        gSourceList_cacheUp           =FALSE;
                        gSourceList_DisplayStatus     =AUDIO_SOURCELIST_DISPLAYLIST_FIRST_ELEMENTS;
                        
                        putvalue(env_ASG_AudioSD_SL_ListOpState, empty_string);
                        SourceList_display();
                        gSourceList_DisplayStatus     =AUDIO_SOURCELIST_DISPLAYLIST_REFRESH;
                        gSourceList_CallBackReason    =AUDIO_SOURCELIST_CALLBACKREASON_NOCALLBACK;
                    }

                    else
                    {           
                        putvalue(env_ASG_AudioSD_SL_ListOpState, "list operating...");

                        shift                   =TRUE;
                        direction               =BACKWARD;
                        transmitpos             =FALSE;
                        indexsize               =TRUE;
                        recordaddress           =0;
                        startelement            =gSourceList_Pos[6]; //first element
                        elements                =1;
                    
                        for(i=AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE-1;i>=0;i--)
                        {  
                            j =i-1;
                            switch (i)
                            {   
                                case 8: 
                                    //buffer data of Pos '8' (local)
                                    buffer_Pos              =gSourceList_Pos[i];
                                    buffer_SourceType       =gSourceList_SourceType[i];
                                    buffer_InstanceID       =gSourceList_InstanceID[i];
                                    buffer_MediaType        =gSourceList_MediaType[i];
                                    buffer_Attributes       =gSourceList_Attributes[i];
                                    buffer_Attributes_bit0  =gSourceList_Attributes_BuiltIn_Bit0[i];
                                    buffer_Attributes_bit1  =gSourceList_Attributes_MediaError_Bit1[i];
                                    buffer_Attributes_bit2  =gSourceList_Attributes_MediaPlay_Bit2[i];
                                    buffer_Attributes_bit3  =gSourceList_Attributes_MediaRead_Bit3[i];
                                    buffer_Attributes_bit4  =gSourceList_Attributes_MediaLoad_Bit4[i];
                                    buffer_Attributes_bit5  =gSourceList_Attributes_ImportRun_Bit5[i];                                
                                    buffer_Attributes_bit6  =gSourceList_Attributes_MediaSupp_Bit6[i];   

                                    for (k=0; k<AUDIO_SOURCELIST_NAME_LENGTH;k++) //clear string
                                        buffer_Name[k] =0;                                     

                                    for(k=0;k<strlen(gSourceList_Name[i]);k++) 
                                        buffer_Name[k]=gSourceList_Name[i][k];

                                    //copy data from Pos '7' to Pos '8'
                                    gSourceList_Pos[i]                          =gSourceList_Pos[j]; 
                                    gSourceList_SourceType[i]                   =gSourceList_SourceType[j];
                                    gSourceList_InstanceID[i]                   =gSourceList_InstanceID[j];
                                    gSourceList_MediaType[i]                    =gSourceList_MediaType[j];
                                    gSourceList_Attributes[i]                   =gSourceList_Attributes[j];
                                    gSourceList_Attributes_BuiltIn_Bit0[i]      =gSourceList_Attributes_BuiltIn_Bit0[j];
                                    gSourceList_Attributes_MediaError_Bit1[i]   =gSourceList_Attributes_MediaError_Bit1[j];
                                    gSourceList_Attributes_MediaPlay_Bit2[i]    =gSourceList_Attributes_MediaPlay_Bit2[j];
                                    gSourceList_Attributes_MediaRead_Bit3[i]    =gSourceList_Attributes_MediaRead_Bit3[j];
                                    gSourceList_Attributes_MediaLoad_Bit4[i]    =gSourceList_Attributes_MediaLoad_Bit4[j];
                                    gSourceList_Attributes_ImportRun_Bit5[i]    =gSourceList_Attributes_ImportRun_Bit5[j];
                                    gSourceList_Attributes_MediaSupp_Bit6[i]    =gSourceList_Attributes_MediaSupp_Bit6[j];
                                    
                                    for (k=0; k<AUDIO_SOURCELIST_NAME_LENGTH;k++) //clear string
                                        gSourceList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gSourceList_Name[j]);k++) 
                                        gSourceList_Name[i][k]=gSourceList_Name[j][k];
                                    
                                break;
                            
                                case 6: 
                                    //clear first element in list 
                                    gSourceList_ListEntryReceptionInformation[i]    =0;
                                    gSourceList_Pos[i]                              =0;
                                    gSourceList_SourceType[i]                       =0;
                                    gSourceList_InstanceID[i]                       =0;
                                    gSourceList_MediaType[i]                        =0;
                                    gSourceList_Attributes[i]                       =0;
                                    gSourceList_Attributes_BuiltIn_Bit0[i]          =0;
                                    gSourceList_Attributes_MediaError_Bit1[i]       =0;
                                    gSourceList_Attributes_MediaPlay_Bit2[i]        =0;
                                    gSourceList_Attributes_MediaRead_Bit3[i]        =0;
                                    gSourceList_Attributes_MediaLoad_Bit4[i]        =0;
                                    gSourceList_Attributes_ImportRun_Bit5[i]        =0;
                                    gSourceList_Attributes_MediaSupp_Bit6[i]        =0;
                            
                                    for (k=0; k<AUDIO_SOURCELIST_NAME_LENGTH;k++) //clear string
                                        gSourceList_Name[i][k] =0;
                                                                            
                                break;
                            
                                case 0: 
                                    //copy data from buffer in Pos '0'
                                    gSourceList_Pos[i]                          =buffer_Pos; 
                                    gSourceList_SourceType[i]                   =buffer_SourceType;
                                    gSourceList_InstanceID[i]                   =buffer_InstanceID;
                                    gSourceList_MediaType[i]                    =buffer_MediaType;
                                    gSourceList_Attributes[i]                   =buffer_Attributes;
                                    gSourceList_Attributes_BuiltIn_Bit0[i]      =buffer_Attributes_bit0;
                                    gSourceList_Attributes_MediaError_Bit1[i]   =buffer_Attributes_bit1;
                                    gSourceList_Attributes_MediaPlay_Bit2[i]    =buffer_Attributes_bit2;
                                    gSourceList_Attributes_MediaRead_Bit3[i]    =buffer_Attributes_bit3;
                                    gSourceList_Attributes_MediaLoad_Bit4[i]    =buffer_Attributes_bit4;
                                    gSourceList_Attributes_ImportRun_Bit5[i]    =buffer_Attributes_bit5;
                                    gSourceList_Attributes_MediaSupp_Bit6[i]    =buffer_Attributes_bit6;

                                    for (k=0; k<AUDIO_SOURCELIST_NAME_LENGTH;k++) //clear string
                                        gSourceList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_Name);k++) 
                                        gSourceList_Name[i][k]=buffer_Name[k];

                                break;
                                
                                default: //other elements
                                    //copy element on other position
                                    gSourceList_Pos[i]                          =gSourceList_Pos[j]; 
                                    gSourceList_SourceType[i]                   =gSourceList_SourceType[j];
                                    gSourceList_InstanceID[i]                   =gSourceList_InstanceID[j];
                                    gSourceList_MediaType[i]                    =gSourceList_MediaType[j]; 
                                    gSourceList_Attributes[i]                   =gSourceList_Attributes[j];
                                    gSourceList_Attributes_BuiltIn_Bit0[i]      =gSourceList_Attributes_BuiltIn_Bit0[j];
                                    gSourceList_Attributes_MediaError_Bit1[i]   =gSourceList_Attributes_MediaError_Bit1[j];
                                    gSourceList_Attributes_MediaPlay_Bit2[i]    =gSourceList_Attributes_MediaPlay_Bit2[j];
                                    gSourceList_Attributes_MediaRead_Bit3[i]    =gSourceList_Attributes_MediaRead_Bit3[j];
                                    gSourceList_Attributes_MediaLoad_Bit4[i]    =gSourceList_Attributes_MediaLoad_Bit4[j];
                                    gSourceList_Attributes_ImportRun_Bit5[i]    =gSourceList_Attributes_ImportRun_Bit5[j];     
                                    gSourceList_Attributes_MediaSupp_Bit6[i]    =gSourceList_Attributes_MediaSupp_Bit6[j];     

                                    for (k=0; k<AUDIO_SOURCELIST_NAME_LENGTH;k++) //clear string
                                        gSourceList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gSourceList_Name[j]);k++) 
                                        gSourceList_Name[i][k]=gSourceList_Name[j][k];
                                     
                                break;
                            } // end of switch 'i'
                        }
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        SourceList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);                        
                        
                        //to check, if valid data received
                        gSourceList_CallBackReason    =AUDIO_SOURCELIST_CALLBACKREASON_CHECKCACHE;
                    }
        break;

        default:
        break;
    } //end of switch 'type of cache handling' 
}

SourceList_display()
{   
    int Element_1 =0, Element_2 =1, Element_3 =2;
    
    if(POWER_ON==gASG_PowerOnOff && getvalue(env_ASG_AudioSD_SL_OnOff))
	{   
        /******'sliding window' not active******/         
        if(gSourceList_DisplayStatus ==AUDIO_SOURCELIST_DISPLAYLIST_SEARCH_ELEMENTS)
        {
            //1. Element              
            if(gSourceList_CursorAction ==AUDIO_SOURCELIST_CURSORACTION_DOWN)
                Element_1 =SourceList_GetNextCachedElement(gSourceList_LastFirstElement, AUDIO_SOURCELIST_DISPLAYLIST_FIND_NEXT_ELEMENT);
            
            else if(gSourceList_CursorAction ==AUDIO_SOURCELIST_CURSORACTION_UP)            
                Element_1 =SourceList_GetNextCachedElement(gSourceList_LastFirstElement, AUDIO_SOURCELIST_DISPLAYLIST_FIND_PREVIUOS_ELEMENT);

            //Pos
            putvalue(env_ASG_AudioSD_SL_pos_0, gSourceList_Pos[Element_1]);               
            
            //SourceType
            if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_SL_SrcType_0, gSourceList_SourceType[Element_1]);

                if(gSourceList_SourceType[Element_1] <0x2E)
                    putvalue(env_ASG_AudioSD_SL_SrcType_s_0,gSourceList_SourceType_s[gSourceList_SourceType[Element_1]]);
                else if(gSourceList_SourceType[Element_1] ==AUDIO_SOURCELIST_ST_UNKNOWN)
                    putvalue(env_ASG_AudioSD_SL_SrcType_s_0,gstring_unknown);
                else
                    putvalue(env_ASG_AudioSD_SL_SrcType_s_0,gstring_reserved);
            }

            //InstanceID
            if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_SL_IID_0,gSourceList_InstanceID[Element_1]);
            
            //MediaType
            if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1 || gSourceList_recordaddress ==4) 
            {
                putvalue(env_ASG_AudioSD_SL_MedType_0, gSourceList_MediaType[Element_1]);

                if(gSourceList_MediaType[Element_1] <0x0E)
                    putvalue(env_ASG_AudioSD_SL_MedType_s_0,gSourceList_MediaType_s[gSourceList_MediaType[Element_1]]);
                else if(gSourceList_MediaType[Element_1] ==AUDIO_SOURCELIST_MT_UNKNOWN)
                    putvalue(env_ASG_AudioSD_SL_MedType_s_0,gstring_unknown);
                else
                    putvalue(env_ASG_AudioSD_SL_MedType_s_0,gstring_reserved);
            }

            //Attributes
            if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1|| gSourceList_recordaddress ==3) 
            {
                putvalue(env_ASG_AudioSD_SL_Attr_bit0_0, gSourceList_Attributes_BuiltIn_Bit0[Element_1]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit0_0,gSourceList_Attributes_BuiltIn_Bit0_s[gSourceList_Attributes_BuiltIn_Bit0[Element_1]]);

                putvalue(env_ASG_AudioSD_SL_Attr_bit1_0, gSourceList_Attributes_MediaError_Bit1[Element_1]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit1_0,gSourceList_Attributes_MediaError_Bit1_s[gSourceList_Attributes_MediaError_Bit1[Element_1]]);

                putvalue(env_ASG_AudioSD_SL_Attr_bit2_0, gSourceList_Attributes_MediaPlay_Bit2[Element_1]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit2_0,gSourceList_Attributes_MediaPlay_Bit2_s[gSourceList_Attributes_MediaPlay_Bit2[Element_1]]);

                putvalue(env_ASG_AudioSD_SL_Attr_bit3_0, gSourceList_Attributes_MediaRead_Bit3[Element_1]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit3_0,gSourceList_Attributes_MediaRead_Bit3_s[gSourceList_Attributes_MediaRead_Bit3[Element_1]]);

                putvalue(env_ASG_AudioSD_SL_Attr_bit4_0, gSourceList_Attributes_MediaLoad_Bit4[Element_1]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit4_0,gSourceList_Attributes_MediaLoad_Bit4_s[gSourceList_Attributes_MediaLoad_Bit4[Element_1]]);

                putvalue(env_ASG_AudioSD_SL_Attr_bit5_0, gSourceList_Attributes_ImportRun_Bit5[Element_1]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit5_0,gSourceList_Attributes_ImportRun_Bit5_s[gSourceList_Attributes_ImportRun_Bit5[Element_1]]);

                putvalue(env_ASG_AudioSD_SL_Attr_bit6_0, gSourceList_Attributes_MediaSupp_Bit6[Element_1]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit6_0,gSourceList_Attributes_MediaSupp_Bit6_s[gSourceList_Attributes_MediaSupp_Bit6[Element_1]]);
            }

            //Name
            if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_SL_Name_s_0,gSourceList_Name[Element_1]);

            gSourceList_LastFirstElement =Element_1;
            
            
            //2. Element             
            Element_2 =SourceList_GetNextCachedElement(Element_1, AUDIO_SOURCELIST_DISPLAYLIST_FIND_NEXT_ELEMENT);
            
            //Pos
            putvalue(env_ASG_AudioSD_SL_pos_1, gSourceList_Pos[Element_2]);               
            
            //SourceType
            if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_SL_SrcType_1, gSourceList_SourceType[Element_2]);

                if(gSourceList_SourceType[Element_2] <0x2E)
                    putvalue(env_ASG_AudioSD_SL_SrcType_s_1,gSourceList_SourceType_s[gSourceList_SourceType[Element_2]]);
                else if(gSourceList_SourceType[Element_2] ==AUDIO_SOURCELIST_ST_UNKNOWN)
                    putvalue(env_ASG_AudioSD_SL_SrcType_s_1,gstring_unknown);
                else
                    putvalue(env_ASG_AudioSD_SL_SrcType_s_1,gstring_reserved);
            }

            //InstanceID
            if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_SL_IID_1,gSourceList_InstanceID[Element_2]);
            
            //MediaType
            if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1 || gSourceList_recordaddress ==4) 
            {
                putvalue(env_ASG_AudioSD_SL_MedType_1, gSourceList_MediaType[Element_2]);

                if(gSourceList_MediaType[Element_2] <0x0E)
                    putvalue(env_ASG_AudioSD_SL_MedType_s_1,gSourceList_MediaType_s[gSourceList_MediaType[Element_2]]);
                else if(gSourceList_MediaType[Element_2] ==AUDIO_SOURCELIST_MT_UNKNOWN)
                    putvalue(env_ASG_AudioSD_SL_MedType_s_1,gstring_unknown);
                else
                    putvalue(env_ASG_AudioSD_SL_MedType_s_1,gstring_reserved);
            }

            //Attributes
            if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1|| gSourceList_recordaddress ==3) 
            {
                putvalue(env_ASG_AudioSD_SL_Attr_bit0_1, gSourceList_Attributes_BuiltIn_Bit0[Element_2]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit0_1,gSourceList_Attributes_BuiltIn_Bit0_s[gSourceList_Attributes_BuiltIn_Bit0[Element_2]]);

                putvalue(env_ASG_AudioSD_SL_Attr_bit1_1, gSourceList_Attributes_MediaError_Bit1[Element_2]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit1_1,gSourceList_Attributes_MediaError_Bit1_s[gSourceList_Attributes_MediaError_Bit1[Element_2]]);

                putvalue(env_ASG_AudioSD_SL_Attr_bit2_1, gSourceList_Attributes_MediaPlay_Bit2[Element_2]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit2_1,gSourceList_Attributes_MediaPlay_Bit2_s[gSourceList_Attributes_MediaPlay_Bit2[Element_2]]);

                putvalue(env_ASG_AudioSD_SL_Attr_bit3_1, gSourceList_Attributes_MediaRead_Bit3[Element_2]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit3_1,gSourceList_Attributes_MediaRead_Bit3_s[gSourceList_Attributes_MediaRead_Bit3[Element_2]]);

                putvalue(env_ASG_AudioSD_SL_Attr_bit4_1, gSourceList_Attributes_MediaLoad_Bit4[Element_2]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit4_1,gSourceList_Attributes_MediaLoad_Bit4_s[gSourceList_Attributes_MediaLoad_Bit4[Element_2]]);

                putvalue(env_ASG_AudioSD_SL_Attr_bit5_1, gSourceList_Attributes_ImportRun_Bit5[Element_2]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit5_1,gSourceList_Attributes_ImportRun_Bit5_s[gSourceList_Attributes_ImportRun_Bit5[Element_2]]);

                putvalue(env_ASG_AudioSD_SL_Attr_bit6_1, gSourceList_Attributes_MediaSupp_Bit6[Element_2]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit6_1,gSourceList_Attributes_MediaSupp_Bit6_s[gSourceList_Attributes_MediaSupp_Bit6[Element_2]]);
            }

            //Name
            if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_SL_Name_s_1,gSourceList_Name[Element_2]);
             
            
            //3. Element          
            Element_3 =SourceList_GetNextCachedElement(Element_3, AUDIO_SOURCELIST_DISPLAYLIST_FIND_NEXT_ELEMENT);

            //Pos
            putvalue(env_ASG_AudioSD_SL_pos_2, gSourceList_Pos[Element_3]);               
            
            //SourceType
            if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_SL_SrcType_2, gSourceList_SourceType[Element_3]);

                if(gSourceList_SourceType[Element_3] <0x2E)
                    putvalue(env_ASG_AudioSD_SL_SrcType_s_2,gSourceList_SourceType_s[gSourceList_SourceType[Element_3]]);
                else if(gSourceList_SourceType[Element_3] ==AUDIO_SOURCELIST_ST_UNKNOWN)
                    putvalue(env_ASG_AudioSD_SL_SrcType_s_2,gstring_unknown);
                else
                    putvalue(env_ASG_AudioSD_SL_SrcType_s_2,gstring_reserved);
            }

            //InstanceID
            if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_SL_IID_2,gSourceList_InstanceID[Element_3]);
            
            //MediaType
            if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1 || gSourceList_recordaddress ==4) 
            {
                putvalue(env_ASG_AudioSD_SL_MedType_2, gSourceList_MediaType[Element_3]);

                if(gSourceList_MediaType[Element_3] <0x0E)
                    putvalue(env_ASG_AudioSD_SL_MedType_s_2,gSourceList_MediaType_s[gSourceList_MediaType[Element_3]]);
                else if(gSourceList_MediaType[Element_3] ==AUDIO_SOURCELIST_MT_UNKNOWN)
                    putvalue(env_ASG_AudioSD_SL_MedType_s_2,gstring_unknown);
                else
                    putvalue(env_ASG_AudioSD_SL_MedType_s_2,gstring_reserved);
            }

            //Attributes
            if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1|| gSourceList_recordaddress ==3) 
            {
                putvalue(env_ASG_AudioSD_SL_Attr_bit0_2, gSourceList_Attributes_BuiltIn_Bit0[Element_3]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit0_2,gSourceList_Attributes_BuiltIn_Bit0_s[gSourceList_Attributes_BuiltIn_Bit0[Element_3]]);

                putvalue(env_ASG_AudioSD_SL_Attr_bit1_2, gSourceList_Attributes_MediaError_Bit1[Element_3]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit1_2,gSourceList_Attributes_MediaError_Bit1_s[gSourceList_Attributes_MediaError_Bit1[Element_3]]);

                putvalue(env_ASG_AudioSD_SL_Attr_bit2_2, gSourceList_Attributes_MediaPlay_Bit2[Element_3]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit2_2,gSourceList_Attributes_MediaPlay_Bit2_s[gSourceList_Attributes_MediaPlay_Bit2[Element_3]]);

                putvalue(env_ASG_AudioSD_SL_Attr_bit3_2, gSourceList_Attributes_MediaRead_Bit3[Element_3]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit3_2,gSourceList_Attributes_MediaRead_Bit3_s[gSourceList_Attributes_MediaRead_Bit3[Element_3]]);

                putvalue(env_ASG_AudioSD_SL_Attr_bit4_2, gSourceList_Attributes_MediaLoad_Bit4[Element_3]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit4_2,gSourceList_Attributes_MediaLoad_Bit4_s[gSourceList_Attributes_MediaLoad_Bit4[Element_3]]);

                putvalue(env_ASG_AudioSD_SL_Attr_bit5_2, gSourceList_Attributes_ImportRun_Bit5[Element_3]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit5_2,gSourceList_Attributes_ImportRun_Bit5_s[gSourceList_Attributes_ImportRun_Bit5[Element_3]]);

                putvalue(env_ASG_AudioSD_SL_Attr_bit6_2, gSourceList_Attributes_MediaSupp_Bit6[Element_3]);
                putvalue(env_ASG_AudioSD_SL_Attr_s_bit6_2,gSourceList_Attributes_MediaSupp_Bit6_s[gSourceList_Attributes_MediaSupp_Bit6[Element_3]]);

            }

            //Name
            if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_SL_Name_s_2,gSourceList_Name[Element_3]);         
        }
        
        /******'sliding Window' active or 'build-up List'******/
        else if(gSourceList_DisplayStatus ==AUDIO_SOURCELIST_DISPLAYLIST_FIRST_ELEMENTS) 
        {
            //1. Element    
            if(gSourceList_ListEntryReceptionInformation [0] ==TRUE && getvalue(env_ASG_AudioSD_SL_OnOff))
            {   
                Element_1 =0;
                
                //Pos
                putvalue(env_ASG_AudioSD_SL_pos_0, gSourceList_Pos[Element_1]);               
            
                //SourceType
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_SL_SrcType_0, gSourceList_SourceType[Element_1]);

                    if(gSourceList_SourceType[Element_1] <0x2E)
                        putvalue(env_ASG_AudioSD_SL_SrcType_s_0,gSourceList_SourceType_s[gSourceList_SourceType[Element_1]]);
                    else if(gSourceList_SourceType[Element_1] ==AUDIO_SOURCELIST_ST_UNKNOWN)
                        putvalue(env_ASG_AudioSD_SL_SrcType_s_0,gstring_unknown);
                    else
                        putvalue(env_ASG_AudioSD_SL_SrcType_s_0,gstring_reserved);
                }

                //InstanceID
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_SL_IID_0,gSourceList_InstanceID[Element_1]);
            
                //MediaType
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1 || gSourceList_recordaddress ==4) 
                {
                    putvalue(env_ASG_AudioSD_SL_MedType_0, gSourceList_MediaType[Element_1]);

                    if(gSourceList_MediaType[Element_1] <0x0E)
                        putvalue(env_ASG_AudioSD_SL_MedType_s_0,gSourceList_MediaType_s[gSourceList_MediaType[Element_1]]);
                    else if(gSourceList_MediaType[Element_1] ==AUDIO_SOURCELIST_MT_UNKNOWN)
                        putvalue(env_ASG_AudioSD_SL_MedType_s_0,gstring_unknown);
                    else
                        putvalue(env_ASG_AudioSD_SL_MedType_s_0,gstring_reserved);
                }

                //Attributes
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1|| gSourceList_recordaddress ==3) 
                {
                    putvalue(env_ASG_AudioSD_SL_Attr_bit0_0, gSourceList_Attributes_BuiltIn_Bit0[Element_1]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit0_0,gSourceList_Attributes_BuiltIn_Bit0_s[gSourceList_Attributes_BuiltIn_Bit0[Element_1]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit1_0, gSourceList_Attributes_MediaError_Bit1[Element_1]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit1_0,gSourceList_Attributes_MediaError_Bit1_s[gSourceList_Attributes_MediaError_Bit1[Element_1]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit2_0, gSourceList_Attributes_MediaPlay_Bit2[Element_1]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit2_0,gSourceList_Attributes_MediaPlay_Bit2_s[gSourceList_Attributes_MediaPlay_Bit2[Element_1]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit3_0, gSourceList_Attributes_MediaRead_Bit3[Element_1]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit3_0,gSourceList_Attributes_MediaRead_Bit3_s[gSourceList_Attributes_MediaRead_Bit3[Element_1]]);
    
                    putvalue(env_ASG_AudioSD_SL_Attr_bit4_0, gSourceList_Attributes_MediaLoad_Bit4[Element_1]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit4_0,gSourceList_Attributes_MediaLoad_Bit4_s[gSourceList_Attributes_MediaLoad_Bit4[Element_1]]);
    
                    putvalue(env_ASG_AudioSD_SL_Attr_bit5_0, gSourceList_Attributes_ImportRun_Bit5[Element_1]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit5_0,gSourceList_Attributes_ImportRun_Bit5_s[gSourceList_Attributes_ImportRun_Bit5[Element_1]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit6_0, gSourceList_Attributes_MediaSupp_Bit6[Element_1]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit6_0,gSourceList_Attributes_MediaSupp_Bit6_s[gSourceList_Attributes_MediaSupp_Bit6[Element_1]]);

                }

                //Name
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==2)
                    putvalue(env_ASG_AudioSD_SL_Name_s_0,gSourceList_Name[Element_1]);
            }
            
            //2. Element    
            if(gSourceList_ListEntryReceptionInformation [1] ==TRUE && getvalue(env_ASG_AudioSD_SL_OnOff))
            {
                Element_2 =1;
                
                //Pos
                putvalue(env_ASG_AudioSD_SL_pos_1, gSourceList_Pos[Element_2]);               
            
                //SourceType
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_SL_SrcType_1, gSourceList_SourceType[Element_2]);

                    if(gSourceList_SourceType[Element_2] <0x2E)
                        putvalue(env_ASG_AudioSD_SL_SrcType_s_1,gSourceList_SourceType_s[gSourceList_SourceType[Element_2]]);
                    else if(gSourceList_SourceType[Element_2] ==AUDIO_SOURCELIST_ST_UNKNOWN)
                        putvalue(env_ASG_AudioSD_SL_SrcType_s_1,gstring_unknown);
                    else
                        putvalue(env_ASG_AudioSD_SL_SrcType_s_1,gstring_reserved);
                }

                //InstanceID
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_SL_IID_1,gSourceList_InstanceID[Element_2]);
            
                //MediaType
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1 || gSourceList_recordaddress ==4) 
                {
                    putvalue(env_ASG_AudioSD_SL_MedType_1, gSourceList_MediaType[Element_2]);

                    if(gSourceList_MediaType[Element_2] <0x0E)
                        putvalue(env_ASG_AudioSD_SL_MedType_s_1,gSourceList_MediaType_s[gSourceList_MediaType[Element_2]]);
                    else if(gSourceList_MediaType[Element_2] ==AUDIO_SOURCELIST_MT_UNKNOWN)
                        putvalue(env_ASG_AudioSD_SL_MedType_s_1,gstring_unknown);
                    else
                        putvalue(env_ASG_AudioSD_SL_MedType_s_1,gstring_reserved);
                }

                //Attributes
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1|| gSourceList_recordaddress ==3) 
                {
                    putvalue(env_ASG_AudioSD_SL_Attr_bit0_1, gSourceList_Attributes_BuiltIn_Bit0[Element_2]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit0_1,gSourceList_Attributes_BuiltIn_Bit0_s[gSourceList_Attributes_BuiltIn_Bit0[Element_2]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit1_1, gSourceList_Attributes_MediaError_Bit1[Element_2]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit1_1,gSourceList_Attributes_MediaError_Bit1_s[gSourceList_Attributes_MediaError_Bit1[Element_2]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit2_1, gSourceList_Attributes_MediaPlay_Bit2[Element_2]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit2_1,gSourceList_Attributes_MediaPlay_Bit2_s[gSourceList_Attributes_MediaPlay_Bit2[Element_2]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit3_1, gSourceList_Attributes_MediaRead_Bit3[Element_2]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit3_1,gSourceList_Attributes_MediaRead_Bit3_s[gSourceList_Attributes_MediaRead_Bit3[Element_2]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit4_1, gSourceList_Attributes_MediaLoad_Bit4[Element_2]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit4_1,gSourceList_Attributes_MediaLoad_Bit4_s[gSourceList_Attributes_MediaLoad_Bit4[Element_2]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit5_1, gSourceList_Attributes_ImportRun_Bit5[Element_2]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit5_1,gSourceList_Attributes_ImportRun_Bit5_s[gSourceList_Attributes_ImportRun_Bit5[Element_2]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit6_1, gSourceList_Attributes_MediaSupp_Bit6[Element_2]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit6_1,gSourceList_Attributes_MediaSupp_Bit6_s[gSourceList_Attributes_MediaSupp_Bit6[Element_2]]);

                }

                //Name
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==2)
                    putvalue(env_ASG_AudioSD_SL_Name_s_1,gSourceList_Name[Element_2]);
            }

            //3. Element    
            if(gSourceList_ListEntryReceptionInformation [2] ==TRUE && getvalue(env_ASG_AudioSD_SL_OnOff))
            {
                Element_3 =2;
             
                //Pos
                putvalue(env_ASG_AudioSD_SL_pos_2, gSourceList_Pos[Element_3]);               
            
                //SourceType
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_SL_SrcType_2, gSourceList_SourceType[Element_3]);

                    if(gSourceList_SourceType[Element_3] <0x2E)
                        putvalue(env_ASG_AudioSD_SL_SrcType_s_2,gSourceList_SourceType_s[gSourceList_SourceType[Element_3]]);
                    else if(gSourceList_SourceType[Element_3] ==AUDIO_SOURCELIST_ST_UNKNOWN)
                        putvalue(env_ASG_AudioSD_SL_SrcType_s_2,gstring_unknown);
                    else
                        putvalue(env_ASG_AudioSD_SL_SrcType_s_2,gstring_reserved);
                }

                //InstanceID
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_SL_IID_2,gSourceList_InstanceID[Element_3]);
            
                //MediaType
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1 || gSourceList_recordaddress ==4) 
                {
                    putvalue(env_ASG_AudioSD_SL_MedType_2, gSourceList_MediaType[Element_3]);

                    if(gSourceList_MediaType[Element_3] <0x0E)
                        putvalue(env_ASG_AudioSD_SL_MedType_s_2,gSourceList_MediaType_s[gSourceList_MediaType[Element_3]]);
                    else if(gSourceList_MediaType[Element_3] ==AUDIO_SOURCELIST_MT_UNKNOWN)
                        putvalue(env_ASG_AudioSD_SL_MedType_s_2,gstring_unknown);
                    else
                        putvalue(env_ASG_AudioSD_SL_MedType_s_2,gstring_reserved);
                }

                //Attributes
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1|| gSourceList_recordaddress ==3) 
                {
                    putvalue(env_ASG_AudioSD_SL_Attr_bit0_2, gSourceList_Attributes_BuiltIn_Bit0[Element_3]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit0_2,gSourceList_Attributes_BuiltIn_Bit0_s[gSourceList_Attributes_BuiltIn_Bit0[Element_3]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit1_2, gSourceList_Attributes_MediaError_Bit1[Element_3]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit1_2,gSourceList_Attributes_MediaError_Bit1_s[gSourceList_Attributes_MediaError_Bit1[Element_3]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit2_2, gSourceList_Attributes_MediaPlay_Bit2[Element_3]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit2_2,gSourceList_Attributes_MediaPlay_Bit2_s[gSourceList_Attributes_MediaPlay_Bit2[Element_3]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit3_2, gSourceList_Attributes_MediaRead_Bit3[Element_3]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit3_2,gSourceList_Attributes_MediaRead_Bit3_s[gSourceList_Attributes_MediaRead_Bit3[Element_3]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit4_2, gSourceList_Attributes_MediaLoad_Bit4[Element_3]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit4_2,gSourceList_Attributes_MediaLoad_Bit4_s[gSourceList_Attributes_MediaLoad_Bit4[Element_3]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit5_2, gSourceList_Attributes_ImportRun_Bit5[Element_3]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit5_2,gSourceList_Attributes_ImportRun_Bit5_s[gSourceList_Attributes_ImportRun_Bit5[Element_3]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit6_2, gSourceList_Attributes_MediaSupp_Bit6[Element_3]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit6_2,gSourceList_Attributes_MediaSupp_Bit6_s[gSourceList_Attributes_MediaSupp_Bit6[Element_3]]);

                }

                //Name
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==2)
                    putvalue(env_ASG_AudioSD_SL_Name_s_2,gSourceList_Name[Element_3]);
            }
        }    
            
        else if (gSourceList_DisplayStatus ==AUDIO_SOURCELIST_DISPLAYLIST_REFRESH)
        {          
            //1. Element
            if(gSourceList_SlidingWindow_State ==AUDIO_SOURCELIST_SLIDINGWINDOW_NOTACTIVE)
                Element_1 =gSourceList_LastFirstElement; 
            else
                Element_1 =0;

            if(gSourceList_ListEntryReceptionInformation[Element_1])
            {
                //Pos
                putvalue(env_ASG_AudioSD_SL_pos_0, gSourceList_Pos[Element_1]);               
            
                //SourceType
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_SL_SrcType_0, gSourceList_SourceType[Element_1]);

                    if(gSourceList_SourceType[Element_1] <0x2E)
                        putvalue(env_ASG_AudioSD_SL_SrcType_s_0,gSourceList_SourceType_s[gSourceList_SourceType[Element_1]]);
                    else if(gSourceList_SourceType[Element_1] ==AUDIO_SOURCELIST_ST_UNKNOWN)
                        putvalue(env_ASG_AudioSD_SL_SrcType_s_0,gstring_unknown);
                    else
                        putvalue(env_ASG_AudioSD_SL_SrcType_s_0,gstring_reserved);
                }

                //InstanceID
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_SL_IID_0,gSourceList_InstanceID[Element_1]);
            
                //MediaType
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1 || gSourceList_recordaddress ==4) 
                {
                    putvalue(env_ASG_AudioSD_SL_MedType_0, gSourceList_MediaType[Element_1]);

                    if(gSourceList_MediaType[Element_1] <0x0E)
                        putvalue(env_ASG_AudioSD_SL_MedType_s_0,gSourceList_MediaType_s[gSourceList_MediaType[Element_1]]);
                    else if(gSourceList_MediaType[Element_1] ==AUDIO_SOURCELIST_MT_UNKNOWN)
                        putvalue(env_ASG_AudioSD_SL_MedType_s_0,gstring_unknown);
                    else
                        putvalue(env_ASG_AudioSD_SL_MedType_s_0,gstring_reserved);
                }

                //Attributes
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1|| gSourceList_recordaddress ==3) 
                {
                    putvalue(env_ASG_AudioSD_SL_Attr_bit0_0, gSourceList_Attributes_BuiltIn_Bit0[Element_1]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit0_0,gSourceList_Attributes_BuiltIn_Bit0_s[gSourceList_Attributes_BuiltIn_Bit0[Element_1]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit1_0, gSourceList_Attributes_MediaError_Bit1[Element_1]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit1_0,gSourceList_Attributes_MediaError_Bit1_s[gSourceList_Attributes_MediaError_Bit1[Element_1]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit2_0, gSourceList_Attributes_MediaPlay_Bit2[Element_1]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit2_0,gSourceList_Attributes_MediaPlay_Bit2_s[gSourceList_Attributes_MediaPlay_Bit2[Element_1]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit3_0, gSourceList_Attributes_MediaRead_Bit3[Element_1]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit3_0,gSourceList_Attributes_MediaRead_Bit3_s[gSourceList_Attributes_MediaRead_Bit3[Element_1]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit4_0, gSourceList_Attributes_MediaLoad_Bit4[Element_1]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit4_0,gSourceList_Attributes_MediaLoad_Bit4_s[gSourceList_Attributes_MediaLoad_Bit4[Element_1]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit5_0, gSourceList_Attributes_ImportRun_Bit5[Element_1]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit5_0,gSourceList_Attributes_ImportRun_Bit5_s[gSourceList_Attributes_ImportRun_Bit5[Element_1]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit6_0, gSourceList_Attributes_MediaSupp_Bit6[Element_1]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit6_0,gSourceList_Attributes_MediaSupp_Bit6_s[gSourceList_Attributes_MediaSupp_Bit6[Element_1]]);

                }

                //Name
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==2)
                    putvalue(env_ASG_AudioSD_SL_Name_s_0,gSourceList_Name[Element_1]);
            }//END: Element_1
                

            //2. Element             
            if(gSourceList_SlidingWindow_State ==AUDIO_SOURCELIST_SLIDINGWINDOW_NOTACTIVE)
                Element_2 =SourceList_GetNextCachedElement(Element_1, AUDIO_SOURCELIST_DISPLAYLIST_FIND_NEXT_ELEMENT);
            else
                Element_2 =1;

            if(gSourceList_ListEntryReceptionInformation[Element_2])
            {
                //Pos
                putvalue(env_ASG_AudioSD_SL_pos_1, gSourceList_Pos[Element_2]);               
            
                //SourceType
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_SL_SrcType_1, gSourceList_SourceType[Element_2]);

                    if(gSourceList_SourceType[Element_2] <0x2E)
                        putvalue(env_ASG_AudioSD_SL_SrcType_s_1,gSourceList_SourceType_s[gSourceList_SourceType[Element_2]]);
                    else if(gSourceList_SourceType[Element_2] ==AUDIO_SOURCELIST_ST_UNKNOWN)
                        putvalue(env_ASG_AudioSD_SL_SrcType_s_1,gstring_unknown);
                    else
                        putvalue(env_ASG_AudioSD_SL_SrcType_s_1,gstring_reserved);
                }

                //InstanceID
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_SL_IID_1,gSourceList_InstanceID[Element_2]);
            
                //MediaType
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1 || gSourceList_recordaddress ==4) 
                {
                    putvalue(env_ASG_AudioSD_SL_MedType_1, gSourceList_MediaType[Element_2]);

                    if(gSourceList_MediaType[Element_2] <0x0E)
                        putvalue(env_ASG_AudioSD_SL_MedType_s_1,gSourceList_MediaType_s[gSourceList_MediaType[Element_2]]);
                    else if(gSourceList_MediaType[Element_2] ==AUDIO_SOURCELIST_MT_UNKNOWN)
                        putvalue(env_ASG_AudioSD_SL_MedType_s_1,gstring_unknown);
                    else
                        putvalue(env_ASG_AudioSD_SL_MedType_s_1,gstring_reserved);
                }

                //Attributes
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1|| gSourceList_recordaddress ==3) 
                {
                    putvalue(env_ASG_AudioSD_SL_Attr_bit0_1, gSourceList_Attributes_BuiltIn_Bit0[Element_2]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit0_1,gSourceList_Attributes_BuiltIn_Bit0_s[gSourceList_Attributes_BuiltIn_Bit0[Element_2]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit1_1, gSourceList_Attributes_MediaError_Bit1[Element_2]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit1_1,gSourceList_Attributes_MediaError_Bit1_s[gSourceList_Attributes_MediaError_Bit1[Element_2]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit2_1, gSourceList_Attributes_MediaPlay_Bit2[Element_2]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit2_1,gSourceList_Attributes_MediaPlay_Bit2_s[gSourceList_Attributes_MediaPlay_Bit2[Element_2]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit3_1, gSourceList_Attributes_MediaRead_Bit3[Element_2]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit3_1,gSourceList_Attributes_MediaRead_Bit3_s[gSourceList_Attributes_MediaRead_Bit3[Element_2]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit4_1, gSourceList_Attributes_MediaLoad_Bit4[Element_2]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit4_1,gSourceList_Attributes_MediaLoad_Bit4_s[gSourceList_Attributes_MediaLoad_Bit4[Element_2]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit5_1, gSourceList_Attributes_ImportRun_Bit5[Element_2]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit5_1,gSourceList_Attributes_ImportRun_Bit5_s[gSourceList_Attributes_ImportRun_Bit5[Element_2]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit6_1, gSourceList_Attributes_MediaSupp_Bit6[Element_2]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit6_1,gSourceList_Attributes_MediaSupp_Bit6_s[gSourceList_Attributes_MediaSupp_Bit6[Element_2]]);

                }

                //Name
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==2)
                    putvalue(env_ASG_AudioSD_SL_Name_s_1,gSourceList_Name[Element_2]);
            
            }//END: Element_2

            //3. Element          
            if(gSourceList_SlidingWindow_State ==AUDIO_SOURCELIST_SLIDINGWINDOW_NOTACTIVE)
                Element_3 =SourceList_GetNextCachedElement(Element_2, AUDIO_SOURCELIST_DISPLAYLIST_FIND_NEXT_ELEMENT);
            else
                Element_3 =2;

            if(gSourceList_ListEntryReceptionInformation[Element_3])
            {    
                //Pos
                putvalue(env_ASG_AudioSD_SL_pos_2, gSourceList_Pos[Element_3]);               
            
                //SourceType
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_SL_SrcType_2, gSourceList_SourceType[Element_3]);

                    if(gSourceList_SourceType[Element_3] <0x2E)
                        putvalue(env_ASG_AudioSD_SL_SrcType_s_2,gSourceList_SourceType_s[gSourceList_SourceType[Element_3]]);
                    else if(gSourceList_SourceType[Element_3] ==AUDIO_SOURCELIST_ST_UNKNOWN)
                        putvalue(env_ASG_AudioSD_SL_SrcType_s_2,gstring_unknown);
                    else
                        putvalue(env_ASG_AudioSD_SL_SrcType_s_2,gstring_reserved);
                }

                //InstanceID
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1)
                    putvalue(env_ASG_AudioSD_SL_IID_2,gSourceList_InstanceID[Element_3]);
            
                //MediaType                                               
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1 || gSourceList_recordaddress ==4) 
                {
                    putvalue(env_ASG_AudioSD_SL_MedType_2, gSourceList_MediaType[Element_3]);

                    if(gSourceList_MediaType[Element_3] <0x0E)
                        putvalue(env_ASG_AudioSD_SL_MedType_s_2,gSourceList_MediaType_s[gSourceList_MediaType[Element_3]]);
                    else if(gSourceList_MediaType[Element_3] ==AUDIO_SOURCELIST_MT_UNKNOWN)
                        putvalue(env_ASG_AudioSD_SL_MedType_s_2,gstring_unknown);
                    else
                        putvalue(env_ASG_AudioSD_SL_MedType_s_2,gstring_reserved);
                }

                //Attributes
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==1|| gSourceList_recordaddress ==3) 
                {
                    putvalue(env_ASG_AudioSD_SL_Attr_bit0_2, gSourceList_Attributes_BuiltIn_Bit0[Element_3]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit0_2,gSourceList_Attributes_BuiltIn_Bit0_s[gSourceList_Attributes_BuiltIn_Bit0[Element_3]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit1_2, gSourceList_Attributes_MediaError_Bit1[Element_3]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit1_2,gSourceList_Attributes_MediaError_Bit1_s[gSourceList_Attributes_MediaError_Bit1[Element_3]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit2_2, gSourceList_Attributes_MediaPlay_Bit2[Element_3]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit2_2,gSourceList_Attributes_MediaPlay_Bit2_s[gSourceList_Attributes_MediaPlay_Bit2[Element_3]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit3_2, gSourceList_Attributes_MediaRead_Bit3[Element_3]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit3_2,gSourceList_Attributes_MediaRead_Bit3_s[gSourceList_Attributes_MediaRead_Bit3[Element_3]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit4_2, gSourceList_Attributes_MediaLoad_Bit4[Element_3]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit4_2,gSourceList_Attributes_MediaLoad_Bit4_s[gSourceList_Attributes_MediaLoad_Bit4[Element_3]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit5_2, gSourceList_Attributes_ImportRun_Bit5[Element_3]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit5_2,gSourceList_Attributes_ImportRun_Bit5_s[gSourceList_Attributes_ImportRun_Bit5[Element_3]]);

                    putvalue(env_ASG_AudioSD_SL_Attr_bit6_2, gSourceList_Attributes_MediaSupp_Bit6[Element_3]);
                    putvalue(env_ASG_AudioSD_SL_Attr_s_bit6_2,gSourceList_Attributes_MediaSupp_Bit6_s[gSourceList_Attributes_MediaSupp_Bit6[Element_3]]);

                }

                //Name
                if (gSourceList_recordaddress ==0 || gSourceList_recordaddress ==2)
                    putvalue(env_ASG_AudioSD_SL_Name_s_2,gSourceList_Name[Element_3]);     
            }
        }
    }
}

on envVar env_ASG_AudioSD_SL_down
{
    int i=0, j=0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gSourceList_ListHandlingType ==AUDIO_SOURCELIST_NOCACHE)
	{      
        gSourceList_CursorAction =AUDIO_SOURCELIST_CURSORACTION_DOWN;
        
        if(gSourceList_SlidingWindow_State ==AUDIO_SOURCELIST_SLIDINGWINDOW_ACTIVE)
        {   
            gSourceList_ListHandlingType  =AUDIO_SOURCELIST_DOWN_CACHE;
            gSourceList_DisplayStatus     =AUDIO_SOURCELIST_DISPLAYLIST_FIRST_ELEMENTS;
            gSourceList_CursorAction      =AUDIO_SOURCELIST_CURSORACTION_NOTHING;
            
            SourceList_ListHandling ();
        }
        else if(gSourceList_SlidingWindow_State ==AUDIO_SOURCELIST_SLIDINGWINDOW_NOTACTIVE)
        {
            gSourceList_DisplayStatus     =AUDIO_SOURCELIST_DISPLAYLIST_SEARCH_ELEMENTS;
            gSourceList_CursorAction      =AUDIO_SOURCELIST_CURSORACTION_DOWN;

            SourceList_display();

            //reset values
            gSourceList_DisplayStatus     =AUDIO_SOURCELIST_DISPLAYLIST_REFRESH;
            gSourceList_CursorAction      =AUDIO_SOURCELIST_CURSORACTION_NOTHING;
        }
    }
}

on envVar env_ASG_AudioSD_SL_up
{
    int i=0, j=0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gSourceList_ListHandlingType ==AUDIO_SOURCELIST_NOCACHE)
	{   
        gSourceList_CursorAction =AUDIO_SOURCELIST_CURSORACTION_UP;

        if(gSourceList_SlidingWindow_State ==AUDIO_SOURCELIST_SLIDINGWINDOW_ACTIVE)
        {  
            gSourceList_ListHandlingType  =AUDIO_SOURCELIST_UP_CACHE;
            gSourceList_DisplayStatus     =AUDIO_SOURCELIST_DISPLAYLIST_FIRST_ELEMENTS;
            gSourceList_CursorAction      =AUDIO_SOURCELIST_CURSORACTION_NOTHING;
            
            SourceList_ListHandling ();
        }
        else if(gSourceList_SlidingWindow_State ==AUDIO_SOURCELIST_SLIDINGWINDOW_NOTACTIVE)
        {
            gSourceList_DisplayStatus     =AUDIO_SOURCELIST_DISPLAYLIST_SEARCH_ELEMENTS;
            gSourceList_CursorAction      =AUDIO_SOURCELIST_CURSORACTION_UP;

            SourceList_ListHandling();
            
            SourceList_display();

            //reset values
            gSourceList_DisplayStatus     =AUDIO_SOURCELIST_DISPLAYLIST_REFRESH;
            gSourceList_CursorAction      =AUDIO_SOURCELIST_CURSORACTION_NOTHING;
        }    
    }
}

on envVar env_ASG_AudioSD_SL_GetArray
{
    byte mode, shift, direction, transmitpos, indexsize,recordaddress;
    word requested_startelement, startelement, elements;

    // Init local variables. 
    mode                    =0;
    shift                   =0;
    direction               =0;
    transmitpos             =0;
    indexsize               =0;
    recordaddress           =0;
    requested_startelement  =0;
    startelement            =0;
    elements                =0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gSourceList_ListHandlingType ==AUDIO_SOURCELIST_NOCACHE)
	{
        gSourceList_ASGID            =getvalue(env_ASG_AudioSD_SL_ASGID);
        gSourceList_TAID             =getvalue(env_ASG_AudioSD_SL_TAID);

        shift                           =getvalue(env_ASG_AudioSD_SL_AH_shift);
        direction                       =getvalue(env_ASG_AudioSD_SL_AH_dir);
        transmitpos                     =getvalue(env_ASG_AudioSD_SL_AH_PosTrans);
        indexsize                       =getvalue(env_ASG_AudioSD_SL_AH_IS);
        recordaddress                   =getvalue(env_ASG_AudioSD_SL_AH_RA);
        startelement                    =getvalue(env_ASG_AudioSD_SL_AH_start);
        elements                        =getvalue(env_ASG_AudioSD_SL_AH_elements);
        
        requested_startelement  =startelement;
        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

        SourceList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
    }
}

int RadioTVPresetList_GetNextCachedElement (int currentElement,byte direction)
{
    int i=0, nextElement=0;

    switch (direction)
    {
        case AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_FIND_NEXT_ELEMENT:                
                nextElement = ++currentElement;

                if (nextElement<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE) //start at next element, if next element is not >8
                {
                    for(i =nextElement; i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i= AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;
                        }
                        else
                            nextElement =0;
                    }
                }
                else    //start at first element
                {
                    nextElement =0;

                    for(i =nextElement; i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;
                        }   
                    }
                }
        break;

        case AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_FIND_PREVIUOS_ELEMENT:
                nextElement = --currentElement;
                if (nextElement ==0 && gRadioTVPresetList_ListEntryReceptionInformation[nextElement] ==TRUE)
                    nextElement =0;
                else if (nextElement>0) 
                {
                    for(i =nextElement; i>0; i--)
                    {
                        if(gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =0;
                        }
                        else
                            nextElement =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE-1;
                    }
                }    
                else    //start at last element
                {
                    nextElement =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE-1;

                    for(i =nextElement; i>0; i--)
                    {
                        if(gRadioTVPresetList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =0;
                        }
                        else if(gRadioTVPresetList_ListEntryReceptionInformation[0] ==TRUE)
                            nextElement =0;          
                    }
                }
        break;

        default:
        break;
    }
    return(nextElement);
}

int RadioTVPresetList_GetNextLineInCache (int currentElement,byte direction)
{
    int i=0, nextElement=0;

    switch (direction)
    {
        case FORWARD:
                           
                if(currentElement<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE-1 && currentElement !=5) 
                    nextElement = ++currentElement;  
                
                else if (currentElement ==8)            
                    nextElement =0;
                else
                    nextElement =AUDIO_RADIOTVPRESETLIST_NO_NEXT_POSITION;
        break;

        case BACKWARD:
                if(currentElement<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE && currentElement !=0 && currentElement !=6) 
                    nextElement =--currentElement;
                
                else if (currentElement ==0)            
                    nextElement =8;
                
                else
                    nextElement =AUDIO_RADIOTVPRESETLIST_NO_NEXT_POSITION;
        break;

        default:
        break;
    }
    return(nextElement);
}

RadioTVPresetList_ListHandling () //for sliding window concept, list handling and 'build-up' list...
{
    byte mode, shift, direction, transmitpos, indexsize, recordaddress, buffer_PresetIndex, buffer_Waveband, buffer_Attributes_bit0, buffer_Attributes_bit1, buffer_Attributes_bit2, buffer_Attributes_bit5, buffer_Attributes_bit6, buffer_Attributes_bit7, buffer_ReceptionInformation;
    byte buffer_Attributes_bit3, buffer_Attributes_bit4, buffer_Attributes_bit8, buffer_Attributes_bit9, buffer_Attributes_bitA;
    word requested_startelement, startelement, elements, buffer_Pos, buffer_Attributes;
    char buffer_Name[AUDIO_RADIOTVPRESETLIST_NAME_LENGTH];
    int i,j,k;

    // Init local variables. 
    mode                        =0;
    shift                       =0;
    direction                   =0;
    transmitpos                 =0;
    indexsize                   =0;
    recordaddress               =0;
    requested_startelement      =0;
    startelement                =0;
    elements                    =0;
    i                           =0;
    j                           =0;
    k                           =0;
    buffer_Pos                  =0;
    buffer_PresetIndex          =0;
    buffer_Waveband             =0;
    buffer_ReceptionInformation =0;
    buffer_Attributes           =0;
    buffer_Attributes_bit0      =0;
    buffer_Attributes_bit1      =0;
    buffer_Attributes_bit2      =0;
    buffer_Attributes_bit3      =0;
    buffer_Attributes_bit4      =0;
    buffer_Attributes_bit5      =0;
    buffer_Attributes_bit6      =0;
    buffer_Attributes_bit7      =0;
    buffer_Attributes_bit8      =0;
    buffer_Attributes_bit9      =0;
    buffer_Attributes_bitA      =0;
    
    /***build-up complete cache***/

    switch (gRadioTVPresetList_ListHandlingType)
    {
        case AUDIO_RADIOTVPRESETLIST_BUILDUPCACHE:
             
            switch (gRadioTVPresetList_cacheBuildUp)
            {   
                //cache-up  
                case AUDIO_RADIOTVPRESETLIST_BUILDUPCACHECACHE_UP:  
                    if(gRadioTVPresetList_CallBackReason !=AUDIO_RADIOTVPRESETLIST_BUILDUPCACHENOCACHE && gRadioTVPresetList_CallBackReason !=AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_CACHENEXT)
                    {
                        switch (gRadioTVPresetList_CallBackReason)
                        {
                            case AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_CHECKCACHE:

                                    if(gRadioTVPresetList_ListEntryReceptionInformation[2] ==TRUE) //cache-down required?
                                    {            
                                        gRadioTVPresetList_cacheBuildUp      =AUDIO_RADIOTVPRESETLIST_BUILDUPCACHECACHE_DOWN;      //next step: build-up upper cache
                                        gRadioTVPresetList_CallBackReason    =AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_CACHENEXT;    
                                        
                                        
                                        RadioTVPresetList_ListHandling ();
                                    }
                                    else //stop caching
                                    {   
                                        gRadioTVPresetList_cacheBuildUp      =AUDIO_RADIOTVPRESETLIST_BUILDUPCACHENOCACHE;  //"build-up cache" finished
                                        gRadioTVPresetList_ListHandlingType  =AUDIO_RADIOTVPRESETLIST_NOCACHE;              
                                        gRadioTVPresetList_CallBackReason    =AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_NOCALLBACK; 
                                        gRadioTVPresetList_CursorAction      =AUDIO_RADIOTVPRESETLIST_CURSORACTION_NOTHING;
                                        
                                        putvalue(env_ASG_AudioSD_RTPL_ListOpState, empty_string);
                                        RadioTVPresetList_display();
                                    }
                            break;
                        }
                    }
                    else
                    {   
                        shift               =TRUE;
                        direction           =BACKWARD;
                        transmitpos         =FALSE;
                        indexsize           =FALSE;
                        recordaddress       =0;
                        startelement        =0;
                        elements            =3;
                
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gRadioTVPresetList_CallBackReason  =AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_CHECKCACHE;

                        RadioTVPresetList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;
                
                //cache "window"
                case AUDIO_RADIOTVPRESETLIST_BUILDUPCACHECACHE_WINDOW: 
                    if(gRadioTVPresetList_CallBackReason !=AUDIO_RADIOTVPRESETLIST_BUILDUPCACHENOCACHE && gRadioTVPresetList_CallBackReason !=AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_CACHENEXT)
                    {   
                        switch (gRadioTVPresetList_CallBackReason)
                        {
                            case AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_CHECKCACHE:
                                                 
                                    gRadioTVPresetList_cacheBuildUp      =AUDIO_RADIOTVPRESETLIST_BUILDUPCACHECACHE_UP;      //next step: build-up upper cache
                                    gRadioTVPresetList_CallBackReason    =AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_CACHENEXT;    
                                    
                                    RadioTVPresetList_ListHandling ();
                            break;
                        }
                    }
                    else
                    { 
                        putvalue(env_ASG_AudioSD_RTPL_ListOpState, "build-up list...");
                        shift               =FALSE;
                        direction           =FORWARD;
                        transmitpos         =FALSE;
                        indexsize           =FALSE;
                        recordaddress       =0;
                        startelement        =0;
                        elements            =3; 
    
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gRadioTVPresetList_CallBackReason  =AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_CHECKCACHE;

                        RadioTVPresetList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;
                
                //cache-down
                case AUDIO_RADIOTVPRESETLIST_BUILDUPCACHECACHE_DOWN:
                    if(gRadioTVPresetList_CallBackReason !=AUDIO_RADIOTVPRESETLIST_BUILDUPCACHENOCACHE && gRadioTVPresetList_CallBackReason !=AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_CACHENEXT)
                    {
                        switch (gRadioTVPresetList_CallBackReason)
                        {
                            case AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_CHECKCACHE:
                                    
                                    //stop caching
                                    gRadioTVPresetList_cacheBuildUp      =AUDIO_RADIOTVPRESETLIST_BUILDUPCACHENOCACHE;  //"build-up cache" finished
                                    gRadioTVPresetList_ListHandlingType  =AUDIO_RADIOTVPRESETLIST_NOCACHE;              
                                    gRadioTVPresetList_CallBackReason    =AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_NOCALLBACK;
                                    gRadioTVPresetList_CursorAction      =AUDIO_RADIOTVPRESETLIST_CURSORACTION_NOTHING;
                                    
                                    gRadioTVPresetList_DisplayStatus     =AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_REFRESH;
                                    
                                    putvalue(env_ASG_AudioSD_RTPL_ListOpState, empty_string);
                                    
                                    RadioTVPresetList_display();
                            break;
                        }
                    }
                    else
                    { 
                        shift                   =TRUE;
                        direction               =FORWARD;
                        transmitpos             =FALSE;
                        indexsize               =FALSE;
                        recordaddress           =0;
                        for(i=0;i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; i++) //find last cached element
                        {   
                            if(gRadioTVPresetList_ListEntryReceptionInformation[i] ==FALSE) //abort loop
                                i =AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; 
                            else
                                startelement    =gRadioTVPresetList_Pos[i];
                        }
                        elements                =3;                         
        
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gRadioTVPresetList_CallBackReason    =AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_CHECKCACHE;
                        
                        RadioTVPresetList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;

                default:
                break;
            }//build-up cache finished
        break;
        
        /********sliding-window********/
        case AUDIO_RADIOTVPRESETLIST_DOWN_CACHE: 
                    if (gRadioTVPresetList_CallBackReason ==AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_CHECKCACHE) //check if valid data received
                    {   
                        if(gRadioTVPresetList_ListEntryReceptionInformation[5] ==0) //No valid data in last list pos -> last list element reached, start with element 0!  
                        {    
                            shift                   =FALSE;
                            direction               =FORWARD;
                            transmitpos             =FALSE;
                            indexsize               =FALSE;
                            recordaddress           =0;
                            startelement            =0; //first element
                            elements                =1;        
                            
                            requested_startelement  =startelement;
                            mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;
                            
                            gRadioTVPresetList_CallBackReason    =AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_DISPLAYLIST; 
                            gRadioTVPresetList_cacheDown         =TRUE;

                            RadioTVPresetList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);    
                        }
                        else
                        {
                            gRadioTVPresetList_CallBackReason =AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_DISPLAYLIST;
                            RadioTVPresetList_ListHandling(); 
                        }    
                    }
                    else if (gRadioTVPresetList_CallBackReason ==AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_DISPLAYLIST)
                    {   
                        gRadioTVPresetList_ListHandlingType  =AUDIO_RADIOTVPRESETLIST_NOCACHE;
                        gRadioTVPresetList_cacheDown         =FALSE;
                        gRadioTVPresetList_DisplayStatus     =AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_FIRST_ELEMENTS;
                        
                        putvalue(env_ASG_AudioSD_RTPL_ListOpState, empty_string);
                        RadioTVPresetList_display();
                        gRadioTVPresetList_DisplayStatus     =AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_REFRESH;
                        gRadioTVPresetList_CallBackReason    =AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_NOCALLBACK;
                    }
                    else
                    {   
                        putvalue(env_ASG_AudioSD_RTPL_ListOpState, "list operating...");
                                
                        shift                   =TRUE;
                        direction               =FORWARD;
                        transmitpos             =FALSE;
                        indexsize               =FALSE;
                        recordaddress           =0;
                        startelement            =gRadioTVPresetList_Pos[5]; //last element
                        elements                =1;
                        
                        for(i=0;i<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE;i++)
                        {   
                            j =i+1;
                            
                            switch (i)
                            {   
                                case 0: 
                                    //buffer data of Pos '0' (local)
                                    buffer_Pos              =gRadioTVPresetList_Pos[i];
                                    buffer_PresetIndex      =gRadioTVPresetList_PresetIndex[i];
                                    buffer_Waveband         =gRadioTVPresetList_Waveband[i];
                                    buffer_Attributes       =gRadioTVPresetList_Attributes[i];
                                    buffer_Attributes_bit0  =gRadioTVPresetList_Attributes_IBOC_Bit0[i];
                                    buffer_Attributes_bit1  =gRadioTVPresetList_Attributes_DABSecServ_Bit1[i];
                                    buffer_Attributes_bit2  =gRadioTVPresetList_Attributes_DABPrimServ_Bit2[i];
                                    buffer_Attributes_bit5  =gRadioTVPresetList_Attributes_TP_Bit5[i];
                                    buffer_Attributes_bit6  =gRadioTVPresetList_Attributes_TMC_Bit6[i];
                                    buffer_Attributes_bit7  =gRadioTVPresetList_Attributes_SDRAS_Bit7[i];
                                    buffer_Attributes_bit3  =gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[i];
                                    buffer_Attributes_bit4  =gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[i];
                                    buffer_Attributes_bit8  =gRadioTVPresetList_Attributes_StationSelect_Bit8[i];
                                    buffer_Attributes_bit9  =gRadioTVPresetList_Attributes_OnRadMute_Bit9[i];
                                    buffer_Attributes_bitA  =gRadioTVPresetList_Attributes_StationLinked_BitA[i];

                                    for (k=0; k<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;k++) //clear string
                                        buffer_Name[k] =0;                                     

                                    for(k=0;k<strlen(gRadioTVPresetList_Name[i]);k++) 
                                        buffer_Name[k]=gRadioTVPresetList_Name[i][k];

                                    //copy data from Pos '1' to Pos '0'
                                    gRadioTVPresetList_Pos[i]                           =gRadioTVPresetList_Pos[j]; 
                                    gRadioTVPresetList_PresetIndex[i]                   =gRadioTVPresetList_PresetIndex[j];
                                    gRadioTVPresetList_Waveband[i]                      =gRadioTVPresetList_Waveband[j]; 
                                    gRadioTVPresetList_Attributes[i]                    =gRadioTVPresetList_Attributes[j];
                                    gRadioTVPresetList_Attributes_IBOC_Bit0[i]          =gRadioTVPresetList_Attributes_IBOC_Bit0[j];
                                    gRadioTVPresetList_Attributes_DABSecServ_Bit1[i]    =gRadioTVPresetList_Attributes_DABSecServ_Bit1[j];
                                    gRadioTVPresetList_Attributes_DABPrimServ_Bit2[i]   =gRadioTVPresetList_Attributes_DABPrimServ_Bit2[j];
                                    gRadioTVPresetList_Attributes_TP_Bit5[i]            =gRadioTVPresetList_Attributes_TP_Bit5[j];
                                    gRadioTVPresetList_Attributes_TMC_Bit6[i]           =gRadioTVPresetList_Attributes_TMC_Bit6[j];
                                    gRadioTVPresetList_Attributes_SDRAS_Bit7[i]         =gRadioTVPresetList_Attributes_SDRAS_Bit7[j];
                                    gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[i]  =gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[j];
                                    gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[i]  =gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[j];
                                    gRadioTVPresetList_Attributes_StationSelect_Bit8[i]  =gRadioTVPresetList_Attributes_StationSelect_Bit8[j];
                                    gRadioTVPresetList_Attributes_OnRadMute_Bit9[i]  =gRadioTVPresetList_Attributes_OnRadMute_Bit9[j];
                                    gRadioTVPresetList_Attributes_StationLinked_BitA[i]  =gRadioTVPresetList_Attributes_StationLinked_BitA[j];
                                
                                    for (k=0; k<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;k++) //clear string
                                        gRadioTVPresetList_Name[i][k] =0;                                     

                                    for(k=0;k<strlen(gRadioTVPresetList_Name[j]);k++) 
                                        gRadioTVPresetList_Name[i][k]=gRadioTVPresetList_Name[j][k];

                                break;
                            
                                case 5:
                                    //clear last element in list 
                                    gRadioTVPresetList_ListEntryReceptionInformation[i]     =0;
                                    gRadioTVPresetList_Pos[i]                               =0;
                                    gRadioTVPresetList_PresetIndex[i]                       =0;
                                    gRadioTVPresetList_Waveband[i]                          =0;
                                    gRadioTVPresetList_Attributes[i]                        =0;
                                    gRadioTVPresetList_Attributes_IBOC_Bit0[i]              =0;
                                    gRadioTVPresetList_Attributes_DABSecServ_Bit1[i]        =0;
                                    gRadioTVPresetList_Attributes_DABPrimServ_Bit2[i]       =0;
                                    gRadioTVPresetList_Attributes_TP_Bit5[i]                =0;
                                    gRadioTVPresetList_Attributes_TMC_Bit6[i]               =0;
                                    gRadioTVPresetList_Attributes_SDRAS_Bit7[i]             =0;
                                    gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[i]    =0;
                                    gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[i]      =0;
                                    gRadioTVPresetList_Attributes_StationSelect_Bit8[i]     =0;
                                    gRadioTVPresetList_Attributes_OnRadMute_Bit9[i]         =0;
                                    gRadioTVPresetList_Attributes_StationLinked_BitA[i]     =0;
                                    
                                    for (k=0; k<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;k++) //clear string
                                        gRadioTVPresetList_Name[i][k] =0;
                                                                 
                                break;
                            
                                case 8:
                                    //copy data from buffer in Pos '8'
                                    gRadioTVPresetList_Pos[i]                           =buffer_Pos; 
                                    gRadioTVPresetList_PresetIndex[i]                   =buffer_PresetIndex;
                                    gRadioTVPresetList_Waveband[i]                      =buffer_Waveband;
                                    gRadioTVPresetList_Attributes[i]                    =buffer_Attributes;
                                    gRadioTVPresetList_Attributes_IBOC_Bit0[i]          =buffer_Attributes_bit0;
                                    gRadioTVPresetList_Attributes_DABSecServ_Bit1[i]    =buffer_Attributes_bit1;
                                    gRadioTVPresetList_Attributes_DABPrimServ_Bit2[i]   =buffer_Attributes_bit2;
                                    gRadioTVPresetList_Attributes_TP_Bit5[i]            =buffer_Attributes_bit7;
                                    gRadioTVPresetList_Attributes_TMC_Bit6[i]           =buffer_Attributes_bit6;
                                    gRadioTVPresetList_Attributes_SDRAS_Bit7[i]         =buffer_Attributes_bit7;
                                    gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[i]=buffer_Attributes_bit3;
                                    gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[i]  =buffer_Attributes_bit4;
                                    gRadioTVPresetList_Attributes_StationSelect_Bit8[i] =buffer_Attributes_bit8;
                                    gRadioTVPresetList_Attributes_OnRadMute_Bit9[i]     =buffer_Attributes_bit9;
                                    gRadioTVPresetList_Attributes_StationLinked_BitA[i] =buffer_Attributes_bitA;
                                    
                                    for (k=0; k<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;k++) //clear string
                                        gRadioTVPresetList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_Name);k++) 
                                        gRadioTVPresetList_Name[i][k]=buffer_Name[k];

                                break;
                                
                                default://other elements
                                    //copy element on other position
                                    gRadioTVPresetList_Pos[i]                           =gRadioTVPresetList_Pos[j]; 
                                    gRadioTVPresetList_PresetIndex[i]                   =gRadioTVPresetList_PresetIndex[j];
                                    gRadioTVPresetList_Waveband[i]                      =gRadioTVPresetList_Waveband[j];
                                    gRadioTVPresetList_Attributes[i]                    =gRadioTVPresetList_Attributes[j];
                                    gRadioTVPresetList_Attributes_IBOC_Bit0[i]          =gRadioTVPresetList_Attributes_IBOC_Bit0[j];
                                    gRadioTVPresetList_Attributes_DABSecServ_Bit1[i]    =gRadioTVPresetList_Attributes_DABSecServ_Bit1[j]; 
                                    gRadioTVPresetList_Attributes_DABPrimServ_Bit2[i]   =gRadioTVPresetList_Attributes_DABPrimServ_Bit2[j];
                                    gRadioTVPresetList_Attributes_TP_Bit5[i]            =gRadioTVPresetList_Attributes_TP_Bit5[j];
                                    gRadioTVPresetList_Attributes_TMC_Bit6[i]           =gRadioTVPresetList_Attributes_TMC_Bit6[j];
                                    gRadioTVPresetList_Attributes_SDRAS_Bit7[i]         =gRadioTVPresetList_Attributes_SDRAS_Bit7[j];
                                    gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[i]  =gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[j];
                                    gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[i]  =gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[j];
                                    gRadioTVPresetList_Attributes_StationSelect_Bit8[i]  =gRadioTVPresetList_Attributes_StationSelect_Bit8[j];
                                    gRadioTVPresetList_Attributes_OnRadMute_Bit9[i]  =gRadioTVPresetList_Attributes_OnRadMute_Bit9[j];
                                    gRadioTVPresetList_Attributes_StationLinked_BitA[i]  =gRadioTVPresetList_Attributes_StationLinked_BitA[j];
                                 
                                    for (k=0; k<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;k++) //clear string
                                        gRadioTVPresetList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gRadioTVPresetList_Name[j]);k++) 
                                        gRadioTVPresetList_Name[i][k]=gRadioTVPresetList_Name[j][k];
                                        
                                break;
                            } // end of switch 'i'
                        }
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        RadioTVPresetList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);                        
                        
                        //to check, if valid data received
                        gRadioTVPresetList_CallBackReason    =AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_CHECKCACHE;
                    }
        break;

        case AUDIO_RADIOTVPRESETLIST_UP_CACHE: 
                    if (gRadioTVPresetList_CallBackReason ==AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_CHECKCACHE) //check if valid data received
                    {   
                        if(gRadioTVPresetList_ListEntryReceptionInformation[6] ==0) //No valid data in first list pos -> last list element reached, start with element 0!  
                        {
                            shift                   =TRUE;
                            direction               =BACKWARD;
                            transmitpos             =FALSE;
                            indexsize               =FALSE;
                            recordaddress           =0;
                            startelement            =0; //Last element
                            elements                =1;        
                            
                            requested_startelement  =startelement;
                            mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                            gRadioTVPresetList_cacheUp        =TRUE;
                            gRadioTVPresetList_CallBackReason =AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_DISPLAYLIST;
                            
                            RadioTVPresetList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                        }
                        else
                        {
                            gRadioTVPresetList_CallBackReason =AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_DISPLAYLIST;
                            RadioTVPresetList_ListHandling();
                        }           
                    }

                    else if (gRadioTVPresetList_CallBackReason ==AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_DISPLAYLIST)
                    {   
                        gRadioTVPresetList_ListHandlingType  =AUDIO_RADIOTVPRESETLIST_NOCACHE;
                        gRadioTVPresetList_cacheUp           =FALSE;
                        gRadioTVPresetList_DisplayStatus     =AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_FIRST_ELEMENTS;
                        
                        putvalue(env_ASG_AudioSD_RTPL_ListOpState, empty_string);
                        RadioTVPresetList_display();
                        gRadioTVPresetList_DisplayStatus     =AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_REFRESH;
                        gRadioTVPresetList_CallBackReason    =AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_NOCALLBACK;
                    }

                    else
                    {           
                        putvalue(env_ASG_AudioSD_RTPL_ListOpState, "list operating...");

                        shift                   =TRUE;
                        direction               =BACKWARD;
                        transmitpos             =FALSE;
                        indexsize               =FALSE;
                        recordaddress           =0;
                        startelement            =gRadioTVPresetList_Pos[6]; //first element
                        elements                =1;
                    
                        for(i=AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE-1;i>=0;i--)
                        {  
                            j =i-1;
                            switch (i)
                            {   
                                case 8: 
                                    //buffer data of Pos '8' (local)
                                    buffer_Pos              =gRadioTVPresetList_Pos[i];
                                    buffer_PresetIndex      =gRadioTVPresetList_PresetIndex[i];
                                    buffer_Waveband         =gRadioTVPresetList_Waveband[i];
                                    buffer_Attributes       =gRadioTVPresetList_Attributes[i];
                                    buffer_Attributes_bit0  =gRadioTVPresetList_Attributes_IBOC_Bit0[i];
                                    buffer_Attributes_bit1  =gRadioTVPresetList_Attributes_DABSecServ_Bit1[i];
                                    buffer_Attributes_bit2  =gRadioTVPresetList_Attributes_DABPrimServ_Bit2[i];
                                    buffer_Attributes_bit5  =gRadioTVPresetList_Attributes_TP_Bit5[i];
                                    buffer_Attributes_bit6  =gRadioTVPresetList_Attributes_TMC_Bit6[i];
                                    buffer_Attributes_bit7  =gRadioTVPresetList_Attributes_SDRAS_Bit7[i];   
                                    buffer_Attributes_bit3  =gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[j];
                                    buffer_Attributes_bit4  =gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[j];
                                    buffer_Attributes_bit8  =gRadioTVPresetList_Attributes_StationSelect_Bit8[j];
                                    buffer_Attributes_bit9  =gRadioTVPresetList_Attributes_OnRadMute_Bit9[j];
                                    buffer_Attributes_bitA  =gRadioTVPresetList_Attributes_StationLinked_BitA[j];

                                    for (k=0; k<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;k++) //clear string
                                        buffer_Name[k] =0;                                     

                                    for(k=0;k<strlen(gRadioTVPresetList_Name[i]);k++) 
                                        buffer_Name[k]=gRadioTVPresetList_Name[i][k];

                                    //copy data from Pos '7' to Pos '8'
                                    gRadioTVPresetList_Pos[i]                           =gRadioTVPresetList_Pos[j]; 
                                    gRadioTVPresetList_PresetIndex[i]                   =gRadioTVPresetList_PresetIndex[j];
                                    gRadioTVPresetList_Waveband[i]                      =gRadioTVPresetList_Waveband[j];
                                    gRadioTVPresetList_Attributes[i]                    =gRadioTVPresetList_Attributes[j];
                                    gRadioTVPresetList_Attributes_IBOC_Bit0[i]          =gRadioTVPresetList_Attributes_IBOC_Bit0[j];
                                    gRadioTVPresetList_Attributes_DABSecServ_Bit1[i]    =gRadioTVPresetList_Attributes_DABSecServ_Bit1[j];
                                    gRadioTVPresetList_Attributes_DABPrimServ_Bit2[i]   =gRadioTVPresetList_Attributes_DABPrimServ_Bit2[j];
                                    gRadioTVPresetList_Attributes_TP_Bit5[i]            =gRadioTVPresetList_Attributes_TP_Bit5[j];
                                    gRadioTVPresetList_Attributes_TMC_Bit6[i]           =gRadioTVPresetList_Attributes_TMC_Bit6[j];
                                    gRadioTVPresetList_Attributes_SDRAS_Bit7[i]         =gRadioTVPresetList_Attributes_SDRAS_Bit7[j];
                                    gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[i]  =gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[j];
                                    gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[i]  =gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[j];
                                    gRadioTVPresetList_Attributes_StationSelect_Bit8[i]  =gRadioTVPresetList_Attributes_StationSelect_Bit8[j];
                                    gRadioTVPresetList_Attributes_OnRadMute_Bit9[i]  =gRadioTVPresetList_Attributes_OnRadMute_Bit9[j];
                                    gRadioTVPresetList_Attributes_StationLinked_BitA[i]  =gRadioTVPresetList_Attributes_StationLinked_BitA[j];
                                    
                                    for (k=0; k<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;k++) //clear string
                                        gRadioTVPresetList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gRadioTVPresetList_Name[j]);k++) 
                                        gRadioTVPresetList_Name[i][k]=gRadioTVPresetList_Name[j][k];
                                    
                                break;
                            
                                case 6: 
                                    //clear first element in list 
                                    gRadioTVPresetList_ListEntryReceptionInformation[i]    =0;
                                    gRadioTVPresetList_Pos[i]                              =0;
                                    gRadioTVPresetList_PresetIndex[i]                      =0;
                                    gRadioTVPresetList_Waveband[i]                         =0;
                                    gRadioTVPresetList_Attributes[i]                       =0;
                                    gRadioTVPresetList_Attributes_IBOC_Bit0[i]             =0;
                                    gRadioTVPresetList_Attributes_DABSecServ_Bit1[i]       =0;
                                    gRadioTVPresetList_Attributes_DABPrimServ_Bit2[i]      =0;
                                    gRadioTVPresetList_Attributes_TP_Bit5[i]               =0;
                                    gRadioTVPresetList_Attributes_TMC_Bit6[i]              =0;
                                    gRadioTVPresetList_Attributes_SDRAS_Bit7[i]            =0;
                                    gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[i]   =0;
                                    gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[i]     =0;
                                    gRadioTVPresetList_Attributes_StationSelect_Bit8[i]    =0;
                                    gRadioTVPresetList_Attributes_OnRadMute_Bit9[i]        =0;
                                    gRadioTVPresetList_Attributes_StationLinked_BitA[i]    =0;
                            
                                    for (k=0; k<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;k++) //clear string
                                        gRadioTVPresetList_Name[i][k] =0;
                                                                            
                                break;
                            
                                case 0: 
                                    //copy data from buffer in Pos '0'
                                    gRadioTVPresetList_Pos[i]                           =buffer_Pos; 
                                    gRadioTVPresetList_PresetIndex[i]                   =buffer_PresetIndex;
                                    gRadioTVPresetList_Waveband[i]                      =buffer_Waveband;
                                    gRadioTVPresetList_Attributes[i]                    =buffer_Attributes;
                                    gRadioTVPresetList_Attributes_IBOC_Bit0[i]          =buffer_Attributes_bit0;
                                    gRadioTVPresetList_Attributes_DABSecServ_Bit1[i]    =buffer_Attributes_bit1;
                                    gRadioTVPresetList_Attributes_DABPrimServ_Bit2[i]   =buffer_Attributes_bit2;
                                    gRadioTVPresetList_Attributes_TP_Bit5[i]            =buffer_Attributes_bit7;
                                    gRadioTVPresetList_Attributes_TMC_Bit6[i]           =buffer_Attributes_bit6;
                                    gRadioTVPresetList_Attributes_SDRAS_Bit7[i]         =buffer_Attributes_bit7;
                                    gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[i]=buffer_Attributes_bit3;
                                    gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[i]  =buffer_Attributes_bit4;
                                    gRadioTVPresetList_Attributes_StationSelect_Bit8[i] =buffer_Attributes_bit8;
                                    gRadioTVPresetList_Attributes_OnRadMute_Bit9[i]     =buffer_Attributes_bit9;
                                    gRadioTVPresetList_Attributes_StationLinked_BitA[i] =buffer_Attributes_bitA;

                                    for (k=0; k<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;k++) //clear string
                                        gRadioTVPresetList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_Name);k++) 
                                        gRadioTVPresetList_Name[i][k]=buffer_Name[k];

                                break;
                                
                                default: //other elements
                                    //copy element on other position
                                    gRadioTVPresetList_Pos[i]                           =gRadioTVPresetList_Pos[j]; 
                                    gRadioTVPresetList_PresetIndex[i]                   =gRadioTVPresetList_PresetIndex[j];
                                    gRadioTVPresetList_Waveband[i]                      =gRadioTVPresetList_Waveband[j];
                                    gRadioTVPresetList_Attributes[i]                    =gRadioTVPresetList_Attributes[j];
                                    gRadioTVPresetList_Attributes_IBOC_Bit0[i]          =gRadioTVPresetList_Attributes_IBOC_Bit0[j];
                                    gRadioTVPresetList_Attributes_DABSecServ_Bit1[i]    =gRadioTVPresetList_Attributes_DABSecServ_Bit1[j];
                                    gRadioTVPresetList_Attributes_DABPrimServ_Bit2[i]   =gRadioTVPresetList_Attributes_DABPrimServ_Bit2[j];
                                    gRadioTVPresetList_Attributes_TP_Bit5[i]            =gRadioTVPresetList_Attributes_TP_Bit5[j];
                                    gRadioTVPresetList_Attributes_TMC_Bit6[i]           =gRadioTVPresetList_Attributes_TMC_Bit6[j];
                                    gRadioTVPresetList_Attributes_SDRAS_Bit7[i]         =gRadioTVPresetList_Attributes_SDRAS_Bit7[j];     
                                    gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[i]=gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[j];
                                    gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[i]  =gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[j];
                                    gRadioTVPresetList_Attributes_StationSelect_Bit8[i] =gRadioTVPresetList_Attributes_StationSelect_Bit8[j];
                                    gRadioTVPresetList_Attributes_OnRadMute_Bit9[i]     =gRadioTVPresetList_Attributes_OnRadMute_Bit9[j];
                                    gRadioTVPresetList_Attributes_StationLinked_BitA[i] =gRadioTVPresetList_Attributes_StationLinked_BitA[j];

                                    for (k=0; k<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;k++) //clear string
                                        gRadioTVPresetList_Name[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gRadioTVPresetList_Name[j]);k++) 
                                        gRadioTVPresetList_Name[i][k]=gRadioTVPresetList_Name[j][k];
                                     
                                break;
                            } // end of switch 'i'
                        }
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        RadioTVPresetList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);                        
                        
                        //to check, if valid data received
                        gRadioTVPresetList_CallBackReason    =AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_CHECKCACHE;
                    }
        break;

        default:
        break;
    } //end of switch 'type of cache handling' 
}

RadioTVPresetList_display()
{   
    int Element_1 =0, Element_2 =1, Element_3 =2;

    if(POWER_ON==gASG_PowerOnOff && getvalue(env_ASG_AudioSD_RTPL_OnOff))
	{   
        /******'sliding window' not active******/         
        if(gRadioTVPresetList_DisplayStatus ==AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_SEARCH_ELEMENTS)
        {
            //1. Element              
            if(gRadioTVPresetList_CursorAction ==AUDIO_RADIOTVPRESETLIST_CURSORACTION_DOWN)
                Element_1 =RadioTVPresetList_GetNextCachedElement(gRadioTVPresetList_LastFirstElement, AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);
            
            else if(gRadioTVPresetList_CursorAction ==AUDIO_RADIOTVPRESETLIST_CURSORACTION_UP)            
                Element_1 =RadioTVPresetList_GetNextCachedElement(gRadioTVPresetList_LastFirstElement, AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_FIND_PREVIUOS_ELEMENT);

            //Pos
            putvalue(env_ASG_AudioSD_RTPL_pos_0, gRadioTVPresetList_Pos[Element_1]);               

            //PresetIndex
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1 || gRadioTVPresetList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_RTPL_PI_0,gRadioTVPresetList_PresetIndex[Element_1]);
            
            //Waveband
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_RTPL_WB_0, gRadioTVPresetList_Waveband[Element_1]);

                if(gRadioTVPresetList_Waveband[Element_1] <0x0E)
                    putvalue(env_ASG_AudioSD_RTPL_WB_s_0,gRadioTVPresetList_Waveband_s[gRadioTVPresetList_Waveband[Element_1]]);
                else
                    putvalue(env_ASG_AudioSD_RTPL_WB_s_0,gstring_reserved);
            }

            //Attributes
            if (gRadioTVPresetList_recordaddress ==0) 
            {
                putvalue(env_ASG_AudioSD_RTPL_At_bit0_0, gRadioTVPresetList_Attributes_IBOC_Bit0[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit0_0,gRadioTVPresetList_Attributes_IBOC_Bit0_s[gRadioTVPresetList_Attributes_IBOC_Bit0[Element_1]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit1_0, gRadioTVPresetList_Attributes_DABSecServ_Bit1[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit1_0,gRadioTVPresetList_Attributes_DABSecServ_Bit1_s[gRadioTVPresetList_Attributes_DABSecServ_Bit1[Element_1]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit2_0, gRadioTVPresetList_Attributes_DABPrimServ_Bit2[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit2_0,gRadioTVPresetList_Attributes_DABPrimServ_Bit2_s[gRadioTVPresetList_Attributes_DABPrimServ_Bit2[Element_1]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit5_0, gRadioTVPresetList_Attributes_TP_Bit5[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit5_0,gRadioTVPresetList_Attributes_TP_Bit5_s[gRadioTVPresetList_Attributes_TP_Bit5[Element_1]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit6_0, gRadioTVPresetList_Attributes_TMC_Bit6[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit6_0,gRadioTVPresetList_Attributes_TMC_Bit6_s[gRadioTVPresetList_Attributes_TMC_Bit6[Element_1]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit7_0, gRadioTVPresetList_Attributes_SDRAS_Bit7[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit7_0,gRadioTVPresetList_Attributes_SDARS_Bit7_s[gRadioTVPresetList_Attributes_SDRAS_Bit7[Element_1]]);
              
                putvalue(env_ASG_AudioSD_RTPL_At_bit3_0, gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit3_0,gRadioTVPresetList_Attributes_OnRadSecondary_Bit3_s[gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[Element_1]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit4_0, gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit4_0,gRadioTVPresetList_Attributes_OnRadPrimary_Bit4_s[gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[Element_1]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit8_0, gRadioTVPresetList_Attributes_StationSelect_Bit8[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit8_0,gRadioTVPresetList_Attributes_StationSelect_Bit8_s[gRadioTVPresetList_Attributes_StationSelect_Bit8[Element_1]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit9_0, gRadioTVPresetList_Attributes_OnRadMute_Bit9[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit9_0,gRadioTVPresetList_Attributes_OnRadMute_Bit9_s[gRadioTVPresetList_Attributes_OnRadMute_Bit9[Element_1]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bitA_0, gRadioTVPresetList_Attributes_StationLinked_BitA[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bitA_0,gRadioTVPresetList_Attributes_StationLinked_BitA_s[gRadioTVPresetList_Attributes_StationLinked_BitA[Element_1]]);
            }

            //Name
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1 || gRadioTVPresetList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_RTPL_Name_s_0,gRadioTVPresetList_Name[Element_1]);

            gRadioTVPresetList_LastFirstElement =Element_1;
            
            
            //2. Element             
            Element_2 =RadioTVPresetList_GetNextCachedElement(Element_1, AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);

            //Pos
            putvalue(env_ASG_AudioSD_RTPL_pos_1, gRadioTVPresetList_Pos[Element_2]);               

            //PresetIndex
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1 || gRadioTVPresetList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_RTPL_PI_1,gRadioTVPresetList_PresetIndex[Element_2]);
            
            //Waveband
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_RTPL_WB_1, gRadioTVPresetList_Waveband[Element_2]);

                if(gRadioTVPresetList_Waveband[Element_2] <0x0E)
                    putvalue(env_ASG_AudioSD_RTPL_WB_s_1,gRadioTVPresetList_Waveband_s[gRadioTVPresetList_Waveband[Element_2]]);
                else
                    putvalue(env_ASG_AudioSD_RTPL_WB_s_1,gstring_reserved);
            }

            //Attributes
            if (gRadioTVPresetList_recordaddress ==0) 
            {
                putvalue(env_ASG_AudioSD_RTPL_At_bit0_1, gRadioTVPresetList_Attributes_IBOC_Bit0[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit0_1,gRadioTVPresetList_Attributes_IBOC_Bit0_s[gRadioTVPresetList_Attributes_IBOC_Bit0[Element_2]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit1_1, gRadioTVPresetList_Attributes_DABSecServ_Bit1[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit1_1,gRadioTVPresetList_Attributes_DABSecServ_Bit1_s[gRadioTVPresetList_Attributes_DABSecServ_Bit1[Element_2]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit2_1, gRadioTVPresetList_Attributes_DABPrimServ_Bit2[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit2_1,gRadioTVPresetList_Attributes_DABPrimServ_Bit2_s[gRadioTVPresetList_Attributes_DABPrimServ_Bit2[Element_2]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit5_1, gRadioTVPresetList_Attributes_TP_Bit5[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit5_1,gRadioTVPresetList_Attributes_TP_Bit5_s[gRadioTVPresetList_Attributes_TP_Bit5[Element_2]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit6_1, gRadioTVPresetList_Attributes_TMC_Bit6[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit6_1,gRadioTVPresetList_Attributes_TMC_Bit6_s[gRadioTVPresetList_Attributes_TMC_Bit6[Element_2]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit7_1, gRadioTVPresetList_Attributes_SDRAS_Bit7[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit7_1,gRadioTVPresetList_Attributes_SDARS_Bit7_s[gRadioTVPresetList_Attributes_SDRAS_Bit7[Element_2]]);
              
                putvalue(env_ASG_AudioSD_RTPL_At_bit3_1, gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit3_1,gRadioTVPresetList_Attributes_OnRadSecondary_Bit3_s[gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[Element_2]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit4_1, gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit4_1,gRadioTVPresetList_Attributes_OnRadPrimary_Bit4_s[gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[Element_2]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit8_1, gRadioTVPresetList_Attributes_StationSelect_Bit8[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit8_1,gRadioTVPresetList_Attributes_StationSelect_Bit8_s[gRadioTVPresetList_Attributes_StationSelect_Bit8[Element_2]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit9_1, gRadioTVPresetList_Attributes_OnRadMute_Bit9[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit9_1,gRadioTVPresetList_Attributes_OnRadMute_Bit9_s[gRadioTVPresetList_Attributes_OnRadMute_Bit9[Element_2]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bitA_1, gRadioTVPresetList_Attributes_StationLinked_BitA[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bitA_1,gRadioTVPresetList_Attributes_StationLinked_BitA_s[gRadioTVPresetList_Attributes_StationLinked_BitA[Element_2]]);
            }

            //Name
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1 || gRadioTVPresetList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_RTPL_Name_s_1,gRadioTVPresetList_Name[Element_2]);
             
            
            //3. Element          
            Element_3 =RadioTVPresetList_GetNextCachedElement(Element_2, AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);

            //Pos
            putvalue(env_ASG_AudioSD_RTPL_pos_2, gRadioTVPresetList_Pos[Element_3]);               

            //PresetIndex
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1 || gRadioTVPresetList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_RTPL_PI_2,gRadioTVPresetList_PresetIndex[Element_3]);
            
            //Waveband
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_RTPL_WB_2, gRadioTVPresetList_Waveband[Element_3]);

                if(gRadioTVPresetList_Waveband[Element_3] <0x0E)
                    putvalue(env_ASG_AudioSD_RTPL_WB_s_2,gRadioTVPresetList_Waveband_s[gRadioTVPresetList_Waveband[Element_3]]);
                else
                    putvalue(env_ASG_AudioSD_RTPL_WB_s_2,gstring_reserved);
            }

            //Attributes
            if (gRadioTVPresetList_recordaddress ==0) 
            {
                putvalue(env_ASG_AudioSD_RTPL_At_bit0_2, gRadioTVPresetList_Attributes_IBOC_Bit0[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit0_2,gRadioTVPresetList_Attributes_IBOC_Bit0_s[gRadioTVPresetList_Attributes_IBOC_Bit0[Element_3]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit1_2, gRadioTVPresetList_Attributes_DABSecServ_Bit1[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit1_2,gRadioTVPresetList_Attributes_DABSecServ_Bit1_s[gRadioTVPresetList_Attributes_DABSecServ_Bit1[Element_3]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit2_2, gRadioTVPresetList_Attributes_DABPrimServ_Bit2[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit2_2,gRadioTVPresetList_Attributes_DABPrimServ_Bit2_s[gRadioTVPresetList_Attributes_DABPrimServ_Bit2[Element_3]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit5_2, gRadioTVPresetList_Attributes_TP_Bit5[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit5_2,gRadioTVPresetList_Attributes_TP_Bit5_s[gRadioTVPresetList_Attributes_TP_Bit5[Element_3]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit6_2, gRadioTVPresetList_Attributes_TMC_Bit6[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit6_2,gRadioTVPresetList_Attributes_TMC_Bit6_s[gRadioTVPresetList_Attributes_TMC_Bit6[Element_3]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit7_2, gRadioTVPresetList_Attributes_SDRAS_Bit7[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit7_2,gRadioTVPresetList_Attributes_SDARS_Bit7_s[gRadioTVPresetList_Attributes_SDRAS_Bit7[Element_3]]);
              
                putvalue(env_ASG_AudioSD_RTPL_At_bit3_2, gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit3_2,gRadioTVPresetList_Attributes_OnRadSecondary_Bit3_s[gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[Element_3]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit4_2, gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit4_2,gRadioTVPresetList_Attributes_OnRadPrimary_Bit4_s[gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[Element_3]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit8_2, gRadioTVPresetList_Attributes_StationSelect_Bit8[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit8_2,gRadioTVPresetList_Attributes_StationSelect_Bit8_s[gRadioTVPresetList_Attributes_StationSelect_Bit8[Element_3]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit9_2, gRadioTVPresetList_Attributes_OnRadMute_Bit9[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit9_2,gRadioTVPresetList_Attributes_OnRadMute_Bit9_s[gRadioTVPresetList_Attributes_OnRadMute_Bit9[Element_3]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bitA_2, gRadioTVPresetList_Attributes_StationLinked_BitA[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bitA_2,gRadioTVPresetList_Attributes_StationLinked_BitA_s[gRadioTVPresetList_Attributes_StationLinked_BitA[Element_3]]);
            }

            //Name
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1 || gRadioTVPresetList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_RTPL_Name_s_2,gRadioTVPresetList_Name[Element_3]);       
        }
        
        /******'sliding Window' active or 'build-up List'******/
        else if(gRadioTVPresetList_DisplayStatus ==AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_FIRST_ELEMENTS) 
        {
            //1. Element    
            if(gRadioTVPresetList_ListEntryReceptionInformation [0] ==TRUE && getvalue(env_ASG_AudioSD_RTPL_OnOff))
            {   
                Element_1 =0;
                
            //Pos
            putvalue(env_ASG_AudioSD_RTPL_pos_0, gRadioTVPresetList_Pos[Element_1]);               

            //PresetIndex
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1 || gRadioTVPresetList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_RTPL_PI_0,gRadioTVPresetList_PresetIndex[Element_1]);
            
            //Waveband
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_RTPL_WB_0, gRadioTVPresetList_Waveband[Element_1]);

                if(gRadioTVPresetList_Waveband[Element_1] <0x0E)
                    putvalue(env_ASG_AudioSD_RTPL_WB_s_0,gRadioTVPresetList_Waveband_s[gRadioTVPresetList_Waveband[Element_1]]);
                else
                    putvalue(env_ASG_AudioSD_RTPL_WB_s_0,gstring_reserved);
            }

            //Attributes
            if (gRadioTVPresetList_recordaddress ==0) 
            {
                putvalue(env_ASG_AudioSD_RTPL_At_bit0_0, gRadioTVPresetList_Attributes_IBOC_Bit0[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit0_0,gRadioTVPresetList_Attributes_IBOC_Bit0_s[gRadioTVPresetList_Attributes_IBOC_Bit0[Element_1]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit1_0, gRadioTVPresetList_Attributes_DABSecServ_Bit1[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit1_0,gRadioTVPresetList_Attributes_DABSecServ_Bit1_s[gRadioTVPresetList_Attributes_DABSecServ_Bit1[Element_1]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit2_0, gRadioTVPresetList_Attributes_DABPrimServ_Bit2[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit2_0,gRadioTVPresetList_Attributes_DABPrimServ_Bit2_s[gRadioTVPresetList_Attributes_DABPrimServ_Bit2[Element_1]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit5_0, gRadioTVPresetList_Attributes_TP_Bit5[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit5_0,gRadioTVPresetList_Attributes_TP_Bit5_s[gRadioTVPresetList_Attributes_TP_Bit5[Element_1]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit6_0, gRadioTVPresetList_Attributes_TMC_Bit6[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit6_0,gRadioTVPresetList_Attributes_TMC_Bit6_s[gRadioTVPresetList_Attributes_TMC_Bit6[Element_1]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit7_0, gRadioTVPresetList_Attributes_SDRAS_Bit7[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit7_0,gRadioTVPresetList_Attributes_SDARS_Bit7_s[gRadioTVPresetList_Attributes_SDRAS_Bit7[Element_1]]);
              
                putvalue(env_ASG_AudioSD_RTPL_At_bit3_0, gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit3_0,gRadioTVPresetList_Attributes_OnRadSecondary_Bit3_s[gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[Element_1]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit4_0, gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit4_0,gRadioTVPresetList_Attributes_OnRadPrimary_Bit4_s[gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[Element_1]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit8_0, gRadioTVPresetList_Attributes_StationSelect_Bit8[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit8_0,gRadioTVPresetList_Attributes_StationSelect_Bit8_s[gRadioTVPresetList_Attributes_StationSelect_Bit8[Element_1]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit9_0, gRadioTVPresetList_Attributes_OnRadMute_Bit9[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit9_0,gRadioTVPresetList_Attributes_OnRadMute_Bit9_s[gRadioTVPresetList_Attributes_OnRadMute_Bit9[Element_1]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bitA_0, gRadioTVPresetList_Attributes_StationLinked_BitA[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bitA_0,gRadioTVPresetList_Attributes_StationLinked_BitA_s[gRadioTVPresetList_Attributes_StationLinked_BitA[Element_1]]);
            }

            //Name
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1 || gRadioTVPresetList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_RTPL_Name_s_0,gRadioTVPresetList_Name[Element_1]);
            }
            
            //2. Element    
            if(gRadioTVPresetList_ListEntryReceptionInformation [1] ==TRUE && getvalue(env_ASG_AudioSD_RTPL_OnOff))
            {
                Element_2 =1;
                
            //Pos
            putvalue(env_ASG_AudioSD_RTPL_pos_1, gRadioTVPresetList_Pos[Element_2]);               

            //PresetIndex
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1 || gRadioTVPresetList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_RTPL_PI_1,gRadioTVPresetList_PresetIndex[Element_2]);
            
            //Waveband
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_RTPL_WB_1, gRadioTVPresetList_Waveband[Element_2]);

                if(gRadioTVPresetList_Waveband[Element_2] <0x0E)
                    putvalue(env_ASG_AudioSD_RTPL_WB_s_1,gRadioTVPresetList_Waveband_s[gRadioTVPresetList_Waveband[Element_2]]);
                else
                    putvalue(env_ASG_AudioSD_RTPL_WB_s_1,gstring_reserved);
            }

            //Attributes
            if (gRadioTVPresetList_recordaddress ==0) 
            {
                putvalue(env_ASG_AudioSD_RTPL_At_bit0_1, gRadioTVPresetList_Attributes_IBOC_Bit0[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit0_1,gRadioTVPresetList_Attributes_IBOC_Bit0_s[gRadioTVPresetList_Attributes_IBOC_Bit0[Element_2]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit1_1, gRadioTVPresetList_Attributes_DABSecServ_Bit1[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit1_1,gRadioTVPresetList_Attributes_DABSecServ_Bit1_s[gRadioTVPresetList_Attributes_DABSecServ_Bit1[Element_2]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit2_1, gRadioTVPresetList_Attributes_DABPrimServ_Bit2[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit2_1,gRadioTVPresetList_Attributes_DABPrimServ_Bit2_s[gRadioTVPresetList_Attributes_DABPrimServ_Bit2[Element_2]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit5_1, gRadioTVPresetList_Attributes_TP_Bit5[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit5_1,gRadioTVPresetList_Attributes_TP_Bit5_s[gRadioTVPresetList_Attributes_TP_Bit5[Element_2]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit6_1, gRadioTVPresetList_Attributes_TMC_Bit6[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit6_1,gRadioTVPresetList_Attributes_TMC_Bit6_s[gRadioTVPresetList_Attributes_TMC_Bit6[Element_2]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit7_1, gRadioTVPresetList_Attributes_SDRAS_Bit7[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit7_1,gRadioTVPresetList_Attributes_SDARS_Bit7_s[gRadioTVPresetList_Attributes_SDRAS_Bit7[Element_2]]);
              
                putvalue(env_ASG_AudioSD_RTPL_At_bit3_1, gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit3_1,gRadioTVPresetList_Attributes_OnRadSecondary_Bit3_s[gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[Element_2]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit4_1, gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit4_1,gRadioTVPresetList_Attributes_OnRadPrimary_Bit4_s[gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[Element_2]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit8_1, gRadioTVPresetList_Attributes_StationSelect_Bit8[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit8_1,gRadioTVPresetList_Attributes_StationSelect_Bit8_s[gRadioTVPresetList_Attributes_StationSelect_Bit8[Element_2]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit9_1, gRadioTVPresetList_Attributes_OnRadMute_Bit9[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit9_1,gRadioTVPresetList_Attributes_OnRadMute_Bit9_s[gRadioTVPresetList_Attributes_OnRadMute_Bit9[Element_2]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bitA_1, gRadioTVPresetList_Attributes_StationLinked_BitA[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bitA_1,gRadioTVPresetList_Attributes_StationLinked_BitA_s[gRadioTVPresetList_Attributes_StationLinked_BitA[Element_2]]);
            }

            //Name
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1 || gRadioTVPresetList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_RTPL_Name_s_1,gRadioTVPresetList_Name[Element_2]);
            }

            //3. Element    
            if(gRadioTVPresetList_ListEntryReceptionInformation [2] ==TRUE && getvalue(env_ASG_AudioSD_RTPL_OnOff))
            {
                Element_3 =2;
             
                //Pos
            putvalue(env_ASG_AudioSD_RTPL_pos_2, gRadioTVPresetList_Pos[Element_3]);               

            //PresetIndex
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1 || gRadioTVPresetList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_RTPL_PI_2,gRadioTVPresetList_PresetIndex[Element_3]);
            
            //Waveband
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_RTPL_WB_2, gRadioTVPresetList_Waveband[Element_3]);

                if(gRadioTVPresetList_Waveband[Element_3] <0x0E)
                    putvalue(env_ASG_AudioSD_RTPL_WB_s_2,gRadioTVPresetList_Waveband_s[gRadioTVPresetList_Waveband[Element_3]]);
                else
                    putvalue(env_ASG_AudioSD_RTPL_WB_s_2,gstring_reserved);
            }

            //Attributes
            if (gRadioTVPresetList_recordaddress ==0) 
            {
                putvalue(env_ASG_AudioSD_RTPL_At_bit0_2, gRadioTVPresetList_Attributes_IBOC_Bit0[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit0_2,gRadioTVPresetList_Attributes_IBOC_Bit0_s[gRadioTVPresetList_Attributes_IBOC_Bit0[Element_3]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit1_2, gRadioTVPresetList_Attributes_DABSecServ_Bit1[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit1_2,gRadioTVPresetList_Attributes_DABSecServ_Bit1_s[gRadioTVPresetList_Attributes_DABSecServ_Bit1[Element_3]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit2_2, gRadioTVPresetList_Attributes_DABPrimServ_Bit2[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit2_2,gRadioTVPresetList_Attributes_DABPrimServ_Bit2_s[gRadioTVPresetList_Attributes_DABPrimServ_Bit2[Element_3]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit5_2, gRadioTVPresetList_Attributes_TP_Bit5[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit5_2,gRadioTVPresetList_Attributes_TP_Bit5_s[gRadioTVPresetList_Attributes_TP_Bit5[Element_3]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit6_2, gRadioTVPresetList_Attributes_TMC_Bit6[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit6_2,gRadioTVPresetList_Attributes_TMC_Bit6_s[gRadioTVPresetList_Attributes_TMC_Bit6[Element_3]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit7_2, gRadioTVPresetList_Attributes_SDRAS_Bit7[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit7_2,gRadioTVPresetList_Attributes_SDARS_Bit7_s[gRadioTVPresetList_Attributes_SDRAS_Bit7[Element_3]]);
              
                putvalue(env_ASG_AudioSD_RTPL_At_bit3_2, gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit3_2,gRadioTVPresetList_Attributes_OnRadSecondary_Bit3_s[gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[Element_3]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit4_2, gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit4_2,gRadioTVPresetList_Attributes_OnRadPrimary_Bit4_s[gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[Element_3]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit8_2, gRadioTVPresetList_Attributes_StationSelect_Bit8[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit8_2,gRadioTVPresetList_Attributes_StationSelect_Bit8_s[gRadioTVPresetList_Attributes_StationSelect_Bit8[Element_3]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit9_2, gRadioTVPresetList_Attributes_OnRadMute_Bit9[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit9_2,gRadioTVPresetList_Attributes_OnRadMute_Bit9_s[gRadioTVPresetList_Attributes_OnRadMute_Bit9[Element_3]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bitA_2, gRadioTVPresetList_Attributes_StationLinked_BitA[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bitA_2,gRadioTVPresetList_Attributes_StationLinked_BitA_s[gRadioTVPresetList_Attributes_StationLinked_BitA[Element_3]]);
            }

            //Name
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1 || gRadioTVPresetList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_RTPL_Name_s_2,gRadioTVPresetList_Name[Element_3]);
            }
        }    
            
        else if (gRadioTVPresetList_DisplayStatus ==AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_REFRESH)
        {          
            //1. Element
            if(gRadioTVPresetList_SlidingWindow_State ==AUDIO_RADIOTVPRESETLIST_SLIDINGWINDOW_NOTACTIVE)
                Element_1 =gRadioTVPresetList_LastFirstElement; 
            else
                Element_1 =0;

            if(gRadioTVPresetList_ListEntryReceptionInformation[Element_1])
            {
                //Pos
            putvalue(env_ASG_AudioSD_RTPL_pos_0, gRadioTVPresetList_Pos[Element_1]);               

            //PresetIndex
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1 || gRadioTVPresetList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_RTPL_PI_0,gRadioTVPresetList_PresetIndex[Element_1]);
            
            //Waveband
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_RTPL_WB_0, gRadioTVPresetList_Waveband[Element_1]);

                if(gRadioTVPresetList_Waveband[Element_1] <0x0E)
                    putvalue(env_ASG_AudioSD_RTPL_WB_s_0,gRadioTVPresetList_Waveband_s[gRadioTVPresetList_Waveband[Element_1]]);
                else
                    putvalue(env_ASG_AudioSD_RTPL_WB_s_0,gstring_reserved);
            }

            //Attributes
            if (gRadioTVPresetList_recordaddress ==0) 
            {
                putvalue(env_ASG_AudioSD_RTPL_At_bit0_0, gRadioTVPresetList_Attributes_IBOC_Bit0[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit0_0,gRadioTVPresetList_Attributes_IBOC_Bit0_s[gRadioTVPresetList_Attributes_IBOC_Bit0[Element_1]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit1_0, gRadioTVPresetList_Attributes_DABSecServ_Bit1[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit1_0,gRadioTVPresetList_Attributes_DABSecServ_Bit1_s[gRadioTVPresetList_Attributes_DABSecServ_Bit1[Element_1]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit2_0, gRadioTVPresetList_Attributes_DABPrimServ_Bit2[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit2_0,gRadioTVPresetList_Attributes_DABPrimServ_Bit2_s[gRadioTVPresetList_Attributes_DABPrimServ_Bit2[Element_1]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit5_0, gRadioTVPresetList_Attributes_TP_Bit5[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit5_0,gRadioTVPresetList_Attributes_TP_Bit5_s[gRadioTVPresetList_Attributes_TP_Bit5[Element_1]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit6_0, gRadioTVPresetList_Attributes_TMC_Bit6[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit6_0,gRadioTVPresetList_Attributes_TMC_Bit6_s[gRadioTVPresetList_Attributes_TMC_Bit6[Element_1]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit7_0, gRadioTVPresetList_Attributes_SDRAS_Bit7[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit7_0,gRadioTVPresetList_Attributes_SDARS_Bit7_s[gRadioTVPresetList_Attributes_SDRAS_Bit7[Element_1]]);
                
                putvalue(env_ASG_AudioSD_RTPL_At_bit3_0, gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit3_0,gRadioTVPresetList_Attributes_OnRadSecondary_Bit3_s[gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[Element_1]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit4_0, gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit4_0,gRadioTVPresetList_Attributes_OnRadPrimary_Bit4_s[gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[Element_1]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit8_0, gRadioTVPresetList_Attributes_StationSelect_Bit8[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit8_0,gRadioTVPresetList_Attributes_StationSelect_Bit8_s[gRadioTVPresetList_Attributes_StationSelect_Bit8[Element_1]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit9_0, gRadioTVPresetList_Attributes_OnRadMute_Bit9[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit9_0,gRadioTVPresetList_Attributes_OnRadMute_Bit9_s[gRadioTVPresetList_Attributes_OnRadMute_Bit9[Element_1]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bitA_0, gRadioTVPresetList_Attributes_StationLinked_BitA[Element_1]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bitA_0,gRadioTVPresetList_Attributes_StationLinked_BitA_s[gRadioTVPresetList_Attributes_StationLinked_BitA[Element_1]]);
            }

            //Name
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1 || gRadioTVPresetList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_RTPL_Name_s_0,gRadioTVPresetList_Name[Element_1]);
            }//END: Element_1
                

            //2. Element             
            if(gRadioTVPresetList_SlidingWindow_State ==AUDIO_RADIOTVPRESETLIST_SLIDINGWINDOW_NOTACTIVE)
                Element_2 =RadioTVPresetList_GetNextCachedElement(Element_1, AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);
            else
                Element_2 =1;

            if(gRadioTVPresetList_ListEntryReceptionInformation[Element_2])
            {
                //Pos
            putvalue(env_ASG_AudioSD_RTPL_pos_1, gRadioTVPresetList_Pos[Element_2]);               

            //PresetIndex
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1 || gRadioTVPresetList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_RTPL_PI_1,gRadioTVPresetList_PresetIndex[Element_2]);
            
            //Waveband
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_RTPL_WB_1, gRadioTVPresetList_Waveband[Element_2]);

                if(gRadioTVPresetList_Waveband[Element_2] <0x0E)
                    putvalue(env_ASG_AudioSD_RTPL_WB_s_1,gRadioTVPresetList_Waveband_s[gRadioTVPresetList_Waveband[Element_2]]);
                else
                    putvalue(env_ASG_AudioSD_RTPL_WB_s_1,gstring_reserved);
            }

            //Attributes
            if (gRadioTVPresetList_recordaddress ==0) 
            {
                putvalue(env_ASG_AudioSD_RTPL_At_bit0_1, gRadioTVPresetList_Attributes_IBOC_Bit0[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit0_1,gRadioTVPresetList_Attributes_IBOC_Bit0_s[gRadioTVPresetList_Attributes_IBOC_Bit0[Element_2]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit1_1, gRadioTVPresetList_Attributes_DABSecServ_Bit1[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit1_1,gRadioTVPresetList_Attributes_DABSecServ_Bit1_s[gRadioTVPresetList_Attributes_DABSecServ_Bit1[Element_2]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit2_1, gRadioTVPresetList_Attributes_DABPrimServ_Bit2[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit2_1,gRadioTVPresetList_Attributes_DABPrimServ_Bit2_s[gRadioTVPresetList_Attributes_DABPrimServ_Bit2[Element_2]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit5_1, gRadioTVPresetList_Attributes_TP_Bit5[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit5_1,gRadioTVPresetList_Attributes_TP_Bit5_s[gRadioTVPresetList_Attributes_TP_Bit5[Element_2]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit6_1, gRadioTVPresetList_Attributes_TMC_Bit6[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit6_1,gRadioTVPresetList_Attributes_TMC_Bit6_s[gRadioTVPresetList_Attributes_TMC_Bit6[Element_2]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit7_1, gRadioTVPresetList_Attributes_SDRAS_Bit7[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit7_1,gRadioTVPresetList_Attributes_SDARS_Bit7_s[gRadioTVPresetList_Attributes_SDRAS_Bit7[Element_2]]);
              
                putvalue(env_ASG_AudioSD_RTPL_At_bit3_1, gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit3_1,gRadioTVPresetList_Attributes_OnRadSecondary_Bit3_s[gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[Element_2]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit4_1, gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit4_1,gRadioTVPresetList_Attributes_OnRadPrimary_Bit4_s[gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[Element_2]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit8_1, gRadioTVPresetList_Attributes_StationSelect_Bit8[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit8_1,gRadioTVPresetList_Attributes_StationSelect_Bit8_s[gRadioTVPresetList_Attributes_StationSelect_Bit8[Element_2]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit9_1, gRadioTVPresetList_Attributes_OnRadMute_Bit9[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit9_1,gRadioTVPresetList_Attributes_OnRadMute_Bit9_s[gRadioTVPresetList_Attributes_OnRadMute_Bit9[Element_2]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bitA_1, gRadioTVPresetList_Attributes_StationLinked_BitA[Element_2]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bitA_1,gRadioTVPresetList_Attributes_StationLinked_BitA_s[gRadioTVPresetList_Attributes_StationLinked_BitA[Element_2]]);
            }

            //Name
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1 || gRadioTVPresetList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_RTPL_Name_s_1,gRadioTVPresetList_Name[Element_2]);
            
            }//END: Element_2

            //3. Element          
            if(gRadioTVPresetList_SlidingWindow_State ==AUDIO_RADIOTVPRESETLIST_SLIDINGWINDOW_NOTACTIVE)
                Element_3 =RadioTVPresetList_GetNextCachedElement(Element_2, AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);
            else
                Element_3 =2;

            if(gRadioTVPresetList_ListEntryReceptionInformation[Element_3])
            {    
                //Pos
            putvalue(env_ASG_AudioSD_RTPL_pos_2, gRadioTVPresetList_Pos[Element_3]);               

            //PresetIndex
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1 || gRadioTVPresetList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_RTPL_PI_2,gRadioTVPresetList_PresetIndex[Element_3]);
            
            //Waveband
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_RTPL_WB_2, gRadioTVPresetList_Waveband[Element_3]);

                if(gRadioTVPresetList_Waveband[Element_3] <0x0E)
                    putvalue(env_ASG_AudioSD_RTPL_WB_s_2,gRadioTVPresetList_Waveband_s[gRadioTVPresetList_Waveband[Element_3]]);
                else
                    putvalue(env_ASG_AudioSD_RTPL_WB_s_2,gstring_reserved);
            }

            //Attributes
            if (gRadioTVPresetList_recordaddress ==0) 
            {
                putvalue(env_ASG_AudioSD_RTPL_At_bit0_2, gRadioTVPresetList_Attributes_IBOC_Bit0[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit0_2,gRadioTVPresetList_Attributes_IBOC_Bit0_s[gRadioTVPresetList_Attributes_IBOC_Bit0[Element_3]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit1_2, gRadioTVPresetList_Attributes_DABSecServ_Bit1[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit1_2,gRadioTVPresetList_Attributes_DABSecServ_Bit1_s[gRadioTVPresetList_Attributes_DABSecServ_Bit1[Element_3]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit2_2, gRadioTVPresetList_Attributes_DABPrimServ_Bit2[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit2_2,gRadioTVPresetList_Attributes_DABPrimServ_Bit2_s[gRadioTVPresetList_Attributes_DABPrimServ_Bit2[Element_3]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit5_2, gRadioTVPresetList_Attributes_TP_Bit5[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit5_2,gRadioTVPresetList_Attributes_TP_Bit5_s[gRadioTVPresetList_Attributes_TP_Bit5[Element_3]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit6_2, gRadioTVPresetList_Attributes_TMC_Bit6[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit6_2,gRadioTVPresetList_Attributes_TMC_Bit6_s[gRadioTVPresetList_Attributes_TMC_Bit6[Element_3]]);

                putvalue(env_ASG_AudioSD_RTPL_At_bit7_2, gRadioTVPresetList_Attributes_SDRAS_Bit7[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit7_2,gRadioTVPresetList_Attributes_SDARS_Bit7_s[gRadioTVPresetList_Attributes_SDRAS_Bit7[Element_3]]);
              
                putvalue(env_ASG_AudioSD_RTPL_At_bit3_2, gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit3_2,gRadioTVPresetList_Attributes_OnRadSecondary_Bit3_s[gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[Element_3]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit4_2, gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit4_2,gRadioTVPresetList_Attributes_OnRadPrimary_Bit4_s[gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[Element_3]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit8_2, gRadioTVPresetList_Attributes_StationSelect_Bit8[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit8_2,gRadioTVPresetList_Attributes_StationSelect_Bit8_s[gRadioTVPresetList_Attributes_StationSelect_Bit8[Element_3]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bit9_2, gRadioTVPresetList_Attributes_OnRadMute_Bit9[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bit9_2,gRadioTVPresetList_Attributes_OnRadMute_Bit9_s[gRadioTVPresetList_Attributes_OnRadMute_Bit9[Element_3]]);
                putvalue(env_ASG_AudioSD_RTPL_At_bitA_2, gRadioTVPresetList_Attributes_StationLinked_BitA[Element_3]);
                putvalue(env_ASG_AudioSD_RTPL_At_s_bitA_2,gRadioTVPresetList_Attributes_StationLinked_BitA_s[gRadioTVPresetList_Attributes_StationLinked_BitA[Element_3]]);
            }

            //Name
            if (gRadioTVPresetList_recordaddress ==0 || gRadioTVPresetList_recordaddress ==1 || gRadioTVPresetList_recordaddress ==2)
                putvalue(env_ASG_AudioSD_RTPL_Name_s_2,gRadioTVPresetList_Name[Element_3]);     
            }
        }
    }
}

on envVar env_ASG_AudioSD_RTPL_GetArray
{
    byte mode, shift, direction, transmitpos, indexsize,recordaddress;
    word requested_startelement, startelement, elements;

    // Init local variables. 
    mode                    =0;
    shift                   =0;
    direction               =0;
    transmitpos             =0;
    indexsize               =0;
    recordaddress           =0;
    requested_startelement  =0;
    startelement            =0;
    elements                =0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gRadioTVPresetList_ListHandlingType ==AUDIO_RADIOTVPRESETLIST_NOCACHE)
	{
        gRadioTVPresetList_ASGID            =getvalue(env_ASG_AudioSD_RTPL_ASGID);
        gRadioTVPresetList_TAID             =getvalue(env_ASG_AudioSD_RTPL_TAID);

        shift                           =getvalue(env_ASG_AudioSD_RTPL_AH_shift);
        direction                       =getvalue(env_ASG_AudioSD_RTPL_AH_dir);
        transmitpos                     =getvalue(env_ASG_AudioSD_RTPL_AH_PosTrans);
        recordaddress                   =getvalue(env_ASG_AudioSD_RTPL_AH_RA);
        indexsize                       =getvalue(env_ASG_AudioSD_RTPL_AH_IS);
        startelement                    =getvalue(env_ASG_AudioSD_RTPL_AH_start);
        elements                        =getvalue(env_ASG_AudioSD_RTPL_AH_elements);
        
        requested_startelement  =startelement;
        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

        RadioTVPresetList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
    }
}

on envVar env_ASG_AudioSD_RTPL_OnOff
{
    int i =0, j =0;
    if(POWER_ON==gASG_PowerOnOff)
	{   
        if(getvalue(this))
        {
            gRadioTVPresetList_ListHandlingType      =AUDIO_RADIOTVPRESETLIST_BUILDUPCACHE;             //build-up complete cache...
            gRadioTVPresetList_cacheBuildUp          =AUDIO_RADIOTVPRESETLIST_BUILDUPCACHECACHE_WINDOW; //...and start with area "window"            
        
            RadioTVPresetList_ListHandling ();
        }
        else
        {
            gRadioTVPresetList_SlidingWindow_State   =AUDIO_RADIOTVPRESETLIST_SLIDINGWINDOW_NOTACTIVE;
            gRadioTVPresetList_ListHandlingType      =AUDIO_RADIOTVPRESETLIST_NOCACHE;
            gRadioTVPresetList_cacheBuildUp          =AUDIO_RADIOTVPRESETLIST_BUILDUPCACHENOCACHE;
            gRadioTVPresetList_CallBackReason        =AUDIO_RADIOTVPRESETLIST_CALLBACKREASON_NOCALLBACK;

            gRadioTVPresetList_cacheDown             =FALSE;
            gRadioTVPresetList_cacheUp               =FALSE;
            gRadioTVPresetList_LastFirstElement      =0;

            gRadioTVPresetList_recordaddress         =0;
            gRadioTVPresetList_transmitpos           =1;
            gRadioTVPresetList_CursorAction          =AUDIO_RADIOTVPRESETLIST_CURSORACTION_NOTHING;
            gRadioTVPresetList_DisplayStatus         =AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_FIRST_ELEMENTS;
            
            for(j=0; j<AUDIO_RADIOTVPRESETLIST_ASGCACHE_MAX_SIZE; j++)
            {     
                gRadioTVPresetList_Pos[j]                               =0;
                gRadioTVPresetList_PresetIndex[j]                       =0;
                gRadioTVPresetList_Waveband[j]                          =0;
                gRadioTVPresetList_Attributes_IBOC_Bit0[j]              =0;
                gRadioTVPresetList_Attributes_DABSecServ_Bit1[j]        =0;
                gRadioTVPresetList_Attributes_DABPrimServ_Bit2[j]       =0;
                gRadioTVPresetList_Attributes_TP_Bit5[j]                =0;
                gRadioTVPresetList_Attributes_TMC_Bit6[j]               =0;
                gRadioTVPresetList_Attributes_SDRAS_Bit7[j]             =0;
                gRadioTVPresetList_Attributes_OnRadSecondary_Bit3[j]    =0;
                gRadioTVPresetList_Attributes_OnRadPrimary_Bit4[j]      =0;
                gRadioTVPresetList_Attributes_OnRadMute_Bit9[j]         =0;
                gRadioTVPresetList_Attributes_StationSelect_Bit8[j]     =0;
                gRadioTVPresetList_Attributes_StationLinked_BitA[j]     =0;
                gRadioTVPresetList_Attributes[j]                        =0;
                gRadioTVPresetList_ListEntryReceptionInformation[j]     =0;

                for(i=0;i<AUDIO_RADIOTVPRESETLIST_NAME_LENGTH;i++)
			        gRadioTVPresetList_Name[j][i] =0;
            }
            putvalue(env_ASG_AudioSD_RTPL_pos_0, 0);
            putvalue(env_ASG_AudioSD_RTPL_pos_1, 0);
            putvalue(env_ASG_AudioSD_RTPL_pos_2, 0);
    
            putvalue(env_ASG_AudioSD_RTPL_PI_0, 0);
            putvalue(env_ASG_AudioSD_RTPL_PI_1, 0);
            putvalue(env_ASG_AudioSD_RTPL_PI_2, 0);

            putvalue(env_ASG_AudioSD_RTPL_WB_0, 0);
            putvalue(env_ASG_AudioSD_RTPL_WB_1, 0);
            putvalue(env_ASG_AudioSD_RTPL_WB_2, 0);

            putvalue(env_ASG_AudioSD_RTPL_WB_s_0,empty_string);
            putvalue(env_ASG_AudioSD_RTPL_WB_s_1,empty_string);
            putvalue(env_ASG_AudioSD_RTPL_WB_s_2,empty_string);

            putvalue(env_ASG_AudioSD_RTPL_At_bit0_0, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit0_1, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit0_2, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit0_0, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit0_1, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit0_2, empty_string);

            putvalue(env_ASG_AudioSD_RTPL_At_bit1_0, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit1_1, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit1_2, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit1_0, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit1_1, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit1_2, empty_string);

            putvalue(env_ASG_AudioSD_RTPL_At_bit2_0, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit2_1, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit2_2, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit2_0, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit2_1, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit2_2, empty_string);

            putvalue(env_ASG_AudioSD_RTPL_At_bit5_0, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit5_1, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit5_2, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit5_0, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit5_1, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit5_2, empty_string);

            putvalue(env_ASG_AudioSD_RTPL_At_bit6_0, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit6_1, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit6_2, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit6_0, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit6_1, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit6_2, empty_string);

            putvalue(env_ASG_AudioSD_RTPL_At_bit7_0, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit7_1, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit7_2, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit7_0, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit7_1, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit7_2, empty_string);
            
            putvalue(env_ASG_AudioSD_RTPL_At_bit3_0, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit3_1, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit3_2, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit3_0, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit3_1, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit3_2, empty_string);
            
            putvalue(env_ASG_AudioSD_RTPL_At_bit4_0, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit4_1, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit4_2, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit4_0, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit4_1, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit4_2, empty_string);
            
            putvalue(env_ASG_AudioSD_RTPL_At_bit8_0, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit8_1, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit8_2, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit8_0, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit8_1, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit8_2, empty_string);
            
            putvalue(env_ASG_AudioSD_RTPL_At_bit9_0, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit9_1, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bit9_2, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit9_0, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit9_1, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bit9_2, empty_string);
            
            putvalue(env_ASG_AudioSD_RTPL_At_bitA_0, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bitA_1, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_bitA_2, 0);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bitA_0, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bitA_1, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_At_s_bitA_2, empty_string);
            
            putvalue(env_ASG_AudioSD_RTPL_Name_s_0, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_Name_s_1, empty_string);
            putvalue(env_ASG_AudioSD_RTPL_Name_s_2, empty_string);    
        }
    }
}   

on envVar env_ASG_AudioSD_RTPL_down
{
    int i=0, j=0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gRadioTVPresetList_ListHandlingType ==AUDIO_RADIOTVPRESETLIST_NOCACHE)
	{      
        gRadioTVPresetList_CursorAction =AUDIO_RADIOTVPRESETLIST_CURSORACTION_DOWN;
        
        if(gRadioTVPresetList_SlidingWindow_State ==AUDIO_RADIOTVPRESETLIST_SLIDINGWINDOW_ACTIVE)
        {   
            gRadioTVPresetList_ListHandlingType  =AUDIO_RADIOTVPRESETLIST_DOWN_CACHE;
            gRadioTVPresetList_DisplayStatus     =AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_FIRST_ELEMENTS;
            gRadioTVPresetList_CursorAction      =AUDIO_RADIOTVPRESETLIST_CURSORACTION_NOTHING;
            
            RadioTVPresetList_ListHandling ();
        }
        else if(gRadioTVPresetList_SlidingWindow_State ==AUDIO_RADIOTVPRESETLIST_SLIDINGWINDOW_NOTACTIVE)
        {
            gRadioTVPresetList_DisplayStatus     =AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_SEARCH_ELEMENTS;
            gRadioTVPresetList_CursorAction      =AUDIO_RADIOTVPRESETLIST_CURSORACTION_DOWN;

            RadioTVPresetList_display();

            //reset values
            gRadioTVPresetList_DisplayStatus     =AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_REFRESH;
            gRadioTVPresetList_CursorAction      =AUDIO_RADIOTVPRESETLIST_CURSORACTION_NOTHING;
        }
    }
}

on envVar env_ASG_AudioSD_RTPL_up
{
    int i=0, j=0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gRadioTVPresetList_ListHandlingType ==AUDIO_RADIOTVPRESETLIST_NOCACHE)
	{   
        gRadioTVPresetList_CursorAction =AUDIO_RADIOTVPRESETLIST_CURSORACTION_UP;

        if(gRadioTVPresetList_SlidingWindow_State ==AUDIO_RADIOTVPRESETLIST_SLIDINGWINDOW_ACTIVE)
        {  
            gRadioTVPresetList_ListHandlingType  =AUDIO_RADIOTVPRESETLIST_UP_CACHE;
            gRadioTVPresetList_DisplayStatus     =AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_FIRST_ELEMENTS;
            gRadioTVPresetList_CursorAction      =AUDIO_RADIOTVPRESETLIST_CURSORACTION_NOTHING;
            
            RadioTVPresetList_ListHandling ();
        }
        else if(gRadioTVPresetList_SlidingWindow_State ==AUDIO_RADIOTVPRESETLIST_SLIDINGWINDOW_NOTACTIVE)
        {
            gRadioTVPresetList_DisplayStatus     =AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_SEARCH_ELEMENTS;
            gRadioTVPresetList_CursorAction      =AUDIO_RADIOTVPRESETLIST_CURSORACTION_UP;

            RadioTVPresetList_ListHandling();
            
            RadioTVPresetList_display();

            //reset values
            gRadioTVPresetList_DisplayStatus     =AUDIO_RADIOTVPRESETLIST_DISPLAYLIST_REFRESH;
            gRadioTVPresetList_CursorAction      =AUDIO_RADIOTVPRESETLIST_CURSORACTION_NOTHING;
        }    
    }
}

int TpMemoList_GetNextCachedElement (int currentElement,byte direction)
{
    int i=0, nextElement=0;

    switch (direction)
    {
        case AUDIO_TPMEMOLIST_DISPLAYLIST_FIND_NEXT_ELEMENT:                
                nextElement = ++currentElement;

                if (nextElement<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE) //start at next element, if next element is not >8
                {
                    for(i =nextElement; i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(gTpMemoList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i= AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;
                        }
                        else
                            nextElement =0;
                    }
                }
                else    //start at first element
                {
                    nextElement =0;

                    for(i =nextElement; i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(gTpMemoList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;
                        }   
                    }
                }
        break;

        case AUDIO_TPMEMOLIST_DISPLAYLIST_FIND_PREVIUOS_ELEMENT:
                nextElement = --currentElement;
                if (nextElement ==0 && gTpMemoList_ListEntryReceptionInformation[nextElement] ==TRUE)
                    nextElement =0;
                else if (nextElement>0) 
                {
                    for(i =nextElement; i>0; i--)
                    {
                        if(gTpMemoList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =0;
                        }
                        else
                            nextElement =AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE-1;
                    }
                }    
                else    //start at last element
                {
                    nextElement =AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE-1;

                    for(i =nextElement; i>0; i--)
                    {
                        if(gTpMemoList_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =0;
                        }
                        else if(gTpMemoList_ListEntryReceptionInformation[0] ==TRUE)
                            nextElement =0;          
                    }
                }
        break;

        default:
        break;
    }
    return(nextElement);
}

int TpMemoList_GetNextLineInCache (int currentElement,byte direction)
{
    int i=0, nextElement=0;

    switch (direction)
    {
        case FORWARD:
                           
                if(currentElement<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE-1 && currentElement !=5) 
                    nextElement = ++currentElement;  
                
                else if (currentElement ==8)            
                    nextElement =0;
                else
                    nextElement =AUDIO_TPMEMOLIST_NO_NEXT_POSITION;
        break;

        case BACKWARD:
                if(currentElement<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE && currentElement !=0 && currentElement !=6) 
                    nextElement =--currentElement;
                
                else if (currentElement ==0)            
                    nextElement =8;
                
                else
                    nextElement =AUDIO_TPMEMOLIST_NO_NEXT_POSITION;
        break;

        default:
        break;
    }
    return(nextElement);
}

TpMemoList_Request(byte request, byte mode, byte recordaddress, word requested_startelement, word startelement, word elements)
{   
    int  i;
    dword requestarray [BAP_BUFFER_SIZE], Offset;
    word indexsize;

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;
    
    indexsize   =0;
    Offset      =0;

    // decode "mode-byte"
    indexsize   =(mode &0x08)/0x08; 

    // Handle request.
    requestarray[0] =LSG_AudioSD;	            //LSG-ID
	requestarray[1] =FctID_TPMemoList;	        //Fct.-ID
	requestarray[2] =request;                   //request type

    switch(request)
	{
        case DataGet_REQ:            
                requestarray[3] =((gTpMemoList_ASGID *0x10) &0xF0) +(gTpMemoList_TAID &0x0F);
                
                /***ArrayHeader***/
			    requestarray[4] =((mode *0x10) &0xF0) +(recordaddress &0x0F);          
                Offset =5;

                if(indexsize)
                {
                    requestarray[Offset] =requested_startelement &0x00FF;
                    Offset++;
                    requestarray[Offset] =(requested_startelement &0xFF00) /0x100;
                    Offset++;  

                    requestarray[Offset] =elements &0x00FF;
                    Offset++;
                    requestarray[Offset] =(elements &0xFF00) /0x100;
                    Offset++;       
                }
                else
                {
                    requestarray[Offset] =requested_startelement;
                    Offset++;

                    requestarray[Offset] =elements;
                    Offset++;
                }
            
            set_status_requestbuffer (requestarray, Offset, Bap_ByteSequence);
         break;

        default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD TpMemoList_Request: invalid request %d", request);
		break;
    }
}

TpMemoList_Indication(dword Indication_array [], int datalength)
{
    byte mode, direction, shift, recordaddress, indexsize, current_element, transmitpos, length, CacheElements, StartElementInCache;
    word  startelement, elements, startelement_check, Offset =0;
    int i =0, j=0;

    // Init local variables
    mode                    =0;
    direction               =0;
    shift                   =0;
    recordaddress           =0;
    startelement            =0;
    elements                =0;
    current_element         =0;
    transmitpos             =0;
    length                  =0;
    startelement_check      =0;
    StartElementInCache     =FALSE;
    CacheElements           =FALSE;
    
		switch (gBAP_Indication[2])
		{
			case Data_IND:
				//get data
                gTpMemoList_ASGID =(Indication_array[3] &0xF0) /0x10;
                gTpMemoList_TAID  =Indication_array[3] &0x0F;             

                gTpMemoList_TotalNumListElements =Indication_array[4];
              
                /***ArrayHeader***/
                mode            =(Indication_array[5] &0xF0) /0x10;
                recordaddress   =Indication_array[5] &0x0F;
                Offset =6;
                
                // decode "mode-byte"
                shift       =mode &0x01;
                direction   =(mode &0x02)/0x02;
                transmitpos =(mode &0x04)/0x04;
                indexsize   =(mode &0x08)/0x08; 
                
                if (indexsize)
                {   
                    startelement =Indication_array[Offset];
                    Offset++;
                    startelement +=(Indication_array[Offset] *0x100);
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                    elements +=(Indication_array[Offset] *0x100);
                    Offset++;
                }
                else
                {   
                    startelement =Indication_array[Offset];
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                }           
                
                if(startelement !=0)
                {
                    for (i=0;i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(startelement ==gTpMemoList_Pos[i])  
                            i =AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;              
                    }
                }
                
                switch (recordaddress)
                {
                    case 0: //recordaddress =0 -> complete record
                         
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gTpMemoList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gTpMemoList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =TpMemoList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gTpMemoList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gTpMemoList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                              
                            /***copy elements***/
                            if (current_element !=AUDIO_TPMEMOLIST_NO_NEXT_POSITION) 
                            {   
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gTpMemoList_Pos[i] && gTpMemoList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gTpMemoList_Pos[i] && gTpMemoList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gTpMemoList_ListHandlingType !=AUDIO_TPMEMOLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gTpMemoList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++; 
                                        
                                        gTpMemoList_Attributes_NewMessage_Bit0[current_element]        =(gTpMemoList_Attributes[current_element] &0x01);
                                    }

                                    //MessageTime_Hour
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Hour[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //MessageTime_Minute
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Minute[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //StationName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_TPMEMOLIST_STATIONNAME_LENGTH;i++) //clear
			                                gTpMemoList_StationName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gTpMemoList_StationName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gTpMemoList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =TpMemoList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gTpMemoList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =TpMemoList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_TPMEMOLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gTpMemoList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gTpMemoList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gTpMemoList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++; 
                                        
                                        gTpMemoList_Attributes_NewMessage_Bit0[current_element]        =(gTpMemoList_Attributes[current_element] &0x01);
                                    }

                                    //MessageTime_Hour
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Hour[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //MessageTime_Minute
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Minute[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //StationName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_TPMEMOLIST_STATIONNAME_LENGTH;i++) //clear
			                                gTpMemoList_StationName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gTpMemoList_StationName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gTpMemoList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =TpMemoList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0 ends
                    
                    case 1: //recordaddress =1 -> Attributes, MessageTime_Hour, MessageTime_Minute
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gTpMemoList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gTpMemoList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =TpMemoList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gTpMemoList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gTpMemoList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                              
                            /***copy elements***/
                            if (current_element !=AUDIO_TPMEMOLIST_NO_NEXT_POSITION) 
                            {   
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gTpMemoList_Pos[i] && gTpMemoList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gTpMemoList_Pos[i] && gTpMemoList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gTpMemoList_ListHandlingType !=AUDIO_TPMEMOLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gTpMemoList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++; 
                                        
                                        gTpMemoList_Attributes_NewMessage_Bit0[current_element]        =(gTpMemoList_Attributes[current_element] &0x01);
                                    }

                                    //MessageTime_Hour
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Hour[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //MessageTime_Minute
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Minute[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gTpMemoList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =TpMemoList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gTpMemoList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =TpMemoList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_TPMEMOLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gTpMemoList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gTpMemoList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gTpMemoList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++; 
                                        
                                        gTpMemoList_Attributes_NewMessage_Bit0[current_element]        =(gTpMemoList_Attributes[current_element] &0x01);
                                    }

                                    //MessageTime_Hour
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Hour[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //MessageTime_Minute
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Minute[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gTpMemoList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =TpMemoList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =1 ends
                    
                    
                    
                    case 15: //recordaddress =0xf -> Pos
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gTpMemoList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gTpMemoList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =TpMemoList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gTpMemoList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gTpMemoList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                              
                            /***copy elements***/
                            if (current_element !=AUDIO_TPMEMOLIST_NO_NEXT_POSITION) 
                            {   
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gTpMemoList_Pos[i] && gTpMemoList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gTpMemoList_Pos[i] && gTpMemoList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gTpMemoList_ListHandlingType !=AUDIO_TPMEMOLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gTpMemoList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                    
                                        gTpMemoList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =TpMemoList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gTpMemoList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =TpMemoList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_TPMEMOLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gTpMemoList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gTpMemoList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gTpMemoList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gTpMemoList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =TpMemoList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                        
                     break; //recordaddress =0xf ends
                }
                                   
                //Panel
                putvalue(env_ASG_AudioSD_TML_ASGID, gTpMemoList_ASGID);
                putvalue(env_ASG_AudioSD_TML_TAID, gTpMemoList_TAID);
                putvalue(env_ASG_AudioSD_TML_TotalNumLE, gTpMemoList_TotalNumListElements);

                gTpMemoList_recordaddress =recordaddress;
                gTpMemoList_transmitpos   =transmitpos;             
            
			break;

            case Changed_IND:
                /***ArrayHeader***/
                mode            =(Indication_array[3] &0xF0) /0x10;
                recordaddress   =Indication_array[3] &0x0F;
                Offset =4;
                
                // decode "mode-byte"
                shift       =mode &0x01;
                direction   =(mode &0x02)/0x02;
                transmitpos =(mode &0x04)/0x04;
                indexsize   =(mode &0x08)/0x08; 
                
                if (indexsize)
                {   
                    startelement =Indication_array[Offset];
                    Offset++;
                    startelement +=(Indication_array[Offset] *0x100);
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                    elements +=(Indication_array[Offset] *0x100);
                    Offset++;
                }
                else
                {   
                    startelement =Indication_array[Offset];
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                }           
                
                if(startelement !=0)
                {
                    for (i=0;i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(startelement ==gTpMemoList_Pos[i])  
                            i =AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;              
                    }
                }
                
                if(startelement ==0 && shift==0 && transmitpos==0 && recordaddress==0 && elements==255) //check 'full range update'?
                {
                    putvalue(env_ASG_AudioSD_TML_OnOff, FALSE);
                    putvalue(env_ASG_AudioSD_TML_ListOpState, "'full range update' received");
                }
                else if (datalength>8)
                {
                switch (recordaddress)
                {
                    case 0: //recordaddress =0 -> complete record
                         
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gTpMemoList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gTpMemoList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =TpMemoList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gTpMemoList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gTpMemoList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                              
                            /***copy elements***/
                            if (current_element !=AUDIO_TPMEMOLIST_NO_NEXT_POSITION) 
                            {   
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gTpMemoList_Pos[i] && gTpMemoList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gTpMemoList_Pos[i] && gTpMemoList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gTpMemoList_ListHandlingType !=AUDIO_TPMEMOLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gTpMemoList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++; 
                                        
                                        gTpMemoList_Attributes_NewMessage_Bit0[current_element]        =(gTpMemoList_Attributes[current_element] &0x01);
                                    }

                                    //MessageTime_Hour
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Hour[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //MessageTime_Minute
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Minute[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //StationName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_TPMEMOLIST_STATIONNAME_LENGTH;i++) //clear
			                                gTpMemoList_StationName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gTpMemoList_StationName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gTpMemoList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =TpMemoList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gTpMemoList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =TpMemoList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_TPMEMOLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gTpMemoList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gTpMemoList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gTpMemoList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++; 
                                        
                                        gTpMemoList_Attributes_NewMessage_Bit0[current_element]        =(gTpMemoList_Attributes[current_element] &0x01);
                                    }

                                    //MessageTime_Hour
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Hour[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //MessageTime_Minute
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Minute[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //StationName
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_TPMEMOLIST_STATIONNAME_LENGTH;i++) //clear
			                                gTpMemoList_StationName[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gTpMemoList_StationName[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gTpMemoList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =TpMemoList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0 ends
                    
                    case 1: //recordaddress =1 -> Attributes, MessageTime_Hour, MessageTime_Minute
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gTpMemoList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gTpMemoList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =TpMemoList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gTpMemoList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gTpMemoList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                              
                            /***copy elements***/
                            if (current_element !=AUDIO_TPMEMOLIST_NO_NEXT_POSITION) 
                            {   
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gTpMemoList_Pos[i] && gTpMemoList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gTpMemoList_Pos[i] && gTpMemoList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gTpMemoList_ListHandlingType !=AUDIO_TPMEMOLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gTpMemoList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++; 
                                        
                                        gTpMemoList_Attributes_NewMessage_Bit0[current_element]        =(gTpMemoList_Attributes[current_element] &0x01);
                                    }

                                    //MessageTime_Hour
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Hour[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //MessageTime_Minute
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Minute[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gTpMemoList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =TpMemoList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gTpMemoList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =TpMemoList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_TPMEMOLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gTpMemoList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gTpMemoList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gTpMemoList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++; 
                                        
                                        gTpMemoList_Attributes_NewMessage_Bit0[current_element]        =(gTpMemoList_Attributes[current_element] &0x01);
                                    }

                                    //MessageTime_Hour
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Hour[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //MessageTime_Minute
                                    if(CacheElements ==TRUE)
                                    {
                                        gTpMemoList_Minute[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gTpMemoList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =TpMemoList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =1 ends
                    
                    
                    
                    case 15: //recordaddress =0xf -> Pos
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gTpMemoList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gTpMemoList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =TpMemoList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gTpMemoList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gTpMemoList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                              
                            /***copy elements***/
                            if (current_element !=AUDIO_TPMEMOLIST_NO_NEXT_POSITION) 
                            {   
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gTpMemoList_Pos[i] && gTpMemoList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gTpMemoList_Pos[i] && gTpMemoList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gTpMemoList_ListHandlingType !=AUDIO_TPMEMOLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gTpMemoList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                    
                                        gTpMemoList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =TpMemoList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gTpMemoList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =TpMemoList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_TPMEMOLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gTpMemoList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gTpMemoList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gTpMemoList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gTpMemoList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gTpMemoList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =TpMemoList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                        
                     break; //recordaddress =0xf ends
                }
                }
                                   
                //Panel
                putvalue(env_ASG_AudioSD_TML_ASGID, gTpMemoList_ASGID);
                putvalue(env_ASG_AudioSD_TML_TAID, gTpMemoList_TAID);
                putvalue(env_ASG_AudioSD_TML_TotalNumLE, gTpMemoList_TotalNumListElements);

                gTpMemoList_recordaddress =recordaddress;
                gTpMemoList_transmitpos   =transmitpos; 
            break;
			
            case Error_IND:
					
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD TpMemoList_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD TpMemoList_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD TpMemoList_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD TpMemoList_Indication: Application-Error: 0x%x", Indication_array[3]);
				
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD TpMemoList_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
		}

    //for "sliding window concept"
    if(gTpMemoList_TotalNumListElements<=AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE)
        gTpMemoList_SlidingWindow_State =AUDIO_TPMEMOLIST_SLIDINGWINDOW_NOTACTIVE;
    else
        gTpMemoList_SlidingWindow_State =AUDIO_TPMEMOLIST_SLIDINGWINDOW_ACTIVE;

    if (gTpMemoList_CallBackReason !=AUDIO_TPMEMOLIST_CALLBACKREASON_NOCALLBACK)
        TpMemoList_ListHandling ();
    else
        TpMemoList_display();
}

TpMemoList_ListHandling () //for sliding window concept, list handling and 'build-up' list...
{
    byte mode, shift, direction, transmitpos, indexsize, recordaddress, buffer_Attributes_bit0, buffer_Attributes, buffer_Hour, buffer_Minute, buffer_ReceptionInformation;
    word requested_startelement, startelement, elements, buffer_Pos;
    char buffer_StationName[AUDIO_TPMEMOLIST_STATIONNAME_LENGTH];
    int i,j,k;

    // Init local variables. 
    mode                        =0;
    shift                       =0;
    direction                   =0;
    transmitpos                 =0;
    indexsize                   =0;
    recordaddress               =0;
    requested_startelement      =0;
    startelement                =0;
    elements                    =0;
    i                           =0;
    j                           =0;
    k                           =0;
    buffer_Pos                  =0;
    buffer_Hour                 =0;
    buffer_Minute               =0;
    buffer_ReceptionInformation =0;
    buffer_Attributes           =0;
    buffer_Attributes_bit0      =0;
    
    /***build-up complete cache***/

    switch (gTpMemoList_ListHandlingType)
    {
        case AUDIO_TPMEMOLIST_BUILDUPCACHE:
             
            switch (gTpMemoList_cacheBuildUp)
            {   
                //cache-up  
                case AUDIO_TPMEMOLIST_BUILDUPCACHECACHE_UP:  
                    if(gTpMemoList_CallBackReason !=AUDIO_TPMEMOLIST_BUILDUPCACHENOCACHE && gTpMemoList_CallBackReason !=AUDIO_TPMEMOLIST_CALLBACKREASON_CACHENEXT)
                    {
                        switch (gTpMemoList_CallBackReason)
                        {
                            case AUDIO_TPMEMOLIST_CALLBACKREASON_CHECKCACHE:

                                    if(gTpMemoList_ListEntryReceptionInformation[2] ==TRUE) //cache-down required?
                                    {            
                                        gTpMemoList_cacheBuildUp      =AUDIO_TPMEMOLIST_BUILDUPCACHECACHE_DOWN;      //next step: build-up upper cache
                                        gTpMemoList_CallBackReason    =AUDIO_TPMEMOLIST_CALLBACKREASON_CACHENEXT;    
                                        
                                        
                                        TpMemoList_ListHandling ();
                                    }
                                    else //stop caching
                                    {   
                                        gTpMemoList_cacheBuildUp      =AUDIO_TPMEMOLIST_BUILDUPCACHENOCACHE;  //"build-up cache" finished
                                        gTpMemoList_ListHandlingType  =AUDIO_TPMEMOLIST_NOCACHE;              
                                        gTpMemoList_CallBackReason    =AUDIO_TPMEMOLIST_CALLBACKREASON_NOCALLBACK; 
                                        gTpMemoList_CursorAction      =AUDIO_TPMEMOLIST_CURSORACTION_NOTHING;
                                        
                                        putvalue(env_ASG_AudioSD_TML_ListOpState, empty_string);
                                        TpMemoList_display();
                                    }
                            break;
                        }
                    }
                    else
                    {   
                        shift               =TRUE;
                        direction           =BACKWARD;
                        transmitpos         =FALSE;
                        indexsize           =FALSE;
                        recordaddress       =0;
                        startelement        =0;
                        elements            =3;
                
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gTpMemoList_CallBackReason  =AUDIO_TPMEMOLIST_CALLBACKREASON_CHECKCACHE;

                        TpMemoList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;
                
                //cache "window"
                case AUDIO_TPMEMOLIST_BUILDUPCACHECACHE_WINDOW: 
                    if(gTpMemoList_CallBackReason !=AUDIO_TPMEMOLIST_BUILDUPCACHENOCACHE && gTpMemoList_CallBackReason !=AUDIO_TPMEMOLIST_CALLBACKREASON_CACHENEXT)
                    {   
                        switch (gTpMemoList_CallBackReason)
                        {
                            case AUDIO_TPMEMOLIST_CALLBACKREASON_CHECKCACHE:
                                                 
                                    gTpMemoList_cacheBuildUp      =AUDIO_TPMEMOLIST_BUILDUPCACHECACHE_UP;      //next step: build-up upper cache
                                    gTpMemoList_CallBackReason    =AUDIO_TPMEMOLIST_CALLBACKREASON_CACHENEXT;    
                                    
                                    TpMemoList_ListHandling ();
                            break;
                        }
                    }
                    else
                    { 
                        putvalue(env_ASG_AudioSD_TML_ListOpState, "build-up list...");
                        shift               =FALSE;
                        direction           =FORWARD;
                        transmitpos         =FALSE;
                        indexsize           =FALSE;
                        recordaddress       =0;
                        startelement        =0;
                        elements            =3; 
    
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gTpMemoList_CallBackReason  =AUDIO_TPMEMOLIST_CALLBACKREASON_CHECKCACHE;

                        TpMemoList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;
                
                //cache-down
                case AUDIO_TPMEMOLIST_BUILDUPCACHECACHE_DOWN:   
                    if(gTpMemoList_CallBackReason !=AUDIO_TPMEMOLIST_BUILDUPCACHENOCACHE && gTpMemoList_CallBackReason !=AUDIO_TPMEMOLIST_CALLBACKREASON_CACHENEXT)
                    {
                        switch (gTpMemoList_CallBackReason)
                        {
                            case AUDIO_TPMEMOLIST_CALLBACKREASON_CHECKCACHE:
                                    
                                    //stop caching
                                    gTpMemoList_cacheBuildUp      =AUDIO_TPMEMOLIST_BUILDUPCACHENOCACHE;  //"build-up cache" finished
                                    gTpMemoList_ListHandlingType  =AUDIO_TPMEMOLIST_NOCACHE;              
                                    gTpMemoList_CallBackReason    =AUDIO_TPMEMOLIST_CALLBACKREASON_NOCALLBACK;
                                    gTpMemoList_CursorAction      =AUDIO_TPMEMOLIST_CURSORACTION_NOTHING;
                                    
                                    gTpMemoList_DisplayStatus     =AUDIO_TPMEMOLIST_DISPLAYLIST_REFRESH;
                                    
                                    putvalue(env_ASG_AudioSD_TML_ListOpState, empty_string);
                                    
                                    TpMemoList_display();
                            break;
                        }
                    }
                    else
                    { 
                        shift                   =TRUE;
                        direction               =FORWARD;
                        transmitpos             =FALSE;
                        indexsize               =FALSE;
                        recordaddress           =0;
                        for(i=0;i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE; i++) //find last cached element
                        {   
                            if(gTpMemoList_ListEntryReceptionInformation[i] ==FALSE) //abort loop
                                i =AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE; 
                            else
                                startelement    =gTpMemoList_Pos[i];
                        }
                        elements                =3;                         
        
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        gTpMemoList_CallBackReason    =AUDIO_TPMEMOLIST_CALLBACKREASON_CHECKCACHE;
                        
                        TpMemoList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                    }
                break;

                default:
                break;
            }//build-up cache finished
        break;
        
        /********sliding-window********/
        case AUDIO_TPMEMOLIST_DOWN_CACHE: 
                    if (gTpMemoList_CallBackReason ==AUDIO_TPMEMOLIST_CALLBACKREASON_CHECKCACHE) //check if valid data received
                    {   
                        if(gTpMemoList_ListEntryReceptionInformation[5] ==0) //No valid data in last list pos -> last list element reached, start with element 0!  
                        {    
                            shift                   =FALSE;
                            direction               =FORWARD;
                            transmitpos             =FALSE;
                            indexsize               =FALSE;
                            recordaddress           =0;
                            startelement            =0; //first element
                            elements                =1;        
                            
                            requested_startelement  =startelement;
                            mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;
                            
                            gTpMemoList_CallBackReason    =AUDIO_TPMEMOLIST_CALLBACKREASON_DISPLAYLIST; 
                            gTpMemoList_cacheDown         =TRUE;

                            TpMemoList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);    
                        }
                        else
                        {
                            gTpMemoList_CallBackReason =AUDIO_TPMEMOLIST_CALLBACKREASON_DISPLAYLIST;
                            TpMemoList_ListHandling(); 
                        }    
                    }
                    else if (gTpMemoList_CallBackReason ==AUDIO_TPMEMOLIST_CALLBACKREASON_DISPLAYLIST)
                    {   
                        gTpMemoList_ListHandlingType  =AUDIO_TPMEMOLIST_NOCACHE;
                        gTpMemoList_cacheDown         =FALSE;
                        gTpMemoList_DisplayStatus     =AUDIO_TPMEMOLIST_DISPLAYLIST_FIRST_ELEMENTS;
                        
                        putvalue(env_ASG_AudioSD_TML_ListOpState, empty_string);
                        TpMemoList_display();
                        gTpMemoList_DisplayStatus     =AUDIO_TPMEMOLIST_DISPLAYLIST_REFRESH;
                        gTpMemoList_CallBackReason    =AUDIO_TPMEMOLIST_CALLBACKREASON_NOCALLBACK;
                    }
                    else
                    {   
                        putvalue(env_ASG_AudioSD_TML_ListOpState, "list operating...");
                                
                        shift                   =TRUE;
                        direction               =FORWARD;
                        transmitpos             =FALSE;
                        indexsize               =FALSE;
                        recordaddress           =0;
                        startelement            =gTpMemoList_Pos[5]; //last element
                        elements                =1;
                        
                        for(i=0;i<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE;i++)
                        {   
                            j =i+1;
                            
                            switch (i)
                            {   
                                case 0: 
                                    //buffer data of Pos '0' (local)
                                    buffer_Pos              =gTpMemoList_Pos[i];
                                    buffer_Attributes       =gTpMemoList_Attributes[i];
                                    buffer_Attributes_bit0  =gTpMemoList_Attributes_NewMessage_Bit0[i];
                                    buffer_Hour             =gTpMemoList_Hour[i];
                                    buffer_Minute           =gTpMemoList_Minute[i];
                                    
                                    for (k=0; k<AUDIO_TPMEMOLIST_STATIONNAME_LENGTH;k++) //clear string
                                        buffer_StationName[k] =0;                                     

                                    for(k=0;k<strlen(gTpMemoList_StationName[i]);k++) 
                                        buffer_StationName[k]=gTpMemoList_StationName[i][k];

                                    //copy data from Pos '1' to Pos '0'
                                    gTpMemoList_Pos[i]                           =gTpMemoList_Pos[j]; 
                                    gTpMemoList_Attributes[i]                    =gTpMemoList_Attributes[j];
                                    gTpMemoList_Attributes_NewMessage_Bit0[i]    =gTpMemoList_Attributes_NewMessage_Bit0[j];
                                    gTpMemoList_Hour[i]                          =gTpMemoList_Hour[j]; 
                                    gTpMemoList_Minute[i]                        =gTpMemoList_Minute[j];    
                                    
                                    for (k=0; k<AUDIO_TPMEMOLIST_STATIONNAME_LENGTH;k++) //clear string
                                        gTpMemoList_StationName[i][k] =0;                                     

                                    for(k=0;k<strlen(gTpMemoList_StationName[j]);k++) 
                                        gTpMemoList_StationName[i][k]=gTpMemoList_StationName[j][k];

                                break;
                            
                                case 5:
                                    //clear last element in list 
                                    gTpMemoList_ListEntryReceptionInformation[i]    =0;
                                    gTpMemoList_Pos[i]                              =0;
                                    gTpMemoList_Attributes[i]                       =0;
                                    gTpMemoList_Attributes_NewMessage_Bit0[i]       =0;
                                    gTpMemoList_Hour[i]                             =0;
                                    gTpMemoList_Minute[i]                           =0;

                                    for (k=0; k<AUDIO_TPMEMOLIST_STATIONNAME_LENGTH;k++) //clear string
                                        gTpMemoList_StationName[i][k] =0;
                                                                 
                                break;
                            
                                case 8:
                                    //copy data from buffer in Pos '8'
                                    gTpMemoList_Pos[i]                           =buffer_Pos; 
                                    gTpMemoList_Attributes[i]                    =buffer_Attributes;
                                    gTpMemoList_Attributes_NewMessage_Bit0[i]    =buffer_Attributes_bit0;
                                    gTpMemoList_Hour[i]                          =buffer_Hour;
                                    gTpMemoList_Minute[i]                        =buffer_Minute;
                                    
                                    for (k=0; k<AUDIO_TPMEMOLIST_STATIONNAME_LENGTH;k++) //clear string
                                        gTpMemoList_StationName[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_StationName);k++) 
                                        gTpMemoList_StationName[i][k]=buffer_StationName[k];

                                break;
                                
                                default://other elements
                                    //copy element on other position
                                    gTpMemoList_Pos[i]                          =gTpMemoList_Pos[j]; 
                                    gTpMemoList_Attributes[i]                   =gTpMemoList_Attributes[j];
                                    gTpMemoList_Attributes_NewMessage_Bit0[i]   =gTpMemoList_Attributes_NewMessage_Bit0[j];
                                    gTpMemoList_Hour[i]                         =gTpMemoList_Hour[j];
                                    gTpMemoList_Minute[i]                       =gTpMemoList_Minute[j];
                                 
                                    for (k=0; k<AUDIO_TPMEMOLIST_STATIONNAME_LENGTH;k++) //clear string
                                        gTpMemoList_StationName[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gTpMemoList_StationName[j]);k++) 
                                        gTpMemoList_StationName[i][k]=gTpMemoList_StationName[j][k];
                                        
                                break;
                            } // end of switch 'i'
                        }
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        TpMemoList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);                        
                        
                        //to check, if valid data received
                        gTpMemoList_CallBackReason    =AUDIO_TPMEMOLIST_CALLBACKREASON_CHECKCACHE;
                    }
        break;

        case AUDIO_TPMEMOLIST_UP_CACHE: 
                    if (gTpMemoList_CallBackReason ==AUDIO_TPMEMOLIST_CALLBACKREASON_CHECKCACHE) //check if valid data received
                    {   
                        if(gTpMemoList_ListEntryReceptionInformation[6] ==0) //No valid data in first list pos -> last list element reached, start with element 0!  
                        {
                            shift                   =TRUE;
                            direction               =BACKWARD;
                            transmitpos             =FALSE;
                            indexsize               =FALSE;
                            recordaddress           =0;
                            startelement            =0; //Last element
                            elements                =1;        
                            
                            requested_startelement  =startelement;
                            mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                            gTpMemoList_cacheUp        =TRUE;
                            gTpMemoList_CallBackReason =AUDIO_TPMEMOLIST_CALLBACKREASON_DISPLAYLIST;
                            
                            TpMemoList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
                        }
                        else
                        {
                            gTpMemoList_CallBackReason =AUDIO_TPMEMOLIST_CALLBACKREASON_DISPLAYLIST;
                            TpMemoList_ListHandling();
                        }           
                    }

                    else if (gTpMemoList_CallBackReason ==AUDIO_TPMEMOLIST_CALLBACKREASON_DISPLAYLIST)
                    {   
                        gTpMemoList_ListHandlingType  =AUDIO_TPMEMOLIST_NOCACHE;
                        gTpMemoList_cacheUp           =FALSE;
                        gTpMemoList_DisplayStatus     =AUDIO_TPMEMOLIST_DISPLAYLIST_FIRST_ELEMENTS;
                        
                        putvalue(env_ASG_AudioSD_TML_ListOpState, empty_string);
                        TpMemoList_display();
                        gTpMemoList_DisplayStatus     =AUDIO_TPMEMOLIST_DISPLAYLIST_REFRESH;
                        gTpMemoList_CallBackReason    =AUDIO_TPMEMOLIST_CALLBACKREASON_NOCALLBACK;
                    }

                    else
                    {           
                        putvalue(env_ASG_AudioSD_TML_ListOpState, "list operating...");

                        shift                   =TRUE;
                        direction               =BACKWARD;
                        transmitpos             =FALSE;
                        indexsize               =FALSE;
                        recordaddress           =0;
                        startelement            =gTpMemoList_Pos[6]; //first element
                        elements                =1;
                    
                        for(i=AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE-1;i>=0;i--)
                        {  
                            j =i-1;
                            switch (i)
                            {   
                                case 8: 
                                    //buffer data of Pos '8' (local)
                                    buffer_Pos              =gTpMemoList_Pos[i];
                                    buffer_Attributes       =gTpMemoList_Attributes[i];
                                    buffer_Attributes_bit0  =gTpMemoList_Attributes_NewMessage_Bit0[i];                              
                                    buffer_Hour             =gTpMemoList_Hour[i];
                                    buffer_Minute           =gTpMemoList_Minute[i];
                                    
                                    for (k=0; k<AUDIO_TPMEMOLIST_STATIONNAME_LENGTH;k++) //clear string
                                        buffer_StationName[k] =0;                                     

                                    for(k=0;k<strlen(gTpMemoList_StationName[i]);k++) 
                                        buffer_StationName[k]=gTpMemoList_StationName[i][k];

                                    //copy data from Pos '7' to Pos '8'
                                    gTpMemoList_Pos[i]                          =gTpMemoList_Pos[j]; 
                                    gTpMemoList_Attributes[i]                   =gTpMemoList_Attributes[j];
                                    gTpMemoList_Attributes_NewMessage_Bit0[i]   =gTpMemoList_Attributes_NewMessage_Bit0[j];
                                    gTpMemoList_Hour[i]                         =gTpMemoList_Hour[j];
                                    gTpMemoList_Minute[i]                       =gTpMemoList_Minute[j];

                                    for (k=0; k<AUDIO_TPMEMOLIST_STATIONNAME_LENGTH;k++) //clear string
                                        gTpMemoList_StationName[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gTpMemoList_StationName[j]);k++) 
                                        gTpMemoList_StationName[i][k]=gTpMemoList_StationName[j][k];
                                    
                                break;
                            
                                case 6: 
                                    //clear first element in list 
                                    gTpMemoList_ListEntryReceptionInformation[i]    =0;
                                    gTpMemoList_Pos[i]                              =0;
                                    gTpMemoList_Attributes[i]                       =0;
                                    gTpMemoList_Attributes_NewMessage_Bit0[i]       =0;
                                    gTpMemoList_Hour[i]                             =0;
                                    gTpMemoList_Minute[i]                           =0;                            
                                    
                                    for (k=0; k<AUDIO_TPMEMOLIST_STATIONNAME_LENGTH;k++) //clear string
                                        gTpMemoList_StationName[i][k] =0;
                                                                            
                                break;
                            
                                case 0: 
                                    //copy data from buffer in Pos '0'
                                    gTpMemoList_Pos[i]                          =buffer_Pos; 
                                    gTpMemoList_Attributes[i]                   =buffer_Attributes;
                                    gTpMemoList_Attributes_NewMessage_Bit0[i]   =buffer_Attributes_bit0;
                                    gTpMemoList_Hour[i]                         =buffer_Hour;
                                    gTpMemoList_Minute[i]                       =buffer_Minute;

                                    for (k=0; k<AUDIO_TPMEMOLIST_STATIONNAME_LENGTH;k++) //clear string
                                        gTpMemoList_StationName[i][k] =0; 
                                    
                                    for(k=0;k<strlen(buffer_StationName);k++) 
                                        gTpMemoList_StationName[i][k]=buffer_StationName[k];

                                break;
                                
                                default: //other elements
                                    //copy element on other position
                                    gTpMemoList_Pos[i]                          =gTpMemoList_Pos[j]; 
                                    gTpMemoList_Attributes[i]                   =gTpMemoList_Attributes[j];
                                    gTpMemoList_Attributes_NewMessage_Bit0[i]   =gTpMemoList_Attributes_NewMessage_Bit0[j];
                                    gTpMemoList_Hour[i]                         =gTpMemoList_Hour[j];
                                    gTpMemoList_Minute[i]                       =gTpMemoList_Minute[j];

                                    for (k=0; k<AUDIO_TPMEMOLIST_STATIONNAME_LENGTH;k++) //clear string
                                        gTpMemoList_StationName[i][k] =0; 
                                    
                                    for(k=0;k<strlen(gTpMemoList_StationName[j]);k++) 
                                        gTpMemoList_StationName[i][k]=gTpMemoList_StationName[j][k];
                                     
                                break;
                            } // end of switch 'i'
                        }
                        requested_startelement  =startelement;
                        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

                        TpMemoList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);                        
                        
                        //to check, if valid data received
                        gTpMemoList_CallBackReason    =AUDIO_TPMEMOLIST_CALLBACKREASON_CHECKCACHE;
                    }
        break;

        default:
        break;
    } //end of switch 'type of cache handling' 
}

TpMemoList_display()
{   
    int Element_1 =0, Element_2 =1, Element_3 =2;

    if(POWER_ON==gASG_PowerOnOff && getvalue(env_ASG_AudioSD_TML_OnOff))
	{   
        /******'sliding window' not active******/         
        if(gTpMemoList_DisplayStatus ==AUDIO_TPMEMOLIST_DISPLAYLIST_SEARCH_ELEMENTS)
        {
            //1. Element              
            if(gTpMemoList_CursorAction ==AUDIO_TPMEMOLIST_CURSORACTION_DOWN)
                Element_1 =TpMemoList_GetNextCachedElement(gTpMemoList_LastFirstElement, AUDIO_TPMEMOLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);
            
            else if(gTpMemoList_CursorAction ==AUDIO_TPMEMOLIST_CURSORACTION_UP)            
                Element_1 =TpMemoList_GetNextCachedElement(gTpMemoList_LastFirstElement, AUDIO_TPMEMOLIST_DISPLAYLIST_FIND_PREVIUOS_ELEMENT);

            //Pos
            putvalue(env_ASG_AudioSD_TML_pos_0, gTpMemoList_Pos[Element_1]);               

            //Attributes
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_TML_At_bit0_0, gTpMemoList_Attributes_NewMessage_Bit0[Element_1]);
                putvalue(env_ASG_AudioSD_TML_At_s_bit0_0,gTpMemoList_Attributes_NewMessage_Bit0_s[gTpMemoList_Attributes_NewMessage_Bit0[Element_1]]);
            }
            
            //MessageTime_Hour
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_TML_Hour_0,gTpMemoList_Hour[Element_1]);

            //MessageTime_Minute
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_TML_Minute_0,gTpMemoList_Minute[Element_1]);

            //StationName
            if (gTpMemoList_recordaddress ==0)
                putvalue(env_ASG_AudioSD_TML_StName_s_0,gTpMemoList_StationName[Element_1]);

            gTpMemoList_LastFirstElement =Element_1;
            
            
            //2. Element             
            Element_2 =TpMemoList_GetNextCachedElement(Element_1, AUDIO_TPMEMOLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);

            //Pos
            putvalue(env_ASG_AudioSD_TML_pos_1, gTpMemoList_Pos[Element_2]);               

            //Attributes
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_TML_At_bit0_1, gTpMemoList_Attributes_NewMessage_Bit0[Element_2]);
                putvalue(env_ASG_AudioSD_TML_At_s_bit0_1,gTpMemoList_Attributes_NewMessage_Bit0_s[gTpMemoList_Attributes_NewMessage_Bit0[Element_2]]);
            }
            
            //MessageTime_Hour
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_TML_Hour_1,gTpMemoList_Hour[Element_2]);

            //MessageTime_Minute
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_TML_Minute_1,gTpMemoList_Minute[Element_2]);

            //StationName
            if (gTpMemoList_recordaddress ==0)
                putvalue(env_ASG_AudioSD_TML_StName_s_1,gTpMemoList_StationName[Element_2]);
             
            
            //3. Element          
            Element_3 =TpMemoList_GetNextCachedElement(Element_2, AUDIO_TPMEMOLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);

            //Pos
            putvalue(env_ASG_AudioSD_TML_pos_2, gTpMemoList_Pos[Element_3]);               

            //Attributes
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_TML_At_bit0_2, gTpMemoList_Attributes_NewMessage_Bit0[Element_3]);
                putvalue(env_ASG_AudioSD_TML_At_s_bit0_2,gTpMemoList_Attributes_NewMessage_Bit0_s[gTpMemoList_Attributes_NewMessage_Bit0[Element_3]]);
            }
            
            //MessageTime_Hour
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_TML_Hour_2,gTpMemoList_Hour[Element_3]);

            //MessageTime_Minute
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_TML_Minute_2,gTpMemoList_Minute[Element_3]);

            //StationName
            if (gTpMemoList_recordaddress ==0)
                putvalue(env_ASG_AudioSD_TML_StName_s_2,gTpMemoList_StationName[Element_3]);       
        }
        
        /******'sliding Window' active or 'build-up List'******/
        else if(gTpMemoList_DisplayStatus ==AUDIO_TPMEMOLIST_DISPLAYLIST_FIRST_ELEMENTS) 
        {
            //1. Element    
            if(gTpMemoList_ListEntryReceptionInformation [0] ==TRUE && getvalue(env_ASG_AudioSD_TML_OnOff))
            {   
                Element_1 =0;
                
            //Pos
            putvalue(env_ASG_AudioSD_TML_pos_0, gTpMemoList_Pos[Element_1]);               

            //Attributes
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_TML_At_bit0_0, gTpMemoList_Attributes_NewMessage_Bit0[Element_1]);
                putvalue(env_ASG_AudioSD_TML_At_s_bit0_0,gTpMemoList_Attributes_NewMessage_Bit0_s[gTpMemoList_Attributes_NewMessage_Bit0[Element_1]]);
            }
            
            //MessageTime_Hour
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_TML_Hour_0,gTpMemoList_Hour[Element_1]);

            //MessageTime_Minute
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_TML_Minute_0,gTpMemoList_Minute[Element_1]);

            //StationName
            if (gTpMemoList_recordaddress ==0)
                putvalue(env_ASG_AudioSD_TML_StName_s_0,gTpMemoList_StationName[Element_1]);
            }
            
            //2. Element    
            if(gTpMemoList_ListEntryReceptionInformation [1] ==TRUE && getvalue(env_ASG_AudioSD_TML_OnOff))
            {
                Element_2 =1;
                
            //Pos
            putvalue(env_ASG_AudioSD_TML_pos_1, gTpMemoList_Pos[Element_2]);               

            //Attributes
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_TML_At_bit0_1, gTpMemoList_Attributes_NewMessage_Bit0[Element_2]);
                putvalue(env_ASG_AudioSD_TML_At_s_bit0_1,gTpMemoList_Attributes_NewMessage_Bit0_s[gTpMemoList_Attributes_NewMessage_Bit0[Element_2]]);
            }
            
            //MessageTime_Hour
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_TML_Hour_1,gTpMemoList_Hour[Element_2]);

            //MessageTime_Minute
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_TML_Minute_1,gTpMemoList_Minute[Element_2]);

            //StationName
            if (gTpMemoList_recordaddress ==0)
                putvalue(env_ASG_AudioSD_TML_StName_s_1,gTpMemoList_StationName[Element_2]);
            }

            //3. Element    
            if(gTpMemoList_ListEntryReceptionInformation [2] ==TRUE && getvalue(env_ASG_AudioSD_TML_OnOff))
            {
                Element_3 =2;
             
                //Pos
            putvalue(env_ASG_AudioSD_TML_pos_2, gTpMemoList_Pos[Element_3]);               

            //Attributes
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_TML_At_bit0_2, gTpMemoList_Attributes_NewMessage_Bit0[Element_3]);
                putvalue(env_ASG_AudioSD_TML_At_s_bit0_2,gTpMemoList_Attributes_NewMessage_Bit0_s[gTpMemoList_Attributes_NewMessage_Bit0[Element_3]]);
            }
            
            //MessageTime_Hour
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_TML_Hour_2,gTpMemoList_Hour[Element_3]);

            //MessageTime_Minute
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_TML_Minute_2,gTpMemoList_Minute[Element_3]);

            //StationName
            if (gTpMemoList_recordaddress ==0)
                putvalue(env_ASG_AudioSD_TML_StName_s_2,gTpMemoList_StationName[Element_3]); 
            }
        }    
            
        else if (gTpMemoList_DisplayStatus ==AUDIO_TPMEMOLIST_DISPLAYLIST_REFRESH)
        {          
            //1. Element
            if(gTpMemoList_SlidingWindow_State ==AUDIO_TPMEMOLIST_SLIDINGWINDOW_NOTACTIVE)
                Element_1 =gTpMemoList_LastFirstElement; 
            else
                Element_1 =0;

            if(gTpMemoList_ListEntryReceptionInformation[Element_1])
            {
                //Pos
            putvalue(env_ASG_AudioSD_TML_pos_0, gTpMemoList_Pos[Element_1]);               

            //Attributes
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_TML_At_bit0_0, gTpMemoList_Attributes_NewMessage_Bit0[Element_1]);
                putvalue(env_ASG_AudioSD_TML_At_s_bit0_0,gTpMemoList_Attributes_NewMessage_Bit0_s[gTpMemoList_Attributes_NewMessage_Bit0[Element_1]]);
            }
            
            //MessageTime_Hour
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_TML_Hour_0,gTpMemoList_Hour[Element_1]);

            //MessageTime_Minute
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_TML_Minute_0,gTpMemoList_Minute[Element_1]);

            //StationName
            if (gTpMemoList_recordaddress ==0)
                putvalue(env_ASG_AudioSD_TML_StName_s_0,gTpMemoList_StationName[Element_1]);
            }//END: Element_1
                

            //2. Element             
            if(gTpMemoList_SlidingWindow_State ==AUDIO_TPMEMOLIST_SLIDINGWINDOW_NOTACTIVE)
                Element_2 =TpMemoList_GetNextCachedElement(Element_1, AUDIO_TPMEMOLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);
            else
                Element_2 =1;

            if(gTpMemoList_ListEntryReceptionInformation[Element_2])
            {
                //Pos
            putvalue(env_ASG_AudioSD_TML_pos_1, gTpMemoList_Pos[Element_2]);               

            //Attributes
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_TML_At_bit0_1, gTpMemoList_Attributes_NewMessage_Bit0[Element_2]);
                putvalue(env_ASG_AudioSD_TML_At_s_bit0_1,gTpMemoList_Attributes_NewMessage_Bit0_s[gTpMemoList_Attributes_NewMessage_Bit0[Element_2]]);
            }
            
            //MessageTime_Hour
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_TML_Hour_1,gTpMemoList_Hour[Element_2]);

            //MessageTime_Minute
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_TML_Minute_1,gTpMemoList_Minute[Element_2]);

            //StationName
            if (gTpMemoList_recordaddress ==0)
                putvalue(env_ASG_AudioSD_TML_StName_s_1,gTpMemoList_StationName[Element_2]);
            
            }//END: Element_2

            //3. Element          
            if(gTpMemoList_SlidingWindow_State ==AUDIO_TPMEMOLIST_SLIDINGWINDOW_NOTACTIVE)
                Element_3 =TpMemoList_GetNextCachedElement(Element_2, AUDIO_TPMEMOLIST_DISPLAYLIST_FIND_NEXT_ELEMENT);
            else
                Element_3 =2;

            if(gTpMemoList_ListEntryReceptionInformation[Element_3])
            {    
                //Pos
            putvalue(env_ASG_AudioSD_TML_pos_2, gTpMemoList_Pos[Element_3]);               

            //Attributes
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_TML_At_bit0_2, gTpMemoList_Attributes_NewMessage_Bit0[Element_3]);
                putvalue(env_ASG_AudioSD_TML_At_s_bit0_2,gTpMemoList_Attributes_NewMessage_Bit0_s[gTpMemoList_Attributes_NewMessage_Bit0[Element_3]]);
            }
            
            //MessageTime_Hour
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_TML_Hour_2,gTpMemoList_Hour[Element_3]);

            //MessageTime_Minute
            if (gTpMemoList_recordaddress ==0 || gTpMemoList_recordaddress ==1)
                putvalue(env_ASG_AudioSD_TML_Minute_2,gTpMemoList_Minute[Element_3]);

            //StationName
            if (gTpMemoList_recordaddress ==0)
                putvalue(env_ASG_AudioSD_TML_StName_s_2,gTpMemoList_StationName[Element_3]);    
            }
        }
    }
}

on envVar env_ASG_AudioSD_TML_GetArray
{
    byte mode, shift, direction, transmitpos, indexsize,recordaddress;
    word requested_startelement, startelement, elements;

    // Init local variables. 
    mode                    =0;
    shift                   =0;
    direction               =0;
    transmitpos             =0;
    indexsize               =0;
    recordaddress           =0;
    requested_startelement  =0;
    startelement            =0;
    elements                =0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gTpMemoList_ListHandlingType ==AUDIO_TPMEMOLIST_NOCACHE)
	{
        gTpMemoList_ASGID            =getvalue(env_ASG_AudioSD_TML_ASGID);
        gTpMemoList_TAID             =getvalue(env_ASG_AudioSD_TML_TAID);

        shift                           =getvalue(env_ASG_AudioSD_TML_AH_shift);
        direction                       =getvalue(env_ASG_AudioSD_TML_AH_dir);
        transmitpos                     =getvalue(env_ASG_AudioSD_TML_AH_PosTrans);
        recordaddress                   =getvalue(env_ASG_AudioSD_TML_AH_RA);
        indexsize                       =getvalue(env_ASG_AudioSD_TML_AH_IS);
        startelement                    =getvalue(env_ASG_AudioSD_TML_AH_start);
        elements                        =getvalue(env_ASG_AudioSD_TML_AH_elements);
        
        requested_startelement  =startelement;
        mode                    =shift +(direction*0x02) +(transmitpos*0x04) +indexsize*0x08;

        TpMemoList_Request(DataGet_REQ, mode, recordaddress, requested_startelement, startelement, elements);
    }
}

on envVar env_ASG_AudioSD_TML_OnOff
{
    int i =0, j =0;
    if(POWER_ON==gASG_PowerOnOff)
	{   
        if(getvalue(this))
        {
            gTpMemoList_ListHandlingType      =AUDIO_TPMEMOLIST_BUILDUPCACHE;             //build-up complete cache...
            gTpMemoList_cacheBuildUp          =AUDIO_TPMEMOLIST_BUILDUPCACHECACHE_WINDOW; //...and start with area "window"            
        
            TpMemoList_ListHandling ();
        }
        else
        {
            gTpMemoList_SlidingWindow_State   =AUDIO_TPMEMOLIST_SLIDINGWINDOW_NOTACTIVE;
            gTpMemoList_ListHandlingType      =AUDIO_TPMEMOLIST_NOCACHE;
            gTpMemoList_cacheBuildUp          =AUDIO_TPMEMOLIST_BUILDUPCACHENOCACHE;
            gTpMemoList_CallBackReason        =AUDIO_TPMEMOLIST_CALLBACKREASON_NOCALLBACK;

            gTpMemoList_cacheDown             =FALSE;
            gTpMemoList_cacheUp               =FALSE;
            gTpMemoList_LastFirstElement      =0;

            gTpMemoList_recordaddress         =0;
            gTpMemoList_transmitpos           =1;
            gTpMemoList_CursorAction          =AUDIO_TPMEMOLIST_CURSORACTION_NOTHING;
            gTpMemoList_DisplayStatus         =AUDIO_TPMEMOLIST_DISPLAYLIST_FIRST_ELEMENTS;
            
            for(j=0; j<AUDIO_TPMEMOLIST_ASGCACHE_MAX_SIZE; j++)
            {     
                gTpMemoList_Pos[j]                               =0;
                gTpMemoList_Attributes_NewMessage_Bit0[j]        =0;
                gTpMemoList_Attributes[j]                        =0;
                gTpMemoList_Hour[j]                              =0;
                gTpMemoList_Minute[j]                            =0;
                gTpMemoList_ListEntryReceptionInformation[j]     =0;

                for(i=0;i<AUDIO_TPMEMOLIST_STATIONNAME_LENGTH;i++)
			        gTpMemoList_StationName[j][i] =0;
            }
            putvalue(env_ASG_AudioSD_TML_pos_0, 0);
            putvalue(env_ASG_AudioSD_TML_pos_1, 0);
            putvalue(env_ASG_AudioSD_TML_pos_2, 0);
    
            putvalue(env_ASG_AudioSD_TML_At_bit0_0, 0);
            putvalue(env_ASG_AudioSD_TML_At_bit0_1, 0);
            putvalue(env_ASG_AudioSD_TML_At_bit0_2, 0);
            putvalue(env_ASG_AudioSD_TML_At_s_bit0_0, empty_string);
            putvalue(env_ASG_AudioSD_TML_At_s_bit0_1, empty_string);
            putvalue(env_ASG_AudioSD_TML_At_s_bit0_2, empty_string);

            putvalue(env_ASG_AudioSD_TML_Hour_0, 0);
            putvalue(env_ASG_AudioSD_TML_Hour_1, 0);
            putvalue(env_ASG_AudioSD_TML_Hour_2, 0);

            putvalue(env_ASG_AudioSD_TML_Minute_0, 0);
            putvalue(env_ASG_AudioSD_TML_Minute_1, 0);
            putvalue(env_ASG_AudioSD_TML_Minute_2, 0);
            
            putvalue(env_ASG_AudioSD_TML_StName_s_0, empty_string);
            putvalue(env_ASG_AudioSD_TML_StName_s_1, empty_string);
            putvalue(env_ASG_AudioSD_TML_StName_s_2, empty_string);    
        }
    }
}   

on envVar env_ASG_AudioSD_TML_down
{
    int i=0, j=0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gTpMemoList_ListHandlingType ==AUDIO_TPMEMOLIST_NOCACHE)
	{      
        gTpMemoList_CursorAction =AUDIO_TPMEMOLIST_CURSORACTION_DOWN;
        
        if(gTpMemoList_SlidingWindow_State ==AUDIO_TPMEMOLIST_SLIDINGWINDOW_ACTIVE)
        {   
            gTpMemoList_ListHandlingType  =AUDIO_TPMEMOLIST_DOWN_CACHE;
            gTpMemoList_DisplayStatus     =AUDIO_TPMEMOLIST_DISPLAYLIST_FIRST_ELEMENTS;
            gTpMemoList_CursorAction      =AUDIO_TPMEMOLIST_CURSORACTION_NOTHING;
            
            TpMemoList_ListHandling ();
        }
        else if(gTpMemoList_SlidingWindow_State ==AUDIO_TPMEMOLIST_SLIDINGWINDOW_NOTACTIVE)
        {
            gTpMemoList_DisplayStatus     =AUDIO_TPMEMOLIST_DISPLAYLIST_SEARCH_ELEMENTS;
            gTpMemoList_CursorAction      =AUDIO_TPMEMOLIST_CURSORACTION_DOWN;

            TpMemoList_display();

            //reset values
            gTpMemoList_DisplayStatus     =AUDIO_TPMEMOLIST_DISPLAYLIST_REFRESH;
            gTpMemoList_CursorAction      =AUDIO_TPMEMOLIST_CURSORACTION_NOTHING;
        }
    }
}

on envVar env_ASG_AudioSD_TML_up
{
    int i=0, j=0;

    if(POWER_ON==gASG_PowerOnOff && getvalue(this) && gTpMemoList_ListHandlingType ==AUDIO_TPMEMOLIST_NOCACHE)
	{   
        gTpMemoList_CursorAction =AUDIO_TPMEMOLIST_CURSORACTION_UP;

        if(gTpMemoList_SlidingWindow_State ==AUDIO_TPMEMOLIST_SLIDINGWINDOW_ACTIVE)
        {  
            gTpMemoList_ListHandlingType  =AUDIO_TPMEMOLIST_UP_CACHE;
            gTpMemoList_DisplayStatus     =AUDIO_TPMEMOLIST_DISPLAYLIST_FIRST_ELEMENTS;
            gTpMemoList_CursorAction      =AUDIO_TPMEMOLIST_CURSORACTION_NOTHING;
            
            TpMemoList_ListHandling ();
        }
        else if(gTpMemoList_SlidingWindow_State ==AUDIO_TPMEMOLIST_SLIDINGWINDOW_NOTACTIVE)
        {
            gTpMemoList_DisplayStatus     =AUDIO_TPMEMOLIST_DISPLAYLIST_SEARCH_ELEMENTS;
            gTpMemoList_CursorAction      =AUDIO_TPMEMOLIST_CURSORACTION_UP;

            TpMemoList_ListHandling();
            
            TpMemoList_display();

            //reset values
            gTpMemoList_DisplayStatus     =AUDIO_TPMEMOLIST_DISPLAYLIST_REFRESH;
            gTpMemoList_CursorAction      =AUDIO_TPMEMOLIST_CURSORACTION_NOTHING;
        }    
    }
}

int MediaBrowser_GetNextCachedElement (int currentElement,byte direction)
{
    int i=0, nextElement=0;

    switch (direction)
    {
        case AUDIO_MEDIABROWSER_DISPLAYLIST_FIND_NEXT_ELEMENT:                
                nextElement = ++currentElement;

                if (nextElement<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE) //start at next element, if next element is not >8
                {
                    for(i =nextElement; i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i= AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;
                        }
                        else
                            nextElement =0;
                    }
                }
                else    //start at first element
                {
                    nextElement =0;

                    for(i =nextElement; i<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE;
                        }   
                    }
                }
        break;

        case AUDIO_MEDIABROWSER_DISPLAYLIST_FIND_PREVIUOS_ELEMENT:
                nextElement = --currentElement;
                if (nextElement ==0 && gMediaBrowser_ListEntryReceptionInformation[nextElement] ==TRUE)
                    nextElement =0;
                else if (nextElement>0) 
                {
                    for(i =nextElement; i>0; i--)
                    {
                        if(gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =0;
                        }
                        else
                            nextElement =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE-1;
                    }
                }    
                else    //start at last element
                {
                    nextElement =AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE-1;

                    for(i =nextElement; i>0; i--)
                    {
                        if(gMediaBrowser_ListEntryReceptionInformation[i] ==TRUE)
                        {   
                            nextElement =i; 
                            i =0;
                        }
                        else if(gMediaBrowser_ListEntryReceptionInformation[0] ==TRUE)
                            nextElement =0;          
                    }
                }
        break;

        default:
        break;
    }
    return(nextElement);
}

int MediaBrowser_GetNextLineInCache (int currentElement,byte direction)
{
    int i=0, nextElement=0;

    switch (direction)
    {
        case FORWARD:
                           
                if(currentElement<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE-1 && currentElement !=5) 
                    nextElement = ++currentElement;  
                
                else if (currentElement ==8)            
                    nextElement =0;
                else
                    nextElement =AUDIO_MEDIABROWSER_NO_NEXT_POSITION;
        break;

        case BACKWARD:
                if(currentElement<AUDIO_MEDIABROWSER_ASGCACHE_MAX_SIZE && currentElement !=0 && currentElement !=6) 
                    nextElement =--currentElement;
                
                else if (currentElement ==0)            
                    nextElement =8;
                
                else
                    nextElement =AUDIO_MEDIABROWSER_NO_NEXT_POSITION;
        break;

        default:
        break;
    }
    return(nextElement);
}

MediaBrowser_display()
{   
    int Element_1 =0, Element_2 =1, Element_3 =2;

    if(POWER_ON==gASG_PowerOnOff && getvalue(env_ASG_AudioSD_MB_OnOff))
	{   
        /******'sliding window' not active******/         
        if(gMediaBrowser_DisplayStatus ==AUDIO_MEDIABROWSER_DISPLAYLIST_SEARCH_ELEMENTS)
        {
            //1. Element              
            if(gMediaBrowser_CursorAction ==AUDIO_MEDIABROWSER_CURSORACTION_DOWN)
                Element_1 =MediaBrowser_GetNextCachedElement(gMediaBrowser_LastFirstElement, AUDIO_MEDIABROWSER_DISPLAYLIST_FIND_NEXT_ELEMENT);
            
            else if(gMediaBrowser_CursorAction ==AUDIO_MEDIABROWSER_CURSORACTION_UP)            
                Element_1 =MediaBrowser_GetNextCachedElement(gMediaBrowser_LastFirstElement, AUDIO_MEDIABROWSER_DISPLAYLIST_FIND_PREVIUOS_ELEMENT);

            //Pos
            putvalue(env_ASG_AudioSD_MB_pos_0, gMediaBrowser_Pos[Element_1]);               
            
            //FileType
            if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_MB_FileType_0, gMediaBrowser_FileType[Element_1]);

                if(gMediaBrowser_FileType[Element_1] <0x67)
                    putvalue(env_ASG_AudioSD_MB_FileType_s_0,gMediaBrowser_FileType_s[gMediaBrowser_FileType[Element_1]]);
                else if (gMediaBrowser_FileType[Element_1] ==0xFF)
                    putvalue(env_ASG_AudioSD_MB_FileType_s_0,gstring_not_supported);
                else
                    putvalue(env_ASG_AudioSD_MB_FileType_s_0,gstring_reserved);
            }

            //FileState
            if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_MB_FS_bit0_0, gMediaBrowser_FileState_emptyFolder_Bit0[Element_1]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit0_0,gMediaBrowser_FileState_emptyFolder_Bit0_s[gMediaBrowser_FileState_emptyFolder_Bit0[Element_1]]);

                putvalue(env_ASG_AudioSD_MB_FS_bit1_0, gMediaBrowser_FileState_DRM_Bit1[Element_1]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit1_0,gMediaBrowser_FileState_DRM_Bit1_s[gMediaBrowser_FileState_DRM_Bit1[Element_1]]);

                putvalue(env_ASG_AudioSD_MB_FS_bit2_0, gMediaBrowser_FileState_FileCorrupted_Bit2[Element_1]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit2_0,gMediaBrowser_FileState_FileCorrupted_Bit2_s[gMediaBrowser_FileState_FileCorrupted_Bit2[Element_1]]);

                putvalue(env_ASG_AudioSD_MB_FS_bit3_0, gMediaBrowser_FileState_DeadLink_Bit3[Element_1]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit3_0,gMediaBrowser_FileState_DeadLink_Bit3_s[gMediaBrowser_FileState_DeadLink_Bit3[Element_1]]);

                putvalue(env_ASG_AudioSD_MB_FS_bit4_0, gMediaBrowser_FileState_ImportFinished_Bit4[Element_1]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit4_0,gMediaBrowser_FileState_ImportFinished_Bit4_s[gMediaBrowser_FileState_ImportFinished_Bit4[Element_1]]);

                putvalue(env_ASG_AudioSD_MB_FS_bit5_0, gMediaBrowser_FileState_ImportPending_Bit5[Element_1]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit5_0,gMediaBrowser_FileState_ImportPending_Bit5_s[gMediaBrowser_FileState_ImportPending_Bit5[Element_1]]);

                putvalue(env_ASG_AudioSD_MB_FS_bit6_0, gMediaBrowser_FileState_ImportPlayable_Bit6[Element_1]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit6_0,gMediaBrowser_FileState_ImportPlayable_Bit6_s[gMediaBrowser_FileState_ImportPlayable_Bit6[Element_1]]);
            }

            //FileName
            if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==2)
                putvalue(env_ASG_AudioSD_MB_FileName_s_0,gMediaBrowser_FileName[Element_1]);
                        
            gMediaBrowser_LastFirstElement =Element_1;
            
            
            //2. Element             
            Element_2 =MediaBrowser_GetNextCachedElement(Element_1, AUDIO_MEDIABROWSER_DISPLAYLIST_FIND_NEXT_ELEMENT);
            
            //Pos
            putvalue(env_ASG_AudioSD_MB_pos_1, gMediaBrowser_Pos[Element_2]);               
            
            //FileType
            if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_MB_FileType_1, gMediaBrowser_FileType[Element_2]);

                if(gMediaBrowser_FileType[Element_2] <0x67)
                    putvalue(env_ASG_AudioSD_MB_FileType_s_1,gMediaBrowser_FileType_s[gMediaBrowser_FileType[Element_2]]);
                else if (gMediaBrowser_FileType[Element_2] ==0xFF)
                    putvalue(env_ASG_AudioSD_MB_FileType_s_1,gstring_not_supported);
                else
                    putvalue(env_ASG_AudioSD_MB_FileType_s_1,gstring_reserved);
            }

            //FileState
            if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_MB_FS_bit0_1, gMediaBrowser_FileState_emptyFolder_Bit0[Element_2]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit0_1,gMediaBrowser_FileState_emptyFolder_Bit0_s[gMediaBrowser_FileState_emptyFolder_Bit0[Element_2]]);

                putvalue(env_ASG_AudioSD_MB_FS_bit1_1, gMediaBrowser_FileState_DRM_Bit1[Element_2]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit1_1,gMediaBrowser_FileState_DRM_Bit1_s[gMediaBrowser_FileState_DRM_Bit1[Element_2]]);

                putvalue(env_ASG_AudioSD_MB_FS_bit2_1, gMediaBrowser_FileState_FileCorrupted_Bit2[Element_2]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit2_1,gMediaBrowser_FileState_FileCorrupted_Bit2_s[gMediaBrowser_FileState_FileCorrupted_Bit2[Element_2]]);

                putvalue(env_ASG_AudioSD_MB_FS_bit3_1, gMediaBrowser_FileState_DeadLink_Bit3[Element_2]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit3_1,gMediaBrowser_FileState_DeadLink_Bit3_s[gMediaBrowser_FileState_DeadLink_Bit3[Element_2]]);

                putvalue(env_ASG_AudioSD_MB_FS_bit4_1, gMediaBrowser_FileState_ImportFinished_Bit4[Element_2]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit4_1,gMediaBrowser_FileState_ImportFinished_Bit4_s[gMediaBrowser_FileState_ImportFinished_Bit4[Element_2]]);

                putvalue(env_ASG_AudioSD_MB_FS_bit5_1, gMediaBrowser_FileState_ImportPending_Bit5[Element_2]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit5_1,gMediaBrowser_FileState_ImportPending_Bit5_s[gMediaBrowser_FileState_ImportPending_Bit5[Element_2]]);

                putvalue(env_ASG_AudioSD_MB_FS_bit6_1, gMediaBrowser_FileState_ImportPlayable_Bit6[Element_2]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit6_1,gMediaBrowser_FileState_ImportPlayable_Bit6_s[gMediaBrowser_FileState_ImportPlayable_Bit6[Element_2]]);
            }

            //FileName
            if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==2)
                putvalue(env_ASG_AudioSD_MB_FileName_s_1,gMediaBrowser_FileName[Element_2]);
             
            
            //3. Element          
            Element_3 =MediaBrowser_GetNextCachedElement(Element_3, AUDIO_MEDIABROWSER_DISPLAYLIST_FIND_NEXT_ELEMENT);

            //Pos
            putvalue(env_ASG_AudioSD_MB_pos_2, gMediaBrowser_Pos[Element_3]);               
            
            //FileType
            if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_MB_FileType_2, gMediaBrowser_FileType[Element_3]);

                if(gMediaBrowser_FileType[Element_3] <0x67)
                    putvalue(env_ASG_AudioSD_MB_FileType_s_2,gMediaBrowser_FileType_s[gMediaBrowser_FileType[Element_3]]);
                else if (gMediaBrowser_FileType[Element_3] ==0xFF)
                    putvalue(env_ASG_AudioSD_MB_FileType_s_2,gstring_not_supported);
                else
                    putvalue(env_ASG_AudioSD_MB_FileType_s_2,gstring_reserved);
            }

            //FileState
            if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==1) 
            {
                putvalue(env_ASG_AudioSD_MB_FS_bit0_2, gMediaBrowser_FileState_emptyFolder_Bit0[Element_3]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit0_2,gMediaBrowser_FileState_emptyFolder_Bit0_s[gMediaBrowser_FileState_emptyFolder_Bit0[Element_3]]);

                putvalue(env_ASG_AudioSD_MB_FS_bit1_2, gMediaBrowser_FileState_DRM_Bit1[Element_3]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit1_2,gMediaBrowser_FileState_DRM_Bit1_s[gMediaBrowser_FileState_DRM_Bit1[Element_3]]);

                putvalue(env_ASG_AudioSD_MB_FS_bit2_2, gMediaBrowser_FileState_FileCorrupted_Bit2[Element_3]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit2_2,gMediaBrowser_FileState_FileCorrupted_Bit2_s[gMediaBrowser_FileState_FileCorrupted_Bit2[Element_3]]);

                putvalue(env_ASG_AudioSD_MB_FS_bit3_2, gMediaBrowser_FileState_DeadLink_Bit3[Element_3]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit3_2,gMediaBrowser_FileState_DeadLink_Bit3_s[gMediaBrowser_FileState_DeadLink_Bit3[Element_3]]);

                putvalue(env_ASG_AudioSD_MB_FS_bit4_2, gMediaBrowser_FileState_ImportFinished_Bit4[Element_3]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit4_2,gMediaBrowser_FileState_ImportFinished_Bit4_s[gMediaBrowser_FileState_ImportFinished_Bit4[Element_3]]);

                putvalue(env_ASG_AudioSD_MB_FS_bit5_2, gMediaBrowser_FileState_ImportPending_Bit5[Element_3]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit5_2,gMediaBrowser_FileState_ImportPending_Bit5_s[gMediaBrowser_FileState_ImportPending_Bit5[Element_3]]);

                putvalue(env_ASG_AudioSD_MB_FS_bit6_2, gMediaBrowser_FileState_ImportPlayable_Bit6[Element_3]);
                putvalue(env_ASG_AudioSD_MB_FS_s_bit6_2,gMediaBrowser_FileState_ImportPlayable_Bit6_s[gMediaBrowser_FileState_ImportPlayable_Bit6[Element_3]]);
            }

            //FileName
            if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==2)
                putvalue(env_ASG_AudioSD_MB_FileName_s_2,gMediaBrowser_FileName[Element_3]);         
        }

        /******'sliding Window' active or 'build-up List'******/
        else if(gMediaBrowser_DisplayStatus ==AUDIO_MEDIABROWSER_DISPLAYLIST_FIRST_ELEMENTS) 
        {
            //1. Element    
            if(gMediaBrowser_ListEntryReceptionInformation [0] ==TRUE && getvalue(env_ASG_AudioSD_MB_OnOff))
            {   
                Element_1 =0;
                
                //Pos
                putvalue(env_ASG_AudioSD_MB_pos_0, gMediaBrowser_Pos[Element_1]);               
            
                //FileType
                if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_MB_FileType_0, gMediaBrowser_FileType[Element_1]);

                    if(gMediaBrowser_FileType[Element_1] <0x67)
                        putvalue(env_ASG_AudioSD_MB_FileType_s_0,gMediaBrowser_FileType_s[gMediaBrowser_FileType[Element_1]]);
                    else if (gMediaBrowser_FileType[Element_1] ==0xFF)
                        putvalue(env_ASG_AudioSD_MB_FileType_s_0,gstring_not_supported);
                    else
                        putvalue(env_ASG_AudioSD_MB_FileType_s_0,gstring_reserved);
                }

                //FileState
                if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_MB_FS_bit0_0, gMediaBrowser_FileState_emptyFolder_Bit0[Element_1]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit0_0,gMediaBrowser_FileState_emptyFolder_Bit0_s[gMediaBrowser_FileState_emptyFolder_Bit0[Element_1]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit1_0, gMediaBrowser_FileState_DRM_Bit1[Element_1]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit1_0,gMediaBrowser_FileState_DRM_Bit1_s[gMediaBrowser_FileState_DRM_Bit1[Element_1]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit2_0, gMediaBrowser_FileState_FileCorrupted_Bit2[Element_1]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit2_0,gMediaBrowser_FileState_FileCorrupted_Bit2_s[gMediaBrowser_FileState_FileCorrupted_Bit2[Element_1]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit3_0, gMediaBrowser_FileState_DeadLink_Bit3[Element_1]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit3_0,gMediaBrowser_FileState_DeadLink_Bit3_s[gMediaBrowser_FileState_DeadLink_Bit3[Element_1]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit4_0, gMediaBrowser_FileState_ImportFinished_Bit4[Element_1]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit4_0,gMediaBrowser_FileState_ImportFinished_Bit4_s[gMediaBrowser_FileState_ImportFinished_Bit4[Element_1]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit5_0, gMediaBrowser_FileState_ImportPending_Bit5[Element_1]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit5_0,gMediaBrowser_FileState_ImportPending_Bit5_s[gMediaBrowser_FileState_ImportPending_Bit5[Element_1]]);

                    putvalue(env_ASG_AudioSD_MB_FS_bit6_0, gMediaBrowser_FileState_ImportPlayable_Bit6[Element_1]);
                    putvalue(env_ASG_AudioSD_MB_FS_s_bit6_0,gMediaBrowser_FileState_ImportPlayable_Bit6_s[gMediaBrowser_FileState_ImportPlayable_Bit6[Element_1]]);
                }

                //FileName
                if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==2)
                    putvalue(env_ASG_AudioSD_MB_FileName_s_0,gMediaBrowser_FileName[Element_1]);

            }
            
            //2. Element    
            if(gMediaBrowser_ListEntryReceptionInformation [1] ==TRUE && getvalue(env_ASG_AudioSD_MB_OnOff))
            {
                Element_2 =1;
                   
                //Pos
                putvalue(env_ASG_AudioSD_MB_pos_1, gMediaBrowser_Pos[Element_2]);               
            
                //FileType
                if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_MB_FileType_1, gMediaBrowser_FileType[Element_2]);

                    if(gMediaBrowser_FileType[Element_2] <0x67)
                        putvalue(env_ASG_AudioSD_MB_FileType_s_1,gMediaBrowser_FileType_s[gMediaBrowser_FileType[Element_2]]);
                    
                    else if (gMediaBrowser_FileType[Element_2] ==0xFF)
                        putvalue(env_ASG_AudioSD_MB_FileType_s_1,gstring_not_supported);
                    
                    else
                        putvalue(env_ASG_AudioSD_MB_FileType_s_1,gstring_reserved);
                }

                //FileState
                if (gMediaBrowser_recordaddress ==0 || gMediaBrowser_recordaddress ==1) 
                {
                    putvalue(env_ASG_AudioSD_MB_FS_bit0_1, gMediaBrowser_FileState_emptyFolder_Bit0[Element_2]);
