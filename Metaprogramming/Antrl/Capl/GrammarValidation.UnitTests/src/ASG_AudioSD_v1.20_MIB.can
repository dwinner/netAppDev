                                if(gReceptionList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gReceptionList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gReceptionList_ListHandlingType !=AUDIO_RECEPTIONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Type
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Type[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gReceptionList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gReceptionList_Attributes_available_Bit0[current_element]    =(gReceptionList_Attributes[current_element] &0x01);
                                        gReceptionList_Attributes_DVB_Bit1[current_element]          =(gReceptionList_Attributes[current_element] &0x02) /0x02;
                                        gReceptionList_Attributes_DAB_Bit2[current_element]          =(gReceptionList_Attributes[current_element] &0x04) /0x04; 
                                        gReceptionList_Attributes_DAB_Bit3[current_element]          =(gReceptionList_Attributes[current_element] &0x08) /0x08;
                                        gReceptionList_Attributes_DAB_Bit4[current_element]          =(gReceptionList_Attributes[current_element] &0x10) /0x10;
                                        gReceptionList_Attributes_TP_Bit5[current_element]           =(gReceptionList_Attributes[current_element] &0x20) /0x20;
                                        gReceptionList_Attributes_TMC_Bit6[current_element]          =(gReceptionList_Attributes[current_element] &0x40) /0x40;
                                        gReceptionList_Attributes_SDARS_Bit7[current_element]        =(gReceptionList_Attributes[current_element] &0x80) /0x80;
                                        gReceptionList_Attributes_DABserv_Bit8[current_element]      =(gReceptionList_Attributes[current_element] &0x100) /0x100;
                                        gReceptionList_Attributes_FMOnline_Bit9[current_element]     =(gReceptionList_Attributes[current_element] &0x200) /0x200;
                                        gReceptionList_Attributes_StationSelect_BitA[current_element]=(gReceptionList_Attributes[current_element] &0x400) /0x700;
                                        gReceptionList_Attributes_OnlineRadioMute_BitB[current_element]=(gReceptionList_Attributes[current_element] &0x800) /0x800;
                                        gReceptionList_Attributes_StationLinked_BitC[current_element]  =(gReceptionList_Attributes[current_element] &0x1000) /0x1000;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FmREG_Code
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_FmRegCode[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Category
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Category[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                   
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;i++) //clear
			                                gReceptionList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gReceptionList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gReceptionList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Type
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Type[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gReceptionList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gReceptionList_Attributes_available_Bit0[current_element]    =(gReceptionList_Attributes[current_element] &0x01);
                                        gReceptionList_Attributes_DVB_Bit1[current_element]          =(gReceptionList_Attributes[current_element] &0x02) /0x02;
                                        gReceptionList_Attributes_DAB_Bit2[current_element]          =(gReceptionList_Attributes[current_element] &0x04) /0x04; 
                                        gReceptionList_Attributes_DAB_Bit3[current_element]          =(gReceptionList_Attributes[current_element] &0x08) /0x08;
                                        gReceptionList_Attributes_DAB_Bit4[current_element]          =(gReceptionList_Attributes[current_element] &0x10) /0x10;
                                        gReceptionList_Attributes_TP_Bit5[current_element]           =(gReceptionList_Attributes[current_element] &0x20) /0x20;
                                        gReceptionList_Attributes_TMC_Bit6[current_element]          =(gReceptionList_Attributes[current_element] &0x40) /0x40;
                                        gReceptionList_Attributes_SDARS_Bit7[current_element]        =(gReceptionList_Attributes[current_element] &0x80) /0x80;
                                        gReceptionList_Attributes_DABserv_Bit8[current_element]      =(gReceptionList_Attributes[current_element] &0x100) /0x100;
                                        gReceptionList_Attributes_FMOnline_Bit9[current_element]     =(gReceptionList_Attributes[current_element] &0x200) /0x200;
                                        gReceptionList_Attributes_StationSelect_BitA[current_element]=(gReceptionList_Attributes[current_element] &0x400) /0x700;
                                        gReceptionList_Attributes_OnlineRadioMute_BitB[current_element]=(gReceptionList_Attributes[current_element] &0x800) /0x800;
                                        gReceptionList_Attributes_StationLinked_BitC[current_element]  =(gReceptionList_Attributes[current_element] &0x1000) /0x1000;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FmREG_Code
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_FmRegCode[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Category
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Category[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;i++) //clear
			                                gReceptionList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0 ends
                    
                    case 1: //recordaddress =1 -> Type, Attributes, PResetID, FmREG_Code, Category, Name, Frequency

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gReceptionList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gReceptionList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gReceptionList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gReceptionList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gReceptionList_ListHandlingType !=AUDIO_RECEPTIONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }
                                    
                                    //Type
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Type[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gReceptionList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gReceptionList_Attributes_available_Bit0[current_element]    =(gReceptionList_Attributes[current_element] &0x01);
                                        gReceptionList_Attributes_DVB_Bit1[current_element]          =(gReceptionList_Attributes[current_element] &0x02) /0x02;
                                        gReceptionList_Attributes_DAB_Bit2[current_element]          =(gReceptionList_Attributes[current_element] &0x04) /0x04; 
                                        gReceptionList_Attributes_DAB_Bit3[current_element]          =(gReceptionList_Attributes[current_element] &0x08) /0x08;
                                        gReceptionList_Attributes_DAB_Bit4[current_element]          =(gReceptionList_Attributes[current_element] &0x10) /0x10;
                                        gReceptionList_Attributes_TP_Bit5[current_element]           =(gReceptionList_Attributes[current_element] &0x20) /0x20;
                                        gReceptionList_Attributes_TMC_Bit6[current_element]          =(gReceptionList_Attributes[current_element] &0x40) /0x40;
                                        gReceptionList_Attributes_SDARS_Bit7[current_element]        =(gReceptionList_Attributes[current_element] &0x80) /0x80;
                                        gReceptionList_Attributes_DABserv_Bit8[current_element]      =(gReceptionList_Attributes[current_element] &0x100) /0x100;
                                        gReceptionList_Attributes_FMOnline_Bit9[current_element]     =(gReceptionList_Attributes[current_element] &0x200) /0x200;
                                        gReceptionList_Attributes_StationSelect_BitA[current_element]=(gReceptionList_Attributes[current_element] &0x400) /0x700;
                                        gReceptionList_Attributes_OnlineRadioMute_BitB[current_element]=(gReceptionList_Attributes[current_element] &0x800) /0x800;
                                        gReceptionList_Attributes_StationLinked_BitC[current_element]  =(gReceptionList_Attributes[current_element] &0x1000) /0x1000;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FmREG_Code
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_FmRegCode[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Category
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Category[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                   
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gReceptionList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gReceptionList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Type
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Type[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gReceptionList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gReceptionList_Attributes_available_Bit0[current_element]    =(gReceptionList_Attributes[current_element] &0x01);
                                        gReceptionList_Attributes_DVB_Bit1[current_element]          =(gReceptionList_Attributes[current_element] &0x02) /0x02;
                                        gReceptionList_Attributes_DAB_Bit2[current_element]          =(gReceptionList_Attributes[current_element] &0x04) /0x04; 
                                        gReceptionList_Attributes_DAB_Bit3[current_element]          =(gReceptionList_Attributes[current_element] &0x08) /0x08;
                                        gReceptionList_Attributes_DAB_Bit4[current_element]          =(gReceptionList_Attributes[current_element] &0x10) /0x10;
                                        gReceptionList_Attributes_TP_Bit5[current_element]           =(gReceptionList_Attributes[current_element] &0x20) /0x20;
                                        gReceptionList_Attributes_TMC_Bit6[current_element]          =(gReceptionList_Attributes[current_element] &0x40) /0x40;
                                        gReceptionList_Attributes_SDARS_Bit7[current_element]        =(gReceptionList_Attributes[current_element] &0x80) /0x80;
                                        gReceptionList_Attributes_DABserv_Bit8[current_element]      =(gReceptionList_Attributes[current_element] &0x100) /0x100;
                                        gReceptionList_Attributes_FMOnline_Bit9[current_element]     =(gReceptionList_Attributes[current_element] &0x200) /0x200;
                                        gReceptionList_Attributes_StationSelect_BitA[current_element]=(gReceptionList_Attributes[current_element] &0x400) /0x700;
                                        gReceptionList_Attributes_OnlineRadioMute_BitB[current_element]=(gReceptionList_Attributes[current_element] &0x800) /0x800;
                                        gReceptionList_Attributes_StationLinked_BitC[current_element]  =(gReceptionList_Attributes[current_element] &0x1000) /0x1000;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FmREG_Code
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_FmRegCode[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Category
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Category[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =1 ends
                    
                    case 2: //recordaddress =2 -> Type, Attributes

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gReceptionList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gReceptionList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gReceptionList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gReceptionList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gReceptionList_ListHandlingType !=AUDIO_RECEPTIONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }
                                    
                                    //Type
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Type[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gReceptionList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gReceptionList_Attributes_available_Bit0[current_element]    =(gReceptionList_Attributes[current_element] &0x01);
                                        gReceptionList_Attributes_DVB_Bit1[current_element]          =(gReceptionList_Attributes[current_element] &0x02) /0x02;
                                        gReceptionList_Attributes_DAB_Bit2[current_element]          =(gReceptionList_Attributes[current_element] &0x04) /0x04; 
                                        gReceptionList_Attributes_DAB_Bit3[current_element]          =(gReceptionList_Attributes[current_element] &0x08) /0x08;
                                        gReceptionList_Attributes_DAB_Bit4[current_element]          =(gReceptionList_Attributes[current_element] &0x10) /0x10;
                                        gReceptionList_Attributes_TP_Bit5[current_element]           =(gReceptionList_Attributes[current_element] &0x20) /0x20;
                                        gReceptionList_Attributes_TMC_Bit6[current_element]          =(gReceptionList_Attributes[current_element] &0x40) /0x40;
                                        gReceptionList_Attributes_SDARS_Bit7[current_element]        =(gReceptionList_Attributes[current_element] &0x80) /0x80;
                                        gReceptionList_Attributes_DABserv_Bit8[current_element]      =(gReceptionList_Attributes[current_element] &0x100) /0x100;
                                        gReceptionList_Attributes_FMOnline_Bit9[current_element]     =(gReceptionList_Attributes[current_element] &0x200) /0x200;
                                        gReceptionList_Attributes_StationSelect_BitA[current_element]=(gReceptionList_Attributes[current_element] &0x400) /0x700;
                                        gReceptionList_Attributes_OnlineRadioMute_BitB[current_element]=(gReceptionList_Attributes[current_element] &0x800) /0x800;
                                        gReceptionList_Attributes_StationLinked_BitC[current_element]  =(gReceptionList_Attributes[current_element] &0x1000) /0x1000;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gReceptionList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gReceptionList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Type
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Type[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gReceptionList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gReceptionList_Attributes_available_Bit0[current_element]    =(gReceptionList_Attributes[current_element] &0x01);
                                        gReceptionList_Attributes_DVB_Bit1[current_element]          =(gReceptionList_Attributes[current_element] &0x02) /0x02;
                                        gReceptionList_Attributes_DAB_Bit2[current_element]          =(gReceptionList_Attributes[current_element] &0x04) /0x04; 
                                        gReceptionList_Attributes_DAB_Bit3[current_element]          =(gReceptionList_Attributes[current_element] &0x08) /0x08;
                                        gReceptionList_Attributes_DAB_Bit4[current_element]          =(gReceptionList_Attributes[current_element] &0x10) /0x10;
                                        gReceptionList_Attributes_TP_Bit5[current_element]           =(gReceptionList_Attributes[current_element] &0x20) /0x20;
                                        gReceptionList_Attributes_TMC_Bit6[current_element]          =(gReceptionList_Attributes[current_element] &0x40) /0x40;
                                        gReceptionList_Attributes_SDARS_Bit7[current_element]        =(gReceptionList_Attributes[current_element] &0x80) /0x80;
                                        gReceptionList_Attributes_DABserv_Bit8[current_element]      =(gReceptionList_Attributes[current_element] &0x100) /0x100;
                                        gReceptionList_Attributes_FMOnline_Bit9[current_element]     =(gReceptionList_Attributes[current_element] &0x200) /0x200;
                                        gReceptionList_Attributes_StationSelect_BitA[current_element]=(gReceptionList_Attributes[current_element] &0x400) /0x700;
                                        gReceptionList_Attributes_OnlineRadioMute_BitB[current_element]=(gReceptionList_Attributes[current_element] &0x800) /0x800;
                                        gReceptionList_Attributes_StationLinked_BitC[current_element]  =(gReceptionList_Attributes[current_element] &0x1000) /0x1000;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =2 ends
                    
                    case 3: //recordaddress =3 -> PresetID, FmREG_Code, Category, Name

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gReceptionList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gReceptionList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gReceptionList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gReceptionList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gReceptionList_ListHandlingType !=AUDIO_RECEPTIONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FmREG_Code
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_FmRegCode[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Category
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Category[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                   
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gReceptionList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gReceptionList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FmREG_Code
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_FmRegCode[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Category
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Category[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =3 ends
                    
                    case 4: //recordaddress =4 -> complete record

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gReceptionList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gReceptionList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gReceptionList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gReceptionList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gReceptionList_ListHandlingType !=AUDIO_RECEPTIONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }
                                   
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gReceptionList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gReceptionList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =4 ends 
                    
                    case 5: //recordaddress =5 -> Frequency

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gReceptionList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gReceptionList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gReceptionList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gReceptionList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gReceptionList_ListHandlingType !=AUDIO_RECEPTIONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;i++) //clear
			                                gReceptionList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gReceptionList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gReceptionList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;i++) //clear
			                                gReceptionList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =5 ends
                    case 6: //recordaddress =6 -> Type, Attributes, Category, Name

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gReceptionList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gReceptionList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gReceptionList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gReceptionList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gReceptionList_ListHandlingType !=AUDIO_RECEPTIONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Type
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Type[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gReceptionList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gReceptionList_Attributes_available_Bit0[current_element]    =(gReceptionList_Attributes[current_element] &0x01);
                                        gReceptionList_Attributes_DVB_Bit1[current_element]          =(gReceptionList_Attributes[current_element] &0x02) /0x02;
                                        gReceptionList_Attributes_DAB_Bit2[current_element]          =(gReceptionList_Attributes[current_element] &0x04) /0x04; 
                                        gReceptionList_Attributes_DAB_Bit3[current_element]          =(gReceptionList_Attributes[current_element] &0x08) /0x08;
                                        gReceptionList_Attributes_DAB_Bit4[current_element]          =(gReceptionList_Attributes[current_element] &0x10) /0x10;
                                        gReceptionList_Attributes_TP_Bit5[current_element]           =(gReceptionList_Attributes[current_element] &0x20) /0x20;
                                        gReceptionList_Attributes_TMC_Bit6[current_element]          =(gReceptionList_Attributes[current_element] &0x40) /0x40;
                                        gReceptionList_Attributes_SDARS_Bit7[current_element]        =(gReceptionList_Attributes[current_element] &0x80) /0x80;
                                        gReceptionList_Attributes_DABserv_Bit8[current_element]      =(gReceptionList_Attributes[current_element] &0x100) /0x100;
                                        gReceptionList_Attributes_FMOnline_Bit9[current_element]     =(gReceptionList_Attributes[current_element] &0x200) /0x200;
                                        gReceptionList_Attributes_StationSelect_BitA[current_element]=(gReceptionList_Attributes[current_element] &0x400) /0x700;
                                        gReceptionList_Attributes_OnlineRadioMute_BitB[current_element]=(gReceptionList_Attributes[current_element] &0x800) /0x800;
                                        gReceptionList_Attributes_StationLinked_BitC[current_element]  =(gReceptionList_Attributes[current_element] &0x1000) /0x1000;
                                    }

                                    //Category
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Category[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                   
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gReceptionList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gReceptionList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Type
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Type[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gReceptionList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gReceptionList_Attributes_available_Bit0[current_element]    =(gReceptionList_Attributes[current_element] &0x01);
                                        gReceptionList_Attributes_DVB_Bit1[current_element]          =(gReceptionList_Attributes[current_element] &0x02) /0x02;
                                        gReceptionList_Attributes_DAB_Bit2[current_element]          =(gReceptionList_Attributes[current_element] &0x04) /0x04; 
                                        gReceptionList_Attributes_DAB_Bit3[current_element]          =(gReceptionList_Attributes[current_element] &0x08) /0x08;
                                        gReceptionList_Attributes_DAB_Bit4[current_element]          =(gReceptionList_Attributes[current_element] &0x10) /0x10;
                                        gReceptionList_Attributes_TP_Bit5[current_element]           =(gReceptionList_Attributes[current_element] &0x20) /0x20;
                                        gReceptionList_Attributes_TMC_Bit6[current_element]          =(gReceptionList_Attributes[current_element] &0x40) /0x40;
                                        gReceptionList_Attributes_SDARS_Bit7[current_element]        =(gReceptionList_Attributes[current_element] &0x80) /0x80;
                                        gReceptionList_Attributes_DABserv_Bit8[current_element]      =(gReceptionList_Attributes[current_element] &0x100) /0x100;
                                        gReceptionList_Attributes_FMOnline_Bit9[current_element]     =(gReceptionList_Attributes[current_element] &0x200) /0x200;
                                        gReceptionList_Attributes_StationSelect_BitA[current_element]=(gReceptionList_Attributes[current_element] &0x400) /0x700;
                                        gReceptionList_Attributes_OnlineRadioMute_BitB[current_element]=(gReceptionList_Attributes[current_element] &0x800) /0x800;
                                        gReceptionList_Attributes_StationLinked_BitC[current_element]  =(gReceptionList_Attributes[current_element] &0x1000) /0x1000;
                                    }

                                    //Category
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Category[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =6 ends
                    case 15: //recordaddress =0xf -> Pos

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gReceptionList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gReceptionList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gReceptionList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gReceptionList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gReceptionList_ListHandlingType !=AUDIO_RECEPTIONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                    
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gReceptionList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gReceptionList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0xf ends
                }
                                   
                //Panel
                putvalue(env_ASG_AudioSD_RL_ASGID, gReceptionList_ASGID);
                putvalue(env_ASG_AudioSD_RL_TAID, gReceptionList_TAID);
                putvalue(env_ASG_AudioSD_RL_TotalNumLE, gReceptionList_TotalNumListElements);
                putvalue(env_ASG_AudioSD_RL_ParentID, gReceptionList_ParentID);
                putvalue(env_ASG_AudioSD_RL_ElementType, gReceptionList_ElementType);

                gReceptionList_recordaddress =recordaddress;
                gReceptionList_transmitpos   =transmitpos;             
            
			break;

            case Changed_IND:
                //get data  
                gReceptionList_ElementType =Indication_array[3];
                
                gReceptionList_ParentID =Indication_array[4]; 
                gReceptionList_ParentID +=(Indication_array[5] *0x100);              
              
                /***ArrayHeader***/
                mode            =(Indication_array[6] &0xF0) /0x10;
                recordaddress   =Indication_array[6] &0x0F;
                Offset =7;
                
                // decode "mode-byte"
                shift       =mode &0x01;
                direction   =(mode &0x02)/0x02;
                transmitpos =(mode &0x04)/0x04;
                indexsize   =(mode &0x08)/0x08; 

                if (indexsize)
                {   
                    startelement =Indication_array[Offset];
                    Offset++;
                    startelement +=(Indication_array[Offset] *0x100);
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                    elements +=(Indication_array[Offset] *0x100);
                    Offset++;
                }
                else
                {   
                    startelement =Indication_array[Offset];
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                }           
            
                if(startelement ==0 && shift==0 && transmitpos==0 && recordaddress==0 && elements==65535) //check 'full range update'?
                {
                    putvalue(env_ASG_AudioSD_RL_OnOff, FALSE);
                    putvalue(env_ASG_AudioSD_RL_ListOpState, "'full range update' received");
                }
                else if (datalength>11)
                {
                if(startelement !=0)
                {
                    for (i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(startelement ==gReceptionList_Pos[i])  
                            i =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;              
                    }
                }

                switch (recordaddress)
                {
                    case 0: //recordaddress =0 -> complete record

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gReceptionList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gReceptionList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gReceptionList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gReceptionList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gReceptionList_ListHandlingType !=AUDIO_RECEPTIONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }
                                    
                                    //Type
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Type[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gReceptionList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gReceptionList_Attributes_available_Bit0[current_element]    =(gReceptionList_Attributes[current_element] &0x01);
                                        gReceptionList_Attributes_DVB_Bit1[current_element]          =(gReceptionList_Attributes[current_element] &0x02) /0x02;
                                        gReceptionList_Attributes_DAB_Bit2[current_element]          =(gReceptionList_Attributes[current_element] &0x04) /0x04; 
                                        gReceptionList_Attributes_DAB_Bit3[current_element]          =(gReceptionList_Attributes[current_element] &0x08) /0x08;
                                        gReceptionList_Attributes_DAB_Bit4[current_element]          =(gReceptionList_Attributes[current_element] &0x10) /0x10;
                                        gReceptionList_Attributes_TP_Bit5[current_element]           =(gReceptionList_Attributes[current_element] &0x20) /0x20;
                                        gReceptionList_Attributes_TMC_Bit6[current_element]          =(gReceptionList_Attributes[current_element] &0x40) /0x40;
                                        gReceptionList_Attributes_SDARS_Bit7[current_element]        =(gReceptionList_Attributes[current_element] &0x80) /0x80;
                                        gReceptionList_Attributes_DABserv_Bit8[current_element]      =(gReceptionList_Attributes[current_element] &0x100) /0x100;
                                        gReceptionList_Attributes_FMOnline_Bit9[current_element]     =(gReceptionList_Attributes[current_element] &0x200) /0x200;
                                        gReceptionList_Attributes_StationSelect_BitA[current_element]=(gReceptionList_Attributes[current_element] &0x400) /0x700;
                                        gReceptionList_Attributes_OnlineRadioMute_BitB[current_element]=(gReceptionList_Attributes[current_element] &0x800) /0x800;
                                        gReceptionList_Attributes_StationLinked_BitC[current_element]  =(gReceptionList_Attributes[current_element] &0x1000) /0x1000;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FmREG_Code
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_FmRegCode[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Category
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Category[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                   
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;i++) //clear
			                                gReceptionList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gReceptionList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gReceptionList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Type
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Type[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gReceptionList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gReceptionList_Attributes_available_Bit0[current_element]    =(gReceptionList_Attributes[current_element] &0x01);
                                        gReceptionList_Attributes_DVB_Bit1[current_element]          =(gReceptionList_Attributes[current_element] &0x02) /0x02;
                                        gReceptionList_Attributes_DAB_Bit2[current_element]          =(gReceptionList_Attributes[current_element] &0x04) /0x04; 
                                        gReceptionList_Attributes_DAB_Bit3[current_element]          =(gReceptionList_Attributes[current_element] &0x08) /0x08;
                                        gReceptionList_Attributes_DAB_Bit4[current_element]          =(gReceptionList_Attributes[current_element] &0x10) /0x10;
                                        gReceptionList_Attributes_TP_Bit5[current_element]           =(gReceptionList_Attributes[current_element] &0x20) /0x20;
                                        gReceptionList_Attributes_TMC_Bit6[current_element]          =(gReceptionList_Attributes[current_element] &0x40) /0x40;
                                        gReceptionList_Attributes_SDARS_Bit7[current_element]        =(gReceptionList_Attributes[current_element] &0x80) /0x80;
                                        gReceptionList_Attributes_DABserv_Bit8[current_element]      =(gReceptionList_Attributes[current_element] &0x100) /0x100;
                                        gReceptionList_Attributes_FMOnline_Bit9[current_element]     =(gReceptionList_Attributes[current_element] &0x200) /0x200;
                                        gReceptionList_Attributes_StationSelect_BitA[current_element]=(gReceptionList_Attributes[current_element] &0x400) /0x700;
                                        gReceptionList_Attributes_OnlineRadioMute_BitB[current_element]=(gReceptionList_Attributes[current_element] &0x800) /0x800;
                                        gReceptionList_Attributes_StationLinked_BitC[current_element]  =(gReceptionList_Attributes[current_element] &0x1000) /0x1000;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FmREG_Code
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_FmRegCode[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Category
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Category[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;i++) //clear
			                                gReceptionList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0 ends
                    
                    case 1: //recordaddress =1 -> Type, Attributes, PResetID, FmREG_Code, Category, Name, Frequency

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gReceptionList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gReceptionList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gReceptionList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gReceptionList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gReceptionList_ListHandlingType !=AUDIO_RECEPTIONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }
                                    
                                    //Type
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Type[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gReceptionList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gReceptionList_Attributes_available_Bit0[current_element]    =(gReceptionList_Attributes[current_element] &0x01);
                                        gReceptionList_Attributes_DVB_Bit1[current_element]          =(gReceptionList_Attributes[current_element] &0x02) /0x02;
                                        gReceptionList_Attributes_DAB_Bit2[current_element]          =(gReceptionList_Attributes[current_element] &0x04) /0x04; 
                                        gReceptionList_Attributes_DAB_Bit3[current_element]          =(gReceptionList_Attributes[current_element] &0x08) /0x08;
                                        gReceptionList_Attributes_DAB_Bit4[current_element]          =(gReceptionList_Attributes[current_element] &0x10) /0x10;
                                        gReceptionList_Attributes_TP_Bit5[current_element]           =(gReceptionList_Attributes[current_element] &0x20) /0x20;
                                        gReceptionList_Attributes_TMC_Bit6[current_element]          =(gReceptionList_Attributes[current_element] &0x40) /0x40;
                                        gReceptionList_Attributes_SDARS_Bit7[current_element]        =(gReceptionList_Attributes[current_element] &0x80) /0x80;
                                        gReceptionList_Attributes_DABserv_Bit8[current_element]      =(gReceptionList_Attributes[current_element] &0x100) /0x100;
                                        gReceptionList_Attributes_FMOnline_Bit9[current_element]     =(gReceptionList_Attributes[current_element] &0x200) /0x200;
                                        gReceptionList_Attributes_StationSelect_BitA[current_element]=(gReceptionList_Attributes[current_element] &0x400) /0x700;
                                        gReceptionList_Attributes_OnlineRadioMute_BitB[current_element]=(gReceptionList_Attributes[current_element] &0x800) /0x800;
                                        gReceptionList_Attributes_StationLinked_BitC[current_element]  =(gReceptionList_Attributes[current_element] &0x1000) /0x1000;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FmREG_Code
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_FmRegCode[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Category
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Category[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                   
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gReceptionList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gReceptionList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Type
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Type[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gReceptionList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gReceptionList_Attributes_available_Bit0[current_element]    =(gReceptionList_Attributes[current_element] &0x01);
                                        gReceptionList_Attributes_DVB_Bit1[current_element]          =(gReceptionList_Attributes[current_element] &0x02) /0x02;
                                        gReceptionList_Attributes_DAB_Bit2[current_element]          =(gReceptionList_Attributes[current_element] &0x04) /0x04; 
                                        gReceptionList_Attributes_DAB_Bit3[current_element]          =(gReceptionList_Attributes[current_element] &0x08) /0x08;
                                        gReceptionList_Attributes_DAB_Bit4[current_element]          =(gReceptionList_Attributes[current_element] &0x10) /0x10;
                                        gReceptionList_Attributes_TP_Bit5[current_element]           =(gReceptionList_Attributes[current_element] &0x20) /0x20;
                                        gReceptionList_Attributes_TMC_Bit6[current_element]          =(gReceptionList_Attributes[current_element] &0x40) /0x40;
                                        gReceptionList_Attributes_SDARS_Bit7[current_element]        =(gReceptionList_Attributes[current_element] &0x80) /0x80;
                                        gReceptionList_Attributes_DABserv_Bit8[current_element]      =(gReceptionList_Attributes[current_element] &0x100) /0x100;
                                        gReceptionList_Attributes_FMOnline_Bit9[current_element]     =(gReceptionList_Attributes[current_element] &0x200) /0x200;
                                        gReceptionList_Attributes_StationSelect_BitA[current_element]=(gReceptionList_Attributes[current_element] &0x400) /0x700;
                                        gReceptionList_Attributes_OnlineRadioMute_BitB[current_element]=(gReceptionList_Attributes[current_element] &0x800) /0x800;
                                        gReceptionList_Attributes_StationLinked_BitC[current_element]  =(gReceptionList_Attributes[current_element] &0x1000) /0x1000;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FmREG_Code
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_FmRegCode[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Category
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Category[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =1 ends
                    
                    case 2: //recordaddress =2 -> Type, Attributes

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gReceptionList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gReceptionList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gReceptionList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gReceptionList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gReceptionList_ListHandlingType !=AUDIO_RECEPTIONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }
                                    
                                    //Type
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Type[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gReceptionList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gReceptionList_Attributes_available_Bit0[current_element]    =(gReceptionList_Attributes[current_element] &0x01);
                                        gReceptionList_Attributes_DVB_Bit1[current_element]          =(gReceptionList_Attributes[current_element] &0x02) /0x02;
                                        gReceptionList_Attributes_DAB_Bit2[current_element]          =(gReceptionList_Attributes[current_element] &0x04) /0x04; 
                                        gReceptionList_Attributes_DAB_Bit3[current_element]          =(gReceptionList_Attributes[current_element] &0x08) /0x08;
                                        gReceptionList_Attributes_DAB_Bit4[current_element]          =(gReceptionList_Attributes[current_element] &0x10) /0x10;
                                        gReceptionList_Attributes_TP_Bit5[current_element]           =(gReceptionList_Attributes[current_element] &0x20) /0x20;
                                        gReceptionList_Attributes_TMC_Bit6[current_element]          =(gReceptionList_Attributes[current_element] &0x40) /0x40;
                                        gReceptionList_Attributes_SDARS_Bit7[current_element]        =(gReceptionList_Attributes[current_element] &0x80) /0x80;
                                        gReceptionList_Attributes_DABserv_Bit8[current_element]      =(gReceptionList_Attributes[current_element] &0x100) /0x100;
                                        gReceptionList_Attributes_FMOnline_Bit9[current_element]     =(gReceptionList_Attributes[current_element] &0x200) /0x200;
                                        gReceptionList_Attributes_StationSelect_BitA[current_element]=(gReceptionList_Attributes[current_element] &0x400) /0x700;
                                        gReceptionList_Attributes_OnlineRadioMute_BitB[current_element]=(gReceptionList_Attributes[current_element] &0x800) /0x800;
                                        gReceptionList_Attributes_StationLinked_BitC[current_element]  =(gReceptionList_Attributes[current_element] &0x1000) /0x1000;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gReceptionList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gReceptionList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Type
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Type[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gReceptionList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gReceptionList_Attributes_available_Bit0[current_element]    =(gReceptionList_Attributes[current_element] &0x01);
                                        gReceptionList_Attributes_DVB_Bit1[current_element]          =(gReceptionList_Attributes[current_element] &0x02) /0x02;
                                        gReceptionList_Attributes_DAB_Bit2[current_element]          =(gReceptionList_Attributes[current_element] &0x04) /0x04; 
                                        gReceptionList_Attributes_DAB_Bit3[current_element]          =(gReceptionList_Attributes[current_element] &0x08) /0x08;
                                        gReceptionList_Attributes_DAB_Bit4[current_element]          =(gReceptionList_Attributes[current_element] &0x10) /0x10;
                                        gReceptionList_Attributes_TP_Bit5[current_element]           =(gReceptionList_Attributes[current_element] &0x20) /0x20;
                                        gReceptionList_Attributes_TMC_Bit6[current_element]          =(gReceptionList_Attributes[current_element] &0x40) /0x40;
                                        gReceptionList_Attributes_SDARS_Bit7[current_element]        =(gReceptionList_Attributes[current_element] &0x80) /0x80;
                                        gReceptionList_Attributes_DABserv_Bit8[current_element]      =(gReceptionList_Attributes[current_element] &0x100) /0x100;
                                        gReceptionList_Attributes_FMOnline_Bit9[current_element]     =(gReceptionList_Attributes[current_element] &0x200) /0x200;
                                        gReceptionList_Attributes_StationSelect_BitA[current_element]=(gReceptionList_Attributes[current_element] &0x400) /0x700;
                                        gReceptionList_Attributes_OnlineRadioMute_BitB[current_element]=(gReceptionList_Attributes[current_element] &0x800) /0x800;
                                        gReceptionList_Attributes_StationLinked_BitC[current_element]  =(gReceptionList_Attributes[current_element] &0x1000) /0x1000;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =2 ends
                    
                    case 3: //recordaddress =3 -> PresetID, FmREG_Code, Category, Name

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gReceptionList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gReceptionList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gReceptionList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gReceptionList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gReceptionList_ListHandlingType !=AUDIO_RECEPTIONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }

                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FmREG_Code
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_FmRegCode[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Category
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Category[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                   
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gReceptionList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gReceptionList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //PresetID
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_PresetID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //FmREG_Code
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_FmRegCode[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Category
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Category[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =3 ends
                    
                    case 4: //recordaddress =4 -> complete record

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gReceptionList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gReceptionList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gReceptionList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gReceptionList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gReceptionList_ListHandlingType !=AUDIO_RECEPTIONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }
                                   
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gReceptionList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gReceptionList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =4 ends 
                    
                    case 5: //recordaddress =5 -> Frequency

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gReceptionList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gReceptionList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gReceptionList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gReceptionList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gReceptionList_ListHandlingType !=AUDIO_RECEPTIONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;i++) //clear
			                                gReceptionList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gReceptionList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gReceptionList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }

                                    //Frequency
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_FREQUENCY_LENGTH;i++) //clear
			                                gReceptionList_Frequency[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Frequency[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =5 ends
                    case 6: //recordaddress =6 -> Type,Attributes,Category,Name

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gReceptionList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gReceptionList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gReceptionList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gReceptionList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gReceptionList_ListHandlingType !=AUDIO_RECEPTIONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }
                                    
                                    //Type
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Type[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gReceptionList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gReceptionList_Attributes_available_Bit0[current_element]    =(gReceptionList_Attributes[current_element] &0x01);
                                        gReceptionList_Attributes_DVB_Bit1[current_element]          =(gReceptionList_Attributes[current_element] &0x02) /0x02;
                                        gReceptionList_Attributes_DAB_Bit2[current_element]          =(gReceptionList_Attributes[current_element] &0x04) /0x04; 
                                        gReceptionList_Attributes_DAB_Bit3[current_element]          =(gReceptionList_Attributes[current_element] &0x08) /0x08;
                                        gReceptionList_Attributes_DAB_Bit4[current_element]          =(gReceptionList_Attributes[current_element] &0x10) /0x10;
                                        gReceptionList_Attributes_TP_Bit5[current_element]           =(gReceptionList_Attributes[current_element] &0x20) /0x20;
                                        gReceptionList_Attributes_TMC_Bit6[current_element]          =(gReceptionList_Attributes[current_element] &0x40) /0x40;
                                        gReceptionList_Attributes_SDARS_Bit7[current_element]        =(gReceptionList_Attributes[current_element] &0x80) /0x80;
                                        gReceptionList_Attributes_DABserv_Bit8[current_element]      =(gReceptionList_Attributes[current_element] &0x100) /0x100;
                                        gReceptionList_Attributes_FMOnline_Bit9[current_element]     =(gReceptionList_Attributes[current_element] &0x200) /0x200;
                                        gReceptionList_Attributes_StationSelect_BitA[current_element]=(gReceptionList_Attributes[current_element] &0x400) /0x700;
                                        gReceptionList_Attributes_OnlineRadioMute_BitB[current_element]=(gReceptionList_Attributes[current_element] &0x800) /0x800;
                                        gReceptionList_Attributes_StationLinked_BitC[current_element]  =(gReceptionList_Attributes[current_element] &0x1000) /0x1000;
                                    }

                                    //Category
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Category[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                   
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gReceptionList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gReceptionList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Type
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Type[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        gReceptionList_Attributes[current_element] +=(Indication_array[Offset] *0x100);
                                        Offset++;
                                        
                                        gReceptionList_Attributes_available_Bit0[current_element]    =(gReceptionList_Attributes[current_element] &0x01);
                                        gReceptionList_Attributes_DVB_Bit1[current_element]          =(gReceptionList_Attributes[current_element] &0x02) /0x02;
                                        gReceptionList_Attributes_DAB_Bit2[current_element]          =(gReceptionList_Attributes[current_element] &0x04) /0x04; 
                                        gReceptionList_Attributes_DAB_Bit3[current_element]          =(gReceptionList_Attributes[current_element] &0x08) /0x08;
                                        gReceptionList_Attributes_DAB_Bit4[current_element]          =(gReceptionList_Attributes[current_element] &0x10) /0x10;
                                        gReceptionList_Attributes_TP_Bit5[current_element]           =(gReceptionList_Attributes[current_element] &0x20) /0x20;
                                        gReceptionList_Attributes_TMC_Bit6[current_element]          =(gReceptionList_Attributes[current_element] &0x40) /0x40;
                                        gReceptionList_Attributes_SDARS_Bit7[current_element]        =(gReceptionList_Attributes[current_element] &0x80) /0x80;
                                        gReceptionList_Attributes_DABserv_Bit8[current_element]      =(gReceptionList_Attributes[current_element] &0x100) /0x100;
                                        gReceptionList_Attributes_FMOnline_Bit9[current_element]     =(gReceptionList_Attributes[current_element] &0x200) /0x200;
                                        gReceptionList_Attributes_StationSelect_BitA[current_element]=(gReceptionList_Attributes[current_element] &0x400) /0x700;
                                        gReceptionList_Attributes_OnlineRadioMute_BitB[current_element]=(gReceptionList_Attributes[current_element] &0x800) /0x800;
                                        gReceptionList_Attributes_StationLinked_BitC[current_element]  =(gReceptionList_Attributes[current_element] &0x1000) /0x1000;
                                    }

                                    //Category
                                    if(CacheElements ==TRUE)
                                    {
                                        gReceptionList_Category[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_RECEPTIONLIST_NAME_LENGTH;i++) //clear
			                                gReceptionList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gReceptionList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =6 ends
                    case 15: //recordaddress =0xf -> Pos

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gReceptionList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gReceptionList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gReceptionList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gReceptionList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +Indication_array[Offset+1]*100) ==gReceptionList_Pos[i] && gReceptionList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gReceptionList_ListHandlingType !=AUDIO_RECEPTIONLIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                            
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                    
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gReceptionList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =ReceptionList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_RECEPTIONLIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE; i++)
                                        {
                                            if((transmitpos ==TRUE) && gReceptionList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];

                                                if(startelement_check ==gReceptionList_Pos[i])
                                                {
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gReceptionList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gReceptionList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gReceptionList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =ReceptionList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0xf ends
                }
                }                   
                
                //Panel
                putvalue(env_ASG_AudioSD_RL_ASGID, gReceptionList_ASGID);
                putvalue(env_ASG_AudioSD_RL_TAID, gReceptionList_TAID);
                putvalue(env_ASG_AudioSD_RL_ParentID, gReceptionList_ParentID);
                putvalue(env_ASG_AudioSD_RL_ElementType, gReceptionList_ElementType);

                gReceptionList_recordaddress =recordaddress;
                gReceptionList_transmitpos   =transmitpos;             
            
            break;
			
            case Error_IND:
					
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD ReceptionList_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD ReceptionList_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD ReceptionList_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD ReceptionList_Indication: Application-Error: 0x%x", Indication_array[3]);
				
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD ReceptionList_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
		}

    //for "sliding window concept"
    if(gReceptionList_TotalNumListElements<=AUDIO_RECEPTIONLIST_ASGCACHE_MAX_SIZE)
        gReceptionList_SlidingWindow_State =AUDIO_RECEPTIONLIST_SLIDINGWINDOW_NOTACTIVE;
    else
        gReceptionList_SlidingWindow_State =AUDIO_RECEPTIONLIST_SLIDINGWINDOW_ACTIVE;

    if (gReceptionList_CallBackReason !=AUDIO_RECEPTIONLIST_CALLBACKREASON_NOCALLBACK)
        ReceptionList_ListHandling ();
    else
        ReceptionList_display();
}

display_InfoList ()
{/*
    if (gInfoList_ONOFF==1)
	{
        putvalue(env_ASG_AudioSD_InfoList_Num, gInfoList_TotalNumListElements);
	
	    putvalue(env_ASG_AudioSD_InfoList_Name_1, gInfoList_Name[3]);
	    putvalue(env_ASG_AudioSD_InfoList_Type_1, gInfoList_Type_s[gInfoList_Type[3]]);
	    putvalue(env_ASG_AudioSD_InfoList_Pos_1, gInfoList_FSGHandle[3]);

        putvalue(env_ASG_AudioSD_InfoList_Name_2, gInfoList_Name[4]);
	    putvalue(env_ASG_AudioSD_InfoList_Type_2, gInfoList_Type_s[gInfoList_Type[4]]);
	    putvalue(env_ASG_AudioSD_InfoList_Pos_2, gInfoList_FSGHandle[4]);
    
        if (getvalue(env_ASG_AudioSD_SaveStation_Src) == 0x01 || getvalue(env_ASG_AudioSD_SaveStation_Src) == 0x02 || getvalue(env_ASG_AudioSD_SaveStation_Src) == 0x03)
            putvalue(env_ASG_AudioSD_SaveStation_fsgH, gInfoList_FSGHandle[4]);
        putvalue(env_ASG_AudioSD_DAC_FSGHandle, gInfoList_FSGHandle[4]);    

        putvalue(env_ASG_AudioSD_InfoList_Name_3, gInfoList_Name[5]);
	    putvalue(env_ASG_AudioSD_InfoList_Type_3, gInfoList_Type_s[gInfoList_Type[5]]);
        putvalue(env_ASG_AudioSD_InfoList_Pos_3, gInfoList_FSGHandle[5]);
    }
    */
}

AnnouncementInfo_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	            //LSG-ID
	requestarray[1] =FctID_AnnouncementInfo;	//Fct.-ID
	requestarray[2] =request;                   //request type
	
    switch(request)
	{
		case DataGet_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD AnnouncementInfo_Request: invalid request %d", request);
		break;
	}
}

AnnouncementInfo_Indication (dword Indication_array [], int datalength)
{   
    int i =0;   
    
    switch (gBAP_Indication[2])
	{
	    case Data_IND:
            if(datalength >=2) 
            {
                //get data
				gAudioSD_AnnouncementInfo_Type =Indication_array[3];
                
                //clear
                for(i=0; i<ANNOUNCEMENT_STATIONNAME_TEXTLENGTH; i++)
                    gAudioSD_AnnouncementInfo_StationName[i] =0;
                
                for(i=0; i<Indication_array[4]; i++)
                    gAudioSD_AnnouncementInfo_StationName[i] =Indication_array[5+i];

                //Panel
                if(gAudioSD_AnnouncementInfo_Type <0x0E)
                    putvalue(env_ASG_AudioSD_AnInf_Type_s, gAudioSD_AnnouncementInfo_Type_string[gAudioSD_AnnouncementInfo_Type]);
                
                else
                    putvalue(env_ASG_AudioSD_AnInf_Type_s, gstring_reserved);

                putvalue(env_ASG_AudioSD_AnInf_Name_s, gAudioSD_AnnouncementInfo_StationName);
             }
            break;
			
            case Error_IND:
					
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD AnnouncementInfo_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD AnnouncementInfo_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD AnnouncementInfo_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD AnnouncementInfo_Indication: Application-Error: 0x%x", Indication_array[3]);
				
		    break;
		    default:
			    writelineEx(gError_Trace, 0,"ASG-AudioSD AnnouncementInfo_Indication: unknown indication %x", gBAP_Indication[2]);
		    break;
	    }
}

InfoStates_Indication (dword Indication_array [], int datalength)
{
		switch (gBAP_Indication[2])
		{
			case Data_IND:
        //get data
        gAudioSD_InfoStates_States =Indication_array[3];
        
        //Panel
        if (gAudioSD_InfoStates_States <0x52)
            putvalue(env_ASG_AudioSD_InfoSt_States_s, gAudioSD_InfoStates_States_string[gAudioSD_InfoStates_States]);
        else if (gAudioSD_InfoStates_States ==0xff)
            putvalue(env_ASG_AudioSD_InfoSt_States_s,gstring_unknown);    
        else
            putvalue(env_ASG_AudioSD_InfoSt_States_s,gstring_reserved);
      break;
      case Error_IND:
  			if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
  				writelineEx(gError_Trace, 0, "ASG-AudioSD InfoStates_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
  			else if(Indication_array[3]<0x30)			//BPL-error
  				writelineEx(gError_Trace, 0, "ASG-AudioSD InfoStates_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
  			else if(Indication_array[3]<0x40)			//BAL-error
  				writelineEx(gError_Trace, 0, "ASG-AudioSD InfoStates_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
  			else
  				writelineEx(gError_Trace, 0, "ASG-AudioSD InfoStates_Indication: Application-Error: 0x%x", Indication_array[3]);
  		break;
  		default:
  			writelineEx(gError_Trace, 0,"ASG-AudioSD InfoStates_Indication: unknown indication %x", gBAP_Indication[2]);
  		break;
		}
 }

InfoStates_Request (byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	            //LSG-ID
  	requestarray[1] =FctID_InfoStates;	        //Fct.-ID
  	requestarray[2] =request;                   //request type
	
    switch(request)
  	{
  		case DataGet_REQ:
  			set_status_requestbuffer (requestarray, 3, Bap_Void);
  		break;
  		default:	
  			writelineEx(gError_Trace, 0, "ASG-AudioSD InfoStates_Request: invalid request %d", request);
  		break;
  	}
}

AnnouncementEscape_Request (byte request, byte errorcode)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	                //LSG-ID
	requestarray[1] =FctID_AnnouncementEscape;	    //Fct.-ID
	requestarray[2] =request;                       //request type
	
    switch(request)
	{
		case StartResult_REQ:

		    set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
        case AbortResult_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD AnnouncementEscape_Request: invalid request %d", request);
		break;
	}
}

AnnouncementEscape_Indication(dword Indication_array [], int datalength)
{
	switch (gBAP_Indication[2])
	{
		case Processing_IND:
		break;
		case Result_IND:
				
                gAudioSD_AnnoucementEsc_Result =Indication_array[3];
                if(gAudioSD_AnnoucementEsc_Result <0x05)	
					putvalue(env_ASG_AudioSD_AnE_Res_s, gAudioSD_AnnoucementEsc_Result_s[gAudioSD_AnnoucementEsc_Result]);   
				else
					putvalue(env_ASG_AudioSD_AnE_Res_s, gstring_reserved);               
		break;
		case Error_IND:
				
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD AnnouncementEscape_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30 && Indication_array[3] !=0)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD AnnouncementEscape_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40 && Indication_array[3] !=0)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD AnnouncementEscape_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
				{	
                    writelineEx(gError_Trace, 0, "ASG-AudioSD AnnouncementEscape_Indication: Application-Error: 0x%x", Indication_array[3]);
                    putvalue(env_ASG_AudioSD_AnE_Err,Indication_array[3]);
                    
                    if (Indication_array[3] ==0)
                        putvalue(env_ASG_AudioSD_AnE_Err_s,"no error");
                    
                    else if((Indication_array[3]-0x40)<17)
                        putvalue(env_ASG_AudioSD_AnE_Err_s,gerror_codes_0x40_0x7F[Indication_array[3]-0x40]);
                    else
                        putvalue(env_ASG_AudioSD_AnE_Err_s,gstring_reserved);
                }
			
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD AnnouncementEscape_Indication:: unknown indication %d", gBAP_Indication[2]);
		break;
	}
}

DedicatedAudioControl_Request (byte request, byte errorcode)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	                //LSG-ID
	requestarray[1] =FctID_DedicatedAudioControl;	//Fct.-ID
	requestarray[2] =request;                       //request type
	
    switch(request)
	{
		case StartResult_REQ:
            requestarray[3] =gAudioSD_DAC_CT;                 
		    requestarray[4] =gAudioSD_DAC_FSGhandle &0x00FF;
            requestarray[5] =(gAudioSD_DAC_FSGhandle &0xFF00) /0x100;
            requestarray[6] =gAudioSD_DAC_LT;

			set_status_requestbuffer (requestarray, 7, Bap_ByteSequence);
		break;
        case AbortResult_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD DedicatedAudioControl_Request: invalid request %d", request);
		break;
	}
}

DedicatedAudioControl_Indication(dword Indication_array [], int datalength)
{
	switch (gBAP_Indication[2])
	{
		case Processing_IND:
		break;
		case Result_IND:
        gAudioSD_DAC_Result =Indication_array[3];
        if(gAudioSD_DAC_Result <0x04)	
	        putvalue(env_ASG_AudioSD_DAC_Res_s, gAudioSD_DAC_Result_s[gAudioSD_DAC_Result]);   
				else
					putvalue(env_ASG_AudioSD_DAC_Res_s, gstring_reserved);               
		break;
		case Error_IND:
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD DedicatedAudioControl_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30 && Indication_array[3] !=0)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD DedicatedAudioControl_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40 && Indication_array[3] !=0)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD DedicatedAudioControl_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
				{	
            writelineEx(gError_Trace, 0, "ASG-AudioSD DedicatedAudioControl_Indication: Application-Error: 0x%x", Indication_array[3]);
            putvalue(env_ASG_AudioSD_DAC_Err,Indication_array[3]);
            if (Indication_array[3] ==0)
                putvalue(env_ASG_AudioSD_DAC_Err_s,"no error");
            else if((Indication_array[3]-0x40)<17)
                putvalue(env_ASG_AudioSD_DAC_Err_s,gerror_codes_0x40_0x7F[Indication_array[3]-0x40]);
            else
                putvalue(env_ASG_AudioSD_DAC_Err_s,gstring_reserved);
        }	
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD DedicatedAudioControl_Indication:: unknown indication %d", gBAP_Indication[2]);
		break;
	}
}

on envVar env_ASG_AudioSD_DAC_SR
{
	if(POWER_ON==gASG_PowerOnOff && TRUE==gBAP_AudioSD_available && getvalue(this))
	{
		gAudioSD_DAC_CT         =getvalue(env_ASG_AudioSD_DAC_CT);
        gAudioSD_DAC_LT         =getvalue(env_ASG_AudioSD_DAC_LT);
        gAudioSD_DAC_FSGhandle  =getvalue(env_ASG_AudioSD_DAC_FSGHandle);

        putvalue(env_ASG_AudioSD_DAC_Err,0);
        putvalue(env_ASG_AudioSD_DAC_Err_s,empty_string);
        putvalue(env_ASG_AudioSD_DAC_Res_s,empty_string);
        
        DedicatedAudioControl_Request(StartResult_REQ, 0);
	}
}

ReceptionListType_Indication (dword Indication_array [], int datalength)
{
		switch (gBAP_Indication[2])
		{
			case Data_IND:
                //get data
				     gAudioSD_ReceptionListType_Type =Indication_array[3];
                
                //Panel
                if (gAudioSD_ReceptionListType_Type <0x0C)
                    putvalue(env_ASG_AudioSD_RecListTy_Type_s, gAudioSD_ReceptionListType_Type_string[gAudioSD_ReceptionListType_Type]);
                
                else if (gAudioSD_ReceptionListType_Type ==NORECEPTIONLISTAVAILABLE)
                    putvalue(env_ASG_AudioSD_RecListTy_Type_s, gAudioSD_ReceptionListType_Type_string_0xff);

                else
                    putvalue(env_ASG_AudioSD_RecListTy_Type_s, gstring_reserved);

            break;
			
            case Error_IND:
					
				if(Indication_array[3]<0x20 && Indication_array[3] !=0)				//BCL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD ReceptionListType_Indication: BCL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BCL [Indication_array[3]-0x10]);
				else if(Indication_array[3]<0x30)			//BPL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD ReceptionListType_Indication: BPL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BPL [Indication_array[3]-0x20]);				
				else if(Indication_array[3]<0x40)			//BAL-error
					writelineEx(gError_Trace, 0, "ASG-AudioSD ReceptionListType_Indication: BAL-Error: 0x%x - %s", Indication_array[3], gerror_codes_BAL [Indication_array[3]-0x30]);
				else
					writelineEx(gError_Trace, 0, "ASG-AudioSD ReceptionListType_Indication: Application-Error: 0x%x", Indication_array[3]);
				
		break;
		default:
			writelineEx(gError_Trace, 0,"ASG-AudioSD ReceptionListType_Indication: unknown indication %x", gBAP_Indication[2]);
		break;
		}
	
}

ReceptionListType_Request(byte request)
{
    int  i;
    dword requestarray [BAP_BUFFER_SIZE];

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;

    // Handle request.
    requestarray[0] =LSG_AudioSD;	            //LSG-ID
	requestarray[1] =FctID_ReceptionListType;	//Fct.-ID
	requestarray[2] =request;                   //request type
	
    switch(request)
	{
		case DataGet_REQ:
		
			set_status_requestbuffer (requestarray, 3, Bap_Void);
		break;
		default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD ReceptionListType_Request: invalid request %d", request);
		break;
	}
}

SourceList_Request (byte request, byte mode, byte recordaddress, word requested_startelement, word startelement, word elements)
{   
    int  i;
    dword requestarray [BAP_BUFFER_SIZE], Offset;
    word indexsize;

    // Init local variables. 
    for(i=0;i<BAP_BUFFER_SIZE;i++)
	    requestarray [i]=0;
    
    indexsize   =0;
    Offset      =0;

    // decode "mode-byte"
    indexsize   =(mode &0x08)/0x08; 

    // Handle request.
    requestarray[0] =LSG_AudioSD;	        //LSG-ID
	requestarray[1] =FctID_SourceList;	    //Fct.-ID
	requestarray[2] =request;               //request type

    switch(request)
	{
        case DataGet_REQ:              
                requestarray[3] =((gSourceList_ASGID *0x10) &0xF0) +(gSourceList_TAID &0x0F);
                
                /***ArrayHeader***/
			    requestarray[4] =((mode *0x10) &0xF0) +(recordaddress &0x0F);          
                Offset =5;

                if(indexsize)
                {
                    requestarray[Offset] =requested_startelement &0x00FF;
                    Offset++;
                    requestarray[Offset] =(requested_startelement &0xFF00) /0x100;
                    Offset++;  

                    requestarray[Offset] =elements &0x00FF;
                    Offset++;
                    requestarray[Offset] =(elements &0xFF00) /0x100;
                    Offset++;       
                }
                else
                {
                    requestarray[Offset] =requested_startelement;
                    Offset++;

                    requestarray[Offset] =elements;
                    Offset++;
                }
            
            set_status_requestbuffer (requestarray, Offset, Bap_ByteSequence);
         break;

        default:	
			writelineEx(gError_Trace, 0, "ASG-AudioSD SourceList_Request: invalid request %d", request);
		break;
    }
}

SourceList_Indication (dword Indication_array [], int datalength)
{
    byte mode, direction, shift, recordaddress, indexsize, current_element, transmitpos, length, CacheElements, StartElementInCache;
    word  startelement, elements, startelement_check, Offset =0;
    int i =0, j=0;

    // Init local variables
    mode                    =0;
    direction               =0;
    shift                   =0;
    recordaddress           =0;
    startelement            =0;
    elements                =0;
    current_element         =0;
    transmitpos             =0;
    length                  =0;
    startelement_check      =0;
    StartElementInCache     =FALSE;
    CacheElements           =FALSE;
    
		switch (gBAP_Indication[2])
		{
			case Data_IND:
				//get data
                gSourceList_ASGID =(Indication_array[3] &0xF0) /0x10;
                gSourceList_TAID  =Indication_array[3] &0x0F;             

                gSourceList_TotalNumListElements =Indication_array[4];
                gSourceList_TotalNumListElements +=(Indication_array[5] *0x100);
              
                /***ArrayHeader***/
                mode            =(Indication_array[6] &0xF0) /0x10;
                recordaddress   =Indication_array[6] &0x0F;
                Offset =7;
                
                // decode "mode-byte"
                shift       =mode &0x01;
                direction   =(mode &0x02)/0x02;
                transmitpos =(mode &0x04)/0x04;
                indexsize   =(mode &0x08)/0x08; 

                if (indexsize)
                {   
                    startelement =Indication_array[Offset];
                    Offset++;
                    startelement +=(Indication_array[Offset] *0x100);
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                    elements +=(Indication_array[Offset] *0x100);
                    Offset++;
                }
                else
                {   
                    startelement =Indication_array[Offset];
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                }           
            
                if(startelement !=0)
                {
                    for (i=0;i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(startelement ==gSourceList_Pos[i])  
                            i =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;              
                    }
                }

                switch (recordaddress)
                {
                    case 0: //recordaddress =0 -> complete record

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSourceList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSourceList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSourceList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSourceList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSourceList_ListHandlingType !=AUDIO_SOURCELIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //SourceType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_SourceType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //InstanceID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_InstanceID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //MediaType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_MediaType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        
                                        gSourceList_Attributes_BuiltIn_Bit0[current_element]    =(gSourceList_Attributes[current_element] &0x01);
                                        gSourceList_Attributes_MediaError_Bit1[current_element] =(gSourceList_Attributes[current_element] &0x02) /0x02;
                                        gSourceList_Attributes_MediaPlay_Bit2[current_element]  =(gSourceList_Attributes[current_element] &0x04) /0x04; 
                                        gSourceList_Attributes_MediaRead_Bit3[current_element]  =(gSourceList_Attributes[current_element] &0x08) /0x08;
                                        gSourceList_Attributes_MediaLoad_Bit4[current_element]  =(gSourceList_Attributes[current_element] &0x10) /0x10;
                                        gSourceList_Attributes_ImportRun_Bit5[current_element]  =(gSourceList_Attributes[current_element] &0x20) /0x20;
                                        gSourceList_Attributes_MediaSupp_Bit6[current_element]  =(gSourceList_Attributes[current_element] &0x40) /0x40;                                        
                                    }

                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SOURCELIST_NAME_LENGTH;i++) //clear
			                                gSourceList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSourceList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSourceList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSourceList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //SourceType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_SourceType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //InstanceID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_InstanceID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //MediaType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_MediaType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        
                                        gSourceList_Attributes_BuiltIn_Bit0[current_element]    =(gSourceList_Attributes[current_element] &0x01);
                                        gSourceList_Attributes_MediaError_Bit1[current_element] =(gSourceList_Attributes[current_element] &0x02) /0x02;
                                        gSourceList_Attributes_MediaPlay_Bit2[current_element]  =(gSourceList_Attributes[current_element] &0x04) /0x04; 
                                        gSourceList_Attributes_MediaRead_Bit3[current_element]  =(gSourceList_Attributes[current_element] &0x08) /0x08;
                                        gSourceList_Attributes_MediaLoad_Bit4[current_element]  =(gSourceList_Attributes[current_element] &0x10) /0x10;
                                        gSourceList_Attributes_ImportRun_Bit5[current_element]  =(gSourceList_Attributes[current_element] &0x20) /0x20;
                                        gSourceList_Attributes_MediaSupp_Bit6[current_element]  =(gSourceList_Attributes[current_element] &0x40) /0x40;                            
                                    }

                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SOURCELIST_NAME_LENGTH;i++) //clear
			                                gSourceList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSourceList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0 ends
                    
                    case 1: //recordaddress =1 -> SourceType, InstanceID, MediaType, Attributes
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSourceList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSourceList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSourceList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSourceList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSourceList_ListHandlingType !=AUDIO_SOURCELIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //SourceType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_SourceType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //InstanceID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_InstanceID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //MediaType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_MediaType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        
                                        gSourceList_Attributes_BuiltIn_Bit0[current_element]    =(gSourceList_Attributes[current_element] &0x01);
                                        gSourceList_Attributes_MediaError_Bit1[current_element] =(gSourceList_Attributes[current_element] &0x02) /0x02;
                                        gSourceList_Attributes_MediaPlay_Bit2[current_element]  =(gSourceList_Attributes[current_element] &0x04) /0x04; 
                                        gSourceList_Attributes_MediaRead_Bit3[current_element]  =(gSourceList_Attributes[current_element] &0x08) /0x08;
                                        gSourceList_Attributes_MediaLoad_Bit4[current_element]  =(gSourceList_Attributes[current_element] &0x10) /0x10;
                                        gSourceList_Attributes_ImportRun_Bit5[current_element]  =(gSourceList_Attributes[current_element] &0x20) /0x20;
                                        gSourceList_Attributes_MediaSupp_Bit6[current_element]  =(gSourceList_Attributes[current_element] &0x40) /0x40;                                         
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSourceList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSourceList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //SourceType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_SourceType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //InstanceID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_InstanceID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //MediaType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_MediaType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        
                                        gSourceList_Attributes_BuiltIn_Bit0[current_element]    =(gSourceList_Attributes[current_element] &0x01);
                                        gSourceList_Attributes_MediaError_Bit1[current_element] =(gSourceList_Attributes[current_element] &0x02) /0x02;
                                        gSourceList_Attributes_MediaPlay_Bit2[current_element]  =(gSourceList_Attributes[current_element] &0x04) /0x04; 
                                        gSourceList_Attributes_MediaRead_Bit3[current_element]  =(gSourceList_Attributes[current_element] &0x08) /0x08;
                                        gSourceList_Attributes_MediaLoad_Bit4[current_element]  =(gSourceList_Attributes[current_element] &0x10) /0x10;
                                        gSourceList_Attributes_ImportRun_Bit5[current_element]  =(gSourceList_Attributes[current_element] &0x20) /0x20;
                                        gSourceList_Attributes_MediaSupp_Bit6[current_element]  =(gSourceList_Attributes[current_element] &0x40) /0x40;                             
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =1 ends
                    
                    case 2: //recordaddress =2 -> Name
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSourceList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSourceList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSourceList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSourceList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSourceList_ListHandlingType !=AUDIO_SOURCELIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }

                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SOURCELIST_NAME_LENGTH;i++) //clear
			                                gSourceList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSourceList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSourceList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSourceList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }

                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SOURCELIST_NAME_LENGTH;i++) //clear
			                                gSourceList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSourceList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =2 ends
                    
                    case 3: //recordaddress =3 -> Attributes
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSourceList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSourceList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSourceList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSourceList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSourceList_ListHandlingType !=AUDIO_SOURCELIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        
                                        gSourceList_Attributes_BuiltIn_Bit0[current_element]    =(gSourceList_Attributes[current_element] &0x01);
                                        gSourceList_Attributes_MediaError_Bit1[current_element] =(gSourceList_Attributes[current_element] &0x02) /0x02;
                                        gSourceList_Attributes_MediaPlay_Bit2[current_element]  =(gSourceList_Attributes[current_element] &0x04) /0x04; 
                                        gSourceList_Attributes_MediaRead_Bit3[current_element]  =(gSourceList_Attributes[current_element] &0x08) /0x08;
                                        gSourceList_Attributes_MediaLoad_Bit4[current_element]  =(gSourceList_Attributes[current_element] &0x10) /0x10;
                                        gSourceList_Attributes_ImportRun_Bit5[current_element]  =(gSourceList_Attributes[current_element] &0x20) /0x20;
                                        gSourceList_Attributes_MediaSupp_Bit6[current_element]  =(gSourceList_Attributes[current_element] &0x40) /0x40;                                         
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSourceList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSourceList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        
                                        gSourceList_Attributes_BuiltIn_Bit0[current_element]    =(gSourceList_Attributes[current_element] &0x01);
                                        gSourceList_Attributes_MediaError_Bit1[current_element] =(gSourceList_Attributes[current_element] &0x02) /0x02;
                                        gSourceList_Attributes_MediaPlay_Bit2[current_element]  =(gSourceList_Attributes[current_element] &0x04) /0x04; 
                                        gSourceList_Attributes_MediaRead_Bit3[current_element]  =(gSourceList_Attributes[current_element] &0x08) /0x08;
                                        gSourceList_Attributes_MediaLoad_Bit4[current_element]  =(gSourceList_Attributes[current_element] &0x10) /0x10;
                                        gSourceList_Attributes_ImportRun_Bit5[current_element]  =(gSourceList_Attributes[current_element] &0x20) /0x20;
                                        gSourceList_Attributes_MediaSupp_Bit6[current_element]  =(gSourceList_Attributes[current_element] &0x40) /0x40;                             
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =3 ends
                    
                    case 4: //recordaddress =4 -> Mediatype
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSourceList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSourceList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSourceList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSourceList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSourceList_ListHandlingType !=AUDIO_SOURCELIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }

                                    //MediaType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_MediaType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSourceList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSourceList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }

                                    //MediaType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_MediaType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                   
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =4 ends 
                    
                    case 15: //recordaddress =0xf -> Pos
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSourceList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSourceList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSourceList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSourceList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSourceList_ListHandlingType !=AUDIO_SOURCELIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                    
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSourceList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSourceList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0xf ends
                }
                                   
                //Panel
                putvalue(env_ASG_AudioSD_SL_ASGID, gSourceList_ASGID);
                putvalue(env_ASG_AudioSD_SL_TAID, gSourceList_TAID);
                putvalue(env_ASG_AudioSD_SL_TotalNumLE, gSourceList_TotalNumListElements);

                gSourceList_recordaddress =recordaddress;
                gSourceList_transmitpos   =transmitpos;             
            
			break;

            case Changed_IND:
                //get data
                /***ArrayHeader***/
                mode            =(Indication_array[3] &0xF0) /0x10;
                recordaddress   =Indication_array[3] &0x0F;
                Offset =4;
                
                // decode "mode-byte"
                shift       =mode &0x01;
                direction   =(mode &0x02)/0x02;
                transmitpos =(mode &0x04)/0x04;
                indexsize   =(mode &0x08)/0x08; 

                if (indexsize)
                {   
                    startelement =Indication_array[Offset];
                    Offset++;
                    startelement +=(Indication_array[Offset] *0x100);
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                    elements +=(Indication_array[Offset] *0x100);
                    Offset++;
                }
                else
                {   
                    startelement =Indication_array[Offset];
                    Offset++;

                    elements =Indication_array[Offset];
                    Offset++;
                }           
                
                if(startelement ==0 && shift==0 && transmitpos==0 && recordaddress==0 && elements==65535) //check 'full range update'?
                {
                    putvalue(env_ASG_AudioSD_SL_OnOff, FALSE);
                    putvalue(env_ASG_AudioSD_SL_ListOpState, "'full range update' received");
                }
                else if (datalength>8)
                {
                if(startelement !=0)
                {
                    for (i=0;i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;i++)
                    {
                        if(startelement ==gSourceList_Pos[i])  
                            i =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;              
                    }
                }

                switch (recordaddress)
                {
                    case 0: //recordaddress =0 -> complete record

                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSourceList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSourceList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSourceList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSourceList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSourceList_ListHandlingType !=AUDIO_SOURCELIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //SourceType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_SourceType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //InstanceID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_InstanceID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //MediaType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_MediaType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        
                                        gSourceList_Attributes_BuiltIn_Bit0[current_element]    =(gSourceList_Attributes[current_element] &0x01);
                                        gSourceList_Attributes_MediaError_Bit1[current_element] =(gSourceList_Attributes[current_element] &0x02) /0x02;
                                        gSourceList_Attributes_MediaPlay_Bit2[current_element]  =(gSourceList_Attributes[current_element] &0x04) /0x04; 
                                        gSourceList_Attributes_MediaRead_Bit3[current_element]  =(gSourceList_Attributes[current_element] &0x08) /0x08;
                                        gSourceList_Attributes_MediaLoad_Bit4[current_element]  =(gSourceList_Attributes[current_element] &0x10) /0x10;
                                        gSourceList_Attributes_ImportRun_Bit5[current_element]  =(gSourceList_Attributes[current_element] &0x20) /0x20;
                                        gSourceList_Attributes_MediaSupp_Bit6[current_element]  =(gSourceList_Attributes[current_element] &0x40) /0x40;                                         
                                    }

                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SOURCELIST_NAME_LENGTH;i++) //clear
			                                gSourceList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSourceList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSourceList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSourceList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //SourceType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_SourceType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //InstanceID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_InstanceID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //MediaType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_MediaType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        
                                        gSourceList_Attributes_BuiltIn_Bit0[current_element]    =(gSourceList_Attributes[current_element] &0x01);
                                        gSourceList_Attributes_MediaError_Bit1[current_element] =(gSourceList_Attributes[current_element] &0x02) /0x02;
                                        gSourceList_Attributes_MediaPlay_Bit2[current_element]  =(gSourceList_Attributes[current_element] &0x04) /0x04; 
                                        gSourceList_Attributes_MediaRead_Bit3[current_element]  =(gSourceList_Attributes[current_element] &0x08) /0x08;
                                        gSourceList_Attributes_MediaLoad_Bit4[current_element]  =(gSourceList_Attributes[current_element] &0x10) /0x10;
                                        gSourceList_Attributes_ImportRun_Bit5[current_element]  =(gSourceList_Attributes[current_element] &0x20) /0x20;
                                        gSourceList_Attributes_MediaSupp_Bit6[current_element]  =(gSourceList_Attributes[current_element] &0x40) /0x40;                             
                                    }

                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SOURCELIST_NAME_LENGTH;i++) //clear
			                                gSourceList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSourceList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =0 ends
                    
                    case 1: //recordaddress =1 -> SourceType, InstanceID, MediaType, Attributes
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSourceList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSourceList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSourceList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSourceList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSourceList_ListHandlingType !=AUDIO_SOURCELIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }
                                    
                                    //SourceType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_SourceType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //InstanceID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_InstanceID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //MediaType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_MediaType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        
                                        gSourceList_Attributes_BuiltIn_Bit0[current_element]    =(gSourceList_Attributes[current_element] &0x01);
                                        gSourceList_Attributes_MediaError_Bit1[current_element] =(gSourceList_Attributes[current_element] &0x02) /0x02;
                                        gSourceList_Attributes_MediaPlay_Bit2[current_element]  =(gSourceList_Attributes[current_element] &0x04) /0x04; 
                                        gSourceList_Attributes_MediaRead_Bit3[current_element]  =(gSourceList_Attributes[current_element] &0x08) /0x08;
                                        gSourceList_Attributes_MediaLoad_Bit4[current_element]  =(gSourceList_Attributes[current_element] &0x10) /0x10;
                                        gSourceList_Attributes_ImportRun_Bit5[current_element]  =(gSourceList_Attributes[current_element] &0x20) /0x20;
                                        gSourceList_Attributes_MediaSupp_Bit6[current_element]  =(gSourceList_Attributes[current_element] &0x40) /0x40;                                         
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSourceList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSourceList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }
                                    
                                    //SourceType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_SourceType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //InstanceID
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_InstanceID[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    //MediaType
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_MediaType[current_element] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    //Attributes
                                    if(CacheElements ==TRUE)
                                    {
                                        gSourceList_Attributes[current_element] =Indication_array[Offset];
                                        Offset++;
                                        
                                        gSourceList_Attributes_BuiltIn_Bit0[current_element]    =(gSourceList_Attributes[current_element] &0x01);
                                        gSourceList_Attributes_MediaError_Bit1[current_element] =(gSourceList_Attributes[current_element] &0x02) /0x02;
                                        gSourceList_Attributes_MediaPlay_Bit2[current_element]  =(gSourceList_Attributes[current_element] &0x04) /0x04; 
                                        gSourceList_Attributes_MediaRead_Bit3[current_element]  =(gSourceList_Attributes[current_element] &0x08) /0x08;
                                        gSourceList_Attributes_MediaLoad_Bit4[current_element]  =(gSourceList_Attributes[current_element] &0x10) /0x10;
                                        gSourceList_Attributes_ImportRun_Bit5[current_element]  =(gSourceList_Attributes[current_element] &0x20) /0x20;
                                        gSourceList_Attributes_MediaSupp_Bit6[current_element]  =(gSourceList_Attributes[current_element] &0x40) /0x40;                             
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
                     break; //recordaddress =1 ends
                    
                    case 2: //recordaddress =2 -> Name
                        /***startelement ==0***/                        
                        if(0==startelement)
                        {     
                            /***find "start line" in ASG cache***/
                            if(FORWARD ==direction)
                            {    
                                if (gSourceList_cacheDown)
                                {   
                                    current_element         =5; //it's the Pos of last element in ASG cache
                                    
                                    //reset "sliding window" values
                                    gSourceList_cacheDown         =FALSE;
                                }
                                else
                                    current_element =startelement;
                                    
                                if (shift ==TRUE) //startelement not next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);   
                            }
                            
                            else if(BACKWARD ==direction && shift==TRUE)
                            {
                                if(gSourceList_cacheUp)
                                {   
                                    current_element         =6; //it's the Pos of first element in ASG cache
                                    
                                    //reset "sliding window" values
                                        gSourceList_cacheUp           =FALSE;
                                }
                                else 
                                    current_element =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE -1; // position of last element in array 
                            }                 
                                
                            /***copy elements***/
                            if (current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION) 
                            {
                                for (j=0; j<elements;j++) //copy elements
                                {   
                                    //check, if elements must be cached and in case find position in array
                                    CacheElements =FALSE;
                                    for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                    {  
                                        //if element already cached, find position in ASG-cache
                                        if(indexsize ==FALSE && (transmitpos ==TRUE) && Indication_array[Offset] ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        else if((indexsize ==TRUE && (transmitpos ==TRUE) && (Indication_array[Offset] +(Indication_array[Offset+1]*0x100)) ==gSourceList_Pos[i] && gSourceList_ListEntryReceptionInformation[i] ==TRUE))
                                        {   
                                            current_element =i; 
                                            CacheElements   =TRUE;
                                        }
                                        //if not already cached, then store element only, if Cache is build-up!
                                        else if((gSourceList_ListHandlingType !=AUDIO_SOURCELIST_NOCACHE))
                                            CacheElements   =TRUE;
                                    }
                                                                       
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset]; 
                                        }
                                        Offset++;
                                    }

                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SOURCELIST_NAME_LENGTH;i++) //clear
			                                gSourceList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSourceList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }

                                    if(CacheElements ==TRUE)                                    
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                                       
                                    current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element     
                                }   //copy data of current element finished
                            } //copy of elements finished       
                        } //startelement=0 ends
    
                        /***startelement !=0***/
                        else if (startelement !=0) //startelement !=0
                        {
                            //searching for valid startelement in stored list
					        for(i=0;i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;i++)
					        {
						        if(gSourceList_Pos[i] ==startelement)				//found a valid element
						        {                                                                                  
                                    current_element     =i;                         //found element is valid_startelement
						            StartElementInCache =TRUE;
                                    i                   =AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE;
                                }
					        }
                            if (StartElementInCache)
                            {   
                                if (shift ==TRUE) //first array element is next element
                                    current_element =SourceList_GetNextLineInCache (current_element, direction);                 
                                    
                                for (j=0; j<elements;j++) //copy elements
                                {
                                    if(current_element !=AUDIO_SOURCELIST_NO_NEXT_POSITION)
                                    {
                                        CacheElements =TRUE;
                                        //if element already exist in ASG-cache, search the position 
                                        for (i=0; i<AUDIO_SOURCELIST_ASGCACHE_MAX_SIZE; i++)
                                        {   
                                            if((transmitpos ==TRUE) && gSourceList_ListEntryReceptionInformation[i] ==TRUE)
                                            {   
                                                startelement_check =0;
                                                if(indexsize)
                                                    startelement_check =Indication_array[Offset] +(Indication_array[Offset+1]*0x100); 
                                                else
                                                    startelement_check =Indication_array[Offset];
                                               
                                                if(startelement_check ==gSourceList_Pos[i])
                                                {   
                                                    current_element =i; 
                                                    CacheElements   =TRUE;
                                                }
                                                startelement_check=0;
                                            }  
                                        }
                                    }
                                    else
                                        CacheElements =FALSE;
                                        
                                    if (transmitpos)
                                    {   
                                        if(CacheElements ==TRUE)
                                        {   
                                            if(indexsize)
                                            {    
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                                Offset++;
                                                gSourceList_Pos[current_element] +=Indication_array[Offset] *0x100;
                                            }
                                            else
                                                gSourceList_Pos[current_element] =Indication_array[Offset];
                                        }
                                        Offset++;
                                    }

                                    //Name
                                    if(CacheElements ==TRUE)
                                    {
                                        for(i=0; i<AUDIO_SOURCELIST_NAME_LENGTH;i++) //clear
			                                gSourceList_Name[current_element][i] =0; 
                                    }
                                         
                                    length =Indication_array[Offset];
                                    Offset++;
                                    
                                    for(i=0; i<length;i++) //copy data
                                    {   
                                        if(CacheElements ==TRUE)
                                            gSourceList_Name[current_element][i] =Indication_array[Offset];
                                        Offset++;
                                    }
                                    
                                    if(CacheElements ==TRUE)                                   
                                        gSourceList_ListEntryReceptionInformation [current_element] =TRUE;
                                    
                                    if(CacheElements ==TRUE)    
                                        current_element =SourceList_GetNextLineInCache (current_element, direction); //go on with next element       
                                }   //copy data of current element finished
                            }       //copy of elements finished
                        }           //startelement !=0 ends
