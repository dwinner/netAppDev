    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RLS_PosnLmp_Posn := %X\n", getValue( HMI_RLS_PosnLmp_Posn ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RoadsdCallSw_Stat := %X\n", getValue( HMI_RoadsdCallSw_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ServCallSw_Stat := %X\n", getValue( HMI_ServCallSw_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SOS_CallSw_Stat := %X\n", getValue( HMI_SOS_CallSw_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SuspLvlAdjSw_Psd_AMG := %X\n", getValue( HMI_SuspLvlAdjSw_Psd_AMG ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SVS_Sw_Psd := %X\n", getValue( HMI_SVS_Sw_Psd ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount(buffer), "0.0000 HMI_LDP_LongPress_Msg_Disp_Rq := %X\n", getValue( HMI_LDP_LongPress_Msg_Disp_Rq ) );        filePutString( buffer, elcount(buffer), hFile);
}

on timer _tBC_F_Stat2_AR
{
    putValue( HMI__STMSG_BC_F_Stat2_AR, 0 );
}

on EnvVar HMI__STMSG_BC_F_Stat2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_BC_F_Stat2_AR );
        if( tDelay > 0)    
            setTimer( _tBC_F_Stat2_AR, tDelay );
        else
            putValue( HMI__STMSG_BC_F_Stat2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_BC_F_Stat2_AR
{
    if( getValue( this ) )
        openPanel("BC_F_Stat2_AR");
}

on EnvVar HMI_BeltHdOvrSw_Psd_V2
{
    _mBC_F_Stat2_AR.BeltHdOvrSw_Psd_V2.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_CPD_Disp_MsgRq
{
    _mBC_F_Stat2_AR.CPD_Disp_MsgRq.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_CPD_Disp_TrgrRq
{
    _mBC_F_Stat2_AR.CPD_Disp_TrgrRq.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_CPD_DispIcon_Stat
{
    _mBC_F_Stat2_AR.CPD_DispIcon_Stat.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_CPD_UsrActn_Stat
{
    _mBC_F_Stat2_AR.CPD_UsrActn_Stat.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_BrkLnWear_PreWarn_Actv
{
    _mBC_F_Stat2_AR.BrkLnWear_PreWarn_Actv.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_BMM_Status
{
    _mBC_F_Stat2_AR.BMM_Status.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_CPF_Ft_Stat
{
    _mBC_F_Stat2_AR.CPF_Ft_Stat.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_Sw_Md
{
    _mBC_F_Stat2_AR.DTQ_Sw_Md.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HdRst_R_Rq
{
    _mBC_F_Stat2_AR.HdRst_R_Rq.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HUD_Sw_Psd
{
    _mBC_F_Stat2_AR.HUD_Sw_Psd.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDP_Sw_Md
{
    _mBC_F_Stat2_AR.LDP_Sw_Md.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_NV_Sw_Psd
{
    _mBC_F_Stat2_AR.NV_Sw_Psd.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSw_Psd
{
    _mBC_F_Stat2_AR.ParkSw_Psd.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RainCls_Mon_Stat
{
    _mBC_F_Stat2_AR.RainCls_Mon_Stat.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RainCls_Win_FL_Rq
{
    _mBC_F_Stat2_AR.RainCls_Win_FL_Rq.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RainCls_Win_FR_Rq
{
    _mBC_F_Stat2_AR.RainCls_Win_FR_Rq.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RainCls_Win_RL_Rq
{
    _mBC_F_Stat2_AR.RainCls_Win_RL_Rq.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RainCls_Win_RR_Rq
{
    _mBC_F_Stat2_AR.RainCls_Win_RR_Rq.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RB_R_Sw_Psd_Ft
{
    _mBC_F_Stat2_AR.RB_R_Sw_Psd_Ft.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RLS_AutoPosn
{
    _mBC_F_Stat2_AR.RLS_AutoPosn.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RLS_FogLmp_Ft_Posn
{
    _mBC_F_Stat2_AR.RLS_FogLmp_Ft_Posn.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RLS_FogLmp_R_Posn
{
    _mBC_F_Stat2_AR.RLS_FogLmp_R_Posn.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RLS_LoBm_Posn
{
    _mBC_F_Stat2_AR.RLS_LoBm_Posn.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RLS_PkLmp_Posn_Lt
{
    _mBC_F_Stat2_AR.RLS_PkLmp_Posn_Lt.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RLS_PkLmp_Posn_Rt
{
    _mBC_F_Stat2_AR.RLS_PkLmp_Posn_Rt.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RLS_PosnLmp_Posn
{
    _mBC_F_Stat2_AR.RLS_PosnLmp_Posn.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_SuspLvlAdjSw_Psd_AMG
{
    _mBC_F_Stat2_AR.SuspLvlAdjSw_Psd_AMG.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_SVS_Sw_Psd
{
    _mBC_F_Stat2_AR.SVS_Sw_Psd.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDP_LongPress_Msg_Disp_Rq
{
    _mBC_F_Stat2_AR.LDP_LongPress_Msg_Disp_Rq.phys = getValue(this);
    _BC_F_Stat2_AR_SpontanFlag = 1;
}

BC_R_Stat1_AR_check_output()
{
    if( !getValue( HMI__STMSG_BC_R_Stat1_AR ) )
    {
    //  message   BC_R_Stat1_AR ID: 849 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _BC_R_Stat1_AR_Cnt--;
        if( _BC_R_Stat1_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            BC_R_Stat1_AR_output();
            _BC_R_Stat1_AR_Cnt = _BC_R_Stat1_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _BC_R_Stat1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _BC_R_Stat1_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            BC_R_Stat1_AR_output();
            _BC_R_Stat1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

BC_R_Stat1_AR_init()
{   /* Botschaft BC_R_Stat1_AR ID: 849 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 849 0;
BA_ "NmAsrMessage" BO_ 849 0;
BA_ "GenMsgMinAcceptLength" BO_ 849 8;
BA_ "GenMsgILSupport" BO_ 849 1;
BA_ "DiagState" BO_ 849 0;
BA_ "DiagRequest" BO_ 849 0;
BA_ "DiagResponse" BO_ 849 0;
BA_ "GenMsgStartValue" BO_ 849 "0";
BA_ "GenMsgStartDelayTime" BO_ 849 0;
BA_ "GenMsgDelayTime" BO_ 849 5;
BA_ "GenMsgNrOfRepetitions" BO_ 849 0;
BA_ "GenMsgCycleTime" BO_ 849 200;
BA_ "GenMsgSendType" BO_ 849 5;
    */
    _BC_R_Stat1_AR_Timebase =        c_tDBKomTimer_20ms;
    _BC_R_Stat1_AR_CycleCount =    200 / _BC_R_Stat1_AR_Timebase;
    _BC_R_Stat1_AR_StartDelay =      0 / _BC_R_Stat1_AR_Timebase;
    _BC_R_Stat1_AR_Cnt = _BC_R_Stat1_AR_StartDelay;
    _BC_R_Stat1_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_BC_R_Stat1_AR, _BC_R_Stat1_AR_StartDelay * _BC_R_Stat1_AR_Timebase );

    _mBC_R_Stat1_AR.Bckl_Sw_3L_SAM_R_Tgl.phys = getValue( HMI_Bckl_Sw_3L_SAM_R_Tgl );
    _mBC_R_Stat1_AR.Bckl_Sw_3L_Stat_SAM_R.phys = getValue( HMI_Bckl_Sw_3L_Stat_SAM_R );
    _mBC_R_Stat1_AR.Bckl_Sw_3M_SAM_R_Tgl.phys = getValue( HMI_Bckl_Sw_3M_SAM_R_Tgl );
    _mBC_R_Stat1_AR.Bckl_Sw_3M_Stat_SAM_R.phys = getValue( HMI_Bckl_Sw_3M_Stat_SAM_R );
    _mBC_R_Stat1_AR.Bckl_Sw_3R_SAM_R_Tgl.phys = getValue( HMI_Bckl_Sw_3R_SAM_R_Tgl );
    _mBC_R_Stat1_AR.Bckl_Sw_3R_Stat_SAM_R.phys = getValue( HMI_Bckl_Sw_3R_Stat_SAM_R );
    _mBC_R_Stat1_AR.Bckl_Sw_RL_SAM_R_Tgl.phys = getValue( HMI_Bckl_Sw_RL_SAM_R_Tgl );
    _mBC_R_Stat1_AR.Bckl_Sw_RL_Stat_SAM_R.phys = getValue( HMI_Bckl_Sw_RL_Stat_SAM_R );
    _mBC_R_Stat1_AR.Bckl_Sw_RM_SAM_R_Tgl.phys = getValue( HMI_Bckl_Sw_RM_SAM_R_Tgl );
    _mBC_R_Stat1_AR.Bckl_Sw_RM_Stat_SAM_R.phys = getValue( HMI_Bckl_Sw_RM_Stat_SAM_R );
    _mBC_R_Stat1_AR.Bckl_Sw_RR_SAM_R_Tgl.phys = getValue( HMI_Bckl_Sw_RR_SAM_R_Tgl );
    _mBC_R_Stat1_AR.Bckl_Sw_RR_Stat_SAM_R.phys = getValue( HMI_Bckl_Sw_RR_Stat_SAM_R );
    _mBC_R_Stat1_AR.BgC_Sw_Psd.phys = getValue( HMI_BgC_Sw_Psd );
    _mBC_R_Stat1_AR.BrkLnWear_R.phys = getValue( HMI_BrkLnWear_R );
    _mBC_R_Stat1_AR.CPF_R_Stat.phys = getValue( HMI_CPF_R_Stat );
    _mBC_R_Stat1_AR.DL_Lch_Psd.phys = getValue( HMI_DL_Lch_Psd );
    _mBC_R_Stat1_AR.DL_LchTrgr_Actv.phys = getValue( HMI_DL_LchTrgr_Actv );
    _mBC_R_Stat1_AR.DL_RemActn_3rdRow_Stat.phys = getValue( HMI_DL_RemActn_3rdRow_Stat );
    _mBC_R_Stat1_AR.DL_Lk_Ovruse_Prot_Actv.phys = getValue( HMI_DL_Lk_Ovruse_Prot_Actv );
    _mBC_R_Stat1_AR.DL_RLtch_Stat.phys = getValue( HMI_DL_RLtch_Stat );
    _mBC_R_Stat1_AR.DL_Sw_Psd.phys = getValue( HMI_DL_Sw_Psd );
    _mBC_R_Stat1_AR.DL_SwCls_Psd.phys = getValue( HMI_DL_SwCls_Psd );
    _mBC_R_Stat1_AR.DL_SwLkCls_Psd.phys = getValue( HMI_DL_SwLkCls_Psd );
    _mBC_R_Stat1_AR.DL1_Sw_Psd.phys = getValue( HMI_DL1_Sw_Psd );
    _mBC_R_Stat1_AR.DL2_Sw_Psd.phys = getValue( HMI_DL2_Sw_Psd );    
    _mBC_R_Stat1_AR.EBL_Stat.phys = getValue( HMI_EBL_Stat );
    _mBC_R_Stat1_AR.EmgLgt_Term15_In_Stat.phys = getValue( HMI_EmgLgt_Term15_In_Stat );
    _mBC_R_Stat1_AR.Parity_Bckl_Sw_3L_SAM_R.phys = getValue( HMI_Parity_Bckl_Sw_3L_SAM_R );
    _mBC_R_Stat1_AR.Parity_Bckl_Sw_3R_SAM_R.phys = getValue( HMI_Parity_Bckl_Sw_3R_SAM_R );
    _mBC_R_Stat1_AR.Parity_Bckl_Sw_RL_SAM_R.phys = getValue( HMI_Parity_Bckl_Sw_RL_SAM_R );
    _mBC_R_Stat1_AR.Parity_Bckl_Sw_RM_SAM_R.phys = getValue( HMI_Parity_Bckl_Sw_RM_SAM_R );
    _mBC_R_Stat1_AR.Parity_Bckl_Sw_RR_SAM_R.phys = getValue( HMI_Parity_Bckl_Sw_RR_SAM_R );
	  _mBC_R_Stat1_AR.PwrSup_BSM_ExitWarn.phys = getValue( HMI_PwrSup_BSM_ExitWarn );
    _mBC_R_Stat1_AR.RB_R_Stat_V2.phys = getValue( HMI_RB_R_Stat_V2 );
    _mBC_R_Stat1_AR.RemTank_Unlk_Stat.phys = getValue( HMI_RemTank_Unlk_Stat );
    _mBC_R_Stat1_AR.SeatBkRst_FL_Stat.phys = getValue( HMI_SeatBkRst_FL_Stat );
    _mBC_R_Stat1_AR.SeatBkRst_FR_Stat.phys = getValue( HMI_SeatBkRst_FR_Stat );
    _mBC_R_Stat1_AR.SeatBkRst_RL_Stat.phys = getValue( HMI_SeatBkRst_RL_Stat );
    _mBC_R_Stat1_AR.SeatBkRst_RM_Stat.phys = getValue( HMI_SeatBkRst_RM_Stat );
    _mBC_R_Stat1_AR.SeatBkRst_RR_Stat.phys = getValue( HMI_SeatBkRst_RR_Stat );
    _mBC_R_Stat1_AR.Term54_Actv.phys = getValue( HMI_Term54_Actv );
    _mBC_R_Stat1_AR.Wpr_R_OutsdPkPosn.phys = getValue( HMI_Wpr_R_OutsdPkPosn );
    _mBC_R_Stat1_AR.Parity_Bckl_Sw_3M_SAM_R.phys = getValue( HMI_Parity_Bckl_Sw_3M_SAM_R );
}

BC_R_Stat1_AR_output(void)
{
    output( _mBC_R_Stat1_AR );
}

BC_R_Stat1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: BC_R_Stat1_AR\n", 26, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_BC_R_Stat1_AR := %X\n", getValue( HMI__STMSG_BC_R_Stat1_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_BC_R_Stat1_AR := %X\n", getValue( HMI__STMSGT_BC_R_Stat1_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Bckl_Sw_3L_SAM_R_Tgl := %X\n", getValue( HMI_Bckl_Sw_3L_SAM_R_Tgl ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Bckl_Sw_3M_SAM_R_Tgl := %X\n", getValue( HMI_Bckl_Sw_3M_SAM_R_Tgl ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Bckl_Sw_3M_Stat_SAM_R := %X\n", getValue( HMI_Bckl_Sw_3M_Stat_SAM_R ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Bckl_Sw_3L_Stat_SAM_R := %X\n", getValue( HMI_Bckl_Sw_3L_Stat_SAM_R ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Bckl_Sw_3R_SAM_R_Tgl := %X\n", getValue( HMI_Bckl_Sw_3R_SAM_R_Tgl ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Bckl_Sw_3R_Stat_SAM_R := %X\n", getValue( HMI_Bckl_Sw_3R_Stat_SAM_R ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Bckl_Sw_RL_SAM_R_Tgl := %X\n", getValue( HMI_Bckl_Sw_RL_SAM_R_Tgl ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Bckl_Sw_RL_Stat_SAM_R := %X\n", getValue( HMI_Bckl_Sw_RL_Stat_SAM_R ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Bckl_Sw_RM_SAM_R_Tgl := %X\n", getValue( HMI_Bckl_Sw_RM_SAM_R_Tgl ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Bckl_Sw_RM_Stat_SAM_R := %X\n", getValue( HMI_Bckl_Sw_RM_Stat_SAM_R ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Bckl_Sw_RR_SAM_R_Tgl := %X\n", getValue( HMI_Bckl_Sw_RR_SAM_R_Tgl ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Bckl_Sw_RR_Stat_SAM_R := %X\n", getValue( HMI_Bckl_Sw_RR_Stat_SAM_R ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BgC_Sw_Psd := %X\n", getValue( HMI_BgC_Sw_Psd ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkLnWear_R := %X\n", getValue( HMI_BrkLnWear_R ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CPF_R_Stat := %X\n", getValue( HMI_CPF_R_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DL_Lch_Psd := %X\n", getValue( HMI_DL_Lch_Psd ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DL_LchTrgr_Actv := %X\n", getValue( HMI_DL_LchTrgr_Actv ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DL_RemActn_3rdRow_Stat := %X\n", getValue( HMI_DL_RemActn_3rdRow_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DL_Lk_Ovruse_Prot_Actv  := %X\n", getValue( HMI_DL_Lk_Ovruse_Prot_Actv  ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DL_RLtch_Stat := %X\n", getValue( HMI_DL_RLtch_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DL_Sw_Psd := %X\n", getValue( HMI_DL_Sw_Psd ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DL_SwCls_Psd := %X\n", getValue( HMI_DL_SwCls_Psd ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DL_SwLkCls_Psd := %X\n", getValue( HMI_DL_SwLkCls_Psd ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DL1_Sw_Psd := %X\n", getValue( HMI_DL1_Sw_Psd ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DL2_Sw_Psd := %X\n", getValue( HMI_DL2_Sw_Psd ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EBL_Stat := %X\n", getValue( HMI_EBL_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EmgLgt_Term15_In_Stat := %X\n", getValue( HMI_EmgLgt_Term15_In_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Parity_Bckl_Sw_3L_SAM_R := %X\n", getValue( HMI_Parity_Bckl_Sw_3L_SAM_R ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Parity_Bckl_Sw_3R_SAM_R := %X\n", getValue( HMI_Parity_Bckl_Sw_3R_SAM_R ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Parity_Bckl_Sw_RL_SAM_R := %X\n", getValue( HMI_Parity_Bckl_Sw_RL_SAM_R ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Parity_Bckl_Sw_RM_SAM_R := %X\n", getValue( HMI_Parity_Bckl_Sw_RM_SAM_R ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Parity_Bckl_Sw_RR_SAM_R := %X\n", getValue( HMI_Parity_Bckl_Sw_RR_SAM_R ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PwrSup_BSM_ExitWarn := %X\n", getValue( HMI_PwrSup_BSM_ExitWarn ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RB_R_Stat_V2 := %X\n", getValue( HMI_RB_R_Stat_V2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RemTank_Unlk_Stat := %X\n", getValue( HMI_RemTank_Unlk_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_FL_Stat := %X\n", getValue( HMI_SeatBkRst_FL_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_FR_Stat := %X\n", getValue( HMI_SeatBkRst_FR_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_RL_Stat := %X\n", getValue( HMI_SeatBkRst_RL_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_RM_Stat := %X\n", getValue( HMI_SeatBkRst_RM_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_RR_Stat := %X\n", getValue( HMI_SeatBkRst_RR_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Term54_Actv := %X\n", getValue( HMI_Term54_Actv ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Wpr_R_OutsdPkPosn := %X\n", getValue( HMI_Wpr_R_OutsdPkPosn ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Parity_Bckl_Sw_3M_SAM_R := %X\n", getValue( HMI_Parity_Bckl_Sw_3M_SAM_R ) );    filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tBC_R_Stat1_AR
{
    putValue( HMI__STMSG_BC_R_Stat1_AR, 0 );
}

on EnvVar HMI__STMSG_BC_R_Stat1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_BC_R_Stat1_AR );
        if( tDelay > 0)    
            setTimer( _tBC_R_Stat1_AR, tDelay );
        else
            putValue( HMI__STMSG_BC_R_Stat1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_BC_R_Stat1_AR
{
    if( getValue( this ) )
        openPanel("BC_R_Stat1_AR");
}

on EnvVar HMI_Bckl_Sw_3L_SAM_R_Tgl
{
    _mBC_R_Stat1_AR.Bckl_Sw_3L_SAM_R_Tgl.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Bckl_Sw_3M_SAM_R_Tgl
{
    _mBC_R_Stat1_AR.Bckl_Sw_3M_SAM_R_Tgl.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Bckl_Sw_3M_Stat_SAM_R
{
    _mBC_R_Stat1_AR.Bckl_Sw_3M_Stat_SAM_R.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Bckl_Sw_3L_Stat_SAM_R
{
    _mBC_R_Stat1_AR.Bckl_Sw_3L_Stat_SAM_R.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Bckl_Sw_3R_SAM_R_Tgl
{
    _mBC_R_Stat1_AR.Bckl_Sw_3R_SAM_R_Tgl.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Bckl_Sw_3R_Stat_SAM_R
{
    _mBC_R_Stat1_AR.Bckl_Sw_3R_Stat_SAM_R.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Bckl_Sw_RL_SAM_R_Tgl
{
    _mBC_R_Stat1_AR.Bckl_Sw_RL_SAM_R_Tgl.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Bckl_Sw_RL_Stat_SAM_R
{
    _mBC_R_Stat1_AR.Bckl_Sw_RL_Stat_SAM_R.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Bckl_Sw_RM_SAM_R_Tgl
{
    _mBC_R_Stat1_AR.Bckl_Sw_RM_SAM_R_Tgl.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Bckl_Sw_RM_Stat_SAM_R
{
    _mBC_R_Stat1_AR.Bckl_Sw_RM_Stat_SAM_R.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Bckl_Sw_RR_SAM_R_Tgl
{
    _mBC_R_Stat1_AR.Bckl_Sw_RR_SAM_R_Tgl.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Bckl_Sw_RR_Stat_SAM_R
{
    _mBC_R_Stat1_AR.Bckl_Sw_RR_Stat_SAM_R.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_BgC_Sw_Psd
{
    _mBC_R_Stat1_AR.BgC_Sw_Psd.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_BrkLnWear_R
{
    _mBC_R_Stat1_AR.BrkLnWear_R.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_CPF_R_Stat
{
    _mBC_R_Stat1_AR.CPF_R_Stat.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DL_Lch_Psd
{
    _mBC_R_Stat1_AR.DL_Lch_Psd.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DL_LchTrgr_Actv
{
    _mBC_R_Stat1_AR.DL_LchTrgr_Actv.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DL_Lk_Ovruse_Prot_Actv
{
    _mBC_R_Stat1_AR.DL_Lk_Ovruse_Prot_Actv.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DL_RemActn_3rdRow_Stat
{
    _mBC_R_Stat1_AR.DL_RemActn_3rdRow_Stat.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DL_RLtch_Stat
{
    _mBC_R_Stat1_AR.DL_RLtch_Stat.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DL_Sw_Psd
{
    _mBC_R_Stat1_AR.DL_Sw_Psd.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DL_SwCls_Psd
{
    _mBC_R_Stat1_AR.DL_SwCls_Psd.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DL_SwLkCls_Psd
{
    _mBC_R_Stat1_AR.DL_SwLkCls_Psd.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DL1_Sw_Psd
{
    _mBC_R_Stat1_AR.DL1_Sw_Psd.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DL2_Sw_Psd
{
    _mBC_R_Stat1_AR.DL2_Sw_Psd.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_EBL_Stat
{
    _mBC_R_Stat1_AR.EBL_Stat.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on envVar HMI_EmgLgt_Term15_In_Stat
{
    _mBC_R_Stat1_AR.EmgLgt_Term15_In_Stat.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Parity_Bckl_Sw_3L_SAM_R
{
    _mBC_R_Stat1_AR.Parity_Bckl_Sw_3L_SAM_R.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Parity_Bckl_Sw_3R_SAM_R
{
    _mBC_R_Stat1_AR.Parity_Bckl_Sw_3R_SAM_R.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Parity_Bckl_Sw_RL_SAM_R
{
    _mBC_R_Stat1_AR.Parity_Bckl_Sw_RL_SAM_R.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Parity_Bckl_Sw_RM_SAM_R
{
    _mBC_R_Stat1_AR.Parity_Bckl_Sw_RM_SAM_R.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Parity_Bckl_Sw_RR_SAM_R
{
    _mBC_R_Stat1_AR.Parity_Bckl_Sw_RR_SAM_R.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PwrSup_BSM_ExitWarn
{
    _mBC_R_Stat1_AR.PwrSup_BSM_ExitWarn.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_RB_R_Stat_V2
{
    _mBC_R_Stat1_AR.RB_R_Stat_V2.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on envVar HMI_RemTank_Unlk_Stat
{
    _mBC_R_Stat1_AR.RemTank_Unlk_Stat.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_FL_Stat
{
    _mBC_R_Stat1_AR.SeatBkRst_FL_Stat.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_FR_Stat
{
    _mBC_R_Stat1_AR.SeatBkRst_FR_Stat.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_RL_Stat
{
    _mBC_R_Stat1_AR.SeatBkRst_RL_Stat.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_RM_Stat
{
    _mBC_R_Stat1_AR.SeatBkRst_RM_Stat.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_RR_Stat
{
    _mBC_R_Stat1_AR.SeatBkRst_RR_Stat.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Term54_Actv
{
    _mBC_R_Stat1_AR.Term54_Actv.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Wpr_R_OutsdPkPosn
{
    _mBC_R_Stat1_AR.Wpr_R_OutsdPkPosn.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Parity_Bckl_Sw_3M_SAM_R
{
    _mBC_R_Stat1_AR.Parity_Bckl_Sw_3M_SAM_R.phys = getValue(this);
    _BC_R_Stat1_AR_SpontanFlag = 1;
}

BC_R_Stat2_AR_check_output()
{
    if( !getValue( HMI__STMSG_BC_R_Stat2_AR ) )
    {
    //  message   BC_R_Stat2_AR ID: 869 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _BC_R_Stat2_AR_Cnt--;
        if( _BC_R_Stat2_AR_Cnt < 1 )
        {
            BC_R_Stat2_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _BC_R_Stat2_AR_Cnt = _BC_R_Stat2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _BC_R_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _BC_R_Stat1_AR_SpontanFlag)
        {
            BC_R_Stat2_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _BC_R_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

BC_R_Stat2_AR_init()
{   /* Botschaft BC_R_Stat2_AR ID: 869 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 869 0;
BA_ "NmAsrMessage" BO_ 869 0;
BA_ "GenMsgMinAcceptLength" BO_ 869 8;
BA_ "GenMsgILSupport" BO_ 869 1;
BA_ "DiagState" BO_ 869 0;
BA_ "DiagRequest" BO_ 869 0;
BA_ "DiagResponse" BO_ 869 0;
BA_ "GenMsgStartValue" BO_ 869 "0";
BA_ "GenMsgDelayTime" BO_ 869 5;
BA_ "GenMsgNrOfRepetitions" BO_ 869 0;
BA_ "GenMsgCycleTime" BO_ 869 200;
BA_ "GenMsgSendType" BO_ 869 5;
    */
    _BC_R_Stat2_AR_Timebase =              c_tDBKomTimer_20ms;
    _BC_R_Stat2_AR_CycleCount =          200 / _BC_R_Stat2_AR_Timebase;
    _BC_R_Stat2_AR_StartDelay =            0 / _BC_R_Stat2_AR_Timebase;
    _BC_R_Stat2_AR_Cnt = _BC_R_Stat2_AR_StartDelay;
    _BC_R_Stat2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_BC_R_Stat2_AR, _BC_R_Stat2_AR_StartDelay * _BC_R_Stat2_AR_Timebase );

    _mBC_R_Stat2_AR.SeatBkRst_3L_Stat.phys = getValue( HMI_SeatBkRst_3L_Stat );
    _mBC_R_Stat2_AR.SeatBkRst_3R_Stat.phys = getValue( HMI_SeatBkRst_3R_Stat );
    _mBC_R_Stat2_AR.SeatBkRstSleepPosn_RL.phys = getValue( HMI_SeatBkRstSleepPosn_RL );
    _mBC_R_Stat2_AR.SeatBkRstSleepPosn_RR.phys = getValue( HMI_SeatBkRstSleepPosn_RR );
    _mBC_R_Stat2_AR.SeatCsn_RL_Stat.phys = getValue( HMI_SeatCsn_RL_Stat );
    _mBC_R_Stat2_AR.SeatCsn_RR_Stat.phys = getValue( HMI_SeatCsn_RR_Stat );
	_mBC_R_Stat2_AR.TCH_Stat.phys = getValue( HMI_TCH_Stat );
	_mBC_R_Stat2_AR.TSSR_R_RB_Sw_Psd_BC_R.phys = getValue( HMI_TSSR_R_RB_Sw_Psd_BC_R );
    _mBC_R_Stat2_AR.TCH2_Stat.phys = getValue( HMI_TCH2_Stat );
    _mBC_R_Stat2_AR.SB_RLtch_Stat.phys = getValue( HMI_SB_RLtch_Stat );
}

BC_R_Stat2_AR_output(void)
{
    output( _mBC_R_Stat2_AR );
}

BC_R_Stat2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: BC_R_Stat2_AR\n", 26, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_BC_R_Stat2_AR := %X\n", getValue( HMI__STMSG_BC_R_Stat2_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_BC_R_Stat2_AR := %X\n", getValue( HMI__STMSGT_BC_R_Stat2_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_3L_Stat := %X\n", getValue( HMI_SeatBkRst_3L_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_3R_Stat := %X\n", getValue( HMI_SeatBkRst_3R_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRstSleepPosn_RL := %X\n", getValue( HMI_SeatBkRstSleepPosn_RL ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRstSleepPosn_RR := %X\n", getValue( HMI_SeatBkRstSleepPosn_RR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatCsn_RL_Stat := %X\n", getValue( HMI_SeatCsn_RL_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatCsn_RR_Stat := %X\n", getValue( HMI_SeatCsn_RR_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCH_Stat := %X\n", getValue( HMI_TCH_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSSR_R_RB_Sw_Psd_BC_R := %X\n", getValue( HMI_TSSR_R_RB_Sw_Psd_BC_R ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount(buffer), "0.0000 HMI_TCH2_Stat := %X\n", getValue( HMI_TCH2_Stat ) );        filePutString( buffer, elcount(buffer), hFile);
	snprintf( buffer, elcount(buffer), "0.0000 HMI_SB_RLtch_Stat := %X\n", getValue( HMI_SB_RLtch_Stat ) );        filePutString( buffer, elcount(buffer), hFile);
}

on timer _tBC_R_Stat2_AR
{
    putValue( HMI__STMSG_BC_R_Stat2_AR, 0 );
}

on EnvVar HMI__STMSG_BC_R_Stat2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_BC_R_Stat2_AR );
        if( tDelay > 0)    
            setTimer( _tBC_R_Stat2_AR, tDelay );
        else
            putValue( HMI__STMSG_BC_R_Stat2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_BC_R_Stat2_AR
{
    if( getValue( this ) )
        openPanel("BC_R_Stat2_AR");
}

on EnvVar HMI_SeatBkRst_3L_Stat
{
    _mBC_R_Stat2_AR.SeatBkRst_3L_Stat.phys = getValue(this);
    _BC_R_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_3R_Stat
{
    _mBC_R_Stat2_AR.SeatBkRst_3R_Stat.phys = getValue(this);
    _BC_R_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRstSleepPosn_RR
{
    _mBC_R_Stat2_AR.SeatBkRstSleepPosn_RR.phys = getValue(this);
    _BC_R_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRstSleepPosn_RL
{
    _mBC_R_Stat2_AR.SeatBkRstSleepPosn_RL.phys = getValue(this);
    _BC_R_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatCsn_RL_Stat
{
    _mBC_R_Stat2_AR.SeatCsn_RL_Stat.phys = getValue(this);
    _BC_R_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatCsn_RR_Stat
{
    _mBC_R_Stat2_AR.SeatCsn_RR_Stat.phys = getValue(this);
    _BC_R_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCH_Stat
{
    _mBC_R_Stat2_AR.TCH_Stat.phys = getValue(this);
    _BC_R_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSSR_R_RB_Sw_Psd_BC_R
{
    _mBC_R_Stat2_AR.TSSR_R_RB_Sw_Psd_BC_R.phys = getValue(this);
    _BC_R_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCH2_Stat
{
    _mBC_R_Stat2_AR.TCH2_Stat.phys = getValue(this);
    _BC_R_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_SB_RLtch_Stat
{
    _mBC_R_Stat2_AR.SB_RLtch_Stat.phys = getValue(this);
    _BC_R_Stat2_AR_SpontanFlag = 1;
}

BODY_HMI_R0_AR_check_output()
{
    if( !getValue( HMI__STMSG_BODY_HMI_R0_AR ) )
    {
    //  message   BODY_HMI_R0_AR ID: 1111 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _BODY_HMI_R0_AR_Cnt--;
        if( _BODY_HMI_R0_AR_Cnt < 1 )
        {
            BODY_HMI_R0_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _BODY_HMI_R0_AR_Cnt = _BODY_HMI_R0_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
             _BODY_HMI_R0_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _BODY_HMI_R0_AR_SpontanFlag)
        {
            BODY_HMI_R0_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
             _BODY_HMI_R0_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

BODY_HMI_R0_AR_init()
{   /* Botschaft BODY_HMI_R0_AR ID: 1111 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1111 0;
BA_ "NmAsrMessage" BO_ 1111 0;
BA_ "GenMsgMinAcceptLength" BO_ 1111 8;
BA_ "GenMsgILSupport" BO_ 1111 1;
BA_ "DiagState" BO_ 1111 0;
BA_ "DiagRequest" BO_ 1111 0;
BA_ "DiagResponse" BO_ 1111 0;
BA_ "GenMsgStartValue" BO_ 1111 "0";
BA_ "GenMsgStartDelayTime" BO_ 1111 40;
BA_ "GenMsgDelayTime" BO_ 1111 5;
BA_ "GenMsgNrOfRepetitions" BO_ 1111 0;
BA_ "GenMsgCycleTime" BO_ 1111 1000;
BA_ "GenMsgSendType" BO_ 1111 5;
    */
    _BODY_HMI_R0_AR_Timebase =     c_tDBKomTimer_20ms;
    _BODY_HMI_R0_AR_CycleCount = 1000 / _BODY_HMI_R0_AR_Timebase;
    _BODY_HMI_R0_AR_StartDelay =   40 / _BODY_HMI_R0_AR_Timebase;
    _BODY_HMI_R0_AR_Cnt = _BODY_HMI_R0_AR_StartDelay;
    _BODY_HMI_R0_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_BODY_HMI_R0_AR, _BODY_HMI_R0_AR_StartDelay * _BODY_HMI_R0_AR_Timebase );

    _mBODY_HMI_R0_AR.CoronaLgt_Stat.phys = getValue( HMI_CoronaLgt_Stat );
    _mBODY_HMI_R0_AR.CoronaLgt_Stat_UB.phys = getValue( HMI_CoronaLgt_Stat_UB );
    _mBODY_HMI_R0_AR.IL_AgDur_Stat.phys = getValue( HMI_IL_AgDur_Stat );
    _mBODY_HMI_R0_AR.IL_AgDur_Stat_UB.phys = getValue( HMI_IL_AgDur_Stat_UB );
    _mBODY_HMI_R0_AR.PN48_Bat_SOC.phys = getValue( HMI_PN48_Bat_SOC );
    _mBODY_HMI_R0_AR.PN48_Bat_SOC_UB.phys = getValue( HMI_PN48_Bat_SOC_UB );
    _mBODY_HMI_R0_AR.TranspChg_Roof_Stat.phys = getValue( HMI_TranspChg_Roof_Stat );
	_mBODY_HMI_R0_AR.Transp_Roof_R_Stat.phys = getValue( HMI_Transp_Roof_R_Stat );
	_mBODY_HMI_R0_AR.Transp_Roof_Ft_Stat.phys = getValue( HMI_Transp_Roof_Ft_Stat );
	_mBODY_HMI_R0_AR.Transp_Roof_Ft_Stat_UB.phys = getValue( HMI_Transp_Roof_Ft_Stat_UB );
	_mBODY_HMI_R0_AR.Transp_Roof_R_Stat_UB.phys = getValue( HMI_Transp_Roof_R_Stat_UB );
    _mBODY_HMI_R0_AR.TranspChg_Roof_Stat_UB.phys = getValue( HMI_TranspChg_Roof_Stat_UB );
}

BODY_HMI_R0_AR_output(void)
{
    output( _mBODY_HMI_R0_AR );
}

BODY_HMI_R0_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: BODY_HMI_R0_AR\n", 26, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_BODY_HMI_R0_AR := %X\n", getValue( HMI__STMSG_BODY_HMI_R0_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_BODY_HMI_R0_AR := %X\n", getValue( HMI__STMSGT_BODY_HMI_R0_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CoronaLgt_Stat := %X\n", getValue( HMI_CoronaLgt_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CoronaLgt_Stat_UB := %X\n", getValue( HMI_CoronaLgt_Stat_UB ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IL_AgDur_Stat := %X\n", getValue( HMI_IL_AgDur_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IL_AgDur_Stat_UB := %X\n", getValue( HMI_IL_AgDur_Stat_UB ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN48_Bat_SOC := %X\n", getValue( HMI_PN48_Bat_SOC ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN48_Bat_SOC_UB := %X\n", getValue( HMI_PN48_Bat_SOC_UB ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TranspChg_Roof_Stat := %X\n", getValue( HMI_TranspChg_Roof_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Transp_Roof_R_Stat := %X\n", getValue( HMI_Transp_Roof_R_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Transp_Roof_Ft_Stat := %X\n", getValue( HMI_Transp_Roof_Ft_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Transp_Roof_R_Stat_UB := %X\n", getValue( HMI_Transp_Roof_R_Stat_UB ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Transp_Roof_Ft_Stat_UB := %X\n", getValue( HMI_Transp_Roof_Ft_Stat_UB ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TranspChg_Roof_Stat_UB := %X\n", getValue( HMI_TranspChg_Roof_Stat_UB ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_ReProg_BatCpcty := %X\n", getValue( HMI_PN14_ReProg_BatCpcty ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_ReProg_BatCpcty_UB := %X\n", getValue( HMI_PN14_ReProg_BatCpcty_UB ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tBODY_HMI_R0_AR
{
    putValue( HMI__STMSG_BODY_HMI_R0_AR, 0 );
}

on EnvVar HMI__STMSG_BODY_HMI_R0_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_BODY_HMI_R0_AR );
        if( tDelay > 0)    
            setTimer( _tBODY_HMI_R0_AR, tDelay );
        else
            putValue( HMI__STMSG_BODY_HMI_R0_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_BODY_HMI_R0_AR
{
    if( getValue( this ) )
        openPanel("BODY_HMI_R0_AR");
}

on EnvVar HMI_CoronaLgt_Stat
{
    _mBODY_HMI_R0_AR.CoronaLgt_Stat.phys = getValue(this);
    _BODY_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_CoronaLgt_Stat_UB
{
    _mBODY_HMI_R0_AR.CoronaLgt_Stat_UB.phys = getValue(this);
    _BODY_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_IL_AgDur_Stat
{
    _mBODY_HMI_R0_AR.IL_AgDur_Stat.phys = getValue(this);
    _BODY_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_IL_AgDur_Stat_UB
{
    _mBODY_HMI_R0_AR.IL_AgDur_Stat_UB.phys = getValue(this);
    _BODY_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN48_Bat_SOC
{
    _mBODY_HMI_R0_AR.PN48_Bat_SOC.phys = getValue(this);
    _BODY_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN48_Bat_SOC_UB
{
    _mBODY_HMI_R0_AR.PN48_Bat_SOC_UB.phys = getValue(this);
    _BODY_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_TranspChg_Roof_Stat
{
    _mBODY_HMI_R0_AR.TranspChg_Roof_Stat.phys = getValue(this);
    _BODY_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_Transp_Roof_R_Stat
{
    _mBODY_HMI_R0_AR.Transp_Roof_R_Stat.phys = getValue(this);
    _BODY_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_Transp_Roof_Ft_Stat
{
    _mBODY_HMI_R0_AR.Transp_Roof_Ft_Stat.phys = getValue(this);
    _BODY_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_Transp_Roof_Ft_Stat_UB
{
    _mBODY_HMI_R0_AR.Transp_Roof_Ft_Stat_UB.phys = getValue(this);
    _BODY_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_Transp_Roof_R_Stat_UB
{
    _mBODY_HMI_R0_AR.Transp_Roof_R_Stat_UB.phys = getValue(this);
    _BODY_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_TranspChg_Roof_Stat_UB
{
    _mBODY_HMI_R0_AR.TranspChg_Roof_Stat_UB.phys = getValue(this);
    _BODY_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_ReProg_BatCpcty
{
    _mBODY_HMI_R0_AR.PN14_ReProg_BatCpcty.phys = getValue(this);
    _BODY_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_ReProg_BatCpcty_UB
{
    _mBODY_HMI_R0_AR.PN14_ReProg_BatCpcty_UB.phys = getValue(this);
    _BODY_HMI_R0_AR_SpontanFlag = 1;
}

BODY_HMI_R1_AR_check_output()
{
    if( !getValue( HMI__STMSG_BODY_HMI_R1_AR ) )
    {
    //  message   BODY_HMI_R1_AR ID: 543 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _BODY_HMI_R1_AR_Cnt--;
        if( _BODY_HMI_R1_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            BODY_HMI_R1_AR_output();
            _BODY_HMI_R1_AR_Cnt = _BODY_HMI_R1_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _BODY_HMI_R1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _BODY_HMI_R1_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            BODY_HMI_R1_AR_output();
            _BODY_HMI_R1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

BODY_HMI_R1_AR_init()
{   /* Botschaft BODY_HMI_R1_AR ID: 543 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 543 0;
BA_ "NmAsrMessage" BO_ 543 0;
BA_ "GenMsgMinAcceptLength" BO_ 543 8;
BA_ "GenMsgILSupport" BO_ 543 1;
BA_ "DiagState" BO_ 543 0;
BA_ "DiagRequest" BO_ 543 0;
BA_ "DiagResponse" BO_ 543 0;
BA_ "GenMsgStartValue" BO_ 543 "0";
BA_ "GenMsgStartDelayTime" BO_ 543 30;
BA_ "GenMsgDelayTime" BO_ 543 20;
BA_ "GenMsgNrOfRepetitions" BO_ 543 0;
BA_ "GenMsgCycleTime" BO_ 543 100;
BA_ "GenMsgSendType" BO_ 543 5;
    */
    _BODY_HMI_R1_AR_Timebase =        c_tDBKomTimer_20ms;
    _BODY_HMI_R1_AR_CycleCount =    100 / _BODY_HMI_R1_AR_Timebase;
    _BODY_HMI_R1_AR_StartDelay =     30 / _BODY_HMI_R1_AR_Timebase;
    _BODY_HMI_R1_AR_Cnt = _BODY_HMI_R1_AR_StartDelay;
    _BODY_HMI_R1_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_BODY_HMI_R1_AR, _BODY_HMI_R1_AR_StartDelay * _BODY_HMI_R1_AR_Timebase );

    _mBODY_HMI_R1_AR.BeltHdOvr_Lt_Stat.phys = getValue( HMI_BeltHdOvr_Lt_Stat );
    _mBODY_HMI_R1_AR.BeltHdOvr_Lt_Stat_UB.phys = getValue( HMI_BeltHdOvr_Lt_Stat_UB );
    _mBODY_HMI_R1_AR.BeltHdOvr_Rt_Stat.phys = getValue( HMI_BeltHdOvr_Rt_Stat );
    _mBODY_HMI_R1_AR.BeltHdOvr_Rt_Stat_UB.phys = getValue( HMI_BeltHdOvr_Rt_Stat_UB );
    _mBODY_HMI_R1_AR.CT_Stat.phys = getValue( HMI_CT_Stat );
    _mBODY_HMI_R1_AR.CT_Stat_UB.phys = getValue( HMI_CT_Stat_UB );
    _mBODY_HMI_R1_AR.DL_Lim_Stat.phys = getValue( HMI_DL_Lim_Stat );
    _mBODY_HMI_R1_AR.DL_Lim_Stat_UB.phys = getValue( HMI_DL_Lim_Stat_UB );
    _mBODY_HMI_R1_AR.PN14_Bat_Type.phys = getValue( HMI_PN14_Bat_Type );
    _mBODY_HMI_R1_AR.PN14_Bat_Type_UB.phys = getValue( HMI_PN14_Bat_Type_UB );
    _mBODY_HMI_R1_AR.PN14_ProdMd_Stat.phys = getValue( HMI_PN14_ProdMd_Stat );
    _mBODY_HMI_R1_AR.PN14_ProdMd_Stat_UB.phys = getValue( HMI_PN14_ProdMd_Stat_UB );
    _mBODY_HMI_R1_AR.PN14_TDP_Stat_UB.phys = getValue( HMI_PN14_TDP_Stat_UB );
    _mBODY_HMI_R1_AR.PN14_TDP_Sw_Stat.phys = getValue( HMI_PN14_TDP_Sw_Stat );
    _mBODY_HMI_R1_AR.SPCR_Sp_Stat_BC_F.phys = getValue( HMI_SPCR_Sp_Stat_BC_F );
    _mBODY_HMI_R1_AR.SPCR_Stat_BC_F_UB.phys = getValue( HMI_SPCR_Stat_BC_F_UB );
    _mBODY_HMI_R1_AR.TSSR_Ft_RB_Stat.phys = getValue( HMI_TSSR_Ft_RB_Stat );
    _mBODY_HMI_R1_AR.TSSR_Ft_Stat.phys = getValue( HMI_TSSR_Ft_Stat );
  //  _mBODY_HMI_R1_AR.TSSR_Stat_UB.phys = getValue( HMI_TSSR_Stat_UB );
	_mBODY_HMI_R1_AR.TSSR_R_RB_Stat.phys = getValue( HMI_TSSR_R_RB_Stat );
    _mBODY_HMI_R1_AR.VTA_ITS_Dsabl_Ack_V2.phys = getValue( HMI_VTA_ITS_Dsabl_Ack_V2 );
    _mBODY_HMI_R1_AR.VTA_ITS_Dsabl_Ack_V2_UB.phys = getValue( HMI_VTA_ITS_Dsabl_Ack_V2_UB );
	_mBODY_HMI_R1_AR.VTA_ErrMsg_Disp_Rq.phys = getValue( HMI_VTA_ErrMsg_Disp_Rq );
    _mBODY_HMI_R1_AR.VTA_LED_On_Rq.phys = getValue( HMI_VTA_LED_On_Rq );
    _mBODY_HMI_R1_AR.VTA_LED_On_Rq_UB.phys = getValue( HMI_VTA_LED_On_Rq_UB );
    _mBODY_HMI_R1_AR.VTA_TPS_Dsabl_Ack_V2.phys = getValue( HMI_VTA_TPS_Dsabl_Ack_V2 );
    _mBODY_HMI_R1_AR.VTA_TPS_Dsabl_Ack_V2_UB.phys = getValue( HMI_VTA_TPS_Dsabl_Ack_V2_UB );
    _mBODY_HMI_R1_AR.PN14_Hibern_Md_Flt.phys = getValue( HMI_PN14_Hibern_Md_Flt );
    _mBODY_HMI_R1_AR.PN14_Hibern_Md_Flt_UB.phys = getValue( HMI_PN14_Hibern_Md_Flt_UB );
    _mBODY_HMI_R1_AR.PN14_Hibern_Md_Stat.phys = getValue( HMI_PN14_Hibern_Md_Stat );
    _mBODY_HMI_R1_AR.PN14_Hibern_Md_Stat_UB.phys = getValue( HMI_PN14_Hibern_Md_Stat_UB );
    _mBODY_HMI_R1_AR.PN14_Hibern_StdbyTm.phys = getValue( HMI_PN14_Hibern_StdbyTm );
    _mBODY_HMI_R1_AR.PN14_Hibern_StdbyTm_UB.phys = getValue( HMI_PN14_Hibern_StdbyTm_UB );
}

BODY_HMI_R1_AR_output()
{
    output( _mBODY_HMI_R1_AR );
}

BODY_HMI_R1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: BODY_HMI_R1_AR\n", 26, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_BODY_HMI_R1_AR := %X\n", getValue( HMI__STMSG_BODY_HMI_R1_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_BODY_HMI_R1_AR := %X\n", getValue( HMI__STMSGT_BODY_HMI_R1_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BeltHdOvr_Lt_Stat := %X\n", getValue( HMI_BeltHdOvr_Lt_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BeltHdOvr_Lt_Stat_UB := %X\n", getValue( HMI_BeltHdOvr_Lt_Stat_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BeltHdOvr_Rt_Stat := %X\n", getValue( HMI_BeltHdOvr_Rt_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BeltHdOvr_Rt_Stat_UB := %X\n", getValue( HMI_BeltHdOvr_Rt_Stat_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CT_Stat := %X\n", getValue( HMI_CT_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CT_Stat_UB := %X\n", getValue( HMI_CT_Stat_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DL_Lim_Stat := %X\n", getValue( HMI_DL_Lim_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DL_Lim_Stat_UB := %X\n", getValue( HMI_DL_Lim_Stat_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_Bat_Type := %X\n", getValue( HMI_PN14_Bat_Type ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_Bat_Type_UB := %X\n", getValue( HMI_PN14_Bat_Type_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_ProdMd_Stat := %X\n", getValue( HMI_PN14_ProdMd_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_ProdMd_Stat_UB := %X\n", getValue( HMI_PN14_ProdMd_Stat_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_TDP_Stat_UB := %X\n", getValue( HMI_PN14_TDP_Stat_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_TDP_Sw_Stat := %X\n", getValue( HMI_PN14_TDP_Sw_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPCR_Sp_Stat_BC_F := %X\n", getValue( HMI_SPCR_Sp_Stat_BC_F ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPCR_Stat_BC_F_UB := %X\n", getValue( HMI_SPCR_Stat_BC_F_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSSR_Ft_RB_Stat := %X\n", getValue( HMI_TSSR_Ft_RB_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSSR_Ft_Stat := %X\n", getValue( HMI_TSSR_Ft_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSSR_Stat_UB := %X\n", getValue( HMI_TSSR_Stat_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSSR_R_RB_Stat := %X\n", getValue( HMI_TSSR_R_RB_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VTA_ITS_Dsabl_Ack_V2 := %X\n", getValue( HMI_VTA_ITS_Dsabl_Ack_V2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VTA_ITS_Dsabl_Ack_V2_UB := %X\n", getValue( HMI_VTA_ITS_Dsabl_Ack_V2_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_VTA_ErrMsg_Disp_Rq := %X\n", getValue( HMI_VTA_ErrMsg_Disp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VTA_LED_On_Rq := %X\n", getValue( HMI_VTA_LED_On_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VTA_LED_On_Rq_UB := %X\n", getValue( HMI_VTA_LED_On_Rq_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VTA_TPS_Dsabl_Ack_V2 := %X\n", getValue( HMI_VTA_TPS_Dsabl_Ack_V2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VTA_TPS_Dsabl_Ack_V2_UB := %X\n", getValue( HMI_VTA_TPS_Dsabl_Ack_V2_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_Hibern_Md_Flt := %X\n", getValue( HMI_PN14_Hibern_Md_Flt ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_Hibern_Md_Flt_UB := %X\n", getValue( HMI_PN14_Hibern_Md_Flt_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_Hibern_Md_Stat:= %X\n", getValue( HMI_PN14_Hibern_Md_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_Hibern_Md_Stat_UB := %X\n", getValue( HMI_PN14_Hibern_Md_Stat_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_Hibern_StdbyTm := %X\n", getValue( HMI_PN14_Hibern_StdbyTm ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_Hibern_StdbyTm_UB := %X\n", getValue( HMI_PN14_Hibern_StdbyTm_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
  
}

on timer _tBODY_HMI_R1_AR
{
    putValue( HMI__STMSG_BODY_HMI_R1_AR, 0 );
}

on EnvVar HMI__STMSG_BODY_HMI_R1_AR
{
    long tDelay;

    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_BODY_HMI_R1_AR );
        if( tDelay > 0)    
            setTimer( _tBODY_HMI_R1_AR, tDelay );
        else
            putValue( HMI__STMSG_BODY_HMI_R1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_BODY_HMI_R1_AR
{
    if( getValue( this ) )
        openPanel("BODY_HMI_R1_AR");
}

on envVar HMI_BeltHdOvr_Lt_Stat
{
    _mBODY_HMI_R1_AR.BeltHdOvr_Lt_Stat.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_BeltHdOvr_Lt_Stat_UB
{
    _mBODY_HMI_R1_AR.BeltHdOvr_Lt_Stat_UB.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_BeltHdOvr_Rt_Stat
{
    _mBODY_HMI_R1_AR.BeltHdOvr_Rt_Stat.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_BeltHdOvr_Rt_Stat_UB
{
    _mBODY_HMI_R1_AR.BeltHdOvr_Rt_Stat_UB.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_CT_Stat
{
    _mBODY_HMI_R1_AR.CT_Stat.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_CT_Stat_UB
{
    _mBODY_HMI_R1_AR.CT_Stat_UB.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DL_Lim_Stat
{
    _mBODY_HMI_R1_AR.DL_Lim_Stat.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DL_Lim_Stat_UB
{
    _mBODY_HMI_R1_AR.DL_Lim_Stat_UB.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_Bat_Type
{
    _mBODY_HMI_R1_AR.PN14_Bat_Type.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_Bat_Type_UB
{
    _mBODY_HMI_R1_AR.PN14_Bat_Type_UB.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_ProdMd_Stat
{
    _mBODY_HMI_R1_AR.PN14_ProdMd_Stat.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_ProdMd_Stat_UB
{
    _mBODY_HMI_R1_AR.PN14_ProdMd_Stat_UB.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_TDP_Stat_UB
{
    _mBODY_HMI_R1_AR.PN14_TDP_Stat_UB.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_TDP_Sw_Stat
{
    _mBODY_HMI_R1_AR.PN14_TDP_Sw_Stat.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_SPCR_Sp_Stat_BC_F
{
    _mBODY_HMI_R1_AR.SPCR_Sp_Stat_BC_F.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_SPCR_Stat_BC_F_UB
{
    _mBODY_HMI_R1_AR.SPCR_Stat_BC_F_UB.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_TSSR_Ft_RB_Stat
{
    _mBODY_HMI_R1_AR.TSSR_Ft_RB_Stat.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_TSSR_Ft_Stat
{
    _mBODY_HMI_R1_AR.TSSR_Ft_Stat.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

//on envVar HMI_TSSR_Stat_UB
//{
//    _mBODY_HMI_R1_AR.TSSR_Stat_UB.phys = getValue(this);
//    _BODY_HMI_R1_AR_SpontanFlag = 1;
//}

on envVar HMI_TSSR_R_RB_Stat
{
    _mBODY_HMI_R1_AR.TSSR_R_RB_Stat.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_VTA_InfoMsg_Disp_Rq_V2
{
    _mBODY_HMI_R1_AR.VTA_InfoMsg_Disp_Rq_V2.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_VTA_InfoMsg_Disp_Rq_V2_UB
{
    _mBODY_HMI_R1_AR.VTA_InfoMsg_Disp_Rq_V2_UB.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_VTA_ITS_Dsabl_Ack_V2
{
    _mBODY_HMI_R1_AR.VTA_ITS_Dsabl_Ack_V2.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_VTA_ErrMsg_Disp_Rq
{
    _mBODY_HMI_R1_AR.VTA_ErrMsg_Disp_Rq.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_VTA_ITS_Dsabl_Ack_V2_UB
{
    _mBODY_HMI_R1_AR.VTA_ITS_Dsabl_Ack_V2_UB.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_VTA_LED_On_Rq
{
    _mBODY_HMI_R1_AR.VTA_LED_On_Rq.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_VTA_LED_On_Rq_UB
{
    _mBODY_HMI_R1_AR.VTA_LED_On_Rq_UB.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_VTA_TPS_Dsabl_Ack_V2
{
    _mBODY_HMI_R1_AR.VTA_TPS_Dsabl_Ack_V2.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_VTA_TPS_Dsabl_Ack_V2_UB
{
    _mBODY_HMI_R1_AR.VTA_TPS_Dsabl_Ack_V2_UB.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_Hibern_Md_Flt
{
    _mBODY_HMI_R1_AR.PN14_Hibern_Md_Flt.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_Hibern_Md_Flt_UB
{
    _mBODY_HMI_R1_AR.PN14_Hibern_Md_Flt_UB.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_Hibern_Md_Stat
{
    _mBODY_HMI_R1_AR.PN14_Hibern_Md_Stat.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_Hibern_Md_Stat_UB
{
    _mBODY_HMI_R1_AR.PN14_Hibern_Md_Stat_UB.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_Hibern_StdbyTm
{
    _mBODY_HMI_R1_AR.PN14_Hibern_StdbyTm.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_Hibern_StdbyTm_UB
{
    _mBODY_HMI_R1_AR.PN14_Hibern_StdbyTm_UB.phys = getValue(this);
    _BODY_HMI_R1_AR_SpontanFlag = 1;
}

BODY_HMI_R2_AR_check_output()
{
    if( !getValue( HMI__STMSG_BODY_HMI_R2_AR ) )
    {
    //  message   BODY_HMI_R2_AR ID: 544 --- Sendeart 5 cyclicAndSpontanWithDelay
        _BODY_HMI_R2_AR_Cnt--;
        if( _BODY_HMI_R2_AR_Cnt < 1 )
        {
            BODY_HMI_R2_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _BODY_HMI_R2_AR_Cnt = _BODY_HMI_R2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _BODY_HMI_R2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _BODY_HMI_R2_AR_SpontanFlag)
        {
            BODY_HMI_R2_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _BODY_HMI_R2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

BODY_HMI_R2_AR_init()
{   /* Botschaft BODY_HMI_R2_AR ID: 544 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 544 0;
BA_ "NmAsrMessage" BO_ 544 0;
BA_ "GenMsgMinAcceptLength" BO_ 544 8;
BA_ "GenMsgILSupport" BO_ 544 1;
BA_ "DiagState" BO_ 544 0;
BA_ "DiagRequest" BO_ 544 0;
BA_ "DiagResponse" BO_ 544 0;
BA_ "GenMsgStartValue" BO_ 544 "0";
BA_ "GenMsgStartDelayTime" BO_ 544 25;
BA_ "GenMsgDelayTime" BO_ 544 20;
BA_ "GenMsgNrOfRepetitions" BO_ 544 0;
BA_ "GenMsgCycleTime" BO_ 544 100;
BA_ "GenMsgSendType" BO_ 544 5;
    */
    _BODY_HMI_R2_AR_Timebase =      c_tDBKomTimer_20ms;
    _BODY_HMI_R2_AR_CycleCount =    100 / _BODY_HMI_R2_AR_Timebase;
    _BODY_HMI_R2_AR_StartDelay =     25 / _BODY_HMI_R2_AR_Timebase;
    _BODY_HMI_R2_AR_Cnt = _BODY_HMI_R2_AR_StartDelay;
    _BODY_HMI_R2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_BODY_HMI_R2_AR, _BODY_HMI_R2_AR_StartDelay * _BODY_HMI_R2_AR_Timebase );

    _mBODY_HMI_R2_AR.ALC_PwrSup_On_Rq.phys =              getValue( HMI_ALC_PwrSup_On_Rq );
    _mBODY_HMI_R2_AR.ALC_PwrSup_On_Rq_UB.phys =              getValue( HMI_ALC_PwrSup_On_Rq_UB );
    //_mBODY_HMI_R2_AR.AmbLgtColTmToChg_Rq.phys =              getValue( HMI_AmbLgtColTmToChg_Rq );
    //_mBODY_HMI_R2_AR.AmbLgtColTmToChg_Rq_UB.phys =              getValue( HMI_AmbLgtColTmToChg_Rq_UB );
    _mBODY_HMI_R2_AR.CSL_LHD_Inact_UB.phys =              getValue( HMI_CSL_LHD_Inact_UB );
    _mBODY_HMI_R2_AR.CSL_RHD_Inact.phys =              getValue( HMI_CSL_RHD_Inact );
    _mBODY_HMI_R2_AR.CSL_RHD_Inact_UB.phys =              getValue( HMI_CSL_RHD_Inact_UB );
    _mBODY_HMI_R2_AR.Mirr_Privacy_Stat.phys =              getValue( HMI_Mirr_Privacy_Stat );
    _mBODY_HMI_R2_AR.Mirr_Privacy_Stat_UB.phys =              getValue( HMI_Mirr_Privacy_Stat_UB );
    _mBODY_HMI_R2_AR.PDD_Record_Md_UB.phys =              getValue( HMI_PDD_Record_Md_UB );
    _mBODY_HMI_R2_AR.PDD_Record_Md.phys =              getValue( HMI_PDD_Record_Md );
    _mBODY_HMI_R2_AR.PN48_Avl.phys =              getValue( HMI_PN48_Avl );
    _mBODY_HMI_R2_AR.PN48_Avl_UB.phys =              getValue( HMI_PN48_Avl_UB );
    _mBODY_HMI_R2_AR.PW_FL_Posn_Stat.phys =              getValue( HMI_PW_FL_Posn_Stat );
 //   _mBODY_HMI_R2_AR.PW_FL_Stat_V2_UB.phys =              getValue( HMI_PW_FL_Stat_V2_UB );
    _mBODY_HMI_R2_AR.PW_FR_Posn_Stat     .phys =              getValue( HMI_PW_FR_Posn_Stat      );
  //  _mBODY_HMI_R2_AR.PW_FR_Stat_V2_UB.phys =              getValue( HMI_PW_FR_Stat_V2_UB );
    _mBODY_HMI_R2_AR.PW_RL_Posn_Stat.phys =              getValue( HMI_PW_RL_Posn_Stat );
  //  _mBODY_HMI_R2_AR.PW_RL_Stat_V2_UB.phys =              getValue( HMI_PW_RL_Stat_V2_UB );
    _mBODY_HMI_R2_AR.PW_RR_Posn_Stat.phys =              getValue( HMI_PW_RR_Posn_Stat );
  //  _mBODY_HMI_R2_AR.PW_RR_Stat_V2_UB.phys =              getValue( HMI_PW_RR_Stat_V2_UB );
    _mBODY_HMI_R2_AR.PW_Warn_Rq_FL.phys =              getValue( HMI_PW_Warn_Rq_FL );
    _mBODY_HMI_R2_AR.PW_Warn_Rq_FL_UB.phys =              getValue( HMI_PW_Warn_Rq_FL_UB );
    _mBODY_HMI_R2_AR.PW_Warn_Rq_FR.phys =              getValue( HMI_PW_Warn_Rq_FR );
    _mBODY_HMI_R2_AR.PW_Warn_Rq_FR_UB.phys =              getValue( HMI_PW_Warn_Rq_FR_UB );
    _mBODY_HMI_R2_AR.PW_Warn_Rq_RL.phys =              getValue( HMI_PW_Warn_Rq_RL );
    _mBODY_HMI_R2_AR.PW_Warn_Rq_RL_UB.phys =              getValue( HMI_PW_Warn_Rq_RL_UB );
    _mBODY_HMI_R2_AR.PW_Warn_Rq_RR.phys =              getValue( HMI_PW_Warn_Rq_RR );
    _mBODY_HMI_R2_AR.PW_Warn_Rq_RR_UB.phys =              getValue( HMI_PW_Warn_Rq_RR_UB );
    _mBODY_HMI_R2_AR.RoadsdCallSw_Stat.phys =              getValue( HMI_RoadsdCallSw_Stat );
    _mBODY_HMI_R2_AR.RoadsdCallSw_Stat_UB.phys =              getValue( HMI_RoadsdCallSw_Stat_UB );
    _mBODY_HMI_R2_AR.RPC_SRB_Lt_Stat.phys =              getValue( HMI_RPC_SRB_Lt_Stat );
    _mBODY_HMI_R2_AR.RPC_SRB_Lt_Stat_UB.phys =              getValue( HMI_RPC_SRB_Lt_Stat_UB );
    _mBODY_HMI_R2_AR.RPC_SRB_Rt_Stat.phys =              getValue( HMI_RPC_SRB_Rt_Stat );
    _mBODY_HMI_R2_AR.RPC_SRB_Rt_Stat_UB.phys =              getValue( HMI_RPC_SRB_Rt_Stat_UB );
    _mBODY_HMI_R2_AR.ServCallSw_Stat.phys =              getValue( HMI_ServCallSw_Stat );
    _mBODY_HMI_R2_AR.ServCallSw_Stat_UB.phys =              getValue( HMI_ServCallSw_Stat_UB );
    _mBODY_HMI_R2_AR.SOS_CallSw_Stat.phys =              getValue( HMI_SOS_CallSw_Stat );
    _mBODY_HMI_R2_AR.SOS_CallSw_Stat_UB.phys =              getValue( HMI_SOS_CallSw_Stat_UB );
	_mBODY_HMI_R2_AR.RPC_SRB_Quar_Win_Lt_Stat_UB.phys =              getValue( HMI_RPC_SRB_Quar_Win_Lt_Stat_UB );
	_mBODY_HMI_R2_AR.RPC_SRB_Quar_Win_Lt_Stat.phys =              getValue( HMI_RPC_SRB_Quar_Win_Lt_Stat );
	_mBODY_HMI_R2_AR.RPC_SRB_Quar_Win_Rt_Stat_UB.phys =              getValue( HMI_RPC_SRB_Quar_Win_Rt_Stat_UB );
	_mBODY_HMI_R2_AR.RPC_SRB_Quar_Win_Rt_Stat.phys =              getValue( HMI_RPC_SRB_Quar_Win_Rt_Stat );

}

BODY_HMI_R2_AR_output(void)
{
    output( _mBODY_HMI_R2_AR );
}

BODY_HMI_R2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: BODY_HMI_R2_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_BODY_HMI_R2_AR := %X\n", getValue( HMI__STMSG_BODY_HMI_R2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_BODY_HMI_R2_AR := %X\n", getValue( HMI__STMSGT_BODY_HMI_R2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ALC_PwrSup_On_Rq := %X\n", getValue( HMI_ALC_PwrSup_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ALC_PwrSup_On_Rq_UB := %X\n", getValue( HMI_ALC_PwrSup_On_Rq_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    //snprintf( buffer, elcount( buffer ), "0.0000 HMI_AmbLgtColTmToChg_Rq := %X\n", getValue( HMI_AmbLgtColTmToChg_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    //snprintf( buffer, elcount( buffer ), "0.0000 HMI_AmbLgtColTmToChg_Rq_UB := %X\n", getValue( HMI_AmbLgtColTmToChg_Rq_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CSL_LHD_Inact := %X\n", getValue( HMI_CSL_LHD_Inact ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CSL_LHD_Inact_UB := %X\n", getValue( HMI_CSL_LHD_Inact_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CSL_RHD_Inact := %X\n", getValue( HMI_CSL_RHD_Inact ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CSL_RHD_Inact_UB := %X\n", getValue( HMI_CSL_RHD_Inact_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mirr_Privacy_Stat := %X\n", getValue( HMI_Mirr_Privacy_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mirr_Privacy_Stat_UB := %X\n", getValue( HMI_Mirr_Privacy_Stat_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PDD_Record_Md := %X\n", getValue( HMI_PDD_Record_Md ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PDD_Record_Md_UB := %X\n", getValue( HMI_PDD_Record_Md_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN48_Avl := %X\n", getValue( HMI_PN48_Avl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN48_Avl_UB := %X\n", getValue( HMI_PN48_Avl_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PW_FL_Posn_Stat := %X\n", getValue( HMI_PW_FL_Posn_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PW_FL_Stat_V2_UB := %X\n", getValue( HMI_PW_FL_Stat_V2_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PW_FR_Posn_Stat      := %X\n", getValue( HMI_PW_FR_Posn_Stat      ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PW_FR_Stat_V2_UB := %X\n", getValue( HMI_PW_FR_Stat_V2_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PW_RL_Posn_Stat := %X\n", getValue( HMI_PW_RL_Posn_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PW_RL_Stat_V2_UB := %X\n", getValue( HMI_PW_RL_Stat_V2_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PW_RR_Posn_Stat := %X\n", getValue( HMI_PW_RR_Posn_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PW_RR_Stat_V2_UB := %X\n", getValue( HMI_PW_RR_Stat_V2_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PW_Warn_Rq_FL := %X\n", getValue( HMI_PW_Warn_Rq_FL ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PW_Warn_Rq_FL_UB := %X\n", getValue( HMI_PW_Warn_Rq_FL_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PW_Warn_Rq_FR := %X\n", getValue( HMI_PW_Warn_Rq_FR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PW_Warn_Rq_FR_UB := %X\n", getValue( HMI_PW_Warn_Rq_FR_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PW_Warn_Rq_RL := %X\n", getValue( HMI_PW_Warn_Rq_RL ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PW_Warn_Rq_RL_UB := %X\n", getValue( HMI_PW_Warn_Rq_RL_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PW_Warn_Rq_RR := %X\n", getValue( HMI_PW_Warn_Rq_RR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PW_Warn_Rq_RR_UB := %X\n", getValue( HMI_PW_Warn_Rq_RR_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RoadsdCallSw_Stat := %X\n", getValue( HMI_RoadsdCallSw_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RoadsdCallSw_Stat_UB := %X\n", getValue( HMI_RoadsdCallSw_Stat_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RPC_SRB_Lt_Stat := %X\n", getValue( HMI_RPC_SRB_Lt_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RPC_SRB_Lt_Stat_UB := %X\n", getValue( HMI_RPC_SRB_Lt_Stat_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RPC_SRB_Rt_Stat := %X\n", getValue( HMI_RPC_SRB_Rt_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RPC_SRB_Rt_Stat_UB := %X\n", getValue( HMI_RPC_SRB_Rt_Stat_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ServCallSw_Stat := %X\n", getValue( HMI_ServCallSw_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ServCallSw_Stat_UB := %X\n", getValue( HMI_ServCallSw_Stat_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SOS_CallSw_Stat := %X\n", getValue( HMI_SOS_CallSw_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SOS_CallSw_Stat_UB := %X\n", getValue( HMI_SOS_CallSw_Stat_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RPC_SRB_Quar_Win_Lt_Stat_UB := %X\n", getValue( HMI_RPC_SRB_Quar_Win_Lt_Stat_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RPC_SRB_Quar_Win_Lt_Stat := %X\n", getValue( HMI_RPC_SRB_Quar_Win_Lt_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RPC_SRB_Quar_Win_Rt_Stat_UB := %X\n", getValue( HMI_RPC_SRB_Quar_Win_Rt_Stat_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RPC_SRB_Quar_Win_Rt_Stat := %X\n", getValue( HMI_RPC_SRB_Quar_Win_Rt_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tBODY_HMI_R2_AR
{
    putValue( HMI__STMSG_BODY_HMI_R2_AR, 0 );
}

on EnvVar HMI__STMSG_BODY_HMI_R2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_BODY_HMI_R2_AR );
        if( tDelay > 0)    
            setTimer( _tBODY_HMI_R2_AR, tDelay );
        else
            putValue( HMI__STMSG_BODY_HMI_R2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_BODY_HMI_R2_AR
{
    if( getValue( this ) )
        openPanel("BODY_HMI_R2_AR");
}

on EnvVar HMI_ALC_PwrSup_On_Rq
{
    _mBODY_HMI_R2_AR.ALC_PwrSup_On_Rq.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_ALC_PwrSup_On_Rq_UB
{
    _mBODY_HMI_R2_AR.ALC_PwrSup_On_Rq_UB.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

//on EnvVar HMI_AmbLgtColTmToChg_Rq
//{
//    _mBODY_HMI_R2_AR.AmbLgtColTmToChg_Rq.phys = getValue(this);
//    _BODY_HMI_R2_AR_SpontanFlag = 1;
//}
//
//on EnvVar HMI_AmbLgtColTmToChg_Rq_UB
//{
//    _mBODY_HMI_R2_AR.AmbLgtColTmToChg_Rq_UB.phys = getValue(this);
//    _BODY_HMI_R2_AR_SpontanFlag = 1;
//}

on EnvVar HMI_CSL_LHD_Inact
{
    _mBODY_HMI_R2_AR.CSL_LHD_Inact.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_CSL_LHD_Inact_UB
{
    _mBODY_HMI_R2_AR.CSL_LHD_Inact_UB.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_CSL_RHD_Inact
{
    _mBODY_HMI_R2_AR.CSL_RHD_Inact.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_CSL_RHD_Inact_UB
{
    _mBODY_HMI_R2_AR.CSL_RHD_Inact_UB.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Mirr_Privacy_Stat
{
    _mBODY_HMI_R2_AR.Mirr_Privacy_Stat.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Mirr_Privacy_Stat_UB
{
    _mBODY_HMI_R2_AR.Mirr_Privacy_Stat_UB.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PDD_Record_Md
{
    _mBODY_HMI_R2_AR.PDD_Record_Md.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PDD_Record_Md_UB
{
    _mBODY_HMI_R2_AR.PDD_Record_Md_UB.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN48_Avl
{
    _mBODY_HMI_R2_AR.PN48_Avl.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN48_Avl_UB
{
    _mBODY_HMI_R2_AR.PN48_Avl_UB.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PW_FL_Posn_Stat
{
    _mBODY_HMI_R2_AR.PW_FL_Posn_Stat.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

//on EnvVar HMI_PW_FL_Stat_V2_UB
//{
//    _mBODY_HMI_R2_AR.PW_FL_Stat_V2_UB.phys = getValue(this);
//    _BODY_HMI_R2_AR_SpontanFlag = 1;
//}

on EnvVar HMI_PW_FR_Posn_Stat
{
    _mBODY_HMI_R2_AR.PW_FR_Posn_Stat.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

//on EnvVar HMI_PW_FR_Stat_V2_UB
//{
//    _mBODY_HMI_R2_AR.PW_FR_Stat_V2_UB.phys = getValue(this);
//    _BODY_HMI_R2_AR_SpontanFlag = 1;
//}

on EnvVar HMI_PW_RL_Posn_Stat
{
    _mBODY_HMI_R2_AR.PW_RL_Posn_Stat.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

//on EnvVar HMI_PW_RL_Stat_V2_UB
//{
//    _mBODY_HMI_R2_AR.PW_RL_Stat_V2_UB.phys = getValue(this);
//    _BODY_HMI_R2_AR_SpontanFlag = 1;
//}

on EnvVar HMI_PW_RR_Posn_Stat
{
    _mBODY_HMI_R2_AR.PW_RR_Posn_Stat.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

//on EnvVar HMI_PW_RR_Stat_V2_UB
//{
//    _mBODY_HMI_R2_AR.PW_RR_Stat_V2_UB.phys = getValue(this);
//    _BODY_HMI_R2_AR_SpontanFlag = 1;
//}

on EnvVar HMI_PW_Warn_Rq_FL
{
    _mBODY_HMI_R2_AR.PW_Warn_Rq_FL.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PW_Warn_Rq_FL_UB
{
    _mBODY_HMI_R2_AR.PW_Warn_Rq_FL_UB.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PW_Warn_Rq_FR
{
    _mBODY_HMI_R2_AR.PW_Warn_Rq_FR.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PW_Warn_Rq_FR_UB
{
    _mBODY_HMI_R2_AR.PW_Warn_Rq_FR_UB.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PW_Warn_Rq_RL
{
    _mBODY_HMI_R2_AR.PW_Warn_Rq_RL.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PW_Warn_Rq_RL_UB
{
    _mBODY_HMI_R2_AR.PW_Warn_Rq_RL_UB.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PW_Warn_Rq_RR
{
    _mBODY_HMI_R2_AR.PW_Warn_Rq_RR.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PW_Warn_Rq_RR_UB
{
    _mBODY_HMI_R2_AR.PW_Warn_Rq_RR_UB.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RoadsdCallSw_Stat
{
    _mBODY_HMI_R2_AR.RoadsdCallSw_Stat.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RoadsdCallSw_Stat_UB
{
    _mBODY_HMI_R2_AR.RoadsdCallSw_Stat_UB.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RPC_SRB_Lt_Stat
{
    _mBODY_HMI_R2_AR.RPC_SRB_Lt_Stat.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RPC_SRB_Lt_Stat_UB
{
    _mBODY_HMI_R2_AR.RPC_SRB_Lt_Stat_UB.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RPC_SRB_Rt_Stat
{
    _mBODY_HMI_R2_AR.RPC_SRB_Rt_Stat.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RPC_SRB_Rt_Stat_UB
{
    _mBODY_HMI_R2_AR.RPC_SRB_Rt_Stat_UB.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_ServCallSw_Stat
{
    _mBODY_HMI_R2_AR.ServCallSw_Stat.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_ServCallSw_Stat_UB
{
    _mBODY_HMI_R2_AR.ServCallSw_Stat_UB.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_SOS_CallSw_Stat
{
    _mBODY_HMI_R2_AR.SOS_CallSw_Stat.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_SOS_CallSw_Stat_UB
{
    _mBODY_HMI_R2_AR.SOS_CallSw_Stat_UB.phys = getValue(this);
    _BODY_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RPC_SRB_Quar_Win_Lt_Stat_UB  
{     
	_mBODY_HMI_R2_AR.RPC_SRB_Quar_Win_Lt_Stat_UB.phys = getValue(this);
	_BODY_HMI_R2_AR_SpontanFlag = 1;
}     

on EnvVar HMI_RPC_SRB_Quar_Win_Lt_Stat  
{     
	_mBODY_HMI_R2_AR.RPC_SRB_Quar_Win_Lt_Stat.phys = getValue(this);
	_BODY_HMI_R2_AR_SpontanFlag = 1;
}     

on EnvVar HMI_RPC_SRB_Quar_Win_Rt_Stat_UB  
{     
	_mBODY_HMI_R2_AR.RPC_SRB_Quar_Win_Rt_Stat_UB.phys = getValue(this);
	_BODY_HMI_R2_AR_SpontanFlag = 1;
}     

on EnvVar HMI_RPC_SRB_Quar_Win_Rt_Stat  
{     
	_mBODY_HMI_R2_AR.RPC_SRB_Quar_Win_Rt_Stat.phys = getValue(this);
	_BODY_HMI_R2_AR_SpontanFlag = 1;
}     

BSM_Disp_Warn_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_BSM_Disp_Warn_Rq_AR ) )
    {
    //  message   BSM_Disp_Warn_Rq_AR ID: 1049 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _BSM_Disp_Warn_Rq_AR_DelayCnt > 0) _BSM_Disp_Warn_Rq_AR_DelayCnt--; // Mindestsendeabstand
        _BSM_Disp_Warn_Rq_AR_Cnt--;
        if( _BSM_Disp_Warn_Rq_AR_Cnt < 1 )
        {
            if( _BSM_Disp_Warn_Rq_AR_DelayCnt < 1 )
            {
                BSM_Disp_Warn_Rq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                _BSM_Disp_Warn_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _BSM_Disp_Warn_Rq_AR_DelayCnt = _BSM_Disp_Warn_Rq_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
            }
            _BSM_Disp_Warn_Rq_AR_Cnt = _BSM_Disp_Warn_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _BSM_Disp_Warn_Rq_AR_SpontanFlag)
        {
            if( _BSM_Disp_Warn_Rq_AR_DelayCnt < 1 )
            {
                BSM_Disp_Warn_Rq_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _BSM_Disp_Warn_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _BSM_Disp_Warn_Rq_AR_DelayCnt = _BSM_Disp_Warn_Rq_AR_MinDelay;
            }
        }
    }
}

BSM_Disp_Warn_Rq_AR_init()
{   /* Botschaft BSM_Disp_Warn_Rq_AR ID: 1049 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1049 0;
BA_ "NmAsrMessage" BO_ 1049 0;
BA_ "GenMsgMinAcceptLength" BO_ 1049 8;
BA_ "GenMsgILSupport" BO_ 1049 1;
BA_ "DiagState" BO_ 1049 0;
BA_ "DiagRequest" BO_ 1049 0;
BA_ "DiagResponse" BO_ 1049 0;
BA_ "GenMsgStartValue" BO_ 1049 "0";
BA_ "GenMsgDelayTime" BO_ 1049 20;
BA_ "GenMsgNrOfRepetitions" BO_ 1049 0;
BA_ "GenMsgCycleTime" BO_ 1049 200;
BA_ "GenMsgSendType" BO_ 1049 5;
    */
    _BSM_Disp_Warn_Rq_AR_Timebase =             c_tDBKomTimer_20ms;
    _BSM_Disp_Warn_Rq_AR_CycleCount =          200 / _BSM_Disp_Warn_Rq_AR_Timebase;
    _BSM_Disp_Warn_Rq_AR_StartDelay =            0 / _BSM_Disp_Warn_Rq_AR_Timebase;
    _BSM_Disp_Warn_Rq_AR_MinDelay =             20 / _BSM_Disp_Warn_Rq_AR_Timebase;
    _BSM_Disp_Warn_Rq_AR_Cnt = _BSM_Disp_Warn_Rq_AR_StartDelay;
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 0;
    _BSM_Disp_Warn_Rq_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_BSM_Disp_Warn_Rq_AR, _BSM_Disp_Warn_Rq_AR_StartDelay * _BSM_Disp_Warn_Rq_AR_Timebase );
    
    _BSM_Disp_Warn_Rq_AR_Cnt = 1;
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 0;
    _mBSM_Disp_Warn_Rq_AR.BSM_AcustWarn_Lt_Rq.phys = getValue( HMI_BSM_AcustWarn_Lt_Rq );
    _mBSM_Disp_Warn_Rq_AR.BSM_AcustWarn_Rq.phys = getValue( HMI_BSM_AcustWarn_Rq );
    _mBSM_Disp_Warn_Rq_AR.BSM_AcustWarn_Rt_Rq.phys = getValue( HMI_BSM_AcustWarn_Rt_Rq );
    _mBSM_Disp_Warn_Rq_AR.BSM_MsgDisp_Rq.phys = getValue( HMI_BSM_MsgDisp_Rq );
    _mBSM_Disp_Warn_Rq_AR.BSM_ObjCls_Lt_Dist_Y.phys = getValue( HMI_BSM_ObjCls_Lt_Dist_Y );
    _mBSM_Disp_Warn_Rq_AR.BSM_ObjCls_Lt_Type.phys = getValue( HMI_BSM_ObjCls_Lt_Type );
    _mBSM_Disp_Warn_Rq_AR.BSM_ObjCls_Rt_Dist_Y.phys = getValue( HMI_BSM_ObjCls_Rt_Dist_Y );
    _mBSM_Disp_Warn_Rq_AR.BSM_ObjCls_Rt_Type.phys = getValue( HMI_BSM_ObjCls_Rt_Type );
  //  _mBSM_Disp_Warn_Rq_AR.BSM_ObjCls_Stat_UB.phys = getValue( HMI_BSM_ObjCls_Stat_UB );
    _mBSM_Disp_Warn_Rq_AR.BSM_Stat.phys = getValue( HMI_BSM_Stat );
    _mBSM_Disp_Warn_Rq_AR.BSM_Warn_Lt_Rq.phys = getValue( HMI_BSM_Warn_Lt_Rq );
    _mBSM_Disp_Warn_Rq_AR.BSM_Warn_Rt_Rq.phys = getValue( HMI_BSM_Warn_Rt_Rq );
    _mBSM_Disp_Warn_Rq_AR.CTA_Brk_Rq.phys = getValue( HMI_CTA_Brk_Rq );
    _mBSM_Disp_Warn_Rq_AR.CTA_Stat.phys = getValue( HMI_CTA_Stat );
    _mBSM_Disp_Warn_Rq_AR.CTA_Warn_Lt_Rq.phys = getValue( HMI_CTA_Warn_Lt_Rq );
    _mBSM_Disp_Warn_Rq_AR.CTA_Warn_Rt_Rq.phys = getValue( HMI_CTA_Warn_Rt_Rq );
    _mBSM_Disp_Warn_Rq_AR.CTA_Rq_UB.phys = getValue( HMI_CTA_Rq_UB );
    _mBSM_Disp_Warn_Rq_AR.LCMS_Beep_Rq.phys = getValue( HMI_LCMS_Beep_Rq );
    _mBSM_Disp_Warn_Rq_AR.LCMS_BrkMsgDisp_Rq.phys = getValue( HMI_LCMS_BrkMsgDisp_Rq );
    _mBSM_Disp_Warn_Rq_AR.LCMS_MsgDisp_Rq.phys = getValue( HMI_LCMS_MsgDisp_Rq );
	  _mBSM_Disp_Warn_Rq_AR.RadarSensSoil_BSM_IconDisp_Rq_BSM_M.phys = getValue( HMI_RadarSensSoil_BSM_IconDisp_Rq_BSM_M );
    _mBSM_Disp_Warn_Rq_AR.RadarSensSoil_MsgDisp_Rq_BSM_M.phys = getValue( HMI_RadarSensSoil_MsgDisp_Rq_BSM_M );
    _mBSM_Disp_Warn_Rq_AR.BSM_Md_Stat.phys = getValue( HMI_BSM_Md_Stat );
}

BSM_Disp_Warn_Rq_AR_output(void)
{
    output( _mBSM_Disp_Warn_Rq_AR );
}

BSM_Disp_Warn_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: BSM_Disp_Warn_Rq_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_BSM_Disp_Warn_Rq_AR := %X\n", getValue( HMI__STMSG_BSM_Disp_Warn_Rq_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_BSM_Disp_Warn_Rq_AR := %X\n", getValue( HMI__STMSGT_BSM_Disp_Warn_Rq_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_AcustWarn_Lt_Rq := %X\n", getValue( HMI_BSM_AcustWarn_Lt_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_AcustWarn_Rq := %X\n", getValue( HMI_BSM_AcustWarn_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_AcustWarn_Rt_Rq := %X\n", getValue( HMI_BSM_AcustWarn_Rt_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_MsgDisp_Rq := %X\n", getValue( HMI_BSM_MsgDisp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_ObjCls_Lt_Dist_Y := %X\n", getValue( HMI_BSM_ObjCls_Lt_Dist_Y ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_ObjCls_Lt_Type := %X\n", getValue( HMI_BSM_ObjCls_Lt_Type ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_ObjCls_Rt_Dist_Y := %X\n", getValue( HMI_BSM_ObjCls_Rt_Dist_Y ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_ObjCls_Rt_Type := %X\n", getValue( HMI_BSM_ObjCls_Rt_Type ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_ObjCls_Stat_UB := %X\n", getValue( HMI_BSM_ObjCls_Stat_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_Stat := %X\n", getValue( HMI_BSM_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_Warn_Lt_Rq := %X\n", getValue( HMI_BSM_Warn_Lt_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_Warn_Rt_Rq := %X\n", getValue( HMI_BSM_Warn_Rt_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CTA_Brk_Rq := %X\n", getValue( HMI_CTA_Brk_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CTA_Stat := %X\n", getValue( HMI_CTA_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CTA_Warn_Lt_Rq := %X\n", getValue( HMI_CTA_Warn_Lt_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CTA_Warn_Rt_Rq := %X\n", getValue( HMI_CTA_Warn_Rt_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CTA_Rq_UB := %X\n", getValue( HMI_CTA_Rq_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LCMS_Beep_Rq := %X\n", getValue( HMI_LCMS_Beep_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LCMS_BrkMsgDisp_Rq := %X\n", getValue( HMI_LCMS_BrkMsgDisp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LCMS_MsgDisp_Rq := %X\n", getValue( HMI_LCMS_MsgDisp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_RadarSensSoil_BSM_IconDisp_Rq_BSM_M := %X\n", getValue( HMI_RadarSensSoil_BSM_IconDisp_Rq_BSM_M ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_Md_Stat := %X\n", getValue( HMI_BSM_Md_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RadarSensSoil_MsgDisp_Rq_BSM_M := %X\n", getValue( HMI_RadarSensSoil_MsgDisp_Rq_BSM_M ) );    filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tBSM_Disp_Warn_Rq_AR
{
    putValue( HMI__STMSG_BSM_Disp_Warn_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_BSM_Disp_Warn_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_BSM_Disp_Warn_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tBSM_Disp_Warn_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_BSM_Disp_Warn_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_BSM_Disp_Warn_Rq_AR
{
    if( getValue( this ) )
        openPanel("BSM_Disp_Warn_Rq_AR");
}

on EnvVar HMI_BSM_AcustWarn_Lt_Rq
{
    _mBSM_Disp_Warn_Rq_AR.BSM_AcustWarn_Lt_Rq.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BSM_AcustWarn_Rq
{
    _mBSM_Disp_Warn_Rq_AR.BSM_AcustWarn_Rq.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BSM_Md_Stat
{
    _mBSM_Disp_Warn_Rq_AR.BSM_Md_Stat.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BSM_AcustWarn_Rt_Rq
{
    _mBSM_Disp_Warn_Rq_AR.BSM_AcustWarn_Rt_Rq.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BSM_MsgDisp_Rq
{
    _mBSM_Disp_Warn_Rq_AR.BSM_MsgDisp_Rq.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BSM_ObjCls_Lt_Dist_Y
{
    _mBSM_Disp_Warn_Rq_AR.BSM_ObjCls_Lt_Dist_Y.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BSM_ObjCls_Lt_Type
{
    _mBSM_Disp_Warn_Rq_AR.BSM_ObjCls_Lt_Type.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BSM_ObjCls_Rt_Dist_Y
{
    _mBSM_Disp_Warn_Rq_AR.BSM_ObjCls_Rt_Dist_Y.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BSM_ObjCls_Rt_Type
{
    _mBSM_Disp_Warn_Rq_AR.BSM_ObjCls_Rt_Type.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

//on EnvVar HMI_BSM_ObjCls_Stat_UB
//{
//    _mBSM_Disp_Warn_Rq_AR.BSM_ObjCls_Stat_UB.phys = getValue(this);
//    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
//}

on EnvVar HMI_BSM_Stat
{
    _mBSM_Disp_Warn_Rq_AR.BSM_Stat.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BSM_Warn_Lt_Rq
{
    _mBSM_Disp_Warn_Rq_AR.BSM_Warn_Lt_Rq.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BSM_Warn_Rt_Rq
{
    _mBSM_Disp_Warn_Rq_AR.BSM_Warn_Rt_Rq.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CTA_Brk_Rq
{
    _mBSM_Disp_Warn_Rq_AR.CTA_Brk_Rq.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CTA_Stat
{
    _mBSM_Disp_Warn_Rq_AR.CTA_Stat.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CTA_Warn_Lt_Rq
{
    _mBSM_Disp_Warn_Rq_AR.CTA_Warn_Lt_Rq.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CTA_Warn_Rt_Rq
{
    _mBSM_Disp_Warn_Rq_AR.CTA_Warn_Rt_Rq.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CTA_Rq_UB
{
    _mBSM_Disp_Warn_Rq_AR.CTA_Rq_UB.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LCMS_Beep_Rq
{
    _mBSM_Disp_Warn_Rq_AR.LCMS_Beep_Rq.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LCMS_BrkMsgDisp_Rq
{
    _mBSM_Disp_Warn_Rq_AR.LCMS_BrkMsgDisp_Rq.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LCMS_MsgDisp_Rq
{
    _mBSM_Disp_Warn_Rq_AR.LCMS_MsgDisp_Rq.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_RadarSensSoil_BSM_IconDisp_Rq_BSM_M
{
    _mBSM_Disp_Warn_Rq_AR.RadarSensSoil_BSM_IconDisp_Rq_BSM_M.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_RadarSensSoil_MsgDisp_Rq_BSM_M
{
    _mBSM_Disp_Warn_Rq_AR.RadarSensSoil_MsgDisp_Rq_BSM_M.phys = getValue(this);
    _BSM_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

CamLane_Disp_Warn_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_CamLane_Disp_Warn_Rq_AR ) )
    {
    //  message   CamLane_Disp_Warn_Rq_AR ID: 1035 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _CamLane_Disp_Warn_Rq_AR_DelayCnt > 0) _CamLane_Disp_Warn_Rq_AR_DelayCnt--; // Mindestsendeabstand
        _CamLane_Disp_Warn_Rq_AR_Cnt--;
        if( _CamLane_Disp_Warn_Rq_AR_Cnt < 1 )
        {
            if( _CamLane_Disp_Warn_Rq_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                CamLane_Disp_Warn_Rq_AR_output();
                 _CamLane_Disp_Warn_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _CamLane_Disp_Warn_Rq_AR_DelayCnt = _CamLane_Disp_Warn_Rq_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _CamLane_Disp_Warn_Rq_AR_SpontanFlag = 1;
            }
            _CamLane_Disp_Warn_Rq_AR_Cnt = _CamLane_Disp_Warn_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _CamLane_Disp_Warn_Rq_AR_SpontanFlag)
        {
            if( _CamLane_Disp_Warn_Rq_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                CamLane_Disp_Warn_Rq_AR_output();
                _CamLane_Disp_Warn_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _CamLane_Disp_Warn_Rq_AR_DelayCnt = _CamLane_Disp_Warn_Rq_AR_MinDelay;
            }
        }
    }
}

CamLane_Disp_Warn_Rq_AR_init()
{   /* Botschaft CamLane_Disp_Warn_Rq_AR  ID: 1035 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1035 0;
BA_ "NmAsrMessage" BO_ 1035 0;
BA_ "GenMsgMinAcceptLength" BO_ 1035 8;
BA_ "GenMsgILSupport" BO_ 1035 1;
BA_ "DiagState" BO_ 1035 0;
BA_ "DiagRequest" BO_ 1035 0;
BA_ "DiagResponse" BO_ 1035 0;
BA_ "GenMsgStartValue" BO_ 1035 "0";
BA_ "GenMsgDelayTime" BO_ 1035 40;
BA_ "GenMsgNrOfRepetitions" BO_ 1035 0;
BA_ "GenMsgCycleTime" BO_ 1035 160;
BA_ "GenMsgSendType" BO_ 1035 5;
    */
    _CamLane_Disp_Warn_Rq_AR_Timebase =             c_tDBKomTimer_20ms;
    _CamLane_Disp_Warn_Rq_AR_CycleCount =          160 / _CamLane_Disp_Warn_Rq_AR_Timebase;
    _CamLane_Disp_Warn_Rq_AR_StartDelay =            0 / _CamLane_Disp_Warn_Rq_AR_Timebase;
    _CamLane_Disp_Warn_Rq_AR_MinDelay =             40 / _CamLane_Disp_Warn_Rq_AR_Timebase;
    _CamLane_Disp_Warn_Rq_AR_Cnt = _CamLane_Disp_Warn_Rq_AR_StartDelay;
    _CamLane_Disp_Warn_Rq_AR_SpontanFlag = 0;
    _CamLane_Disp_Warn_Rq_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_CamLane_Disp_Warn_Rq_AR, _CamLane_Disp_Warn_Rq_AR_StartDelay * _CamLane_Disp_Warn_Rq_AR_Timebase);
    
    _mCamLane_Disp_Warn_Rq_AR.CrossWalk_Dist.phys = getValue( HMI_CrossWalk_Dist );
    _mCamLane_Disp_Warn_Rq_AR.CrossWalk_Stat.phys = getValue( HMI_CrossWalk_Stat );
    _mCamLane_Disp_Warn_Rq_AR.LDP_IndLmp_SwLED_HU_Rq_MPC.phys = getValue( HMI_LDP_IndLmp_SwLED_HU_Rq_MPC );
    _mCamLane_Disp_Warn_Rq_AR.LDP_MPC_Md_Stat.phys = getValue( HMI_LDP_MPC_Md_Stat );
    _mCamLane_Disp_Warn_Rq_AR.LDP_MPC_MsgDisp_Rq.phys = getValue( HMI_LDP_MPC_MsgDisp_Rq );
    _mCamLane_Disp_Warn_Rq_AR.PavemntSign_LtrlDist_EgoLane.phys = getValue( HMI_PavemntSign_LtrlDist_EgoLane );
    _mCamLane_Disp_Warn_Rq_AR.PavemntSign_LtrlDist_NghbrLane.phys = getValue( HMI_PavemntSign_LtrlDist_NghbrLane );
    _mCamLane_Disp_Warn_Rq_AR.PavemntSign_Type_EgoLane.phys = getValue( HMI_PavemntSign_Type_EgoLane );
    _mCamLane_Disp_Warn_Rq_AR.PavemntSign_Type_NghbrLane.phys = getValue( HMI_PavemntSign_Type_NghbrLane );
    _mCamLane_Disp_Warn_Rq_AR.Rsrv3_CamLane_Disp_Warn_Rq.phys = getValue( HMI_Rsrv3_CamLane_Disp_Warn_Rq );
    _mCamLane_Disp_Warn_Rq_AR.Rsrv4_CamLane_Disp_Warn_Rq.phys = getValue( HMI_Rsrv4_CamLane_Disp_Warn_Rq );
    _mCamLane_Disp_Warn_Rq_AR.ALDW_MPC_Md_Stat.phys = getValue( HMI_ALDW_MPC_Md_Stat );
    _mCamLane_Disp_Warn_Rq_AR.LDP_Sensitive_Md_MPC_Stat.phys = getValue( HMI_LDP_Sensitive_Md_MPC_Stat );
}

CamLane_Disp_Warn_Rq_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_CamLane_Disp_Warn_Rq ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_CamLane_Disp_Warn_Rq_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _CamLane_Disp_Warn_Rq_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _CamLane_Disp_Warn_Rq_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_CamLane_Disp_Warn_Rq_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _CamLane_Disp_Warn_Rq_AR_SQC_WrongSeqJump != 0 ) &&
            ( _CamLane_Disp_Warn_Rq_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _CamLane_Disp_Warn_Rq_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _CamLane_Disp_Warn_Rq_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _CamLane_Disp_Warn_Rq_AR_SQC_RepeatedCnt ) &&
            ( _CamLane_Disp_Warn_Rq_AR_E2E_Armed == 1  )    )
        {
            _CamLane_Disp_Warn_Rq_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_CamLane_Disp_Warn_Rq, SQC_help );
    }
    _mCamLane_Disp_Warn_Rq_AR.SQC_CamLane_Disp_Warn_Rq = SQC_help;

    if( getValue( HMI_CRC_CamLane_Disp_Warn_Rq_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_CamLane_Disp_Warn_Rq_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable_profile02[ crc ^ _mCamLane_Disp_Warn_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mCamLane_Disp_Warn_Rq_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_Disp_Warn_Rq_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_Disp_Warn_Rq_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_Disp_Warn_Rq_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_Disp_Warn_Rq_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_Disp_Warn_Rq_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_Disp_Warn_Rq_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _CamLane_Disp_Warn_Rq_AR_CRC_Offset[ _mCamLane_Disp_Warn_Rq_AR.SQC_CamLane_Disp_Warn_Rq ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _CamLane_Disp_Warn_Rq_AR_CRC_ErrorCnt   && ( _CamLane_Disp_Warn_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_CamLane_Disp_Warn_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _CamLane_Disp_Warn_Rq_AR_CRC_ErrorCnt > 0 )
                    _CamLane_Disp_Warn_Rq_AR_CRC_ErrorCnt--; 
            }
            _mCamLane_Disp_Warn_Rq_AR.CRC_CamLane_Disp_Warn_Rq = crc;
            putValue( HMI_CRC_CamLane_Disp_Warn_Rq, crc );
        }
        else
            _mCamLane_Disp_Warn_Rq_AR.CRC_CamLane_Disp_Warn_Rq = getValue( HMI_CRC_CamLane_Disp_Warn_Rq );
    }
    else
    {
        if( !getValue( HMI_CRC_CamLane_Disp_Warn_Rq_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mCamLane_Disp_Warn_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mCamLane_Disp_Warn_Rq_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mCamLane_Disp_Warn_Rq_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mCamLane_Disp_Warn_Rq_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mCamLane_Disp_Warn_Rq_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mCamLane_Disp_Warn_Rq_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mCamLane_Disp_Warn_Rq_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mCamLane_Disp_Warn_Rq_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _CamLane_Disp_Warn_Rq_AR_CRC_ErrorCnt   && ( _CamLane_Disp_Warn_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_CamLane_Disp_Warn_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _CamLane_Disp_Warn_Rq_AR_CRC_ErrorCnt > 0 )
                    _CamLane_Disp_Warn_Rq_AR_CRC_ErrorCnt--; 
            }
            _mCamLane_Disp_Warn_Rq_AR.CRC_CamLane_Disp_Warn_Rq = crc;
            putValue( HMI_CRC_CamLane_Disp_Warn_Rq, crc );
        }
        else
            _mCamLane_Disp_Warn_Rq_AR.CRC_CamLane_Disp_Warn_Rq = getValue( HMI_CRC_CamLane_Disp_Warn_Rq );
    }
    if( ( _CamLane_Disp_Warn_Rq_AR_MSG_DropCnt > 0 ) &&
        ( _CamLane_Disp_Warn_Rq_AR_E2E_Armed == 1  )    )
    {
        _CamLane_Disp_Warn_Rq_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mCamLane_Disp_Warn_Rq_AR );
        
    if( _CamLane_Disp_Warn_Rq_AR_E2E_Armed == 1 )
    {
        if ( ( _CamLane_Disp_Warn_Rq_AR_MSG_DropCnt == 0      ) &&
             ( _CamLane_Disp_Warn_Rq_AR_CRC_ErrorCnt == 0     ) &&
             ( _CamLane_Disp_Warn_Rq_AR_SQC_RepeatedCnt == 0  ) &&
             ( _CamLane_Disp_Warn_Rq_AR_SQC_WrongSeqJump == 0 )    )
        {
            _CamLane_Disp_Warn_Rq_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_CamLane_Disp_Warn_Rq_State, 0 );
        }
    }
}

CamLane_Disp_Warn_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CamLane_Disp_Warn_Rq_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CamLane_Disp_Warn_Rq_AR := %X\n", getValue( HMI__STMSG_CamLane_Disp_Warn_Rq_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CamLane_Disp_Warn_Rq_AR := %X\n", getValue( HMI__STMSGT_CamLane_Disp_Warn_Rq_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_CamLane_Disp_Warn_Rq := %X\n", getValue( HMI_CRC_CamLane_Disp_Warn_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_CamLane_Disp_Warn_Rq_Auto := %X\n", getValue( HMI_CRC_CamLane_Disp_Warn_Rq_Auto ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_CamLane_Disp_Warn_Rq_Profile_02 := %X\n", getValue( HMI_CRC_CamLane_Disp_Warn_Rq_Profile_02 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CrossWalk_Dist := %X\n", getValue( HMI_CrossWalk_Dist ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CrossWalk_Stat := %X\n", getValue( HMI_CrossWalk_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_IndLmp_SwLED_HU_Rq_MPC := %X\n", getValue( HMI_LDP_IndLmp_SwLED_HU_Rq_MPC ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_MPC_Md_Stat := %X\n", getValue( HMI_LDP_MPC_Md_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_MPC_MsgDisp_Rq := %X\n", getValue( HMI_LDP_MPC_MsgDisp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PavemntSign_LtrlDist_EgoLane := %X\n", getValue( HMI_PavemntSign_LtrlDist_EgoLane ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PavemntSign_LtrlDist_NghbrLane := %X\n", getValue( HMI_PavemntSign_LtrlDist_NghbrLane ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PavemntSign_Type_EgoLane := %X\n", getValue( HMI_PavemntSign_Type_EgoLane ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PavemntSign_Type_NghbrLane := %X\n", getValue( HMI_PavemntSign_Type_NghbrLane ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv4_CamLane_Disp_Warn_Rq := %X\n", getValue( HMI_Rsrv4_CamLane_Disp_Warn_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_CamLane_Disp_Warn_Rq := %X\n", getValue( HMI_SQC_CamLane_Disp_Warn_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_CamLane_Disp_Warn_Rq_Auto := %X\n", getValue( HMI_SQC_CamLane_Disp_Warn_Rq_Auto ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ALDW_MPC_Md_Stat := %X\n", getValue( HMI_ALDW_MPC_Md_Stat ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_Sensitive_Md_MPC_Stat := %X\n", getValue( HMI_LDP_Sensitive_Md_MPC_Stat ) );        filePutString( buffer, elcount(buffer), hFile);
}

on timer _tCamLane_Disp_Warn_Rq_AR
{
    putValue( HMI__STMSG_CamLane_Disp_Warn_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_CamLane_Disp_Warn_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CamLane_Disp_Warn_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tCamLane_Disp_Warn_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_CamLane_Disp_Warn_Rq_AR, 0 );
    }
}

on envVar HMI_E2E_CamLane_Disp_Warn_Rq_Inject
{
    if( getValue( this ) )
    {
        _CamLane_Disp_Warn_Rq_AR_CRC_ErrorCnt = getValue( HMI_CRC_CamLane_Disp_Warn_Rq_ErrorCount );
        _CamLane_Disp_Warn_Rq_AR_SQC_TriggPos = getValue( HMI_SQC_CamLane_Disp_Warn_Rq_TriggerPosition );
        _CamLane_Disp_Warn_Rq_AR_SQC_WrongSeqJump = getValue( HMI_SQC_CamLane_Disp_Warn_Rq_WrongSeq );
        _CamLane_Disp_Warn_Rq_AR_SQC_RepeatedCnt = getValue( HMI_SQC_CamLane_Disp_Warn_Rq_Repeated );
        _CamLane_Disp_Warn_Rq_AR_MSG_DropCnt = getValue( HMI_SQC_CamLane_Disp_Warn_Rq_MSG_DropCnt );
        putValue( HMI_E2E_CamLane_Disp_Warn_Rq_State, 2 );
        _CamLane_Disp_Warn_Rq_AR_E2E_Armed = 2;  //armed
    }
}

on envVar HMI__STMSG_PO_CamLane_Disp_Warn_Rq_AR
{
    if( getValue( this ) )
        openPanel("CamLane_Disp_Warn_Rq_AR");
}

on EnvVar HMI_CrossWalk_Dist
{
    _mCamLane_Disp_Warn_Rq_AR.CrossWalk_Dist.phys = getValue(this);
    _CamLane_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CrossWalk_Stat
{
    _mCamLane_Disp_Warn_Rq_AR.CrossWalk_Stat.phys = getValue(this);
    _CamLane_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDP_IndLmp_SwLED_HU_Rq_MPC
{
    _mCamLane_Disp_Warn_Rq_AR.LDP_IndLmp_SwLED_HU_Rq_MPC.phys = getValue(this);
    _CamLane_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDP_MPC_Md_Stat
{
    _mCamLane_Disp_Warn_Rq_AR.LDP_MPC_Md_Stat.phys = getValue(this);
    _CamLane_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDP_MPC_MsgDisp_Rq
{
    _mCamLane_Disp_Warn_Rq_AR.LDP_MPC_MsgDisp_Rq.phys = getValue(this);
    _CamLane_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PavemntSign_LtrlDist_EgoLane
{
    _mCamLane_Disp_Warn_Rq_AR.PavemntSign_LtrlDist_EgoLane.phys = getValue(this);
    _CamLane_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PavemntSign_LtrlDist_NghbrLane
{
    _mCamLane_Disp_Warn_Rq_AR.PavemntSign_LtrlDist_NghbrLane.phys = getValue(this);
    _CamLane_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PavemntSign_Type_EgoLane
{
    _mCamLane_Disp_Warn_Rq_AR.PavemntSign_Type_EgoLane.phys = getValue(this);
    _CamLane_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PavemntSign_Type_NghbrLane
{
    _mCamLane_Disp_Warn_Rq_AR.PavemntSign_Type_NghbrLane.phys = getValue(this);
    _CamLane_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv3_CamLane_Disp_Warn_Rq
{
    _mCamLane_Disp_Warn_Rq_AR.Rsrv3_CamLane_Disp_Warn_Rq.phys = getValue(this);
    _CamLane_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv4_CamLane_Disp_Warn_Rq
{
    _mCamLane_Disp_Warn_Rq_AR.Rsrv4_CamLane_Disp_Warn_Rq.phys = getValue(this);
    _CamLane_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ALDW_MPC_Md_Stat
{
    _mCamLane_Disp_Warn_Rq_AR.ALDW_MPC_Md_Stat.phys = getValue(this);
    _CamLane_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDP_Sensitive_Md_MPC_Stat
{
    _mCamLane_Disp_Warn_Rq_AR.LDP_Sensitive_Md_MPC_Stat.phys = getValue(this);
    _CamLane_Disp_Warn_Rq_AR_SpontanFlag = 1;
}

CamLane_LaneAttr7_AR_check_output()
{
    if( !getValue( HMI__STMSG_CamLane_LaneAttr7_AR ) )
        {
        //  message   CamLane_LaneAttr7_AR ID: 486 --- Sendeart 0 cyclicX --- 
            _CamLane_LaneAttr7_AR_Cnt--;
            if( _CamLane_LaneAttr7_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                CamLane_LaneAttr7_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _CamLane_LaneAttr7_AR_Cnt = _CamLane_LaneAttr7_AR_CycleCount;
            }
        }
}

CamLane_LaneAttr7_AR_init()
{   /* Botschaft CamLane_LaneAttr7_AR ID: 486 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 486 0;
BA_ "NmAsrMessage" BO_ 486 0;
BA_ "GenMsgMinAcceptLength" BO_ 486 8;
BA_ "GenMsgILSupport" BO_ 486 1;
BA_ "DiagState" BO_ 486 0;
BA_ "DiagRequest" BO_ 486 0;
BA_ "DiagResponse" BO_ 486 0;
BA_ "GenMsgStartValue" BO_ 486 "0";
BA_ "GenMsgCycleTime" BO_ 486 40;
BA_ "GenMsgSendType" BO_ 486 0;
    */
    _CamLane_LaneAttr7_AR_Timebase =      c_tDBKomTimer_20ms;
    _CamLane_LaneAttr7_AR_CycleCount =     40 / _CamLane_LaneAttr7_AR_Timebase;
    _CamLane_LaneAttr7_AR_StartDelay =      0 / _CamLane_LaneAttr7_AR_Timebase;
    _CamLane_LaneAttr7_AR_Cnt = _CamLane_LaneAttr7_AR_StartDelay;
    _CamLane_LaneAttr7_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CamLane_LaneAttr7_AR, _CamLane_LaneAttr7_AR_StartDelay * _CamLane_LaneAttr7_AR_Timebase );

    _mCamLane_LaneAttr7_AR.ALDW_LDP_PulseTm_Rq.phys = getValue( HMI_ALDW_LDP_PulseTm_Rq );
    _mCamLane_LaneAttr7_AR.ALDW_LDP_VibTm_Rq.phys = getValue( HMI_ALDW_LDP_VibTm_Rq );
    _mCamLane_LaneAttr7_AR.ALDW_LDP_Warn_Rq.phys = getValue( HMI_ALDW_LDP_Warn_Rq1 );
	  _mCamLane_LaneAttr7_AR.CamLane_LaneAttr7_TmStmp.phys = getValue( HMI_CamLane_LaneAttr7_TmStmp );
    _mCamLane_LaneAttr7_AR.CamLane_LaneMark_DtctDist_Lt.phys = getValue( HMI_CamLane_LaneMark_DtctDist_Lt );
    _mCamLane_LaneAttr7_AR.CamLane_LaneMark_DtctDist_Rt.phys = getValue( HMI_CamLane_LaneMark_DtctDist_Rt );
	  _mCamLane_LaneAttr7_AR.CamLane_LaneMarkWidth_Lt.phys = getValue( HMI_CamLane_LaneMarkWidth_Lt );
    _mCamLane_LaneAttr7_AR.CamLane_LaneMarkWidth_Rt.phys = getValue( HMI_CamLane_LaneMarkWidth_Rt );
    _mCamLane_LaneAttr7_AR.CamLane_LaneSiteDtct_Stat.phys = getValue( HMI_CamLane_LaneSiteDtct_Stat );
	  _mCamLane_LaneAttr7_AR.CamLane_Stat.phys = getValue( HMI_CamLane_Stat );
    _mCamLane_LaneAttr7_AR.LDP_BrkMsgDisp_Rq_MPC.phys = getValue( HMI_LDP_BrkMsgDisp_Rq_MPC1 );
    _mCamLane_LaneAttr7_AR.Rsrv2_ALDW_LaneAttr7.phys = getValue( HMI_Rsrv2_ALDW_LaneAttr7 );
	
}

CamLane_LaneAttr7_AR_output(void)
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_CamLane_LaneAttr7 ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_CamLane_LaneAttr7_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _CamLane_LaneAttr7_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _CamLane_LaneAttr7_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_CamLane_LaneAttr7_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _CamLane_LaneAttr7_AR_SQC_WrongSeqJump != 0 ) &&
            ( _CamLane_LaneAttr7_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _CamLane_LaneAttr7_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _CamLane_LaneAttr7_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _CamLane_LaneAttr7_AR_SQC_RepeatedCnt ) &&
            ( _CamLane_LaneAttr7_AR_E2E_Armed == 1  )    )
        {
            _CamLane_LaneAttr7_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_CamLane_LaneAttr7, SQC_help );
    }
    _mCamLane_LaneAttr7_AR.SQC_CamLane_LaneAttr7 = SQC_help;

    if( getValue( HMI_CRC_CamLane_LaneAttr7_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_CamLane_LaneAttr7_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr7_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr7_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr7_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr7_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr7_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr7_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr7_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr7_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _CamLane_LaneAttr7_AR_CRC_Offset[ _mCamLane_LaneAttr7_AR.SQC_CamLane_LaneAttr7 ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _CamLane_LaneAttr7_AR_CRC_ErrorCnt   && ( _CamLane_LaneAttr7_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_CamLane_LaneAttr7_Invalid )                                         )    )
            {
                crc++;
                if( _CamLane_LaneAttr7_AR_CRC_ErrorCnt > 0 )
                    _CamLane_LaneAttr7_AR_CRC_ErrorCnt--; 
            }
            _mCamLane_LaneAttr7_AR.CRC_CamLane_LaneAttr7 = crc;
            putValue( HMI_CRC_CamLane_LaneAttr7, crc );
        }
        else
            _mCamLane_LaneAttr7_AR.CRC_CamLane_LaneAttr7 = getValue( HMI_CRC_CamLane_LaneAttr7 );
    }
    else
    {
        if( !getValue( HMI_CRC_CamLane_LaneAttr7_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mCamLane_LaneAttr7_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mCamLane_LaneAttr7_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mCamLane_LaneAttr7_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mCamLane_LaneAttr7_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mCamLane_LaneAttr7_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mCamLane_LaneAttr7_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mCamLane_LaneAttr7_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mCamLane_LaneAttr7_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _CamLane_LaneAttr7_AR_CRC_ErrorCnt   && ( _CamLane_LaneAttr7_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_CamLane_LaneAttr7_Invalid )                                         )    )
            {
                crc++;
                if( _CamLane_LaneAttr7_AR_CRC_ErrorCnt > 0 )
                    _CamLane_LaneAttr7_AR_CRC_ErrorCnt--; 
            }
            _mCamLane_LaneAttr7_AR.CRC_CamLane_LaneAttr7 = crc;
            putValue( HMI_CRC_CamLane_LaneAttr7, crc );
        }
        else
            _mCamLane_LaneAttr7_AR.CRC_CamLane_LaneAttr7 = getValue( HMI_CRC_CamLane_LaneAttr7 );
    }
    if( ( _CamLane_LaneAttr7_AR_MSG_DropCnt > 0 ) &&
        ( _CamLane_LaneAttr7_AR_E2E_Armed == 1  )    )
    {
        _CamLane_LaneAttr7_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mCamLane_LaneAttr7_AR );
        
    if( _CamLane_LaneAttr7_AR_E2E_Armed == 1 )
    {
        if ( ( _CamLane_LaneAttr7_AR_MSG_DropCnt == 0      ) &&
             ( _CamLane_LaneAttr7_AR_CRC_ErrorCnt == 0     ) &&
             ( _CamLane_LaneAttr7_AR_SQC_RepeatedCnt == 0  ) &&
             ( _CamLane_LaneAttr7_AR_SQC_WrongSeqJump == 0 )    )
        {
            _CamLane_LaneAttr7_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_CamLane_LaneAttr7_State, 0 );
        }
    }
}

CamLane_LaneAttr7_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CamLane_LaneAttr7_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CamLane_LaneAttr7_AR := %X\n", getValue( HMI__STMSG_CamLane_LaneAttr7_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CamLane_LaneAttr7_AR := %X\n", getValue( HMI__STMSGT_CamLane_LaneAttr7_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ALDW_LDP_PulseTm_Rq  := %X\n", getValue( HMI_ALDW_LDP_PulseTm_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ALDW_LDP_VibTm_Rq  := %X\n", getValue( HMI_ALDW_LDP_VibTm_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ALDW_LDP_Warn_Rq  := %X\n", getValue( HMI_ALDW_LDP_Warn_Rq1 ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneAttr7_TmStmp  := %X\n", getValue( HMI_CamLane_LaneAttr7_TmStmp ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneMark_DtctDist_Lt  := %X\n", getValue( HMI_CamLane_LaneMark_DtctDist_Lt ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneMark_DtctDist_Rt  := %X\n", getValue( HMI_CamLane_LaneMark_DtctDist_Rt ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneMarkWidth_Lt  := %X\n", getValue( HMI_CamLane_LaneMarkWidth_Lt ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneMarkWidth_Rt  := %X\n", getValue( HMI_CamLane_LaneMarkWidth_Rt ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneSiteDtct_Stat  := %X\n", getValue( HMI_CamLane_LaneSiteDtct_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_Stat  := %X\n", getValue( HMI_CamLane_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_BrkMsgDisp_Rq_MPC  := %X\n", getValue( HMI_LDP_BrkMsgDisp_Rq_MPC1 ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_ALDW_LaneAttr7  := %X\n", getValue( HMI_Rsrv2_ALDW_LaneAttr7 ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tCamLane_LaneAttr7_AR
{
    putValue( HMI__STMSG_CamLane_LaneAttr7_AR, 0 );
}

on EnvVar HMI__STMSG_CamLane_LaneAttr7_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CamLane_LaneAttr7_AR );
        if( tDelay > 0)    
            setTimer( _tCamLane_LaneAttr7_AR, tDelay );
        else
            putValue( HMI__STMSG_CamLane_LaneAttr7_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CamLane_LaneAttr7_AR
{
    if( getValue( this ) )
        openPanel("CamLane_LaneAttr7_AR");
}

on EnvVar HMI_ALDW_LDP_PulseTm_Rq
{
    _mCamLane_LaneAttr7_AR.ALDW_LDP_PulseTm_Rq.phys = getValue(this);
}

on EnvVar HMI_ALDW_LDP_VibTm_Rq
{
    _mCamLane_LaneAttr7_AR.ALDW_LDP_VibTm_Rq.phys = getValue(this);
}

on EnvVar HMI_CamLane_LaneAttr7_TmStmp
{
    _mCamLane_LaneAttr7_AR.CamLane_LaneAttr7_TmStmp.phys = getValue(this);
}

on EnvVar HMI_CamLane_LaneMark_DtctDist_Lt
{
    _mCamLane_LaneAttr7_AR.CamLane_LaneMark_DtctDist_Lt.phys = getValue(this);
}

on EnvVar HMI_CamLane_LaneMark_DtctDist_Rt
{
    _mCamLane_LaneAttr7_AR.CamLane_LaneMark_DtctDist_Rt.phys = getValue(this);
}

on EnvVar HMI_CamLane_LaneMarkWidth_Lt
{
    _mCamLane_LaneAttr7_AR.CamLane_LaneMarkWidth_Lt.phys = getValue(this);
}

on EnvVar HMI_CamLane_LaneMarkWidth_Rt
{
    _mCamLane_LaneAttr7_AR.CamLane_LaneMarkWidth_Rt.phys = getValue(this);
}

on EnvVar HMI_CamLane_LaneSiteDtct_Stat
{
    _mCamLane_LaneAttr7_AR.CamLane_LaneSiteDtct_Stat.phys = getValue(this);
}

on EnvVar HMI_CamLane_Stat
{
    _mCamLane_LaneAttr7_AR.CamLane_Stat.phys = getValue(this);
}

on EnvVar HMI_Rsrv2_ALDW_LaneAttr7
{
    _mCamLane_LaneAttr7_AR.Rsrv2_ALDW_LaneAttr7.phys = getValue(this);
}

//CHASS_PERIPH_HMI_Camlane_R1_AR_check_output()
//{
//    if( !getValue( HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R1_AR ) )
//        {
//        //  message   CHASS_PERIPH_HMI_Camlane_R1_AR ID: 382 --- Sendeart 0 cyclicX --- 
//            _CHASS_PERIPH_HMI_Camlane_R1_AR_Cnt--;
//            if( _CHASS_PERIPH_HMI_Camlane_R1_AR_Cnt < 1 )
//            {
//                // Nachricht wg. abgelaufenem Zyklus ausgeben
//                CHASS_PERIPH_HMI_Camlane_R1_AR_output();
//                // Zyklus-Z�hler zur�cksetzen
//                _CHASS_PERIPH_HMI_Camlane_R1_AR_Cnt = _CHASS_PERIPH_HMI_Camlane_R1_AR_CycleCount;
//            }
//        }
//}
//
//CHASS_PERIPH_HMI_Camlane_R1_AR_init()
//{   /* Botschaft CHASS_PERIPH_HMI_Camlane_R1_AR ID: 382 --- Sendeart 0 cyclicX --- 
//BA_ "ApplMessage" BO_ 382 0;
//BA_ "NmAsrMessage" BO_ 382 0;
//BA_ "GenMsgMinAcceptLength" BO_ 382 8;
//BA_ "GenMsgILSupport" BO_ 382 1;
//BA_ "DiagState" BO_ 382 0;
//BA_ "DiagRequest" BO_ 382 0;
//BA_ "DiagResponse" BO_ 382 0;
//BA_ "GenMsgStartValue" BO_ 382 "0";
//BA_ "GenMsgStartDelayTime" BO_ 382 25;
//BA_ "GenMsgCycleTime" BO_ 382 80;
//BA_ "GenMsgSendType" BO_ 382 0;
//    */
//    _CHASS_PERIPH_HMI_Camlane_R1_AR_Timebase =      c_tDBKomTimer_20ms;
//    _CHASS_PERIPH_HMI_Camlane_R1_AR_CycleCount =   80 / _CHASS_PERIPH_HMI_Camlane_R1_AR_Timebase;
//    _CHASS_PERIPH_HMI_Camlane_R1_AR_StartDelay =      25 / _CHASS_PERIPH_HMI_Camlane_R1_AR_Timebase;
//    _CHASS_PERIPH_HMI_Camlane_R1_AR_Cnt = _CHASS_PERIPH_HMI_Camlane_R1_AR_StartDelay;
//    _CHASS_PERIPH_HMI_Camlane_R1_AR_SpontanFlag = 0;
//
//    putValue( HMI__STMSGSD_CHASS_PERIPH_HMI_Camlane_R1_AR, _CHASS_PERIPH_HMI_Camlane_R1_AR_StartDelay * _CHASS_PERIPH_HMI_Camlane_R1_AR_Timebase );
//
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.ALDW_LDP_Warn_Rq.phys = getValue( HMI_ALDW_LDP_Warn_Rq_ );
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_LaneAttr1_UB.phys = getValue( HMI_CamLane_LaneAttr1_UB_ );
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_LaneAttr7_UB.phys = getValue( HMI_CamLane_LaneAttr7_UB_ );
//	  _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_LaneChg_Stat.phys = getValue( HMI_CamLane_LaneChg_Stat_ );
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_LaneDataQual_Lt.phys = getValue( HMI_CamLane_LaneDataQual_Lt_ );
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_LaneDataQual_Rt.phys = getValue( HMI_CamLane_LaneDataQual_Rt_ );
//	  _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_LaneLtrlDist_Lt.phys = getValue( HMI_CamLane_LaneLtrlDist_Lt_ );
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_LaneLtrlDist_Rt.phys = getValue( HMI_CamLane_LaneLtrlDist_Rt_ );
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_LaneMark_DtctDist_Lt.phys = getValue( HMI_CamLane_LaneMark_DtctDist_Lt_ );
//	  _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_LaneMark_DtctDist_Rt.phys = getValue( HMI_CamLane_LaneMark_DtctDist_Rt_ );
//	  _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_RoadExit_Stat.phys = getValue( HMI_CamLane_RoadExit_Stat_ );
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.LDP_BrkMsgDisp_Rq_MPC.phys = getValue( HMI_LDP_BrkMsgDisp_Rq_MPC_ );
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.NghbrLane_Lt_Stat.phys = getValue( HMI_NghbrLane_Lt_Stat_ );
//	  _mCHASS_PERIPH_HMI_Camlane_R1_AR.NghbrLane_Lt_Width.phys = getValue( HMI_NghbrLane_Lt_Width_ );
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.NghbrLane_Rt_Stat.phys = getValue( HMI_NghbrLane_Rt_Stat_ );
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.NghbrLane_Rt_Width.phys = getValue( HMI_NghbrLane_Rt_Width_ );
//}
//
//CHASS_PERIPH_HMI_Camlane_R1_AR_output(void)
//{
//    output( _mCHASS_PERIPH_HMI_Camlane_R1_AR );
//}
//
//CHASS_PERIPH_HMI_Camlane_R1_AR_saveEnvVars( dword hFile )
//{
//    filePutString("\n// Knoten EIS: CHASS_PERIPH_HMI_Camlane_R1_AR\n", 36, hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R1_AR := %X\n", getValue( HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CHASS_PERIPH_HMI_Camlane_R1_AR := %X\n", getValue( HMI__STMSGT_CHASS_PERIPH_HMI_Camlane_R1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ALDW_LDP_Warn_Rq  := %X\n", getValue( HMI_ALDW_LDP_Warn_Rq_ ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneAttr1_UB  := %X\n", getValue( HMI_CamLane_LaneAttr1_UB_ ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneAttr7_UB  := %X\n", getValue( HMI_CamLane_LaneAttr7_UB_ ) );        filePutString ( buffer, elcount( buffer ), hFile );
//	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneChg_Stat  := %X\n", getValue( HMI_CamLane_LaneChg_Stat_ ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneDataQual_Lt  := %X\n", getValue( HMI_CamLane_LaneDataQual_Lt_ ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneDataQual_Rt  := %X\n", getValue( HMI_CamLane_LaneDataQual_Rt_ ) );        filePutString ( buffer, elcount( buffer ), hFile );
//	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneLtrlDist_Lt  := %X\n", getValue( HMI_CamLane_LaneLtrlDist_Lt_ ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneLtrlDist_Rt  := %X\n", getValue( HMI_CamLane_LaneLtrlDist_Rt_ ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneMark_DtctDist_Lt  := %X\n", getValue( HMI_CamLane_LaneMark_DtctDist_Lt_ ) );        filePutString ( buffer, elcount( buffer ), hFile );
//	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneMark_DtctDist_Rt  := %X\n", getValue( HMI_CamLane_LaneMark_DtctDist_Rt_ ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_RoadExit_Stat  := %X\n", getValue( HMI_CamLane_RoadExit_Stat_ ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_BrkMsgDisp_Rq_MPC  := %X\n", getValue( HMI_LDP_BrkMsgDisp_Rq_MPC_ ) );        filePutString ( buffer, elcount( buffer ), hFile );
//	snprintf( buffer, elcount( buffer ), "0.0000 HMI_NghbrLane_Lt_Stat  := %X\n", getValue( HMI_NghbrLane_Lt_Stat_ ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_NghbrLane_Lt_Width  := %X\n", getValue( HMI_NghbrLane_Lt_Width_ ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_NghbrLane_Rt_Stat  := %X\n", getValue( HMI_NghbrLane_Rt_Stat_ ) );        filePutString ( buffer, elcount( buffer ), hFile );
//	snprintf( buffer, elcount( buffer ), "0.0000 HMI_NghbrLane_Rt_Width  := %X\n", getValue( HMI_NghbrLane_Rt_Width_ ) );        filePutString ( buffer, elcount( buffer ), hFile );
//}
//
//on timer _tCHASS_PERIPH_HMI_Camlane_R1_AR
//{
//    putValue( HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R1_AR, 0 );
//}
//
//on EnvVar HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R1_AR
//{
//    long tDelay;
//    if( getValue( this ) == 2 )
//    {
//        tDelay = getValue( HMI__STMSGT_CHASS_PERIPH_HMI_Camlane_R1_AR );
//        if( tDelay > 0)    
//            setTimer( _tCHASS_PERIPH_HMI_Camlane_R1_AR, tDelay );
//        else
//            putValue( HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R1_AR, 0 );
//    }
//}
//
//on envVar HMI__STMSG_PO_CHASS_PERIPH_HMI_Camlane_R1_AR
//{
//    if( getValue( this ) )
//        openPanel("CHASS_PERIPH_HMI_Camlane_R1_AR");
//}
//
//on EnvVar HMI_ALDW_LDP_Warn_Rq_
//{
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.ALDW_LDP_Warn_Rq.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_LaneAttr1_UB_
//{
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_LaneAttr1_UB.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_LaneAttr7_UB_
//{
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_LaneAttr7_UB.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_LaneChg_Stat_
//{
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_LaneChg_Stat.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_LaneDataQual_Lt_
//{
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_LaneDataQual_Lt.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_LaneDataQual_Rt_
//{
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_LaneDataQual_Rt.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_LaneLtrlDist_Lt_
//{
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_LaneLtrlDist_Lt.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_LaneLtrlDist_Rt_
//{
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_LaneLtrlDist_Rt.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_LaneMark_DtctDist_Lt_
//{
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_LaneMark_DtctDist_Lt.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_LaneMark_DtctDist_Rt_
//{
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_LaneMark_DtctDist_Rt.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_RoadExit_Stat_
//{
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.CamLane_RoadExit_Stat.phys = getValue(this);
//}
//
//on EnvVar HMI_LDP_BrkMsgDisp_Rq_MPC_
//{
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.LDP_BrkMsgDisp_Rq_MPC.phys = getValue(this);
//}
//
//on EnvVar HMI_NghbrLane_Lt_Stat_
//{
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.NghbrLane_Lt_Stat.phys = getValue(this);
//}
//
//on EnvVar HMI_NghbrLane_Lt_Width_
//{
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.NghbrLane_Lt_Width.phys = getValue(this);
//}
//
//on EnvVar HMI_NghbrLane_Rt_Stat_
//{
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.NghbrLane_Rt_Stat.phys = getValue(this);
//}
//
//on EnvVar HMI_NghbrLane_Rt_Width_
//{
//    _mCHASS_PERIPH_HMI_Camlane_R1_AR.NghbrLane_Rt_Width.phys = getValue(this);
//}
//
//CHASS_PERIPH_HMI_Camlane_R2_AR_check_output()
//{
//    if( !getValue( HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R2_AR ) )
//        {
//        //  message   CHASS_PERIPH_HMI_Camlane_R2_AR ID: 387 --- Sendeart 0 cyclicX --- 
//            _CHASS_PERIPH_HMI_Camlane_R2_AR_Cnt--;
//            if( _CHASS_PERIPH_HMI_Camlane_R2_AR_Cnt < 1 )
//            {
//                // Nachricht wg. abgelaufenem Zyklus ausgeben
//                CHASS_PERIPH_HMI_Camlane_R2_AR_output();
//                // Zyklus-Z�hler zur�cksetzen
//                _CHASS_PERIPH_HMI_Camlane_R2_AR_Cnt = _CHASS_PERIPH_HMI_Camlane_R2_AR_CycleCount;
//            }
//        }
//}
//
//CHASS_PERIPH_HMI_Camlane_R2_AR_init()
//{   /* Botschaft CHASS_PERIPH_HMI_Camlane_R2_AR ID: 387 --- Sendeart 0 cyclicX --- 
//BA_ "ApplMessage" BO_ 387 0;
//BA_ "NmAsrMessage" BO_ 387 0;
//BA_ "GenMsgMinAcceptLength" BO_ 387 8;
//BA_ "GenMsgILSupport" BO_ 387 1;
//BA_ "DiagState" BO_ 387 0;
//BA_ "DiagRequest" BO_ 387 0;
//BA_ "DiagResponse" BO_ 387 0;
//BA_ "GenMsgStartValue" BO_ 387 "0";
//BA_ "GenMsgStartDelayTime" BO_ 387 45;
//BA_ "GenMsgCycleTime" BO_ 387 80;
//BA_ "GenMsgSendType" BO_ 387 0;
//    */
//    _CHASS_PERIPH_HMI_Camlane_R2_AR_Timebase =      c_tDBKomTimer_20ms;
//    _CHASS_PERIPH_HMI_Camlane_R2_AR_CycleCount =   80 / _CHASS_PERIPH_HMI_Camlane_R2_AR_Timebase;
//    _CHASS_PERIPH_HMI_Camlane_R2_AR_StartDelay =      45 / _CHASS_PERIPH_HMI_Camlane_R2_AR_Timebase;
//    _CHASS_PERIPH_HMI_Camlane_R2_AR_Cnt = _CHASS_PERIPH_HMI_Camlane_R2_AR_StartDelay;
//    _CHASS_PERIPH_HMI_Camlane_R2_AR_SpontanFlag = 0;
//
//    putValue( HMI__STMSGSD_CHASS_PERIPH_HMI_Camlane_R2_AR, _CHASS_PERIPH_HMI_Camlane_R2_AR_StartDelay * _CHASS_PERIPH_HMI_Camlane_R2_AR_Timebase );
//
//    _mCHASS_PERIPH_HMI_Camlane_R2_AR.CamLane_LaneAttr2_UB.phys = getValue( HMI_CamLane_LaneAttr2_UB );
//    _mCHASS_PERIPH_HMI_Camlane_R2_AR.CamLane_LaneAttr6_UB.phys = getValue( HMI_CamLane_LaneAttr6_UB );
//    _mCHASS_PERIPH_HMI_Camlane_R2_AR.CamLane_LaneHrztCrv_Lt.phys = getValue( HMI_CamLane_LaneHrztCrv_Lt );
//	_mCHASS_PERIPH_HMI_Camlane_R2_AR.CamLane_LaneHrztCrv_Rt.phys = getValue( HMI_CamLane_LaneHrztCrv_Rt );
//    _mCHASS_PERIPH_HMI_Camlane_R2_AR.CamLane_LaneMarkType_Lt.phys = getValue( HMI_CamLane_LaneMarkType_Lt );
//    _mCHASS_PERIPH_HMI_Camlane_R2_AR.CamLane_LaneMarkType_Rt.phys = getValue( HMI_CamLane_LaneMarkType_Rt );
//	_mCHASS_PERIPH_HMI_Camlane_R2_AR.NghbrLaneMarkType_Lt.phys = getValue( HMI_NghbrLaneMarkType_Lt );
//    _mCHASS_PERIPH_HMI_Camlane_R2_AR.NghbrLaneMarkType_Rt.phys = getValue( HMI_NghbrLaneMarkType_Rt );
//}
//
//CHASS_PERIPH_HMI_Camlane_R2_AR_output(void)
//{
//    output( _mCHASS_PERIPH_HMI_Camlane_R2_AR );
//}
//
//CHASS_PERIPH_HMI_Camlane_R2_AR_saveEnvVars( dword hFile )
//{
//    filePutString("\n// Knoten EIS: CHASS_PERIPH_HMI_Camlane_R2_AR\n", 36, hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R2_AR := %X\n", getValue( HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CHASS_PERIPH_HMI_Camlane_R2_AR := %X\n", getValue( HMI__STMSGT_CHASS_PERIPH_HMI_Camlane_R2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneAttr2_UB  := %X\n", getValue( HMI_CamLane_LaneAttr2_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneAttr6_UB  := %X\n", getValue( HMI_CamLane_LaneAttr6_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneHrztCrv_Lt  := %X\n", getValue( HMI_CamLane_LaneHrztCrv_Lt ) );        filePutString ( buffer, elcount( buffer ), hFile );
//	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneHrztCrv_Rt  := %X\n", getValue( HMI_CamLane_LaneHrztCrv_Rt ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneMarkType_Lt  := %X\n", getValue( HMI_CamLane_LaneMarkType_Lt ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneMarkType_Rt  := %X\n", getValue( HMI_CamLane_LaneMarkType_Rt ) );        filePutString ( buffer, elcount( buffer ), hFile );
//	snprintf( buffer, elcount( buffer ), "0.0000 HMI_NghbrLaneMarkType_Lt  := %X\n", getValue( HMI_NghbrLaneMarkType_Lt ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_NghbrLaneMarkType_Rt  := %X\n", getValue( HMI_NghbrLaneMarkType_Rt ) );        filePutString ( buffer, elcount( buffer ), hFile );
//}
//
//on timer _tCHASS_PERIPH_HMI_Camlane_R2_AR
//{
//    putValue( HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R2_AR, 0 );
//}
//
//on EnvVar HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R2_AR
//{
//    long tDelay;
//    if( getValue( this ) == 2 )
//    {
//        tDelay = getValue( HMI__STMSGT_CHASS_PERIPH_HMI_Camlane_R2_AR );
//        if( tDelay > 0)    
//            setTimer( _tCHASS_PERIPH_HMI_Camlane_R2_AR, tDelay );
//        else
//            putValue( HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R2_AR, 0 );
//    }
//}
//
//on envVar HMI__STMSG_PO_CHASS_PERIPH_HMI_Camlane_R2_AR
//{
//    if( getValue( this ) )
//        openPanel("CHASS_PERIPH_HMI_Camlane_R2_AR");
//}
//
//on EnvVar HMI_CamLane_LaneAttr2_UB
//{
//    _mCHASS_PERIPH_HMI_Camlane_R2_AR.CamLane_LaneAttr2_UB.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_LaneAttr6_UB
//{
//    _mCHASS_PERIPH_HMI_Camlane_R2_AR.CamLane_LaneAttr6_UB.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_LaneHrztCrv_Lt
//{
//    _mCHASS_PERIPH_HMI_Camlane_R2_AR.CamLane_LaneHrztCrv_Lt.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_LaneHrztCrv_Rt
//{
//    _mCHASS_PERIPH_HMI_Camlane_R2_AR.CamLane_LaneHrztCrv_Rt.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_LaneMarkType_Lt
//{
//    _mCHASS_PERIPH_HMI_Camlane_R2_AR.CamLane_LaneMarkType_Lt.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_LaneMarkType_Rt
//{
//    _mCHASS_PERIPH_HMI_Camlane_R2_AR.CamLane_LaneMarkType_Rt.phys = getValue(this);
//}
//
//on EnvVar HMI_NghbrLaneMarkType_Lt
//{
//    _mCHASS_PERIPH_HMI_Camlane_R2_AR.NghbrLaneMarkType_Lt.phys = getValue(this);
//}
//
//on EnvVar HMI_NghbrLaneMarkType_Rt
//{
//    _mCHASS_PERIPH_HMI_Camlane_R2_AR.NghbrLaneMarkType_Rt.phys = getValue(this);
//}

//CHASS_PERIPH_HMI_Camlane_R3_AR_check_output()
//{
//    if( !getValue( HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R3_AR ) )
//        {
//        //  message   CHASS_PERIPH_HMI_Camlane_R3_AR ID: 399 --- Sendeart 0 cyclicX --- 
//            _CHASS_PERIPH_HMI_Camlane_R3_AR_Cnt--;
//            if( _CHASS_PERIPH_HMI_Camlane_R3_AR_Cnt < 1 )
//            {
//                // Nachricht wg. abgelaufenem Zyklus ausgeben
//                CHASS_PERIPH_HMI_Camlane_R3_AR_output();
//                // Zyklus-Z�hler zur�cksetzen
//                _CHASS_PERIPH_HMI_Camlane_R3_AR_Cnt = _CHASS_PERIPH_HMI_Camlane_R3_AR_CycleCount;
//            }
//        }
//}
//
//CHASS_PERIPH_HMI_Camlane_R3_AR_init()
//{   /* Botschaft CHASS_PERIPH_HMI_Camlane_R3_AR ID: 399 --- Sendeart 0 cyclicX --- 
//BA_ "ApplMessage" BO_ 399 0;
//BA_ "NmAsrMessage" BO_ 399 0;
//BA_ "GenMsgMinAcceptLength" BO_ 399 8;
//BA_ "GenMsgILSupport" BO_ 399 1;
//BA_ "DiagState" BO_ 399 0;
//BA_ "DiagRequest" BO_ 399 0;
//BA_ "DiagResponse" BO_ 399 0;
//BA_ "GenMsgStartValue" BO_ 399 "0";
//BA_ "GenMsgStartDelayTime" BO_ 399 55;
//BA_ "GenMsgCycleTime" BO_ 399 80;
//BA_ "GenMsgSendType" BO_ 399 0;
//    */
//    _CHASS_PERIPH_HMI_Camlane_R3_AR_Timebase =      c_tDBKomTimer_20ms;
//    _CHASS_PERIPH_HMI_Camlane_R3_AR_CycleCount =   80 / _CHASS_PERIPH_HMI_Camlane_R3_AR_Timebase;
//    _CHASS_PERIPH_HMI_Camlane_R3_AR_StartDelay =      55 / _CHASS_PERIPH_HMI_Camlane_R3_AR_Timebase;
//    _CHASS_PERIPH_HMI_Camlane_R3_AR_Cnt = _CHASS_PERIPH_HMI_Camlane_R3_AR_StartDelay;
//    _CHASS_PERIPH_HMI_Camlane_R3_AR_SpontanFlag = 0;
//
//    putValue( HMI__STMSGSD_CHASS_PERIPH_HMI_Camlane_R3_AR, _CHASS_PERIPH_HMI_Camlane_R3_AR_StartDelay * _CHASS_PERIPH_HMI_Camlane_R3_AR_Timebase );
//
//    _mCHASS_PERIPH_HMI_Camlane_R3_AR.CamLane_LaneAttr3_UB.phys = getValue( HMI_CamLane_LaneAttr3_UB );
//    _mCHASS_PERIPH_HMI_Camlane_R3_AR.CamLane_LaneClothoidPara_Lt.phys = getValue( HMI_CamLane_LaneClothoidPara_Lt );
//    _mCHASS_PERIPH_HMI_Camlane_R3_AR.CamLane_LaneClothoidPara_Rt.phys = getValue( HMI_CamLane_LaneClothoidPara_Rt );
//	  _mCHASS_PERIPH_HMI_Camlane_R3_AR.CamLane_LaneYawAngl_Lt.phys = getValue( HMI_CamLane_LaneYawAngl_Lt );
//    _mCHASS_PERIPH_HMI_Camlane_R3_AR.CamLane_LaneYawAngl_Rt.phys = getValue( HMI_CamLane_LaneYawAngl_Rt );
//
//}
//CHASS_PERIPH_HMI_Camlane_R3_AR_output(void)
//{
//    output( _mCHASS_PERIPH_HMI_Camlane_R3_AR );
//}
//
//CHASS_PERIPH_HMI_Camlane_R3_AR_saveEnvVars( dword hFile )
//{
//    filePutString("\n// Knoten EIS: CHASS_PERIPH_HMI_Camlane_R3_AR\n", 36, hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R3_AR := %X\n", getValue( HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R3_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CHASS_PERIPH_HMI_Camlane_R3_AR := %X\n", getValue( HMI__STMSGT_CHASS_PERIPH_HMI_Camlane_R3_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneAttr3_UB  := %X\n", getValue( HMI_CamLane_LaneAttr3_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneClothoidPara_Lt  := %X\n", getValue( HMI_CamLane_LaneClothoidPara_Lt ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneClothoidPara_Rt  := %X\n", getValue( HMI_CamLane_LaneClothoidPara_Rt ) );        filePutString ( buffer, elcount( buffer ), hFile );
//	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneYawAngl_Lt  := %X\n", getValue( HMI_CamLane_LaneYawAngl_Lt ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneYawAngl_Rt  := %X\n", getValue( HMI_CamLane_LaneYawAngl_Rt ) );        filePutString ( buffer, elcount( buffer ), hFile );
//}
//
//on timer _tCHASS_PERIPH_HMI_Camlane_R3_AR
//{
//    putValue( HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R3_AR, 0 );
//}
//
//on EnvVar HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R3_AR
//{
//    long tDelay;
//    if( getValue( this ) == 2 )
//    {
//        tDelay = getValue( HMI__STMSGT_CHASS_PERIPH_HMI_Camlane_R3_AR );
//        if( tDelay > 0)    
//            setTimer( _tCHASS_PERIPH_HMI_Camlane_R3_AR, tDelay );
//        else
//            putValue( HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R3_AR, 0 );
//    }
//}
//
//on envVar HMI__STMSG_PO_CHASS_PERIPH_HMI_Camlane_R3_AR
//{
//    if( getValue( this ) )
//        openPanel("CHASS_PERIPH_HMI_Camlane_R3_AR");
//}
//
//on EnvVar HMI_CamLane_LaneAttr3_UB
//{
//    _mCHASS_PERIPH_HMI_Camlane_R3_AR.CamLane_LaneAttr3_UB.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_LaneClothoidPara_Lt
//{
//    _mCHASS_PERIPH_HMI_Camlane_R3_AR.CamLane_LaneClothoidPara_Lt.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_LaneClothoidPara_Rt
//{
//    _mCHASS_PERIPH_HMI_Camlane_R3_AR.CamLane_LaneClothoidPara_Rt.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_LaneYawAngl_Lt
//{
//    _mCHASS_PERIPH_HMI_Camlane_R3_AR.CamLane_LaneYawAngl_Lt.phys = getValue(this);
//}
//
//on EnvVar HMI_CamLane_LaneYawAngl_Rt
//{
//    _mCHASS_PERIPH_HMI_Camlane_R3_AR.CamLane_LaneYawAngl_Rt.phys = getValue(this);
//}

CHASSIS_HMI_Radar_R1_AR_check_output()
{
    if( !getValue( HMI__STMSG_CHASSIS_HMI_Radar_R1_AR ) )
        {
        //  message   CHASSIS_HMI_Radar_R1_AR ID: 1066 --- Sendeart 0 cyclicX --- 
            _CHASSIS_HMI_Radar_R1_AR_Cnt--;
            if( _CHASSIS_HMI_Radar_R1_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                CHASSIS_HMI_Radar_R1_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _CHASSIS_HMI_Radar_R1_AR_Cnt = _CHASSIS_HMI_Radar_R1_AR_CycleCount;
            }
        }
}

CHASSIS_HMI_Radar_R1_AR_init()
{   /* Botschaft CHASSIS_HMI_Radar_R1_AR ID: 1066 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 1066 0;
BA_ "NmAsrMessage" BO_ 1066 0;
BA_ "GenMsgMinAcceptLength" BO_ 1066 8;
BA_ "GenMsgILSupport" BO_ 1066 1;
BA_ "DiagState" BO_ 1066 0;
BA_ "DiagRequest" BO_ 1066 0;
BA_ "DiagResponse" BO_ 1066 0;
BA_ "GenMsgStartValue" BO_ 1066 "0";
BA_ "GenMsgStartDelayTime" BO_ 1066 75;
BA_ "GenMsgCycleTime" BO_ 1066 500;
BA_ "GenMsgSendType" BO_ 1066 0;
    */
    _CHASSIS_HMI_Radar_R1_AR_Timebase =      c_tDBKomTimer_20ms;
    _CHASSIS_HMI_Radar_R1_AR_CycleCount =   100 / _CHASSIS_HMI_Radar_R1_AR_Timebase;
    _CHASSIS_HMI_Radar_R1_AR_StartDelay =      75 / _CHASSIS_HMI_Radar_R1_AR_Timebase;
    _CHASSIS_HMI_Radar_R1_AR_Cnt = _CHASSIS_HMI_Radar_R1_AR_StartDelay;
    _CHASSIS_HMI_Radar_R1_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CHASSIS_HMI_Radar_R1_AR, _CHASSIS_HMI_Radar_R1_AR_StartDelay * _CHASSIS_HMI_Radar_R1_AR_Timebase );

    _mCHASSIS_HMI_Radar_R1_AR.Radar_DistRdBorder_MaxNegDev_Lt.phys = getValue( HMI_Radar_DistRdBorder_MaxNegDev_Lt );
    _mCHASSIS_HMI_Radar_R1_AR.Radar_DistRdBorder_MaxNegDev_Rt.phys = getValue( HMI_Radar_DistRdBorder_MaxNegDev_Rt );
    _mCHASSIS_HMI_Radar_R1_AR.Radar_DistRoadBorder_Lt.phys = getValue( HMI_Radar_DistRoadBorder_Lt );
	_mCHASSIS_HMI_Radar_R1_AR.Radar_DistRoadBorder_Rt.phys = getValue( HMI_Radar_DistRoadBorder_Rt );
    _mCHASSIS_HMI_Radar_R1_AR.Radar_Info_UB.phys = getValue( HMI_Radar_Info_UB );

}

CHASSIS_HMI_Radar_R1_AR_output(void)
{
    output( _mCHASSIS_HMI_Radar_R1_AR );
}

CHASSIS_HMI_Radar_R1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CHASSIS_HMI_Radar_R1_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CHASSIS_HMI_Radar_R1_AR := %X\n", getValue( HMI__STMSG_CHASSIS_HMI_Radar_R1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CHASSIS_HMI_Radar_R1_AR := %X\n", getValue( HMI__STMSGT_CHASSIS_HMI_Radar_R1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_DistRdBorder_MaxNegDev_Lt  := %X\n", getValue( HMI_Radar_DistRdBorder_MaxNegDev_Lt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_DistRdBorder_MaxNegDev_Rt  := %X\n", getValue( HMI_Radar_DistRdBorder_MaxNegDev_Rt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_DistRoadBorder_Lt  := %X\n", getValue( HMI_Radar_DistRoadBorder_Lt ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_DistRoadBorder_Rt  := %X\n", getValue( HMI_Radar_DistRoadBorder_Rt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_Info_UB  := %X\n", getValue( HMI_Radar_Info_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tCHASSIS_HMI_Radar_R1_AR
{
    putValue( HMI__STMSG_CHASSIS_HMI_Radar_R1_AR, 0 );
}

on EnvVar HMI__STMSG_CHASSIS_HMI_Radar_R1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CHASSIS_HMI_Radar_R1_AR );
        if( tDelay > 0)    
            setTimer( _tCHASSIS_HMI_Radar_R1_AR, tDelay );
        else
            putValue( HMI__STMSG_CHASSIS_HMI_Radar_R1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CHASSIS_HMI_Radar_R1_AR
{
    if( getValue( this ) )
        openPanel("CHASSIS_HMI_Radar_R1_AR");
}

on EnvVar HMI_Radar_DistRdBorder_MaxNegDev_Lt
{
    _mCHASSIS_HMI_Radar_R1_AR.Radar_DistRdBorder_MaxNegDev_Lt.phys = getValue(this);
}

on EnvVar HMI_Radar_DistRdBorder_MaxNegDev_Rt
{
    _mCHASSIS_HMI_Radar_R1_AR.Radar_DistRdBorder_MaxNegDev_Rt.phys = getValue(this);
}

on EnvVar HMI_Radar_DistRoadBorder_Lt
{
    _mCHASSIS_HMI_Radar_R1_AR.Radar_DistRoadBorder_Lt.phys = getValue(this);
}

on EnvVar HMI_Radar_DistRoadBorder_Rt
{
    _mCHASSIS_HMI_Radar_R1_AR.Radar_DistRoadBorder_Rt.phys = getValue(this);
}

on EnvVar HMI_Radar_Info_UB
{
    _mCHASSIS_HMI_Radar_R1_AR.Radar_Info_UB.phys = getValue(this);
}

CHASSIS_HMI_Radar_R2_AR_check_output()
{
    if( !getValue( HMI__STMSG_CHASSIS_HMI_Radar_R2_AR ) )
        {
        //  message   CHASSIS_HMI_Radar_R2_AR ID: 1080 --- Sendeart 0 cyclicX --- 
            _CHASSIS_HMI_Radar_R2_AR_Cnt--;
            if( _CHASSIS_HMI_Radar_R2_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                CHASSIS_HMI_Radar_R2_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _CHASSIS_HMI_Radar_R2_AR_Cnt = _CHASSIS_HMI_Radar_R2_AR_CycleCount;
            }
        }
}

CHASSIS_HMI_Radar_R2_AR_init()
{   /* Botschaft CHASSIS_HMI_Radar_R2_AR ID: 1080 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 1080 0;
BA_ "NmAsrMessage" BO_ 1080 0;
BA_ "GenMsgMinAcceptLength" BO_ 1080 8;
BA_ "GenMsgILSupport" BO_ 1080 1;
BA_ "DiagState" BO_ 1080 0;
BA_ "DiagRequest" BO_ 1080 0;
BA_ "DiagResponse" BO_ 1080 0;
BA_ "GenMsgStartValue" BO_ 1080 "0";
BA_ "GenMsgStartDelayTime" BO_ 1080 105;
BA_ "GenMsgCycleTime" BO_ 1080 500;
BA_ "GenMsgSendType" BO_ 1080 0;
    */
    _CHASSIS_HMI_Radar_R2_AR_Timebase =      c_tDBKomTimer_20ms;
    _CHASSIS_HMI_Radar_R2_AR_CycleCount =   500 / _CHASSIS_HMI_Radar_R2_AR_Timebase;
    _CHASSIS_HMI_Radar_R2_AR_StartDelay =      105 / _CHASSIS_HMI_Radar_R2_AR_Timebase;
    _CHASSIS_HMI_Radar_R2_AR_Cnt = _CHASSIS_HMI_Radar_R2_AR_StartDelay;
    _CHASSIS_HMI_Radar_R2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CHASSIS_HMI_Radar_R2_AR, _CHASSIS_HMI_Radar_R2_AR_StartDelay * _CHASSIS_HMI_Radar_R2_AR_Timebase );

    _mCHASSIS_HMI_Radar_R2_AR.Radar_LT1_Obj_Attr1_UB.phys = getValue( HMI_Radar_LT1_Obj_Attr1_UB );
    _mCHASSIS_HMI_Radar_R2_AR.Radar_LT1_Obj_Attr2_UB.phys = getValue( HMI_Radar_LT1_Obj_Attr2_UB );
    _mCHASSIS_HMI_Radar_R2_AR.Radar_LT1_Obj_Class.phys = getValue( HMI_Radar_LT1_Obj_Class );
	_mCHASSIS_HMI_Radar_R2_AR.Radar_LT1_Obj_Dist_X.phys = getValue( HMI_Radar_LT1_Obj_Dist_X );
    _mCHASSIS_HMI_Radar_R2_AR.Radar_LT1_Obj_Dist_Y.phys = getValue( HMI_Radar_LT1_Obj_Dist_Y );
    _mCHASSIS_HMI_Radar_R2_AR.Radar_LT1_Obj_ID.phys = getValue( HMI_Radar_LT1_Obj_ID );
	_mCHASSIS_HMI_Radar_R2_AR.Radar_LT1_Obj_MoveType.phys = getValue( HMI_Radar_LT1_Obj_MoveType );
    _mCHASSIS_HMI_Radar_R2_AR.Radar_LT1_Obj_RelSpd_X.phys = getValue( HMI_Radar_LT1_Obj_RelSpd_X );
    _mCHASSIS_HMI_Radar_R2_AR.Radar_LT1_Obj_RelSpd_Y.phys = getValue( HMI_Radar_LT1_Obj_RelSpd_Y );

}

CHASSIS_HMI_Radar_R2_AR_output(void)
{
    output( _mCHASSIS_HMI_Radar_R2_AR );
}

CHASSIS_HMI_Radar_R2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CHASSIS_HMI_Radar_R2_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CHASSIS_HMI_Radar_R2_AR := %X\n", getValue( HMI__STMSG_CHASSIS_HMI_Radar_R2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CHASSIS_HMI_Radar_R2_AR := %X\n", getValue( HMI__STMSGT_CHASSIS_HMI_Radar_R2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_LT1_Obj_Attr1_UB  := %X\n", getValue( HMI_Radar_LT1_Obj_Attr1_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_LT1_Obj_Attr2_UB  := %X\n", getValue( HMI_Radar_LT1_Obj_Attr2_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_LT1_Obj_Class  := %X\n", getValue( HMI_Radar_LT1_Obj_Class ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_LT1_Obj_Dist_X  := %X\n", getValue( HMI_Radar_LT1_Obj_Dist_X ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_LT1_Obj_Dist_Y  := %X\n", getValue( HMI_Radar_LT1_Obj_Dist_Y ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_LT1_Obj_ID  := %X\n", getValue( HMI_Radar_LT1_Obj_ID ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_LT1_Obj_MoveType  := %X\n", getValue( HMI_Radar_LT1_Obj_MoveType ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_LT1_Obj_RelSpd_X  := %X\n", getValue( HMI_Radar_LT1_Obj_RelSpd_X ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_LT1_Obj_RelSpd_Y  := %X\n", getValue( HMI_Radar_LT1_Obj_RelSpd_Y ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tCHASSIS_HMI_Radar_R2_AR
{
    putValue( HMI__STMSG_CHASSIS_HMI_Radar_R2_AR, 0 );
}

on EnvVar HMI__STMSG_CHASSIS_HMI_Radar_R2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CHASSIS_HMI_Radar_R2_AR );
        if( tDelay > 0)    
            setTimer( _tCHASSIS_HMI_Radar_R2_AR, tDelay );
        else
            putValue( HMI__STMSG_CHASSIS_HMI_Radar_R2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CHASSIS_HMI_Radar_R2_AR
{
    if( getValue( this ) )
        openPanel("CHASSIS_HMI_Radar_R2_AR");
}

on EnvVar HMI_Radar_LT1_Obj_Attr1_UB
{
    _mCHASSIS_HMI_Radar_R2_AR.Radar_LT1_Obj_Attr1_UB.phys = getValue(this);
}

on EnvVar HMI_Radar_LT1_Obj_Attr2_UB
{
    _mCHASSIS_HMI_Radar_R2_AR.Radar_LT1_Obj_Attr2_UB.phys = getValue(this);
}

on EnvVar HMI_Radar_LT1_Obj_Class
{
    _mCHASSIS_HMI_Radar_R2_AR.Radar_LT1_Obj_Class.phys = getValue(this);
}

on EnvVar HMI_Radar_LT1_Obj_Dist_X
{
    _mCHASSIS_HMI_Radar_R2_AR.Radar_LT1_Obj_Dist_X.phys = getValue(this);
}

on EnvVar HMI_Radar_LT1_Obj_Dist_Y
{
    _mCHASSIS_HMI_Radar_R2_AR.Radar_LT1_Obj_Dist_Y.phys = getValue(this);
}

on EnvVar HMI_Radar_LT1_Obj_ID
{
    _mCHASSIS_HMI_Radar_R2_AR.Radar_LT1_Obj_ID.phys = getValue(this);
}

on EnvVar HMI_Radar_LT1_Obj_MoveType
{
    _mCHASSIS_HMI_Radar_R2_AR.Radar_LT1_Obj_MoveType.phys = getValue(this);
}

on EnvVar HMI_Radar_LT1_Obj_RelSpd_X
{
    _mCHASSIS_HMI_Radar_R2_AR.Radar_LT1_Obj_RelSpd_X.phys = getValue(this);
}

on EnvVar HMI_Radar_LT1_Obj_RelSpd_Y
{
    _mCHASSIS_HMI_Radar_R2_AR.Radar_LT1_Obj_RelSpd_Y.phys = getValue(this);
}

CHASSIS_HMI_Radar_R3_AR_check_output()
{
    if( !getValue( HMI__STMSG_CHASSIS_HMI_Radar_R3_AR ) )
        {
        //  message   CHASSIS_HMI_Radar_R3_AR ID: 1132 --- Sendeart 0 cyclicX --- 
            _CHASSIS_HMI_Radar_R3_AR_Cnt--;
            if( _CHASSIS_HMI_Radar_R3_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                CHASSIS_HMI_Radar_R3_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _CHASSIS_HMI_Radar_R3_AR_Cnt = _CHASSIS_HMI_Radar_R3_AR_CycleCount;
            }
        }
}

CHASSIS_HMI_Radar_R3_AR_init()
{   /* Botschaft CHASSIS_HMI_Radar_R3_AR ID: 1132 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 1132 0;
BA_ "NmAsrMessage" BO_ 1132 0;
BA_ "GenMsgMinAcceptLength" BO_ 1132 8;
BA_ "GenMsgILSupport" BO_ 1132 1;
BA_ "DiagState" BO_ 1132 0;
BA_ "DiagRequest" BO_ 1132 0;
BA_ "DiagResponse" BO_ 1132 0;
BA_ "GenMsgStartValue" BO_ 1132 "0";
BA_ "GenMsgStartDelayTime" BO_ 1132 135;
BA_ "GenMsgCycleTime" BO_ 1132 500;
BA_ "GenMsgSendType" BO_ 1132 0;
    */
    _CHASSIS_HMI_Radar_R3_AR_Timebase =      c_tDBKomTimer_20ms;
    _CHASSIS_HMI_Radar_R3_AR_CycleCount =   500 / _CHASSIS_HMI_Radar_R3_AR_Timebase;
    _CHASSIS_HMI_Radar_R3_AR_StartDelay =      135 / _CHASSIS_HMI_Radar_R3_AR_Timebase;
    _CHASSIS_HMI_Radar_R3_AR_Cnt = _CHASSIS_HMI_Radar_R3_AR_StartDelay;
    _CHASSIS_HMI_Radar_R3_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CHASSIS_HMI_Radar_R3_AR, _CHASSIS_HMI_Radar_R3_AR_StartDelay * _CHASSIS_HMI_Radar_R3_AR_Timebase );

    _mCHASSIS_HMI_Radar_R3_AR.Radar_LT2_Obj_Attr1_UB.phys = getValue( HMI_Radar_LT2_Obj_Attr1_UB );
    _mCHASSIS_HMI_Radar_R3_AR.Radar_LT2_Obj_Attr2_UB.phys = getValue( HMI_Radar_LT2_Obj_Attr2_UB );
    _mCHASSIS_HMI_Radar_R3_AR.Radar_LT2_Obj_Class.phys = getValue( HMI_Radar_LT2_Obj_Class );
    _mCHASSIS_HMI_Radar_R3_AR.TM_BatColdPlugVeh_Msg_Rq_UB.phys = getValue( HMI_TM_BatColdPlugVeh_Msg_Rq_UB );
    _mCHASSIS_HMI_Radar_R3_AR.TM_BatColdPlugVeh_Msg_Rq.phys = getValue( HMI_TM_BatColdPlugVeh_Msg_Rq );
    _mCHASSIS_HMI_Radar_R3_AR.TM_BatColdStartDelay_Msg_Rq_UB.phys = getValue( HMI_TM_BatColdStartDelay_Msg_Rq_UB );
    _mCHASSIS_HMI_Radar_R3_AR.TM_BatColdStartDelay_Msg_Rq.phys = getValue( HMI_TM_BatColdStartDelay_Msg_Rq );
	_mCHASSIS_HMI_Radar_R3_AR.Radar_LT2_Obj_Dist_X.phys = getValue( HMI_Radar_LT2_Obj_Dist_X );
    _mCHASSIS_HMI_Radar_R3_AR.Radar_LT2_Obj_Dist_Y.phys = getValue( HMI_Radar_LT2_Obj_Dist_Y );
    _mCHASSIS_HMI_Radar_R3_AR.Radar_LT2_Obj_ID.phys = getValue( HMI_Radar_LT2_Obj_ID );
	_mCHASSIS_HMI_Radar_R3_AR.Radar_LT2_Obj_MoveType.phys = getValue( HMI_Radar_LT2_Obj_MoveType );
    _mCHASSIS_HMI_Radar_R3_AR.Radar_LT2_Obj_RelSpd_X.phys = getValue( HMI_Radar_LT2_Obj_RelSpd_X );
    _mCHASSIS_HMI_Radar_R3_AR.Radar_LT2_Obj_RelSpd_Y.phys = getValue( HMI_Radar_LT2_Obj_RelSpd_Y );

}

CHASSIS_HMI_Radar_R3_AR_output(void)
{
    output( _mCHASSIS_HMI_Radar_R3_AR );
}

CHASSIS_HMI_Radar_R3_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CHASSIS_HMI_Radar_R3_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CHASSIS_HMI_Radar_R3_AR := %X\n", getValue( HMI__STMSG_CHASSIS_HMI_Radar_R3_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CHASSIS_HMI_Radar_R3_AR := %X\n", getValue( HMI__STMSGT_CHASSIS_HMI_Radar_R3_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_LT2_Obj_Attr1_UB  := %X\n", getValue( HMI_Radar_LT2_Obj_Attr1_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_LT2_Obj_Attr2_UB  := %X\n", getValue( HMI_Radar_LT2_Obj_Attr2_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_LT2_Obj_Class  := %X\n", getValue( HMI_Radar_LT2_Obj_Class ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TM_BatColdPlugVeh_Msg_Rq  := %X\n", getValue( HMI_TM_BatColdPlugVeh_Msg_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TM_BatColdPlugVeh_Msg_Rq_UB  := %X\n", getValue( HMI_TM_BatColdPlugVeh_Msg_Rq_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TM_BatColdStartDelay_Msg_Rq  := %X\n", getValue( HMI_TM_BatColdStartDelay_Msg_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TM_BatColdStartDelay_Msg_Rq_UB  := %X\n", getValue( HMI_TM_BatColdStartDelay_Msg_Rq_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_LT2_Obj_Dist_X  := %X\n", getValue( HMI_Radar_LT2_Obj_Dist_X ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_LT2_Obj_Dist_Y  := %X\n", getValue( HMI_Radar_LT2_Obj_Dist_Y ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_LT2_Obj_ID  := %X\n", getValue( HMI_Radar_LT2_Obj_ID ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_LT2_Obj_MoveType  := %X\n", getValue( HMI_Radar_LT2_Obj_MoveType ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_LT2_Obj_RelSpd_X  := %X\n", getValue( HMI_Radar_LT2_Obj_RelSpd_X ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_LT2_Obj_RelSpd_Y  := %X\n", getValue( HMI_Radar_LT2_Obj_RelSpd_Y ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tCHASSIS_HMI_Radar_R3_AR
{
    putValue( HMI__STMSG_CHASSIS_HMI_Radar_R3_AR, 0 );
}

on EnvVar HMI__STMSG_CHASSIS_HMI_Radar_R3_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CHASSIS_HMI_Radar_R3_AR );
        if( tDelay > 0)    
            setTimer( _tCHASSIS_HMI_Radar_R3_AR, tDelay );
        else
            putValue( HMI__STMSG_CHASSIS_HMI_Radar_R3_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CHASSIS_HMI_Radar_R3_AR
{
    if( getValue( this ) )
        openPanel("CHASSIS_HMI_Radar_R3_AR");
}

on EnvVar HMI_Radar_LT2_Obj_Attr1_UB
{
    _mCHASSIS_HMI_Radar_R3_AR.Radar_LT2_Obj_Attr1_UB.phys = getValue(this);
}

on EnvVar HMI_Radar_LT2_Obj_Attr2_UB
{
    _mCHASSIS_HMI_Radar_R3_AR.Radar_LT2_Obj_Attr2_UB.phys = getValue(this);
}

on EnvVar HMI_Radar_LT2_Obj_Class
{
    _mCHASSIS_HMI_Radar_R3_AR.Radar_LT2_Obj_Class.phys = getValue(this);
}

on EnvVar HMI_TM_BatColdPlugVeh_Msg_Rq_UB
{
    _mCHASSIS_HMI_Radar_R3_AR.TM_BatColdPlugVeh_Msg_Rq_UB.phys = getValue(this);
}

on EnvVar HMI_TM_BatColdPlugVeh_Msg_Rq
{
    _mCHASSIS_HMI_Radar_R3_AR.TM_BatColdPlugVeh_Msg_Rq.phys = getValue(this);
}

on EnvVar HMI_TM_BatColdStartDelay_Msg_Rq
{
    _mCHASSIS_HMI_Radar_R3_AR.TM_BatColdStartDelay_Msg_Rq.phys = getValue(this);
}

on EnvVar HMI_TM_BatColdStartDelay_Msg_Rq_UB
{
    _mCHASSIS_HMI_Radar_R3_AR.TM_BatColdStartDelay_Msg_Rq_UB.phys = getValue(this);
}

on EnvVar HMI_Radar_LT2_Obj_Dist_X
{
    _mCHASSIS_HMI_Radar_R3_AR.Radar_LT2_Obj_Dist_X.phys = getValue(this);
}

on EnvVar HMI_Radar_LT2_Obj_Dist_Y
{
    _mCHASSIS_HMI_Radar_R3_AR.Radar_LT2_Obj_Dist_Y.phys = getValue(this);
}

on EnvVar HMI_Radar_LT2_Obj_ID
{
    _mCHASSIS_HMI_Radar_R3_AR.Radar_LT2_Obj_ID.phys = getValue(this);
}

on EnvVar HMI_Radar_LT2_Obj_MoveType
{
    _mCHASSIS_HMI_Radar_R3_AR.Radar_LT2_Obj_MoveType.phys = getValue(this);
}

on EnvVar HMI_Radar_LT2_Obj_RelSpd_X
{
    _mCHASSIS_HMI_Radar_R3_AR.Radar_LT2_Obj_RelSpd_X.phys = getValue(this);
}

on EnvVar HMI_Radar_LT2_Obj_RelSpd_Y
{
    _mCHASSIS_HMI_Radar_R3_AR.Radar_LT2_Obj_RelSpd_Y.phys = getValue(this);
}

CHASSIS_HMI_Radar_R4_AR_check_output()
{
    if( !getValue( HMI__STMSG_CHASSIS_HMI_Radar_R4_AR ) )
        {
        //  message   CHASSIS_HMI_Radar_R4_AR ID: 1134 --- Sendeart 0 cyclicX --- 
            _CHASSIS_HMI_Radar_R4_AR_Cnt--;
            if( _CHASSIS_HMI_Radar_R4_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                CHASSIS_HMI_Radar_R4_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _CHASSIS_HMI_Radar_R4_AR_Cnt = _CHASSIS_HMI_Radar_R4_AR_CycleCount;
            }
        }
}

CHASSIS_HMI_Radar_R4_AR_init()
{   /* Botschaft CHASSIS_HMI_Radar_R4_AR ID: 1134 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 1134 0;
BA_ "NmAsrMessage" BO_ 1134 0;
BA_ "GenMsgMinAcceptLength" BO_ 1134 8;
BA_ "GenMsgILSupport" BO_ 1134 1;
BA_ "DiagState" BO_ 1134 0;
BA_ "DiagRequest" BO_ 1134 0;
BA_ "DiagResponse" BO_ 1134 0;
BA_ "GenMsgStartValue" BO_ 1134 "0";
BA_ "GenMsgStartDelayTime" BO_ 1134 170;
BA_ "GenMsgCycleTime" BO_ 1134 500;
BA_ "GenMsgSendType" BO_ 1134 0;
    */
    _CHASSIS_HMI_Radar_R4_AR_Timebase =      c_tDBKomTimer_20ms;
    _CHASSIS_HMI_Radar_R4_AR_CycleCount =   500 / _CHASSIS_HMI_Radar_R4_AR_Timebase;
    _CHASSIS_HMI_Radar_R4_AR_StartDelay =      170 / _CHASSIS_HMI_Radar_R4_AR_Timebase;
    _CHASSIS_HMI_Radar_R4_AR_Cnt = _CHASSIS_HMI_Radar_R4_AR_StartDelay;
    _CHASSIS_HMI_Radar_R4_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CHASSIS_HMI_Radar_R4_AR, _CHASSIS_HMI_Radar_R4_AR_StartDelay * _CHASSIS_HMI_Radar_R4_AR_Timebase );

    _mCHASSIS_HMI_Radar_R4_AR.Radar_RT1_Obj_Attr1_UB.phys = getValue( HMI_Radar_RT1_Obj_Attr1_UB );
    _mCHASSIS_HMI_Radar_R4_AR.Radar_RT1_Obj_Attr2_UB.phys = getValue( HMI_Radar_RT1_Obj_Attr2_UB );
    _mCHASSIS_HMI_Radar_R4_AR.Radar_RT1_Obj_Class.phys = getValue( HMI_Radar_RT1_Obj_Class );
	_mCHASSIS_HMI_Radar_R4_AR.Radar_RT1_Obj_Dist_X.phys = getValue( HMI_Radar_RT1_Obj_Dist_X );
    _mCHASSIS_HMI_Radar_R4_AR.Radar_RT1_Obj_Dist_Y.phys = getValue( HMI_Radar_RT1_Obj_Dist_Y );
    _mCHASSIS_HMI_Radar_R4_AR.Radar_RT1_Obj_ID.phys = getValue( HMI_Radar_RT1_Obj_ID );
	_mCHASSIS_HMI_Radar_R4_AR.Radar_RT1_Obj_MoveType.phys = getValue( HMI_Radar_RT1_Obj_MoveType );
    _mCHASSIS_HMI_Radar_R4_AR.Radar_RT1_Obj_RelSpd_X.phys = getValue( HMI_Radar_RT1_Obj_RelSpd_X );
    _mCHASSIS_HMI_Radar_R4_AR.Radar_RT1_Obj_RelSpd_Y.phys = getValue( HMI_Radar_RT1_Obj_RelSpd_Y );

}

CHASSIS_HMI_Radar_R4_AR_output(void)
{
    output( _mCHASSIS_HMI_Radar_R4_AR );
}

CHASSIS_HMI_Radar_R4_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CHASSIS_HMI_Radar_R4_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CHASSIS_HMI_Radar_R4_AR := %X\n", getValue( HMI__STMSG_CHASSIS_HMI_Radar_R4_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CHASSIS_HMI_Radar_R4_AR := %X\n", getValue( HMI__STMSGT_CHASSIS_HMI_Radar_R4_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_RT1_Obj_Attr1_UB  := %X\n", getValue( HMI_Radar_RT1_Obj_Attr1_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_RT1_Obj_Attr2_UB  := %X\n", getValue( HMI_Radar_RT1_Obj_Attr2_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_RT1_Obj_Class  := %X\n", getValue( HMI_Radar_RT1_Obj_Class ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_RT1_Obj_Dist_X  := %X\n", getValue( HMI_Radar_RT1_Obj_Dist_X ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_RT1_Obj_Dist_Y  := %X\n", getValue( HMI_Radar_RT1_Obj_Dist_Y ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_RT1_Obj_ID  := %X\n", getValue( HMI_Radar_RT1_Obj_ID ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_RT1_Obj_MoveType  := %X\n", getValue( HMI_Radar_RT1_Obj_MoveType ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_RT1_Obj_RelSpd_X  := %X\n", getValue( HMI_Radar_RT1_Obj_RelSpd_X ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_RT1_Obj_RelSpd_Y  := %X\n", getValue( HMI_Radar_RT1_Obj_RelSpd_Y ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tCHASSIS_HMI_Radar_R4_AR
{
    putValue( HMI__STMSG_CHASSIS_HMI_Radar_R4_AR, 0 );
}

on EnvVar HMI__STMSG_CHASSIS_HMI_Radar_R4_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CHASSIS_HMI_Radar_R4_AR );
        if( tDelay > 0)    
            setTimer( _tCHASSIS_HMI_Radar_R4_AR, tDelay );
        else
            putValue( HMI__STMSG_CHASSIS_HMI_Radar_R4_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CHASSIS_HMI_Radar_R4_AR
{
    if( getValue( this ) )
        openPanel("CHASSIS_HMI_Radar_R4_AR");
}

on EnvVar HMI_Radar_RT1_Obj_Attr1_UB
{
    _mCHASSIS_HMI_Radar_R4_AR.Radar_RT1_Obj_Attr1_UB.phys = getValue(this);
}

on EnvVar HMI_Radar_RT1_Obj_Attr2_UB
{
    _mCHASSIS_HMI_Radar_R4_AR.Radar_RT1_Obj_Attr2_UB.phys = getValue(this);
}

on EnvVar HMI_Radar_RT1_Obj_Class
{
    _mCHASSIS_HMI_Radar_R4_AR.Radar_RT1_Obj_Class.phys = getValue(this);
}

on EnvVar HMI_Radar_RT1_Obj_Dist_X
{
    _mCHASSIS_HMI_Radar_R4_AR.Radar_RT1_Obj_Dist_X.phys = getValue(this);
}

on EnvVar HMI_Radar_RT1_Obj_Dist_Y
{
    _mCHASSIS_HMI_Radar_R4_AR.Radar_RT1_Obj_Dist_Y.phys = getValue(this);
}

on EnvVar HMI_Radar_RT1_Obj_ID
{
    _mCHASSIS_HMI_Radar_R4_AR.Radar_RT1_Obj_ID.phys = getValue(this);
}

on EnvVar HMI_Radar_RT1_Obj_MoveType
{
    _mCHASSIS_HMI_Radar_R4_AR.Radar_RT1_Obj_MoveType.phys = getValue(this);
}

on EnvVar HMI_Radar_RT1_Obj_RelSpd_X
{
    _mCHASSIS_HMI_Radar_R4_AR.Radar_RT1_Obj_RelSpd_X.phys = getValue(this);
}

on EnvVar HMI_Radar_RT1_Obj_RelSpd_Y
{
    _mCHASSIS_HMI_Radar_R4_AR.Radar_RT1_Obj_RelSpd_Y.phys = getValue(this);
}

CHASSIS_HMI_Radar_R5_AR_check_output()
{
    if( !getValue( HMI__STMSG_CHASSIS_HMI_Radar_R5_AR ) )
        {
        //  message   CHASSIS_HMI_Radar_R5_AR ID: 1044 --- Sendeart 0 cyclicX --- 
            _CHASSIS_HMI_Radar_R5_AR_Cnt--;
            if( _CHASSIS_HMI_Radar_R5_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                CHASSIS_HMI_Radar_R5_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _CHASSIS_HMI_Radar_R5_AR_Cnt = _CHASSIS_HMI_Radar_R5_AR_CycleCount;
            }
        }
}

CHASSIS_HMI_Radar_R5_AR_init()
{   /* Botschaft CHASSIS_HMI_Radar_R5_AR ID: 1044 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 1044 0;
BA_ "NmAsrMessage" BO_ 1044 0;
BA_ "GenMsgMinAcceptLength" BO_ 1044 8;
BA_ "GenMsgILSupport" BO_ 1044 1;
BA_ "DiagState" BO_ 1044 0;
BA_ "DiagRequest" BO_ 1044 0;
BA_ "DiagResponse" BO_ 1044 0;
BA_ "GenMsgStartValue" BO_ 1044 "0";
BA_ "GenMsgStartDelayTime" BO_ 1044 200;
BA_ "GenMsgCycleTime" BO_ 1044 500;
BA_ "GenMsgSendType" BO_ 1044 0;
    */
    _CHASSIS_HMI_Radar_R5_AR_Timebase =      c_tDBKomTimer_20ms;
    _CHASSIS_HMI_Radar_R5_AR_CycleCount =   500 / _CHASSIS_HMI_Radar_R5_AR_Timebase;
    _CHASSIS_HMI_Radar_R5_AR_StartDelay =      200 / _CHASSIS_HMI_Radar_R5_AR_Timebase;
    _CHASSIS_HMI_Radar_R5_AR_Cnt = _CHASSIS_HMI_Radar_R5_AR_StartDelay;
    _CHASSIS_HMI_Radar_R5_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CHASSIS_HMI_Radar_R5_AR, _CHASSIS_HMI_Radar_R5_AR_StartDelay * _CHASSIS_HMI_Radar_R5_AR_Timebase );

    _mCHASSIS_HMI_Radar_R5_AR.Radar_RT2_Obj_Attr1_UB.phys = getValue( HMI_Radar_RT2_Obj_Attr1_UB );
    _mCHASSIS_HMI_Radar_R5_AR.Radar_RT2_Obj_Attr2_UB.phys = getValue( HMI_Radar_RT2_Obj_Attr2_UB );
    _mCHASSIS_HMI_Radar_R5_AR.Radar_RT2_Obj_Class.phys = getValue( HMI_Radar_RT2_Obj_Class );
	_mCHASSIS_HMI_Radar_R5_AR.Radar_RT2_Obj_Dist_X.phys = getValue( HMI_Radar_RT2_Obj_Dist_X );
    _mCHASSIS_HMI_Radar_R5_AR.Radar_RT2_Obj_Dist_Y.phys = getValue( HMI_Radar_RT2_Obj_Dist_Y );
    _mCHASSIS_HMI_Radar_R5_AR.Radar_RT2_Obj_ID.phys = getValue( HMI_Radar_RT2_Obj_ID );
	_mCHASSIS_HMI_Radar_R5_AR.Radar_RT2_Obj_MoveType.phys = getValue( HMI_Radar_RT2_Obj_MoveType );
    _mCHASSIS_HMI_Radar_R5_AR.Radar_RT2_Obj_RelSpd_X.phys = getValue( HMI_Radar_RT2_Obj_RelSpd_X );
    _mCHASSIS_HMI_Radar_R5_AR.Radar_RT2_Obj_RelSpd_Y.phys = getValue( HMI_Radar_RT2_Obj_RelSpd_Y );

}

CHASSIS_HMI_Radar_R5_AR_output(void)
{
    output( _mCHASSIS_HMI_Radar_R5_AR );
}

CHASSIS_HMI_Radar_R5_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CHASSIS_HMI_Radar_R5_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CHASSIS_HMI_Radar_R5_AR := %X\n", getValue( HMI__STMSG_CHASSIS_HMI_Radar_R5_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CHASSIS_HMI_Radar_R5_AR := %X\n", getValue( HMI__STMSGT_CHASSIS_HMI_Radar_R5_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_RT2_Obj_Attr1_UB  := %X\n", getValue( HMI_Radar_RT2_Obj_Attr1_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_RT2_Obj_Attr2_UB  := %X\n", getValue( HMI_Radar_RT2_Obj_Attr2_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_RT2_Obj_Class  := %X\n", getValue( HMI_Radar_RT2_Obj_Class ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_RT2_Obj_Dist_X  := %X\n", getValue( HMI_Radar_RT2_Obj_Dist_X ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_RT2_Obj_Dist_Y  := %X\n", getValue( HMI_Radar_RT2_Obj_Dist_Y ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_RT2_Obj_ID  := %X\n", getValue( HMI_Radar_RT2_Obj_ID ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_RT2_Obj_MoveType  := %X\n", getValue( HMI_Radar_RT2_Obj_MoveType ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_RT2_Obj_RelSpd_X  := %X\n", getValue( HMI_Radar_RT2_Obj_RelSpd_X ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_RT2_Obj_RelSpd_Y  := %X\n", getValue( HMI_Radar_RT2_Obj_RelSpd_Y ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tCHASSIS_HMI_Radar_R5_AR
{
    putValue( HMI__STMSG_CHASSIS_HMI_Radar_R5_AR, 0 );
}

on EnvVar HMI__STMSG_CHASSIS_HMI_Radar_R5_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CHASSIS_HMI_Radar_R5_AR );
        if( tDelay > 0)    
            setTimer( _tCHASSIS_HMI_Radar_R5_AR, tDelay );
        else
            putValue( HMI__STMSG_CHASSIS_HMI_Radar_R5_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CHASSIS_HMI_Radar_R5_AR
{
    if( getValue( this ) )
        openPanel("CHASSIS_HMI_Radar_R5_AR");
}

on EnvVar HMI_Radar_RT2_Obj_Attr1_UB
{
    _mCHASSIS_HMI_Radar_R5_AR.Radar_RT2_Obj_Attr1_UB.phys = getValue(this);
}

on EnvVar HMI_Radar_RT2_Obj_Attr2_UB
{
    _mCHASSIS_HMI_Radar_R5_AR.Radar_RT2_Obj_Attr2_UB.phys = getValue(this);
}

on EnvVar HMI_Radar_RT2_Obj_Class
{
    _mCHASSIS_HMI_Radar_R5_AR.Radar_RT2_Obj_Class.phys = getValue(this);
}

on EnvVar HMI_Radar_RT2_Obj_Dist_X
{
    _mCHASSIS_HMI_Radar_R5_AR.Radar_RT2_Obj_Dist_X.phys = getValue(this);
}

on EnvVar HMI_Radar_RT2_Obj_Dist_Y
{
    _mCHASSIS_HMI_Radar_R5_AR.Radar_RT2_Obj_Dist_Y.phys = getValue(this);
}

on EnvVar HMI_Radar_RT2_Obj_ID
{
    _mCHASSIS_HMI_Radar_R5_AR.Radar_RT2_Obj_ID.phys = getValue(this);
}

on EnvVar HMI_Radar_RT2_Obj_MoveType
{
    _mCHASSIS_HMI_Radar_R5_AR.Radar_RT2_Obj_MoveType.phys = getValue(this);
}

on EnvVar HMI_Radar_RT2_Obj_RelSpd_X
{
    _mCHASSIS_HMI_Radar_R5_AR.Radar_RT2_Obj_RelSpd_X.phys = getValue(this);
}

on EnvVar HMI_Radar_RT2_Obj_RelSpd_Y
{
    _mCHASSIS_HMI_Radar_R5_AR.Radar_RT2_Obj_RelSpd_Y.phys = getValue(this);
}

CHASSIS_HMI_R0_AR_check_output()
{
    if( !getValue( HMI__STMSG_CHASSIS_HMI_R0_AR ) )
    {
    //  message   CHASSIS_HMI_R0_AR ID: 1071 --- Sendeart 5 cyclicAndSpontanWithDelay ---
        _CHASSIS_HMI_R0_AR_Cnt--;
        if( _CHASSIS_HMI_R0_AR_Cnt < 1 )
        {
            CHASSIS_HMI_R0_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _CHASSIS_HMI_R0_AR_Cnt = _CHASSIS_HMI_R0_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _CHASSIS_HMI_R0_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _CHASSIS_HMI_R0_AR_SpontanFlag)
        {
            CHASSIS_HMI_R0_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _CHASSIS_HMI_R0_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

CHASSIS_HMI_R0_AR_init()
{   /* Botschaft CHASSIS_HMI_R0_AR ID: 1071 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1071 0;
BA_ "NmAsrMessage" BO_ 1071 0;
BA_ "GenMsgMinAcceptLength" BO_ 1071 8;
BA_ "GenMsgILSupport" BO_ 1071 1;
BA_ "DiagState" BO_ 1071 0;
BA_ "DiagRequest" BO_ 1071 0;
BA_ "DiagResponse" BO_ 1071 0;
BA_ "GenMsgStartValue" BO_ 1071 "0";
BA_ "GenMsgStartDelayTime" BO_ 1071 250;
BA_ "GenMsgDelayTime" BO_ 1071 20;
BA_ "GenMsgNrOfRepetition" BO_ 1071 0;
BA_ "GenMsgCycleTime" BO_ 1071 1000;
BA_ "GenMsgSendType" BO_ 1071 5;
    */
    _CHASSIS_HMI_R0_AR_Timebase =      c_tDBKomTimer_20ms;
    _CHASSIS_HMI_R0_AR_CycleCount =   1000 / _CHASSIS_HMI_R0_AR_Timebase;
    _CHASSIS_HMI_R0_AR_StartDelay =    250 / _CHASSIS_HMI_R0_AR_Timebase;
    _CHASSIS_HMI_R0_AR_Cnt = _CHASSIS_HMI_R0_AR_StartDelay;
    _CHASSIS_HMI_R0_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CHASSIS_HMI_R0_AR, _CHASSIS_HMI_R0_AR_StartDelay * _CHASSIS_HMI_R0_AR_Timebase );

    _mCHASSIS_HMI_R0_AR.PNHV_PreCond2_Dsabl.phys =                   getValue( HMI_PNHV_PreCond2_Dsabl );
    _mCHASSIS_HMI_R0_AR.PNHV_PreCond2_Dsabl_UB.phys =                   getValue( HMI_PNHV_PreCond2_Dsabl_UB );
    _mCHASSIS_HMI_R0_AR.PNHV_RemainTm_Wakeup.phys =                   getValue( HMI_PNHV_RemainTm_Wakeup );
    _mCHASSIS_HMI_R0_AR.PNHV_RemainTm_Wakeup_UB.phys =                   getValue( HMI_PNHV_RemainTm_Wakeup_UB );
    _mCHASSIS_HMI_R0_AR.FCU_H2_CtrlLmp.phys = getValue( HMI_FCU_H2_CtrlLmp );
    _mCHASSIS_HMI_R0_AR.FMS_H2_CtrlLmp.phys = getValue( HMI_FMS_H2_CtrlLmp );
    _mCHASSIS_HMI_R0_AR.WhlTrq_Sum_Max.phys = getValue( HMI_WhlTrq_Sum_Max );
    _mCHASSIS_HMI_R0_AR.WhlTrq_Sum_Min.phys = getValue( HMI_WhlTrq_Sum_Min );
    _mCHASSIS_HMI_R0_AR.DPC_Md_Tx_Rs.phys = getValue( HMI_DPC_Md_Tx_Rs );
    _mCHASSIS_HMI_R0_AR.DPC_Md_Tx_Rs_UB.phys = getValue( HMI_DPC_Md_Tx_Rs_UB );
}

CHASSIS_HMI_R0_AR_output(void)
{
    output( _mCHASSIS_HMI_R0_AR );
}

CHASSIS_HMI_R0_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CHASSIS_HMI_R0_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CHASSIS_HMI_R0_AR := %X\n", getValue( HMI__STMSG_CHASSIS_HMI_R0_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CHASSIS_HMI_R0_AR := %X\n", getValue( HMI__STMSGT_CHASSIS_HMI_R0_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_PreCond2_Dsabl := %X\n", getValue( HMI_PNHV_PreCond2_Dsabl ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_PreCond2_Dsabl_UB := %X\n", getValue( HMI_PNHV_PreCond2_Dsabl_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_RemainTm_Wakeup := %X\n", getValue( HMI_PNHV_RemainTm_Wakeup ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_RemainTm_Wakeup_UB := %X\n", getValue( HMI_PNHV_RemainTm_Wakeup_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount(buffer), "0.0000 HMI_FCU_H2_CtrlLmp := %X\n", getValue( HMI_FCU_H2_CtrlLmp ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_FMS_H2_CtrlLmp := %X\n", getValue( HMI_FMS_H2_CtrlLmp ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_WhlTrq_Sum_Max := %X\n", getValue( HMI_WhlTrq_Sum_Max ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_WhlTrq_Sum_Min := %X\n", getValue( HMI_WhlTrq_Sum_Min ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_DPC_Md_Tx_Rs := %X\n", getValue( HMI_DPC_Md_Tx_Rs ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_DPC_Md_Tx_Rs_UB := %X\n", getValue( HMI_DPC_Md_Tx_Rs_UB ) );        filePutString( buffer, elcount(buffer), hFile);
}

on timer _tCHASSIS_HMI_R0_AR
{
    putValue( HMI__STMSG_CHASSIS_HMI_R0_AR, 0 );
}

on EnvVar HMI__STMSG_CHASSIS_HMI_R0_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CHASSIS_HMI_R0_AR );
        if( tDelay > 0)    
            setTimer( _tCHASSIS_HMI_R0_AR, tDelay );
        else
            putValue( HMI__STMSG_CHASSIS_HMI_R0_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CHASSIS_HMI_R0_AR
{
    if( getValue( this ) )
        openPanel("CHASSIS_HMI_R0_AR");
}

on EnvVar HMI_PNHV_PreCond2_Dsabl
{
    _mCHASSIS_HMI_R0_AR.PNHV_PreCond2_Dsabl.phys = getValue(this);
    _CHASSIS_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_PreCond2_Dsabl_UB
{
    _mCHASSIS_HMI_R0_AR.PNHV_PreCond2_Dsabl_UB.phys = getValue(this);
    _CHASSIS_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_RemainTm_Wakeup
{
    _mCHASSIS_HMI_R0_AR.PNHV_RemainTm_Wakeup.phys = getValue(this);
    _CHASSIS_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_RemainTm_Wakeup_UB
{
    _mCHASSIS_HMI_R0_AR.PNHV_RemainTm_Wakeup_UB.phys = getValue(this);
    _CHASSIS_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_FCU_H2_CtrlLmp
{
    _mCHASSIS_HMI_R0_AR.FCU_H2_CtrlLmp.phys = getValue(this);
    _CHASSIS_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_FMS_H2_CtrlLmp
{
    _mCHASSIS_HMI_R0_AR.FMS_H2_CtrlLmp.phys = getValue(this);
    _CHASSIS_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_WhlTrq_Sum_Max
{
    _mCHASSIS_HMI_R0_AR.WhlTrq_Sum_Max.phys = getValue(this);
    _CHASSIS_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_WhlTrq_Sum_Min
{
    _mCHASSIS_HMI_R0_AR.WhlTrq_Sum_Min.phys = getValue(this);
    _CHASSIS_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_Tx_Rs
{
    _mCHASSIS_HMI_R0_AR.DPC_Md_Tx_Rs.phys = getValue(this);
    _CHASSIS_HMI_R0_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_Tx_Rs_UB
{
    _mCHASSIS_HMI_R0_AR.DPC_Md_Tx_Rs_UB.phys = getValue(this);
    _CHASSIS_HMI_R0_AR_SpontanFlag = 1;
}

CHASSIS_HMI_R1_AR_check_output()
{
    if( !getValue( HMI__STMSG_CHASSIS_HMI_R1_AR ) )
    {
    //  message   CHASSIS_HMI_R1_AR ID: 1107 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _CHASSIS_HMI_R1_AR_Cnt--;
        if( _CHASSIS_HMI_R1_AR_Cnt < 1 )
        {
            CHASSIS_HMI_R1_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _CHASSIS_HMI_R1_AR_Cnt = _CHASSIS_HMI_R1_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _CHASSIS_HMI_R1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _CHASSIS_HMI_R1_AR_SpontanFlag)
        {
            CHASSIS_HMI_R1_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _CHASSIS_HMI_R1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

CHASSIS_HMI_R1_AR_init()
{   /* Botschaft CHASSIS_HMI_R1_AR ID: 1107 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1107 0;
BA_ "NmAsrMessage" BO_ 1107 0;
BA_ "GenMsgMinAcceptLength" BO_ 1107 8;
BA_ "GenMsgILSupport" BO_ 1107 1;
BA_ "DiagState" BO_ 1107 0;
BA_ "DiagRequest" BO_ 1107 0;
BA_ "DiagResponse" BO_ 1107 0;
BA_ "GenMsgStartValue" BO_ 1107 "0";
BA_ "GenMsgStartDelayTime" BO_ 1107 50;
BA_ "GenMsgDelayTime" BO_ 1107 20;
BA_ "GenMsgNrOfRepetitions" BO_ 1107 0;
BA_ "GenMsgCycleTime" BO_ 1107 200;
BA_ "GenMsgSendType" BO_ 1107 5;
    */
    _CHASSIS_HMI_R1_AR_Timebase =         c_tDBKomTimer_20ms;
    _CHASSIS_HMI_R1_AR_CycleCount =      200 / _CHASSIS_HMI_R1_AR_Timebase;
    _CHASSIS_HMI_R1_AR_StartDelay =       50 / _CHASSIS_HMI_R1_AR_Timebase;
//  _CHASSIS_HMI_R1_AR_MinDelay =         20 / _CHASSIS_HMI_R1_AR_Timebase;
    _CHASSIS_HMI_R1_AR_Cnt = _CHASSIS_HMI_R1_AR_StartDelay;
    _CHASSIS_HMI_R1_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CHASSIS_HMI_R1_AR, _CHASSIS_HMI_R1_AR_StartDelay * _CHASSIS_HMI_R1_AR_Timebase );

    _mCHASSIS_HMI_R1_AR.AccelPdlPosn.phys =                   getValue( HMI_AccelPdlPosn );
    _mCHASSIS_HMI_R1_AR.AccelPdlPosn_Raw.phys =               getValue( HMI_AccelPdlPosn_Raw );
    _mCHASSIS_HMI_R1_AR.CoastMd_Disp_Rq.phys =                getValue( HMI_CoastMd_Disp_Rq );
    _mCHASSIS_HMI_R1_AR.CoastMd_Disp_Rq_UB.phys =             getValue( HMI_CoastMd_Disp_Rq_UB );
	_mCHASSIS_HMI_R1_AR.DTQ_AcustWarn_Rq.phys =               getValue( HMI_DTQ_AcustWarn_Rq );
	_mCHASSIS_HMI_R1_AR.DTQ_AcustWarn_Rq_UB.phys =            getValue( HMI_DTQ_AcustWarn_Rq_UB );
    _mCHASSIS_HMI_R1_AR.DTQ_Disp_Rq_V2_UB.phys =              getValue( HMI_DTQ_Disp_Rq_V2_UB );
    _mCHASSIS_HMI_R1_AR.DTQ_FltMsgDisp_Rq.phys =              getValue( HMI_DTQ_FltMsgDisp_Rq );
	_mCHASSIS_HMI_R1_AR.DTQ_LaneChg_Md_Stat.phys =            getValue( HMI_DTQ_LaneChg_Md_Stat );
    _mCHASSIS_HMI_R1_AR.DTQ_LaneChg_Md_Stat_UB.phys =         getValue( HMI_DTQ_LaneChg_Md_Stat_UB );
	_mCHASSIS_HMI_R1_AR.DTQ_LaneChgLtStat_Disp_Rq_UB.phys =   getValue( HMI_DTQ_LaneChgLtStat_Disp_Rq_UB );
	_mCHASSIS_HMI_R1_AR.DTQ_LaneChgLtStat_Disp_Rq.phys =      getValue( HMI_DTQ_LaneChgLtStat_Disp_Rq );
	_mCHASSIS_HMI_R1_AR.DTQ_LaneChgMsgDisp_Rq_UB.phys =       getValue( HMI_DTQ_LaneChgMsgDisp_Rq_UB );
	_mCHASSIS_HMI_R1_AR.DTQ_LaneChgMsgDisp_Rq.phys =          getValue( HMI_DTQ_LaneChgMsgDisp_Rq );
	_mCHASSIS_HMI_R1_AR.DTQ_LaneChgRtStat_Disp_Rq_UB.phys =   getValue( HMI_DTQ_LaneChgRtStat_Disp_Rq_UB );
	_mCHASSIS_HMI_R1_AR.DTQ_LaneChgRtStat_Disp_Rq.phys =      getValue( HMI_DTQ_LaneChgRtStat_Disp_Rq );
    _mCHASSIS_HMI_R1_AR.DTQ_Md_Stat.phys =                    getValue( HMI_DTQ_Md_Stat );
    _mCHASSIS_HMI_R1_AR.DTQ_Md_Stat_UB.phys =                 getValue( HMI_DTQ_Md_Stat_UB );
    _mCHASSIS_HMI_R1_AR.DTQ_MsgDisp_Rq_V2.phys =              getValue( HMI_DTQ_MsgDisp_Rq_V2 );
    _mCHASSIS_HMI_R1_AR.DTQ_Stat_Disp_Rq.phys =               getValue( HMI_DTQ_Stat_Disp_Rq );
  //  _mCHASSIS_HMI_R1_AR.Eng_Rs3_UB.phys =                     getValue( HMI_Eng_Rs3_UB );
    _mCHASSIS_HMI_R1_AR.ExhstFlap_Stg_AMG.phys =              getValue( HMI_ExhstFlap_Stg_AMG );
    _mCHASSIS_HMI_R1_AR.ExhstFlap_Stg_AMG_UB.phys =           getValue( HMI_ExhstFlap_Stg_AMG_UB );
	_mCHASSIS_HMI_R1_AR.TxDrvProgMan_Actv.phys =           	  getValue( HMI_TxDrvProgMan_Actv );
	_mCHASSIS_HMI_R1_AR.TxDrvProgMan_Actv_UB.phys =           getValue( HMI_TxDrvProgMan_Actv_UB );
	_mCHASSIS_HMI_R1_AR.VehDrvProg_TCM_V3.phys =              getValue( HMI_VehDrvProg_TCM_V3 );
    _mCHASSIS_HMI_R1_AR.VehDrvProg_TCM_V3_UB.phys =           getValue( HMI_VehDrvProg_TCM_V3_UB );
}

CHASSIS_HMI_R1_AR_output(void)
{
    output( _mCHASSIS_HMI_R1_AR );
}

CHASSIS_HMI_R1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CHASSIS_HMI_R1_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CHASSIS_HMI_R1_AR := %X\n", getValue( HMI__STMSG_CHASSIS_HMI_R1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CHASSIS_HMI_R1_AR := %X\n", getValue( HMI__STMSGT_CHASSIS_HMI_R1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AccelPdlPosn := %X\n", getValue( HMI_AccelPdlPosn ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AccelPdlPosn_Raw := %X\n", getValue( HMI_AccelPdlPosn_Raw ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CoastMd_Disp_Rq := %X\n", getValue( HMI_CoastMd_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CoastMd_Disp_Rq_UB := %X\n", getValue( HMI_CoastMd_Disp_Rq_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_AcustWarn_Rq := %X\n", getValue( HMI_DTQ_AcustWarn_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_AcustWarn_Rq_UB := %X\n", getValue( HMI_DTQ_AcustWarn_Rq_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_Disp_Rq_V2_UB := %X\n", getValue( HMI_DTQ_Disp_Rq_V2_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_FltMsgDisp_Rq := %X\n", getValue( HMI_DTQ_FltMsgDisp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_LaneChg_Md_Stat := %X\n", getValue( HMI_DTQ_LaneChg_Md_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_LaneChg_Md_Stat_UB := %X\n", getValue( HMI_DTQ_LaneChg_Md_Stat_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_LaneChgLtStat_Disp_Rq_UB := %X\n", getValue( HMI_DTQ_LaneChgLtStat_Disp_Rq_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_LaneChgLtStat_Disp_Rq := %X\n", getValue( HMI_DTQ_LaneChgLtStat_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_LaneChgMsgDisp_Rq_UB := %X\n", getValue( HMI_DTQ_LaneChgMsgDisp_Rq_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_LaneChgMsgDisp_Rq := %X\n", getValue( HMI_DTQ_LaneChgMsgDisp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_LaneChgRtStat_Disp_Rq_UB := %X\n", getValue( HMI_DTQ_LaneChgRtStat_Disp_Rq_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_LaneChgRtStat_Disp_Rq := %X\n", getValue( HMI_DTQ_LaneChgRtStat_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_Md_Stat := %X\n", getValue( HMI_DTQ_Md_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_Md_Stat_UB := %X\n", getValue( HMI_DTQ_Md_Stat_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_MsgDisp_Rq_V2 := %X\n", getValue( HMI_DTQ_MsgDisp_Rq_V2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_Stat_Disp_Rq := %X\n", getValue( HMI_DTQ_Stat_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Eng_Rs3_UB := %X\n", getValue( HMI_Eng_Rs3_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ExhstFlap_Stg_AMG := %X\n", getValue( HMI_ExhstFlap_Stg_AMG ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ExhstFlap_Stg_AMG_UB := %X\n", getValue( HMI_ExhstFlap_Stg_AMG_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TxDrvProgMan_Actv := %X\n", getValue( HMI_TxDrvProgMan_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TxDrvProgMan_Actv_UB := %X\n", getValue( HMI_TxDrvProgMan_Actv_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehDrvProg_TCM_V3 := %X\n", getValue( HMI_VehDrvProg_TCM_V3 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehDrvProg_TCM_V3_UB := %X\n", getValue( HMI_VehDrvProg_TCM_V3_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tCHASSIS_HMI_R1_AR
{
    putValue( HMI__STMSG_CHASSIS_HMI_R1_AR, 0 );
}

on EnvVar HMI__STMSG_CHASSIS_HMI_R1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CHASSIS_HMI_R1_AR );
        if( tDelay > 0)    
            setTimer( _tCHASSIS_HMI_R1_AR, tDelay );
        else
            putValue( HMI__STMSG_CHASSIS_HMI_R1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CHASSIS_HMI_R1_AR
{
    if( getValue( this ) )
        openPanel("CHASSIS_HMI_R1_AR");
}

on EnvVar HMI_AccelPdlPosn
{
    _mCHASSIS_HMI_R1_AR.AccelPdlPosn.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_AccelPdlPosn_Raw
{
    _mCHASSIS_HMI_R1_AR.AccelPdlPosn_Raw.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_CoastMd_Disp_Rq
{
    _mCHASSIS_HMI_R1_AR.CoastMd_Disp_Rq.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_CoastMd_Disp_Rq_UB
{
    _mCHASSIS_HMI_R1_AR.CoastMd_Disp_Rq_UB.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_AcustWarn_Rq
{
    _mCHASSIS_HMI_R1_AR.DTQ_AcustWarn_Rq.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_AcustWarn_Rq_UB
{
    _mCHASSIS_HMI_R1_AR.DTQ_AcustWarn_Rq_UB.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_Disp_Rq_V2_UB
{
    _mCHASSIS_HMI_R1_AR.DTQ_Disp_Rq_V2_UB.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_LaneChgLtStat_Disp_Rq_UB
{
    _mCHASSIS_HMI_R1_AR.DTQ_LaneChgLtStat_Disp_Rq_UB.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_LaneChg_Md_Stat
{
    _mCHASSIS_HMI_R1_AR.DTQ_LaneChg_Md_Stat.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_LaneChg_Md_Stat_UB
{
    _mCHASSIS_HMI_R1_AR.DTQ_LaneChg_Md_Stat_UB.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_LaneChgLtStat_Disp_Rq
{
    _mCHASSIS_HMI_R1_AR.DTQ_LaneChgLtStat_Disp_Rq.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_LaneChgMsgDisp_Rq_UB
{
    _mCHASSIS_HMI_R1_AR.DTQ_LaneChgMsgDisp_Rq_UB.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_LaneChgMsgDisp_Rq
{
    _mCHASSIS_HMI_R1_AR.DTQ_LaneChgMsgDisp_Rq.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_LaneChgRtStat_Disp_Rq_UB
{
    _mCHASSIS_HMI_R1_AR.DTQ_LaneChgRtStat_Disp_Rq_UB.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_LaneChgRtStat_Disp_Rq
{
    _mCHASSIS_HMI_R1_AR.DTQ_LaneChgRtStat_Disp_Rq.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_FltMsgDisp_Rq
{
    _mCHASSIS_HMI_R1_AR.DTQ_FltMsgDisp_Rq.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_Md_Stat
{
    _mCHASSIS_HMI_R1_AR.DTQ_Md_Stat.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_Md_Stat_UB
{
    _mCHASSIS_HMI_R1_AR.DTQ_Md_Stat_UB.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_MsgDisp_Rq_V2
{
    _mCHASSIS_HMI_R1_AR.DTQ_MsgDisp_Rq_V2.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_Stat_Disp_Rq
{
    _mCHASSIS_HMI_R1_AR.DTQ_Stat_Disp_Rq.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

//on EnvVar HMI_Eng_Rs3_UB
//{
//    _mCHASSIS_HMI_R1_AR.Eng_Rs3_UB.phys = getValue(this);
//    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
//}

on EnvVar HMI_ExhstFlap_Stg_AMG
{
    _mCHASSIS_HMI_R1_AR.ExhstFlap_Stg_AMG.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_ExhstFlap_Stg_AMG_UB
{
    _mCHASSIS_HMI_R1_AR.ExhstFlap_Stg_AMG_UB.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_TxDrvProgMan_Actv
{
    _mCHASSIS_HMI_R1_AR.TxDrvProgMan_Actv.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_TxDrvProgMan_Actv_UB
{
    _mCHASSIS_HMI_R1_AR.TxDrvProgMan_Actv_UB = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_VehDrvProg_TCM_V3
{
    _mCHASSIS_HMI_R1_AR.VehDrvProg_TCM_V3.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_VehDrvProg_TCM_V3_UB
{
    _mCHASSIS_HMI_R1_AR.VehDrvProg_TCM_V3_UB.phys = getValue(this);
    _CHASSIS_HMI_R1_AR_SpontanFlag = 1;
}

CHASSIS_HMI_R2_AR_check_output()
{
    if( !getValue( HMI__STMSG_CHASSIS_HMI_R2_AR ) )
    {
    //  message   CHASSIS_HMI_R2_AR ID: 615 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _CHASSIS_HMI_R2_AR_Cnt--;
        if( _CHASSIS_HMI_R2_AR_Cnt < 1 )
        {
            CHASSIS_HMI_R2_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _CHASSIS_HMI_R2_AR_Cnt = _CHASSIS_HMI_R2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _CHASSIS_HMI_R2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _CHASSIS_HMI_R2_AR_SpontanFlag )
        {
            CHASSIS_HMI_R2_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _CHASSIS_HMI_R2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

CHASSIS_HMI_R2_AR_init()
{   /* Botschaft CHASSIS_HMI_R2_AR ID: 615 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 615 0;
BA_ "NmAsrMessage" BO_ 615 0;
BA_ "GenMsgMinAcceptLength" BO_ 615 8;
BA_ "GenMsgILSupport" BO_ 615 1;
BA_ "DiagState" BO_ 615 0;
BA_ "DiagRequest" BO_ 615 0;
BA_ "DiagResponse" BO_ 615 0;
BA_ "GenMsgStartValue" BO_ 615 "0";
BA_ "GenMsgStartDelayTime" BO_ 615 140;
BA_ "GenMsgDelayTime" BO_ 615 20;
BA_ "GenMsgNrOfRepetitions" BO_ 615 0;
BA_ "GenMsgCycleTime" BO_ 615 200;
BA_ "GenMsgSendType" BO_ 615 5;
    */
    _CHASSIS_HMI_R2_AR_Timebase =        c_tDBKomTimer_20ms;
    _CHASSIS_HMI_R2_AR_CycleCount =    200 / _CHASSIS_HMI_R2_AR_Timebase;
    _CHASSIS_HMI_R2_AR_StartDelay =    140 / _CHASSIS_HMI_R2_AR_Timebase;
    _CHASSIS_HMI_R2_AR_Cnt = _CHASSIS_HMI_R2_AR_StartDelay;
    _CHASSIS_HMI_R2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CHASSIS_HMI_R2_AR, _CHASSIS_HMI_R2_AR_StartDelay * _CHASSIS_HMI_R2_AR_Timebase );

    _mCHASSIS_HMI_R2_AR.Brk_Stat.phys =              getValue( HMI_Brk_Stat );
    _mCHASSIS_HMI_R2_AR.BrkPdl_Stat.phys =           getValue( HMI_BrkPdl_Stat );
  //  _mCHASSIS_HMI_R2_AR.BrkSys_Stat_UB.phys =        getValue( HMI_BrkSys_Stat_UB );
    _mCHASSIS_HMI_R2_AR.BrkTrq_V2.phys =             getValue( HMI_BrkTrq_V2 );
    _mCHASSIS_HMI_R2_AR.EmgBrk_Actv.phys =           getValue( HMI_EmgBrk_Actv );
  //  _mCHASSIS_HMI_R2_AR.EPKB_Stat_UB.phys =          getValue( HMI_EPKB_Stat_UB );
    _mCHASSIS_HMI_R2_AR.ESP_Enbl_Rq_EPKB.phys =      getValue( HMI_ESP_Enbl_Rq_EPKB );
    _mCHASSIS_HMI_R2_AR.ESP_Oprtn_Stat_AS_V2.phys =  getValue( HMI_ESP_Oprtn_Stat_AS_V2 );
    _mCHASSIS_HMI_R2_AR.Gr.phys =                    getValue( HMI_Gr );
    _mCHASSIS_HMI_R2_AR.Gr_Target.phys =                    getValue( HMI_Gr_Target );
    _mCHASSIS_HMI_R2_AR.PARK_Sp_Stat.phys =          getValue( HMI_PARK_Sp_Stat );
    _mCHASSIS_HMI_R2_AR.PARK_Stat_PARK.phys =        getValue( HMI_PARK_Stat_PARK );
  //  _mCHASSIS_HMI_R2_AR.ParkCfg_Stat_UB.phys =       getValue( HMI_ParkCfg_Stat_UB );
    _mCHASSIS_HMI_R2_AR.ParkGuid_Stat.phys =         getValue( HMI_ParkGuid_Stat );
    _mCHASSIS_HMI_R2_AR.ParkStyle_V2.phys =          getValue( HMI_ParkStyle_V2 );
    _mCHASSIS_HMI_R2_AR.PkBrk_Stat.phys =            getValue( HMI_PkBrk_Stat );
 //   _mCHASSIS_HMI_R2_AR.St_Rq_PARK_UB.phys =         getValue( HMI_St_Rq_PARK_UB );
    _mCHASSIS_HMI_R2_AR.StWhl_Cond_Disp_Rq.phys =    getValue( HMI_StWhl_Cond_Disp_Rq );
    _mCHASSIS_HMI_R2_AR.StWhl_Cond_Disp_Rq_UB.phys = getValue( HMI_StWhl_Cond_Disp_Rq_UB );
    _mCHASSIS_HMI_R2_AR.TCM_Data2_UB.phys =          getValue( HMI_TCM_Data2_UB );
    _mCHASSIS_HMI_R2_AR.TSL_Posn_TCM.phys =          getValue( HMI_TSL_Posn_TCM );
}

CHASSIS_HMI_R2_AR_output(void)
{
    output( _mCHASSIS_HMI_R2_AR );
}

CHASSIS_HMI_R2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CHASSIS_HMI_R2_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CHASSIS_HMI_R2_AR := %X\n", getValue( HMI__STMSG_CHASSIS_HMI_R2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CHASSIS_HMI_R2_AR := %X\n", getValue( HMI__STMSGT_CHASSIS_HMI_R2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Brk_Stat := %X\n", getValue( HMI_Brk_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkPdl_Stat := %X\n", getValue( HMI_BrkPdl_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
  //  snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkSys_Stat_UB := %X\n", getValue( HMI_BrkSys_Stat_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkTrq_V2 := %X\n", getValue( HMI_BrkTrq_V2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EmgBrk_Actv := %X\n", getValue( HMI_EmgBrk_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EPKB_Stat_UB := %X\n", getValue( HMI_EPKB_Stat_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ESP_Enbl_Rq_EPKB := %X\n", getValue( HMI_ESP_Enbl_Rq_EPKB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ESP_Oprtn_Stat_AS_V2 := %X\n", getValue( HMI_ESP_Oprtn_Stat_AS_V2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Gr := %X\n", getValue( HMI_Gr ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Gr_Target := %X\n", getValue( HMI_Gr_Target ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Sp_Stat := %X\n", getValue( HMI_PARK_Sp_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Stat_PARK := %X\n", getValue( HMI_PARK_Stat_PARK ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkCfg_Stat_UB := %X\n", getValue( HMI_ParkCfg_Stat_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkGuid_Stat := %X\n", getValue( HMI_ParkGuid_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkStyle_V2 := %X\n", getValue( HMI_ParkStyle_V2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PkBrk_Stat := %X\n", getValue( HMI_PkBrk_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_St_Rq_PARK_UB := %X\n", getValue( HMI_St_Rq_PARK_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Cond_Disp_Rq := %X\n", getValue( HMI_StWhl_Cond_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Cond_Disp_Rq_UB := %X\n", getValue( HMI_StWhl_Cond_Disp_Rq_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCM_Data2_UB := %X\n", getValue( HMI_TCM_Data2_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSL_Posn_TCM := %X\n", getValue( HMI_TSL_Posn_TCM ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tCHASSIS_HMI_R2_AR
{
    putValue( HMI__STMSG_CHASSIS_HMI_R2_AR, 0 );
}

on EnvVar HMI__STMSG_CHASSIS_HMI_R2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CHASSIS_HMI_R2_AR );
        if( tDelay > 0)    
            setTimer( _tCHASSIS_HMI_R2_AR, tDelay );
        else
            putValue( HMI__STMSG_CHASSIS_HMI_R2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CHASSIS_HMI_R2_AR
{
    if( getValue( this ) )
        openPanel("CHASSIS_HMI_R2_AR");
}

on EnvVar HMI_Brk_Stat
{
    _mCHASSIS_HMI_R2_AR.Brk_Stat.phys = getValue(this);
    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_BrkPdl_Stat
{
    _mCHASSIS_HMI_R2_AR.BrkPdl_Stat.phys = getValue(this);
    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
}

//on EnvVar HMI_BrkSys_Stat_UB
//{
//    _mCHASSIS_HMI_R2_AR.BrkSys_Stat_UB.phys = getValue(this);
//    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
//}

on EnvVar HMI_BrkTrq_V2
{
    _mCHASSIS_HMI_R2_AR.BrkTrq_V2.phys = getValue(this);
    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_EmgBrk_Actv
{
    _mCHASSIS_HMI_R2_AR.EmgBrk_Actv.phys = getValue(this);
    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
}

//on EnvVar HMI_EPKB_Stat_UB
//{
//    _mCHASSIS_HMI_R2_AR.EPKB_Stat_UB.phys = getValue(this);
//    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
//}

on EnvVar HMI_ESP_Enbl_Rq_EPKB
{
    _mCHASSIS_HMI_R2_AR.ESP_Enbl_Rq_EPKB.phys = getValue(this);
    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_ESP_Oprtn_Stat_AS_V2
{
    _mCHASSIS_HMI_R2_AR.ESP_Oprtn_Stat_AS_V2.phys = getValue(this);
    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Gr
{
    _mCHASSIS_HMI_R2_AR.Gr.phys = getValue(this);
    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Gr_Target
{
    _mCHASSIS_HMI_R2_AR.Gr_Target.phys = getValue(this);
    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PARK_Sp_Stat
{
    _mCHASSIS_HMI_R2_AR.PARK_Sp_Stat.phys = getValue(this);
    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PARK_Stat_PARK
{
    _mCHASSIS_HMI_R2_AR.PARK_Stat_PARK.phys = getValue(this);
    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
}

//on EnvVar HMI_ParkCfg_Stat_UB
//{
//    _mCHASSIS_HMI_R2_AR.ParkCfg_Stat_UB.phys = getValue(this);
//    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
//}

on EnvVar HMI_ParkGuid_Stat
{
    _mCHASSIS_HMI_R2_AR.ParkGuid_Stat.phys = getValue(this);
    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkStyle_V2
{
    _mCHASSIS_HMI_R2_AR.ParkStyle_V2.phys = getValue(this);
    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PkBrk_Stat
{
    _mCHASSIS_HMI_R2_AR.PkBrk_Stat.phys = getValue(this);
    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
}

//on EnvVar HMI_St_Rq_PARK_UB
//{
//    _mCHASSIS_HMI_R2_AR.St_Rq_PARK_UB.phys = getValue(this);
//    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
//}

on EnvVar HMI_StWhl_Cond_Disp_Rq
{
    _mCHASSIS_HMI_R2_AR.StWhl_Cond_Disp_Rq.phys = getValue(this);
    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Cond_Disp_Rq_UB
{
    _mCHASSIS_HMI_R2_AR.StWhl_Cond_Disp_Rq_UB.phys = getValue(this);
    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCM_Data2_UB
{
    _mCHASSIS_HMI_R2_AR.TCM_Data2_UB.phys = getValue(this);
    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSL_Posn_TCM
{
    _mCHASSIS_HMI_R2_AR.TSL_Posn_TCM.phys = getValue(this);
    _CHASSIS_HMI_R2_AR_SpontanFlag = 1;
}

CHASSIS_HMI_R3_AR_check_output()
{
    if( !getValue( HMI__STMSG_CHASSIS_HMI_R3_AR ) )
    {
    //  message   CHASSIS_HMI_R3_AR ID: 617 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _CHASSIS_HMI_R3_AR_Cnt--;
        if( _CHASSIS_HMI_R3_AR_Cnt < 1 )
        {
            CHASSIS_HMI_R3_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _CHASSIS_HMI_R3_AR_Cnt = _CHASSIS_HMI_R3_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _CHASSIS_HMI_R3_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _CHASSIS_HMI_R3_AR_SpontanFlag )
        {
            CHASSIS_HMI_R3_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _CHASSIS_HMI_R3_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

CHASSIS_HMI_R3_AR_init()
{   /* Botschaft CHASSIS_HMI_R3_AR ID: 617 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 617 0;
BA_ "NmAsrMessage" BO_ 617 0;
BA_ "GenMsgMinAcceptLength" BO_ 617 8;
BA_ "GenMsgILSupport" BO_ 617 1;
BA_ "DiagState" BO_ 617 0;
BA_ "DiagRequest" BO_ 617 0;
BA_ "DiagResponse" BO_ 617 0;
BA_ "GenMsgStartValue" BO_ 617 "0";
BA_ "GenMsgStartDelayTime" BO_ 617 60;
BA_ "GenMsgDelayTime" BO_ 617 20;
BA_ "GenMsgNrOfRepetition" BO_ 617 0;
BA_ "GenMsgCycleTime" BO_ 617 100;
BA_ "GenMsgSendType" BO_ 617 5;
    */
    _CHASSIS_HMI_R3_AR_Timebase =         c_tDBKomTimer_20ms;
    _CHASSIS_HMI_R3_AR_CycleCount =     100 / _CHASSIS_HMI_R3_AR_Timebase;
    _CHASSIS_HMI_R3_AR_StartDelay =      60 / _CHASSIS_HMI_R3_AR_Timebase;
    _CHASSIS_HMI_R3_AR_Cnt = _CHASSIS_HMI_R3_AR_StartDelay;
    _CHASSIS_HMI_R3_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CHASSIS_HMI_R3_AR, _CHASSIS_HMI_R3_AR_StartDelay * _CHASSIS_HMI_R3_AR_Timebase );

    _mCHASSIS_HMI_R3_AR.AWD_TCASE_Stat1_UB.phys =              getValue( HMI_AWD_TCASE_Stat1_UB );
    _mCHASSIS_HMI_R3_AR.DPC_Md_PT_BatLvl_SOC_Stat.phys =       getValue( HMI_DPC_Md_PT_BatLvl_SOC_Stat );
    _mCHASSIS_HMI_R3_AR.DPC_Md_PT_BatLvl_SOC_Stat_UB.phys =    getValue( HMI_DPC_Md_PT_BatLvl_SOC_Stat_UB );
    _mCHASSIS_HMI_R3_AR.EngOilTemp.phys =                      getValue( HMI_EngOilTemp );
    _mCHASSIS_HMI_R3_AR.EngOilTemp_UB.phys =                   getValue( HMI_EngOilTemp_UB );
    _mCHASSIS_HMI_R3_AR.FanMtrIndLmp_On_Rq.phys =              getValue( HMI_FanMtrIndLmp_On_Rq );
    _mCHASSIS_HMI_R3_AR.FanMtrIndLmp_On_Rq_UB.phys =           getValue( HMI_FanMtrIndLmp_On_Rq_UB );
    _mCHASSIS_HMI_R3_AR.Gr_TCASE_V2.phys =                     getValue( HMI_Gr_TCASE_V2 );  
    _mCHASSIS_HMI_R3_AR.HMSW_Act_Stat.phys =                   getValue( HMI_HMSW_Act_Stat );
    _mCHASSIS_HMI_R3_AR.HMSW_Act_Stat_UB.phys =                getValue( HMI_HMSW_Act_Stat_UB );
    _mCHASSIS_HMI_R3_AR.LowTempCoolIndLmp_On_Rq.phys =         getValue( HMI_LowTempCoolIndLmp_On_Rq );
    _mCHASSIS_HMI_R3_AR.LowTempCoolIndLmp_On_Rq_UB.phys =      getValue( HMI_LowTempCoolIndLmp_On_Rq_UB );
    _mCHASSIS_HMI_R3_AR.PT_Rdy_V2.phys =                       getValue( HMI_PT_Rdy_V2 );
    _mCHASSIS_HMI_R3_AR.PT_Stat_UB.phys =                      getValue( HMI_PT_Stat_UB );
    _mCHASSIS_HMI_R3_AR.SBW_Stat_UB.phys =                     getValue( HMI_SBW_Stat_UB );
    _mCHASSIS_HMI_R3_AR.SSA_Standby_Stat.phys =                getValue( HMI_SSA_Standby_Stat );
    _mCHASSIS_HMI_R3_AR.TSL_Posn_P_ISM.phys =                  getValue( HMI_TSL_Posn_P_ISM );
    _mCHASSIS_HMI_R3_AR.TSL_Posn_Target.phys =                 getValue( HMI_TSL_Posn_Target );
    _mCHASSIS_HMI_R3_AR.TxOilTemp.phys =                       getValue( HMI_TxOilTemp );
    _mCHASSIS_HMI_R3_AR.TxOilTemp_UB.phys =                    getValue( HMI_TxOilTemp_UB );
    _mCHASSIS_HMI_R3_AR.TxShiftStyle_V2.phys =                 getValue( HMI_TxShiftStyle_V2 );
    _mCHASSIS_HMI_R3_AR.TxShiftStyle_V2_UB.phys =              getValue( HMI_TxShiftStyle_V2_UB );
}

CHASSIS_HMI_R3_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_PT_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_PT_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _CHASSIS_HMI_R3_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _CHASSIS_HMI_R3_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_PT_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _CHASSIS_HMI_R3_AR_SQC_WrongSeqJump != 0 ) &&
            ( _CHASSIS_HMI_R3_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _CHASSIS_HMI_R3_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _CHASSIS_HMI_R3_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _CHASSIS_HMI_R3_AR_SQC_RepeatedCnt ) &&
            ( _CHASSIS_HMI_R3_AR_E2E_Armed == 1  )    )
        {
            _CHASSIS_HMI_R3_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_PT_Stat, SQC_help );
    }
    _mCHASSIS_HMI_R3_AR.SQC_PT_Stat = SQC_help;

    if( getValue( HMI_CRC_PT_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_PT_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mCHASSIS_HMI_R3_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mCHASSIS_HMI_R3_AR.byte( 1 ) ];
//            crc = crctable_profile02[ crc ^ _mCHASSIS_HMI_R3_AR.byte( 2 ) ];
//            crc = crctable_profile02[ crc ^ _mCHASSIS_HMI_R3_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mCHASSIS_HMI_R3_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mCHASSIS_HMI_R3_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mCHASSIS_HMI_R3_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mCHASSIS_HMI_R3_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _CHASSIS_HMI_R3_AR_CRC_Offset[ _mCHASSIS_HMI_R3_AR.SQC_PT_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _CHASSIS_HMI_R3_AR_CRC_ErrorCnt   && ( _CHASSIS_HMI_R3_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_PT_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _CHASSIS_HMI_R3_AR_CRC_ErrorCnt > 0 )
                    _CHASSIS_HMI_R3_AR_CRC_ErrorCnt--; 
            }
            _mCHASSIS_HMI_R3_AR.CRC_PT_Stat = crc;
            putValue( HMI_CRC_PT_Stat, crc );
        }
        else
            _mCHASSIS_HMI_R3_AR.CRC_PT_Stat = getValue( HMI_CRC_PT_Stat );
    }
    else
    {
        if( !getValue( HMI_CRC_PT_Stat_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mCHASSIS_HMI_R3_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mCHASSIS_HMI_R3_AR.byte( 1 ) ];
//            crc = crctable[ crc ^ _mCHASSIS_HMI_R3_AR.byte( 2 ) ];
//            crc = crctable[ crc ^ _mCHASSIS_HMI_R3_AR.byte( 3 ) ];
//            crc = crctable[ crc ^ _mCHASSIS_HMI_R3_AR.byte( 4 ) ];
//            crc = crctable[ crc ^ _mCHASSIS_HMI_R3_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mCHASSIS_HMI_R3_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mCHASSIS_HMI_R3_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _CHASSIS_HMI_R3_AR_CRC_ErrorCnt   && ( _CHASSIS_HMI_R3_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_PT_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _CHASSIS_HMI_R3_AR_CRC_ErrorCnt > 0 )
                    _CHASSIS_HMI_R3_AR_CRC_ErrorCnt--; 
            }
            _mCHASSIS_HMI_R3_AR.CRC_PT_Stat = crc;
            putValue( HMI_CRC_PT_Stat, crc );
        }
        else
            _mCHASSIS_HMI_R3_AR.CRC_PT_Stat = getValue( HMI_CRC_PT_Stat );
    }
    if( ( _CHASSIS_HMI_R3_AR_MSG_DropCnt > 0 ) &&
        ( _CHASSIS_HMI_R3_AR_E2E_Armed == 1  )    )
    {
        _CHASSIS_HMI_R3_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mCHASSIS_HMI_R3_AR );
        
    if( _CHASSIS_HMI_R3_AR_E2E_Armed == 1 )
    {
        if ( ( _CHASSIS_HMI_R3_AR_MSG_DropCnt == 0      ) &&
             ( _CHASSIS_HMI_R3_AR_CRC_ErrorCnt == 0     ) &&
             ( _CHASSIS_HMI_R3_AR_SQC_RepeatedCnt == 0  ) &&
             ( _CHASSIS_HMI_R3_AR_SQC_WrongSeqJump == 0 )    )
        {
            _CHASSIS_HMI_R3_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_PT_Stat_State, 0 );
        }
    }
}

CHASSIS_HMI_R3_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CHASSIS_HMI_R3_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CHASSIS_HMI_R3_AR := %X\n", getValue( HMI__STMSG_CHASSIS_HMI_R3_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CHASSIS_HMI_R3_AR := %X\n", getValue( HMI__STMSGT_CHASSIS_HMI_R3_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_PT_Stat := %X\n", getValue( HMI_CRC_PT_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_PT_Stat_Auto := %X\n", getValue( HMI_CRC_PT_Stat_Auto ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_PT_Stat_Profile_02 := %X\n", getValue( HMI_CRC_PT_Stat_Profile_02 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AWD_TCASE_Stat1_UB := %X\n", getValue( HMI_AWD_TCASE_Stat1_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_PT_BatLvl_SOC_Stat := %X\n", getValue( HMI_DPC_Md_PT_BatLvl_SOC_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_PT_BatLvl_SOC_Stat_UB := %X\n", getValue( HMI_DPC_Md_PT_BatLvl_SOC_Stat_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngOilTemp := %X\n", getValue( HMI_EngOilTemp ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngOilTemp_UB := %X\n", getValue( HMI_EngOilTemp_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FanMtrIndLmp_On_Rq := %X\n", getValue( HMI_FanMtrIndLmp_On_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FanMtrIndLmp_On_Rq_UB := %X\n", getValue( HMI_FanMtrIndLmp_On_Rq_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Gr_TCASE_V2 := %X\n", getValue( HMI_Gr_TCASE_V2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HMSW_Act_Stat := %X\n", getValue( HMI_HMSW_Act_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HMSW_Act_Stat_UB := %X\n", getValue( HMI_HMSW_Act_Stat_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LowTempCoolIndLmp_On_Rq := %X\n", getValue( HMI_LowTempCoolIndLmp_On_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LowTempCoolIndLmp_On_Rq_UB := %X\n", getValue( HMI_LowTempCoolIndLmp_On_Rq_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT_Rdy_V2 := %X\n", getValue( HMI_PT_Rdy_V2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT_Stat_UB := %X\n", getValue( HMI_PT_Stat_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SBW_Stat_UB := %X\n", getValue( HMI_SBW_Stat_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_PT_Stat := %X\n", getValue( HMI_SQC_PT_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_PT_Stat_Auto := %X\n", getValue( HMI_SQC_PT_Stat_Auto ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SSA_Standby_Stat := %X\n", getValue( HMI_SSA_Standby_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSL_Posn_P_ISM := %X\n", getValue( HMI_TSL_Posn_P_ISM ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSL_Posn_Target := %X\n", getValue( HMI_TSL_Posn_Target ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TxOilTemp := %X\n", getValue( HMI_TxOilTemp ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TxOilTemp_UB := %X\n", getValue( HMI_TxOilTemp_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TxShiftStyle_V2 := %X\n", getValue( HMI_TxShiftStyle_V2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TxShiftStyle_V2_UB := %X\n", getValue( HMI_TxShiftStyle_V2_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tCHASSIS_HMI_R3_AR
{
    putValue( HMI__STMSG_CHASSIS_HMI_R3_AR, 0 );
}

on EnvVar HMI__STMSG_CHASSIS_HMI_R3_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CHASSIS_HMI_R3_AR );
        if( tDelay > 0)    
            setTimer( _tCHASSIS_HMI_R3_AR, tDelay );
        else
            putValue( HMI__STMSG_CHASSIS_HMI_R3_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CHASSIS_HMI_R3_AR
{
    if( getValue( this ) )
        openPanel("CHASSIS_HMI_R3_AR");
}

on envVar HMI_E2E_PT_Stat_Inject
{
    if( getValue( this ) )
    {
        _CHASSIS_HMI_R3_AR_CRC_ErrorCnt = getValue( HMI_CRC_PT_Stat_ErrorCount );
        _CHASSIS_HMI_R3_AR_SQC_TriggPos = getValue( HMI_SQC_PT_Stat_TriggerPosition );
        _CHASSIS_HMI_R3_AR_SQC_WrongSeqJump = getValue( HMI_SQC_PT_Stat_WrongSeq );
        _CHASSIS_HMI_R3_AR_SQC_RepeatedCnt = getValue( HMI_SQC_PT_Stat_Repeated );
        _CHASSIS_HMI_R3_AR_MSG_DropCnt = getValue( HMI_SQC_PT_Stat_MSG_DropCnt );
        putValue( HMI_E2E_PT_Stat_State, 2 );
        _CHASSIS_HMI_R3_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_AWD_TCASE_Stat1_UB
{
    _mCHASSIS_HMI_R3_AR.AWD_TCASE_Stat1_UB.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_PT_BatLvl_SOC_Stat
{
    _mCHASSIS_HMI_R3_AR.DPC_Md_PT_BatLvl_SOC_Stat.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_PT_BatLvl_SOC_Stat_UB
{
    _mCHASSIS_HMI_R3_AR.DPC_Md_PT_BatLvl_SOC_Stat_UB.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_EngOilTemp
{
    _mCHASSIS_HMI_R3_AR.EngOilTemp.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_EngOilTemp_UB
{
    _mCHASSIS_HMI_R3_AR.EngOilTemp_UB.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_FanMtrIndLmp_On_Rq
{
    _mCHASSIS_HMI_R3_AR.FanMtrIndLmp_On_Rq.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_FanMtrIndLmp_On_Rq_UB
{
    _mCHASSIS_HMI_R3_AR.FanMtrIndLmp_On_Rq_UB.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_Gr_TCASE_V2
{
    _mCHASSIS_HMI_R3_AR.Gr_TCASE_V2.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HMSW_Act_Stat
{
    _mCHASSIS_HMI_R3_AR.HMSW_Act_Stat.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HMSW_Act_Stat_UB
{
    _mCHASSIS_HMI_R3_AR.HMSW_Act_Stat_UB.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_LowTempCoolIndLmp_On_Rq
{
    _mCHASSIS_HMI_R3_AR.LowTempCoolIndLmp_On_Rq.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_LowTempCoolIndLmp_On_Rq_UB
{
    _mCHASSIS_HMI_R3_AR.LowTempCoolIndLmp_On_Rq_UB.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}       

on EnvVar HMI_PT_Stat_UB
{
    _mCHASSIS_HMI_R3_AR.PT_Stat_UB.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_PT_Rdy_V2
{
    _mCHASSIS_HMI_R3_AR.PT_Rdy_V2.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_SBW_Stat_UB
{
    _mCHASSIS_HMI_R3_AR.SBW_Stat_UB.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_SSA_Standby_Stat
{
    _mCHASSIS_HMI_R3_AR.SSA_Standby_Stat.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSL_Posn_P_ISM
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cGearIndNMRequest );
        setTimer( t_GearIndNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mCHASSIS_HMI_R3_AR.TSL_Posn_P_ISM.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSL_Posn_Target
{
    _mCHASSIS_HMI_R3_AR.TSL_Posn_Target.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_TxOilTemp
{
    _mCHASSIS_HMI_R3_AR.TxOilTemp.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_TxOilTemp_UB
{
    _mCHASSIS_HMI_R3_AR.TxOilTemp_UB.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_TxShiftStyle_V2
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cGearIndNMRequest );
        setTimer( t_GearIndNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mCHASSIS_HMI_R3_AR.TxShiftStyle_V2.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

on EnvVar HMI_TxShiftStyle_V2_UB
{
    _mCHASSIS_HMI_R3_AR.TxShiftStyle_V2_UB.phys = getValue(this);
    _CHASSIS_HMI_R3_AR_SpontanFlag = 1;
}

CHASSIS_HMI_R4_AR_check_output()
{
    if( !getValue( HMI__STMSG_CHASSIS_HMI_R4_AR ) )
    {
    //  message   CHASSIS_HMI_R4_AR ID: 619 --- Sendeart 0 cyclic --- 
        _CHASSIS_HMI_R4_AR_Cnt--;
        if( _CHASSIS_HMI_R4_AR_Cnt < 1 )
        {
            CHASSIS_HMI_R4_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _CHASSIS_HMI_R4_AR_Cnt = _CHASSIS_HMI_R4_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

CHASSIS_HMI_R4_AR_init()
{    /* Botschaft CHASSIS_HMI_R4_AR ID: 619--- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 619 0;
BA_ "NmAsrMessage" BO_ 619 0;
BA_ "GenMsgMinAcceptLength" BO_ 619 8;
BA_ "GenMsgILSupport" BO_ 619 1;
BA_ "DiagState" BO_ 619 0;
BA_ "DiagRequest" BO_ 619 0;
BA_ "DiagResponse" BO_ 619 0;
BA_ "GenMsgStartValue" BO_ 619 "0";
BA_ "GenMsgStartDelayTime" BO_ 619 80;
BA_ "GenMsgCycleTime" BO_ 619 100;
BA_ "GenMsgSendType" BO_ 619 0;
    */
    _CHASSIS_HMI_R4_AR_Timebase =         c_tDBKomTimer_20ms;
    _CHASSIS_HMI_R4_AR_CycleCount =     100 / _CHASSIS_HMI_R4_AR_Timebase;
    _CHASSIS_HMI_R4_AR_StartDelay =      80 / _CHASSIS_HMI_R4_AR_Timebase;
    _CHASSIS_HMI_R4_AR_Cnt = _CHASSIS_HMI_R4_AR_StartDelay;

    putValue( HMI__STMSGSD_CHASSIS_HMI_R4_AR, _CHASSIS_HMI_R4_AR_StartDelay * _CHASSIS_HMI_R4_AR_Timebase );

    _mCHASSIS_HMI_R4_AR.EPS_FtWhlAngl.phys = getValue( HMI_EPS_FtWhlAngl );
    _mCHASSIS_HMI_R4_AR.EPS_FtWhlAngl_Offset.phys = getValue( HMI_EPS_FtWhlAngl_Offset );
    _mCHASSIS_HMI_R4_AR.EPS_FtWhlAngl_Stat.phys = getValue( HMI_EPS_FtWhlAngl_Stat );
  //  _mCHASSIS_HMI_R4_AR.STA_Rs1_UB.phys = getValue( HMI_STA_Rs1_UB );
    _mCHASSIS_HMI_R4_AR.PNHV_ChrgCurr_Lim_Disp_Rq.phys = getValue( HMI_PNHV_ChrgCurr_Lim_Disp_Rq );
    _mCHASSIS_HMI_R4_AR.PNHV_ChrgCurr_Lim_Disp_Rq_UB.phys = getValue( HMI_PNHV_ChrgCurr_Lim_Disp_Rq_UB );
    _mCHASSIS_HMI_R4_AR.EM01_RPM.phys = getValue( HMI_EM01_RPM );
	_mCHASSIS_HMI_R4_AR.EM01_Stat1_UB.phys = getValue( HMI_EM01_Stat1_UB );
	_mCHASSIS_HMI_R4_AR.EM01_Trq.phys = getValue( HMI_EM01_Trq );
    _mCHASSIS_HMI_R4_AR.WprSw6Posn.phys = getValue( HMI_WprSw6Posn );
	_mCHASSIS_HMI_R4_AR.WprWashSw_Stat_UB.phys = getValue( HMI_WprWashSw_Stat_UB );
	
	
}

CHASSIS_HMI_R4_AR_output(void)
{
    output( _mCHASSIS_HMI_R4_AR );
}

CHASSIS_HMI_R4_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CHASSIS_HMI_R4_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CHASSIS_HMI_R4_AR := %X\n", getValue( HMI__STMSG_CHASSIS_HMI_R4_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CHASSIS_HMI_R4_AR := %X\n", getValue( HMI__STMSGT_CHASSIS_HMI_R4_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EPS_FtWhlAngl := %X\n", getValue( HMI_EPS_FtWhlAngl ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EPS_FtWhlAngl_Offset := %X\n", getValue( HMI_EPS_FtWhlAngl_Offset ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EPS_FtWhlAngl_Stat := %X\n", getValue( HMI_EPS_FtWhlAngl_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_STA_Rs1_UB := %X\n", getValue( HMI_STA_Rs1_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount(buffer), "0.0000 HMI_PNHV_ChrgCurr_Lim_Disp_Rq := %X\n", getValue( HMI_PNHV_ChrgCurr_Lim_Disp_Rq ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_PNHV_ChrgCurr_Lim_Disp_Rq_UB := %X\n", getValue( HMI_PNHV_ChrgCurr_Lim_Disp_Rq_UB ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EM01_RPM := %X\n", getValue( HMI_EM01_RPM ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EM01_Trq := %X\n", getValue( HMI_EM01_Trq ) );		filePutString (buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_EM01_Stat1_UB := %X\n", getValue( HMI_EM01_Stat1_UB ) );	filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_WprWashSw_Stat_UB := %X\n", getValue( HMI_WprWashSw_Stat_UB ) ); filePutString( buffer, elcount( buffer ), hFile);
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_WprSw6Posn := %X\n", getValue( HMI_WprSw6Posn ) );    filePutString ( buffer, elcount( buffer ), hFile );
	
}

on timer _tCHASSIS_HMI_R4_AR
{
    putValue( HMI__STMSG_CHASSIS_HMI_R4_AR, 0 );
}

on EnvVar HMI__STMSG_CHASSIS_HMI_R4_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CHASSIS_HMI_R4_AR );
        if( tDelay > 0)    
            setTimer( _tCHASSIS_HMI_R4_AR, tDelay );
        else
            putValue( HMI__STMSG_CHASSIS_HMI_R4_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CHASSIS_HMI_R4_AR
{
    if( getValue( this ) )
        openPanel("CHASSIS_HMI_R4_AR");
}

on EnvVar HMI_EPS_FtWhlAngl
{
    _mCHASSIS_HMI_R4_AR.EPS_FtWhlAngl.phys = getValue(this);
}

on EnvVar HMI_EPS_FtWhlAngl_Offset
{
    _mCHASSIS_HMI_R4_AR.EPS_FtWhlAngl_Offset.phys = getValue(this);
}

on EnvVar HMI_EPS_FtWhlAngl_Stat
{
    _mCHASSIS_HMI_R4_AR.EPS_FtWhlAngl_Stat.phys = getValue(this);
}

on EnvVar HMI_EM01_Stat1_UB
{
	_mCHASSIS_HMI_R4_AR.EM01_Stat1_UB.phys = getValue(this);
}

on EnvVar HMI_EM01_Trq
{
	_mCHASSIS_HMI_R4_AR.EM01_Trq.phys = getValue(this);
}

//on EnvVar HMI_STA_Rs1_UB
//{
//    _mCHASSIS_HMI_R4_AR.STA_Rs1_UB.phys = getValue(this);
//}

on EnvVar HMI_PNHV_ChrgCurr_Lim_Disp_Rq
{
    _mCHASSIS_HMI_R4_AR.PNHV_ChrgCurr_Lim_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_PNHV_ChrgCurr_Lim_Disp_Rq_UB
{
    _mCHASSIS_HMI_R4_AR.PNHV_ChrgCurr_Lim_Disp_Rq_UB.phys = getValue(this);
}

on EnvVar HMI_EM01_RPM
{
    _mCHASSIS_HMI_R4_AR.EM01_RPM.phys = getValue(this);
}

on EnvVar HMI_WprSw6Posn
{
    _mCHASSIS_HMI_R4_AR.WprSw6Posn.phys = getValue(this);
}

on EnvVar HMI_WprWashSw_Stat_UB
{
	_mCHASSIS_HMI_R4_AR.WprWashSw_Stat_UB.phys = getValue(this);
}

CHASSISPERIPHERY_HMI_R1_AR_check_output()
{
    if( !getValue( HMI__STMSG_CHASSISPERIPHERY_HMI_R1_AR ) )
    {
    //  message   CHASSISPERIPHERY_HMI_R1_AR ID: 319 --- Sendeart 0 cyclicX
        _CHASSISPERIPHERY_HMI_R1_AR_Cnt--;
        if( _CHASSISPERIPHERY_HMI_R1_AR_Cnt < 1 )
        {
            CHASSISPERIPHERY_HMI_R1_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _CHASSISPERIPHERY_HMI_R1_AR_Cnt = _CHASSISPERIPHERY_HMI_R1_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

//CHASSIS_HMI_R5_AR_check_output()
//{
//    if( !getValue( HMI__STMSG_CHASSIS_HMI_R5_AR ) )
//    {
//    //  message   CHASSIS_HMI_R5_AR ID: 1040 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
//        if( _CHASSIS_HMI_R5_AR_DelayCnt > 0) _CHASSIS_HMI_R5_AR_DelayCnt--; // Mindestsendeabstand
//        _CHASSIS_HMI_R5_AR_Cnt--;
//        if( _CHASSIS_HMI_R5_AR_Cnt < 1 )
//        {
//            if( _CHASSIS_HMI_R5_AR_DelayCnt < 1 )
//            {
//                CHASSIS_HMI_R5_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
//                 _CHASSIS_HMI_R5_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
//                _CHASSIS_HMI_R5_AR_DelayCnt = _CHASSIS_HMI_R5_AR_MinDelay;
//            }
//            else
//            {
//                 _CHASSIS_HMI_R5_AR_SpontanFlag = 1; // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
//            }
//            _CHASSIS_HMI_R5_AR_Cnt = _CHASSIS_HMI_R5_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
//        }
//        else if( _CHASSIS_HMI_R5_AR_SpontanFlag)
//        {
//            if( _CHASSIS_HMI_R5_AR_DelayCnt < 1 )
//            {
//                CHASSIS_HMI_R5_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
//                _CHASSIS_HMI_R5_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
//                _CHASSIS_HMI_R5_AR_DelayCnt = _CHASSIS_HMI_R5_AR_MinDelay;
//            }
//        }
//    }
//}
//
//CHASSIS_HMI_R5_AR_init()
//{   /* Botschaft CHASSIS_HMI_R5_AR ID: 1040 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
//BA_ "ApplMessage" BO_ 1040 0;
//BA_ "NmAsrMessage" BO_ 1040 0;
//BA_ "GenMsgMinAcceptLength" BO_ 1040 8;
//BA_ "GenMsgILSupport" BO_ 1040 1;
//BA_ "DiagState" BO_ 1040 0;
//BA_ "DiagRequest" BO_ 1040 0;
//BA_ "DiagResponse" BO_ 1040 0;
//BA_ "GenMsgStartValue" BO_ 1040 "0";
//BA_ "GenMsgStartDelayTime" BO_ 1040 95;
//BA_ "GenMsgDelayTime" BO_ 1040 20;
//BA_ "GenMsgNrOfRepetition" BO_ 1040 0;
//BA_ "GenMsgCycleTime" BO_ 1040 200;
//BA_ "GenMsgSendType" BO_ 1040 5;
//    */
//    _CHASSIS_HMI_R5_AR_Timebase =          c_tDBKomTimer_20ms;
//    _CHASSIS_HMI_R5_AR_CycleCount =       500 / _CHASSIS_HMI_R5_AR_Timebase;
//    _CHASSIS_HMI_R5_AR_StartDelay =        95 / _CHASSIS_HMI_R5_AR_Timebase;
//    _CHASSIS_HMI_R5_AR_MinDelay =          20 / _CHASSIS_HMI_R5_AR_Timebase;
//    _CHASSIS_HMI_R5_AR_Cnt = _CHASSIS_HMI_R5_AR_StartDelay;
//    _CHASSIS_HMI_R5_AR_SpontanFlag = 0;
//    _CHASSIS_HMI_R5_AR_DelayCnt = 0;
//
//    putValue( HMI__STMSGSD_CHASSIS_HMI_R5_AR, _CHASSIS_HMI_R5_AR_StartDelay * _CHASSIS_HMI_R5_AR_Timebase );
//
//    _mCHASSIS_HMI_R5_AR.PARK_Hitch_DrawbarLgth.phys = getValue( HMI_PARK_Hitch_DrawbarLgth );
//    _mCHASSIS_HMI_R5_AR.PARK_Hitch_DrawbarLgth_UB.phys = getValue( HMI_PARK_Hitch_DrawbarLgth_UB );
//    _mCHASSIS_HMI_R5_AR.PARK_Hitch_DrawbarLgth_Vld.phys = getValue( HMI_PARK_Hitch_DrawbarLgth_Vld );
//    _mCHASSIS_HMI_R5_AR.PARK_Hitch_DrawbarLgth_Vld_UB.phys = getValue( HMI_PARK_Hitch_DrawbarLgth_Vld_UB );
//    _mCHASSIS_HMI_R5_AR.PARK_Hitch_KinkAngl_Target.phys = getValue( HMI_PARK_Hitch_KinkAngl_Target );
//    _mCHASSIS_HMI_R5_AR.PARK_Hitch_KinkAngl_Target_UB.phys = getValue( HMI_PARK_Hitch_KinkAngl_Target_UB );
//	  _mCHASSIS_HMI_R5_AR.PARK_Hitch_Plaus_Stat.phys = getValue( HMI_PARK_Hitch_Plaus_Stat );
//	  _mCHASSIS_HMI_R5_AR.PARK_Hitch_Plaus_Stat_UB.phys = getValue( HMI_PARK_Hitch_Plaus_Stat_UB );
//}
//
//CHASSIS_HMI_R5_AR_output(void)
//{
//    output( _mCHASSIS_HMI_R5_AR );
//}
//
//CHASSIS_HMI_R5_AR_saveEnvVars( dword hFile )
//{
//    filePutString("\n// Knoten EIS: CHASSIS_HMI_R5_AR\n", 25, hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CHASSIS_HMI_R5_AR := %X\n", getValue( HMI__STMSG_CHASSIS_HMI_R5_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CHASSIS_HMI_R5_AR := %X\n", getValue( HMI__STMSGT_CHASSIS_HMI_R5_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Hitch_DrawbarLgth := %X\n", getValue( HMI_PARK_Hitch_DrawbarLgth ) );        filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Hitch_DrawbarLgth_UB := %X\n", getValue( HMI_PARK_Hitch_DrawbarLgth_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Hitch_DrawbarLgth_Vld := %X\n", getValue( HMI_PARK_Hitch_DrawbarLgth_Vld ) );        filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Hitch_DrawbarLgth_Vld_UB := %X\n", getValue( HMI_PARK_Hitch_DrawbarLgth_Vld_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Hitch_KinkAngl_Target := %X\n", getValue( HMI_PARK_Hitch_KinkAngl_Target ) );        filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Hitch_KinkAngl_Target_UB := %X\n", getValue( HMI_PARK_Hitch_KinkAngl_Target_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
//	snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_PARK_Hitch_Plaus_Stat := %X\n", getValue( HMI_PARK_Hitch_Plaus_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
//	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Hitch_Plaus_Stat_UB := %X\n", getValue( HMI_PARK_Hitch_Plaus_Stat_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
//}
//
//on timer _tCHASSIS_HMI_R5_AR
//{
//    putValue( HMI__STMSG_CHASSIS_HMI_R5_AR, 0 );
//}
//
//on EnvVar HMI__STMSG_CHASSIS_HMI_R5_AR
//{
//    long tDelay;
//    if( getValue( this ) == 2 )
//    {
//        tDelay = getValue( HMI__STMSGT_CHASSIS_HMI_R5_AR );
//        if( tDelay > 0)    
//            setTimer( _tCHASSIS_HMI_R5_AR, tDelay );
//        else
//            putValue( HMI__STMSG_CHASSIS_HMI_R5_AR, 0 );
//    }
//}
//
//on envVar HMI__STMSG_PO_CHASSIS_HMI_R5_AR
//{
//    if( getValue( this ) )
//        openPanel("CHASSIS_HMI_R5_AR");
//}
//
//on EnvVar HMI_PARK_Hitch_DrawbarLgth
//{
//    _mCHASSIS_HMI_R5_AR.PARK_Hitch_DrawbarLgth.phys = getValue(this);
//    _CHASSIS_HMI_R5_AR_SpontanFlag = 1;
//}
//
//on EnvVar HMI_PARK_Hitch_DrawbarLgth_UB
//{
//    _mCHASSIS_HMI_R5_AR.PARK_Hitch_DrawbarLgth_UB.phys = getValue(this);
//    _CHASSIS_HMI_R5_AR_SpontanFlag = 1;
//}
//
//on EnvVar HMI_PARK_Hitch_DrawbarLgth_Vld
//{
//    _mCHASSIS_HMI_R5_AR.PARK_Hitch_DrawbarLgth_Vld.phys = getValue(this);
//    _CHASSIS_HMI_R5_AR_SpontanFlag = 1;
//}
//
//on EnvVar HMI_PARK_Hitch_DrawbarLgth_Vld_UB
//{
//    _mCHASSIS_HMI_R5_AR.PARK_Hitch_DrawbarLgth_Vld_UB.phys = getValue(this);
//    _CHASSIS_HMI_R5_AR_SpontanFlag = 1;
//}
//
//on EnvVar HMI_PARK_Hitch_KinkAngl_Target
//{
//    _mCHASSIS_HMI_R5_AR.PARK_Hitch_KinkAngl_Target.phys = getValue(this);
//    _CHASSIS_HMI_R5_AR_SpontanFlag = 1;
//}
//
//on EnvVar HMI_PARK_Hitch_KinkAngl_Target_UB
//{
//    _mCHASSIS_HMI_R5_AR.PARK_Hitch_KinkAngl_Target_UB.phys = getValue(this);
//    _CHASSIS_HMI_R5_AR_SpontanFlag = 1;
//}
//
//on EnvVar HMI_PARK_Hitch_Plaus_Stat
//{
//    _mCHASSIS_HMI_R5_AR.PARK_Hitch_Plaus_Stat.phys = getValue(this);
//    _CHASSIS_HMI_R5_AR_SpontanFlag = 1;
//}
//
//on EnvVar HMI_PARK_Hitch_Plaus_Stat_UB
//{
//    _mCHASSIS_HMI_R5_AR.PARK_Hitch_Plaus_Stat_UB.phys = getValue(this);
//    _CHASSIS_HMI_R5_AR_SpontanFlag = 1;
//}

CHASSISPERIPHERY_HMI_R1_AR_init()
{   /* Botschaft CHASSISPERIPHERY_HMI_R1_AR ID: 319 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 319 0;
BA_ "NmAsrMessage" BO_ 319 0;
BA_ "GenMsgMinAcceptLength" BO_ 319 8;
BA_ "GenMsgILSupport" BO_ 319 1;
BA_ "DiagState" BO_ 319 0;
BA_ "DiagRequest" BO_ 319 0;
BA_ "DiagResponse" BO_ 319 0;
BA_ "GenMsgStartValue" BO_ 319 "0";
BA_ "GenMsgStartDelayTime" BO_ 319 15;
BA_ "GenMsgCycleTime" BO_ 319 40;
BA_ "GenMsgSendType" BO_ 319 0;
    */
    _CHASSISPERIPHERY_HMI_R1_AR_Timebase = 20;
    _CHASSISPERIPHERY_HMI_R1_AR_Cnt = 1;
	
	_mCHASSISPERIPHERY_HMI_R1_AR.ALDW_LDP_Warn_Rq.phys = getValue( HMI_ALDW_LDP_Warn_Rq );
  //  _mCHASSISPERIPHERY_HMI_R1_AR.CamLane_LaneAttr1_UB.phys = getValue( HMI_CamLane_LaneAttr1_UB );
  //  _mCHASSISPERIPHERY_HMI_R1_AR.CamLane_LaneAttr2_UB.phys = getValue( HMI_CamLane_LaneAttr2_UB );
 //   _mCHASSISPERIPHERY_HMI_R1_AR.CamLane_LaneAttr6_UB.phys = getValue( HMI_CamLane_LaneAttr6_UB );
 //   _mCHASSISPERIPHERY_HMI_R1_AR.CamLane_LaneAttr7_UB.phys = getValue( HMI_CamLane_LaneAttr7_UB );
    _mCHASSISPERIPHERY_HMI_R1_AR.CamLane_LaneChg_Stat.phys = getValue( HMI_CamLane_LaneChg_Stat );
    _mCHASSISPERIPHERY_HMI_R1_AR.CamLane_LaneMarkType_Lt.phys = getValue( HMI_CamLane_LaneMarkType_Lt );
    _mCHASSISPERIPHERY_HMI_R1_AR.CamLane_LaneMarkType_Rt.phys = getValue( HMI_CamLane_LaneMarkType_Rt );
    _mCHASSISPERIPHERY_HMI_R1_AR.CamLane_RoadExit_Stat.phys = getValue( HMI_CamLane_RoadExit_Stat );
    _mCHASSISPERIPHERY_HMI_R1_AR.IHC_Block_Disp_Rq.phys = getValue( HMI_IHC_Block_Disp_Rq );
    _mCHASSISPERIPHERY_HMI_R1_AR.IHC_Lgt_Stat_MPC_UB.phys = getValue( HMI_IHC_Lgt_Stat_MPC_UB );
    _mCHASSISPERIPHERY_HMI_R1_AR.LDP_BrkMsgDisp_Rq_MPC.phys = getValue( HMI_LDP_BrkMsgDisp_Rq_MPC );
    _mCHASSISPERIPHERY_HMI_R1_AR.NghbrLane_Lt_Stat.phys = getValue( HMI_NghbrLane_Lt_Stat );
    _mCHASSISPERIPHERY_HMI_R1_AR.NghbrLane_Lt_Width.phys = getValue( HMI_NghbrLane_Lt_Width );
    _mCHASSISPERIPHERY_HMI_R1_AR.NghbrLane_Rt_Stat.phys = getValue( HMI_NghbrLane_Rt_Stat );
    _mCHASSISPERIPHERY_HMI_R1_AR.NghbrLane_Rt_Width.phys = getValue( HMI_NghbrLane_Rt_Width );
	_mCHASSISPERIPHERY_HMI_R1_AR.Street_Turn_Stat_HU_ESP.phys = getValue( HMI_Street_Turn_Stat_HU_ESP );
    _mCHASSISPERIPHERY_HMI_R1_AR.Street_Turn_Stat_HU_ESP_UB.phys = getValue( HMI_Street_Turn_Stat_HU_ESP_UB );
    _mCHASSISPERIPHERY_HMI_R1_AR.VirtDiffLock_M_Ratio_Disp.phys = getValue( HMI_VirtDiffLock_M_Ratio_Disp );
    _mCHASSISPERIPHERY_HMI_R1_AR.VirtDiffLock_M_Ratio_Disp_UB.phys = getValue( HMI_VirtDiffLock_M_Ratio_Disp_UB );
}

CHASSISPERIPHERY_HMI_R1_AR_output(void)
{
    output( _mCHASSISPERIPHERY_HMI_R1_AR );
}

CHASSISPERIPHERY_HMI_R1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CHASSISPERIPHERY_HMI_R1_AR\n", 31, hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CHASSISPERIPHERY_HMI_R1_AR := %X\n", getValue( HMI__STMSG_CHASSISPERIPHERY_HMI_R1_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CHASSISPERIPHERY_HMI_R1_AR := %X\n", getValue( HMI__STMSGT_CHASSISPERIPHERY_HMI_R1_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_ALDW_LDP_Warn_Rq := %X\n", getValue( HMI_ALDW_LDP_Warn_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneAttr1_UB := %X\n", getValue( HMI_CamLane_LaneAttr1_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneAttr2_UB := %X\n", getValue( HMI_CamLane_LaneAttr2_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneAttr6_UB := %X\n", getValue( HMI_CamLane_LaneAttr6_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneAttr7_UB := %X\n", getValue( HMI_CamLane_LaneAttr7_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneChg_Stat := %X\n", getValue( HMI_CamLane_LaneChg_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneMarkType_Lt := %X\n", getValue( HMI_CamLane_LaneMarkType_Lt_2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneMarkType_Rt := %X\n", getValue( HMI_CamLane_LaneMarkType_Rt_2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_RoadExit_Stat := %X\n", getValue( HMI_CamLane_RoadExit_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_Block_Disp_Rq := %X\n", getValue( HMI_IHC_Block_Disp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_Lgt_Stat_MPC_UB := %X\n", getValue( HMI_IHC_Lgt_Stat_MPC_UB ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_BrkMsgDisp_Rq_MPC := %X\n", getValue( HMI_LDP_BrkMsgDisp_Rq_MPC ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_NghbrLane_Lt_Stat := %X\n", getValue( HMI_NghbrLane_Lt_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_NghbrLane_Lt_Width := %X\n", getValue( HMI_NghbrLane_Lt_Width ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_NghbrLane_Rt_Stat := %X\n", getValue( HMI_NghbrLane_Rt_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_NghbrLane_Rt_Width := %X\n", getValue( HMI_NghbrLane_Rt_Width ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Street_Turn_Stat_HU_ESP := %X\n", getValue( HMI_Street_Turn_Stat_HU_ESP ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Street_Turn_Stat_HU_ESP_UB := %X\n", getValue( HMI_Street_Turn_Stat_HU_ESP_UB ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VirtDiffLock_M_Ratio_Disp := %X\n", getValue( HMI_VirtDiffLock_M_Ratio_Disp ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VirtDiffLock_M_Ratio_Disp_UB := %X\n", getValue( HMI_VirtDiffLock_M_Ratio_Disp_UB ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tCHASSISPERIPHERY_HMI_R1_AR
{
    putValue( HMI__STMSG_CHASSISPERIPHERY_HMI_R1_AR, 0 );
}

on EnvVar HMI__STMSG_CHASSISPERIPHERY_HMI_R1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CHASSISPERIPHERY_HMI_R1_AR );
        if( tDelay > 0)    
            setTimer( _tCHASSISPERIPHERY_HMI_R1_AR, tDelay );
        else
            putValue( HMI__STMSG_CHASSISPERIPHERY_HMI_R1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CHASSISPERIPHERY_HMI_R1_AR
{
    if( getValue( this ) )
        openPanel("CHASSISPERIPHERY_HMI_R1_AR");
}

on EnvVar HMI_ALDW_LDP_Warn_Rq
{
    _mCHASSISPERIPHERY_HMI_R1_AR.ALDW_LDP_Warn_Rq.phys = getValue(this);
	_mCamLane_LaneAttr7_AR.ALDW_LDP_Warn_Rq.phys = getValue(this);
}

//on EnvVar HMI_CamLane_LaneAttr1_UB
//{
//    _mCHASSISPERIPHERY_HMI_R1_AR.CamLane_LaneAttr1_UB.phys = getValue(this);
//}

//on EnvVar HMI_CamLane_LaneAttr2_UB_2
//{
//    _mCHASSISPERIPHERY_HMI_R1_AR.CamLane_LaneAttr2_UB.phys = getValue(this);
//}

//on EnvVar HMI_CamLane_LaneAttr6_UB_2
//{
//    _mCHASSISPERIPHERY_HMI_R1_AR.CamLane_LaneAttr6_UB.phys = getValue(this);
//}

//on EnvVar HMI_CamLane_LaneAttr7_UB
//{
//    _mCHASSISPERIPHERY_HMI_R1_AR.CamLane_LaneAttr7_UB.phys = getValue(this);
//}

on EnvVar HMI_CamLane_LaneChg_Stat
{
    _mCHASSISPERIPHERY_HMI_R1_AR.CamLane_LaneChg_Stat.phys = getValue(this);
}

on EnvVar HMI_CamLane_RoadExit_Stat
{
    _mCHASSISPERIPHERY_HMI_R1_AR.CamLane_RoadExit_Stat.phys = getValue(this);
}

on EnvVar HMI_IHC_Block_Disp_Rq
{
    _mCHASSISPERIPHERY_HMI_R1_AR.IHC_Block_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_IHC_Lgt_Stat_MPC_UB
{
    _mCHASSISPERIPHERY_HMI_R1_AR.IHC_Lgt_Stat_MPC_UB.phys = getValue(this);
}

on EnvVar HMI_LDP_BrkMsgDisp_Rq_MPC
{
    _mCHASSISPERIPHERY_HMI_R1_AR.LDP_BrkMsgDisp_Rq_MPC.phys = getValue(this);
	_mCamLane_LaneAttr7_AR.LDP_BrkMsgDisp_Rq_MPC.phys = getValue(this);
}

on EnvVar HMI_NghbrLane_Lt_Stat
{
    _mCHASSISPERIPHERY_HMI_R1_AR.NghbrLane_Lt_Stat.phys = getValue(this);
}

on EnvVar HMI_NghbrLane_Lt_Width
{
    _mCHASSISPERIPHERY_HMI_R1_AR.NghbrLane_Lt_Width.phys = getValue(this);
}

on EnvVar HMI_NghbrLane_Rt_Stat
{
    _mCHASSISPERIPHERY_HMI_R1_AR.NghbrLane_Rt_Stat.phys = getValue(this);
}

on EnvVar HMI_NghbrLane_Rt_Width
{
    _mCHASSISPERIPHERY_HMI_R1_AR.NghbrLane_Rt_Width.phys = getValue(this);
}

on EnvVar HMI_Street_Turn_Stat_HU_ESP
{
    _mCHASSISPERIPHERY_HMI_R1_AR.Street_Turn_Stat_HU_ESP.phys = getValue(this);
}

on EnvVar HMI_Street_Turn_Stat_HU_ESP_UB
{
    _mCHASSISPERIPHERY_HMI_R1_AR.Street_Turn_Stat_HU_ESP_UB.phys = getValue(this);
}

on EnvVar HMI_VirtDiffLock_M_Ratio_Disp
{
    _mCHASSISPERIPHERY_HMI_R1_AR.VirtDiffLock_M_Ratio_Disp.phys = getValue(this);
}

on EnvVar HMI_VirtDiffLock_M_Ratio_Disp_UB
{
    _mCHASSISPERIPHERY_HMI_R1_AR.VirtDiffLock_M_Ratio_Disp_UB.phys = getValue(this);
}
CHASSISPERIPHERY_HMI_R2_AR_check_output()
{
    if( !getValue( HMI__STMSG_CHASSISPERIPHERY_HMI_R2_AR ) )
        {
        //  message   CHASSISPERIPHERY_HMI_R2_AR ID: 377 --- Sendeart 0 cyclicX --- 
            _CHASSISPERIPHERY_HMI_R2_AR_Cnt--;
            if( _CHASSISPERIPHERY_HMI_R2_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                CHASSISPERIPHERY_HMI_R2_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _CHASSISPERIPHERY_HMI_R2_AR_Cnt = _CHASSISPERIPHERY_HMI_R2_AR_CycleCount;
            }
        }
}

CHASSISPERIPHERY_HMI_R2_AR_init()
{   /* Botschaft CHASSISPERIPHERY_HMI_R2_AR ID: 377 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 377 0;
BA_ "NmAsrMessage" BO_ 377 0;
BA_ "GenMsgMinAcceptLength" BO_ 377 8;
BA_ "GenMsgILSupport" BO_ 377 1;
BA_ "DiagState" BO_ 377 0;
BA_ "DiagRequest" BO_ 377 0;
BA_ "DiagResponse" BO_ 377 0;
BA_ "GenMsgStartValue" BO_ 377 "0";
BA_ "GenMsgStartDelayTime" BO_ 377 65;
BA_ "GenMsgCycleTime" BO_ 377 80;
BA_ "GenMsgSendType" BO_ 377 0;
    */
    _CHASSISPERIPHERY_HMI_R2_AR_Timebase =      c_tDBKomTimer_20ms;
    _CHASSISPERIPHERY_HMI_R2_AR_CycleCount =   80 / _CHASSISPERIPHERY_HMI_R2_AR_Timebase;
    _CHASSISPERIPHERY_HMI_R2_AR_StartDelay =      65 / _CHASSISPERIPHERY_HMI_R2_AR_Timebase;
    _CHASSISPERIPHERY_HMI_R2_AR_Cnt = _CHASSISPERIPHERY_HMI_R2_AR_StartDelay;
    _CHASSISPERIPHERY_HMI_R2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CHASSISPERIPHERY_HMI_R2_AR, _CHASSISPERIPHERY_HMI_R2_AR_StartDelay * _CHASSISPERIPHERY_HMI_R2_AR_Timebase );

    _mCHASSISPERIPHERY_HMI_R2_AR.PT_ObjIntrst_Flt.phys = getValue( HMI_PT_ObjIntrst_Flt );
    _mCHASSISPERIPHERY_HMI_R2_AR.PT_ObjIntrstDist.phys = getValue( HMI_PT_ObjIntrstDist );
    _mCHASSISPERIPHERY_HMI_R2_AR.PT_ObjIntrst_UB.phys = getValue( HMI_PT_ObjIntrst_UB );
	_mCHASSISPERIPHERY_HMI_R2_AR.VehAccel_X_Rq.phys = getValue( HMI_VehAccel_X_Rq );
	_mCHASSISPERIPHERY_HMI_R2_AR.VehAccel_X_Rq_AS_Actv.phys = getValue( HMI_VehAccel_X_Rq_AS_Actv );
	_mCHASSISPERIPHERY_HMI_R2_AR.VehAccel_X_Rq_UB.phys = getValue( HMI_VehAccel_X_Rq_UB );

}

CHASSISPERIPHERY_HMI_R2_AR_output(void)
{
    output( _mCHASSISPERIPHERY_HMI_R2_AR );
}

CHASSISPERIPHERY_HMI_R2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CHASSISPERIPHERY_HMI_R2_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CHASSISPERIPHERY_HMI_R2_AR := %X\n", getValue( HMI__STMSG_CHASSISPERIPHERY_HMI_R2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CHASSISPERIPHERY_HMI_R2_AR := %X\n", getValue( HMI__STMSGT_CHASSISPERIPHERY_HMI_R2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT_ObjIntrst_Flt  := %X\n", getValue( HMI_PT_ObjIntrst_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT_ObjIntrstDist  := %X\n", getValue( HMI_PT_ObjIntrstDist ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT_ObjIntrst_UB  := %X\n", getValue( HMI_PT_ObjIntrst_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehAccel_X_Rq := %X\n", getValue( HMI_VehAccel_X_Rq ) );				filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehAccel_X_Rq_AS_Actv := %X\n", getValue( HMI_VehAccel_X_Rq_AS_Actv ) );	filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehAccel_X_Rq_UB := %X\n", getValue( HMI_VehAccel_X_Rq_UB ) );			filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tCHASSISPERIPHERY_HMI_R2_AR
{
    putValue( HMI__STMSG_CHASSISPERIPHERY_HMI_R2_AR, 0 );
}

on EnvVar HMI__STMSG_CHASSISPERIPHERY_HMI_R2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CHASSISPERIPHERY_HMI_R2_AR );
        if( tDelay > 0)    
            setTimer( _tCHASSISPERIPHERY_HMI_R2_AR, tDelay );
        else
            putValue( HMI__STMSG_CHASSISPERIPHERY_HMI_R2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CHASSISPERIPHERY_HMI_R2_AR
{
    if( getValue( this ) )
        openPanel("CHASSISPERIPHERY_HMI_R2_AR");
}

on EnvVar HMI_PT_ObjIntrst_Flt
{
    _mCHASSISPERIPHERY_HMI_R2_AR.PT_ObjIntrst_Flt.phys = getValue(this);
}

on EnvVar HMI_PT_ObjIntrstDist
{
    _mCHASSISPERIPHERY_HMI_R2_AR.PT_ObjIntrstDist.phys = getValue(this);
}

on EnvVar HMI_PT_ObjIntrst_UB
{
    _mCHASSISPERIPHERY_HMI_R2_AR.PT_ObjIntrst_UB.phys = getValue(this);
}

on EnvVar HMI_VehAccel_X_Rq
{
	_mCHASSISPERIPHERY_HMI_R2_AR.VehAccel_X_Rq.phys = getValue(this);
}

on EnvVar HMI_VehAccel_X_Rq_AS_Actv
{
	_mCHASSISPERIPHERY_HMI_R2_AR.VehAccel_X_Rq_AS_Actv.phys = getValue(this);
}

on EnvVar HMI_VehAccel_X_Rq_UB 
{
	_mCHASSISPERIPHERY_HMI_R2_AR.VehAccel_X_Rq_UB.phys = getValue(this);
}

void CLkS_Rq_AR_Activity(int active )
{
    if( active )
    {
        if( _CLkS_Rq_AR_SigActivity == 0)
            _CLkS_Rq_AR_Cnt = 1;
        _CLkS_Rq_AR_SigActivity++;
    }
    else
    {
        _CLkS_Rq_AR_SigActivity--;
    }
}

int CLkS_Rq_AR_Change(int lastValue, int sigValue, int inActValue )
{
    bActiveHelper = (sigValue != inActValue );
      if( !lastValue && bActiveHelper )
        CLkS_Rq_AR_Activity( 1 );
      else if( lastValue && !bActiveHelper )
        CLkS_Rq_AR_Activity(0 );
    return bActiveHelper;
}

CLkS_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_CLkS_Rq_AR ) )
    {
    //  message   CLkS_Rq_AR ID: 775 --- Sendeart 8 cyclicIfActiveFast --- 
        _CLkS_Rq_AR_Cnt--;
        if( _CLkS_Rq_AR_Cnt < 1 )
        {
            CLkS_Rq_AR_output(); // Zyklus abgelaufen, Nachricht senden
            if( _CLkS_Rq_AR_SigActivity )
            _CLkS_Rq_AR_Cnt = _CLkS_Rq_AR_CycleCountFast;
            else
            _CLkS_Rq_AR_Cnt = _CLkS_Rq_AR_CycleCountSlow;
        }
    }
}

CLkS_Rq_AR_init()
{   /* Botschaft CLkS_Rq_AR ID: 775 --- Sendeart 8 cyclicIfActiveFast --- 
BA_ "ApplMessage" BO_ 775 0;
BA_ "NmAsrMessage" BO_ 775 0;
BA_ "GenMsgMinAcceptLength" BO_ 775 8;
BA_ "GenMsgILSupport" BO_ 775 1;
BA_ "DiagState" BO_ 775 0;
BA_ "DiagRequest" BO_ 775 0;
BA_ "DiagResponse" BO_ 775 0;
BA_ "GenMsgStartValue" BO_ 775 "0";
BA_ "GenMsgStartDelayTime" BO_ 775 10;
BA_ "GenMsgDelayTime" BO_ 775 5;
BA_ "GenMsgCycleTime" BO_ 775 200;
BA_ "GenMsgCycleTimeActive" BO_ 775 50;
BA_ "GenMsgSendType" BO_ 775 8;
    */
    _CLkS_Rq_AR_Timebase =            c_tDBKomTimer_5ms;
    _CLkS_Rq_AR_CycleCountSlow =    200 / _CLkS_Rq_AR_Timebase;
    _CLkS_Rq_AR_CycleCountFast =     50 / _CLkS_Rq_AR_Timebase;
    _CLkS_Rq_AR_StartDelay =         10 / _CLkS_Rq_AR_Timebase;
    _CLkS_Rq_AR_Cnt = _CLkS_Rq_AR_StartDelay;
    _CLkS_Rq_AR_SigActivity = 0;

    putValue( HMI__STMSGSD_CLkS_Rq_AR, _CLkS_Rq_AR_StartDelay * _CLkS_Rq_AR_Timebase );

    _mCLkS_Rq_AR.CLkS_DL_Act_Rq.phys = getValue( HMI_CLkS_DL_Act_Rq );                  _CLkS_Rq_AR_CLkS_DL_Act_Rq_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_DL_Act_Rq_LastState, _mCLkS_Rq_AR.CLkS_DL_Act_Rq, 0 );
    _mCLkS_Rq_AR.CLkS_DL_Rq.phys = getValue( HMI_CLkS_DL_Rq );                  _CLkS_Rq_AR_CLkS_DL_Rq_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_DL_Rq_LastState, _mCLkS_Rq_AR.CLkS_DL_Rq, 0 );
    _mCLkS_Rq_AR.CLkS_Dr_FL_Rq.phys = getValue( HMI_CLkS_Dr_FL_Rq );                  _CLkS_Rq_AR_CLkS_Dr_FL_Rq_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_Dr_FL_Rq_LastState, _mCLkS_Rq_AR.CLkS_Dr_FL_Rq, 0 );
    _mCLkS_Rq_AR.CLkS_Dr_FR_Rq.phys = getValue( HMI_CLkS_Dr_FR_Rq );                  _CLkS_Rq_AR_CLkS_Dr_FR_Rq_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_Dr_FR_Rq_LastState, _mCLkS_Rq_AR.CLkS_Dr_FR_Rq, 0 );
    _mCLkS_Rq_AR.CLkS_Dr_RL_Rq.phys = getValue( HMI_CLkS_Dr_RL_Rq );                  _CLkS_Rq_AR_CLkS_Dr_RL_Rq_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_Dr_RL_Rq_LastState, _mCLkS_Rq_AR.CLkS_Dr_RL_Rq, 0 );
    _mCLkS_Rq_AR.CLkS_Dr_RR_Rq.phys = getValue( HMI_CLkS_Dr_RR_Rq );                  _CLkS_Rq_AR_CLkS_Dr_RR_Rq_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_Dr_RR_Rq_LastState, _mCLkS_Rq_AR.CLkS_Dr_RR_Rq, 0 );
    _mCLkS_Rq_AR.CLkS_Ext_Rq.phys = getValue( HMI_CLkS_Ext_Rq );                  _CLkS_Rq_AR_CLkS_Ext_Rq_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_Ext_Rq_LastState, _mCLkS_Rq_AR.CLkS_Ext_Rq, 0 );
    _mCLkS_Rq_AR.CLkS_Gas_Dr_Rq.phys = getValue( HMI_CLkS_Gas_Dr_Rq );                  _CLkS_Rq_AR_CLkS_Gas_Dr_Rq_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_Gas_Dr_Rq_LastState, _mCLkS_Rq_AR.CLkS_Gas_Dr_Rq, 0 );
    _mCLkS_Rq_AR.CLkS_Src_V2.phys = getValue( HMI_CLkS_Src_V2 );                  _CLkS_Rq_AR_CLkS_Src_V2_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_Src_V2_LastState, _mCLkS_Rq_AR.CLkS_Src_V2, 31 );
    _mCLkS_Rq_AR.CLkS_TurnLmp_Rq.phys = getValue( HMI_CLkS_TurnLmp_Rq );                  _CLkS_Rq_AR_CLkS_TurnLmp_Rq_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_TurnLmp_Rq_LastState, _mCLkS_Rq_AR.CLkS_TurnLmp_Rq, 0 );
    _mCLkS_Rq_AR.Key_Sw4_Psd.phys = getValue( HMI_Key_Sw4_Psd );                  _CLkS_Rq_AR_Key_Sw4_Psd_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_Key_Sw4_Psd_LastState, _mCLkS_Rq_AR.Key_Sw4_Psd, 0 );
    _mCLkS_Rq_AR.KeyLine.phys = getValue( HMI_KeyLine );                  _CLkS_Rq_AR_KeyLine_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_KeyLine_LastState, _mCLkS_Rq_AR.KeyLine, 15 );
    _mCLkS_Rq_AR.RemAlm_Rq_MPM.phys = getValue( HMI_RemAlm_Rq_MPM );                  _CLkS_Rq_AR_RemAlm_Rq_MPM_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_RemAlm_Rq_MPM_LastState, _mCLkS_Rq_AR.RemAlm_Rq_MPM, 0 );
    _mCLkS_Rq_AR.TDP_Sw_Cls_Rq_EIS.phys = getValue( HMI_TDP_Sw_Cls_Rq_EIS );                  _CLkS_Rq_AR_TDP_Sw_Cls_Rq_EIS_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_TDP_Sw_Cls_Rq_EIS_LastState, _mCLkS_Rq_AR.TDP_Sw_Cls_Rq_EIS, 0 );
}

CLkS_Rq_AR_output(void)
{
    output( _mCLkS_Rq_AR );
}

CLkS_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CLkS_Rq_AR\n", 24, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CLkS_Rq_AR := %X\n", getValue( HMI__STMSG_CLkS_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CLkS_Rq_AR := %X\n", getValue( HMI__STMSGT_CLkS_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_DL_Act_Rq := %X\n", getValue( HMI_CLkS_DL_Act_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_DL_Rq := %X\n", getValue( HMI_CLkS_DL_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Dr_FL_Rq := %X\n", getValue( HMI_CLkS_Dr_FL_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Dr_FR_Rq := %X\n", getValue( HMI_CLkS_Dr_FR_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Dr_RL_Rq := %X\n", getValue( HMI_CLkS_Dr_RL_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Dr_RR_Rq := %X\n", getValue( HMI_CLkS_Dr_RR_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Ext_Rq := %X\n", getValue( HMI_CLkS_Ext_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Gas_Dr_Rq := %X\n", getValue( HMI_CLkS_Gas_Dr_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Src_V2 := %X\n", getValue( HMI_CLkS_Src_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_TurnLmp_Rq := %X\n", getValue( HMI_CLkS_TurnLmp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Key_Sw4_Psd := %X\n", getValue( HMI_Key_Sw4_Psd ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KeyLine := %X\n", getValue( HMI_KeyLine ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RemAlm_Rq_MPM := %X\n", getValue( HMI_RemAlm_Rq_MPM ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TDP_Sw_Cls_Rq_EIS := %X\n", getValue( HMI_TDP_Sw_Cls_Rq_EIS ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tCLkS_Rq_AR
{
    putValue( HMI__STMSG_CLkS_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_CLkS_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CLkS_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tCLkS_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_CLkS_Rq_AR, 0 );
    }
}

on timer _tCLkS_Ext_Rq_Auto
{
    putValue( HMI_CLkS_Ext_Rq, 0 );
}

on EnvVar HMI__ALLDEF_CLkS_Rq_AR
{
    if( getValue(this) )
    {
        // alle signale auf default einstellen
        putValue( HMI_CLkS_DL_Act_Rq, 0 );
        putValue( HMI_CLkS_DL_Rq, 0 );
        putValue( HMI_CLkS_Dr_FL_Rq, 0 );
        putValue( HMI_CLkS_Dr_FR_Rq, 0 );
        putValue( HMI_CLkS_Dr_RL_Rq, 0 );
        putValue( HMI_CLkS_Dr_RR_Rq, 0 );
        putValue( HMI_CLkS_Ext_Rq, 0 );
        putValue( HMI_CLkS_Gas_Dr_Rq, 0 );
        putValue( HMI_CLkS_Src_V2, 0 );
        putValue( HMI_CLkS_TurnLmp_Rq, 0 );
        putValue( HMI_Key_Sw4_Psd, 0 );
        putValue( HMI_KeyLine, 0 );
        putValue( HMI_RemAlm_Rq_MPM, 0 );
        putValue( HMI_TDP_Sw_Cls_Rq_EIS, 0 );
    }
}

on envVar HMI__STMSG_PO_CLkS_Rq_AR
{
    if( getValue( this ) )
        openPanel("CLkS_Rq_AR");
}

on EnvVar HMI_CLkS_DL_Act_Rq
{
    _mCLkS_Rq_AR.CLkS_DL_Act_Rq.phys = getValue(this);
    _CLkS_Rq_AR_CLkS_DL_Act_Rq_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_DL_Act_Rq_LastState, _mCLkS_Rq_AR.CLkS_DL_Act_Rq, 0 );
}

on EnvVar HMI_CLkS_DL_Rq
{
    _mCLkS_Rq_AR.CLkS_DL_Rq.phys = getValue(this);
    _CLkS_Rq_AR_CLkS_DL_Rq_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_DL_Rq_LastState, _mCLkS_Rq_AR.CLkS_DL_Rq, 0 );
}

on EnvVar HMI_CLkS_Dr_FL_Rq
{
    _mCLkS_Rq_AR.CLkS_Dr_FL_Rq.phys = getValue(this);
    _CLkS_Rq_AR_CLkS_Dr_FL_Rq_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_Dr_FL_Rq_LastState, _mCLkS_Rq_AR.CLkS_Dr_FL_Rq, 0 );
}

on EnvVar HMI_CLkS_Dr_FR_Rq
{
    _mCLkS_Rq_AR.CLkS_Dr_FR_Rq.phys = getValue(this);
    _CLkS_Rq_AR_CLkS_Dr_FR_Rq_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_Dr_FR_Rq_LastState, _mCLkS_Rq_AR.CLkS_Dr_FR_Rq, 0 );
}

on EnvVar HMI_CLkS_Dr_RL_Rq
{
    _mCLkS_Rq_AR.CLkS_Dr_RL_Rq.phys = getValue(this);
    _CLkS_Rq_AR_CLkS_Dr_RL_Rq_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_Dr_RL_Rq_LastState, _mCLkS_Rq_AR.CLkS_Dr_RL_Rq, 0 );
}

on EnvVar HMI_CLkS_Dr_RR_Rq
{
    _mCLkS_Rq_AR.CLkS_Dr_RR_Rq.phys = getValue(this);
    _CLkS_Rq_AR_CLkS_Dr_RR_Rq_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_Dr_RR_Rq_LastState, _mCLkS_Rq_AR.CLkS_Dr_RR_Rq, 0 );
}

on EnvVar HMI_CLkS_Ext_Rq
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cCarClosureNMRequest );
        setTimer( t_CarClosureNMCancelTimer, c_NMCancelTimer_05sec ); // 30 seconds for auto-shut-off
        if( getValue( HMI_CLkS_Ext_Rq_Auto ) == 0 )
        {
           setTimer( _tCLkS_Ext_Rq_Auto, ( 8 * _CLkS_Rq_AR_CycleCountFast ) * c_tDBKomTimer_5ms );
        }
    }
    _mCLkS_Rq_AR.CLkS_Ext_Rq.phys = getValue(this);
    _CLkS_Rq_AR_CLkS_Ext_Rq_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_Ext_Rq_LastState, _mCLkS_Rq_AR.CLkS_Ext_Rq, 0 );
}

on EnvVar HMI_CLkS_Gas_Dr_Rq
{
    _mCLkS_Rq_AR.CLkS_Gas_Dr_Rq.phys = getValue(this);
    _CLkS_Rq_AR_CLkS_Gas_Dr_Rq_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_Gas_Dr_Rq_LastState, _mCLkS_Rq_AR.CLkS_Gas_Dr_Rq, 0 );
}

on EnvVar HMI_CLkS_Src_V2
{
    _mCLkS_Rq_AR.CLkS_Src_V2.phys = getValue(this);
    _CLkS_Rq_AR_CLkS_Src_V2_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_Src_V2_LastState, _mCLkS_Rq_AR.CLkS_Src_V2, 31 );
}

on EnvVar HMI_CLkS_TurnLmp_Rq
{
    _mCLkS_Rq_AR.CLkS_TurnLmp_Rq.phys = getValue(this);
    _CLkS_Rq_AR_CLkS_TurnLmp_Rq_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_CLkS_TurnLmp_Rq_LastState, _mCLkS_Rq_AR.CLkS_TurnLmp_Rq, 0 );
}

on EnvVar HMI_Key_Sw4_Psd
{
    _mCLkS_Rq_AR.Key_Sw4_Psd.phys = getValue(this);
    _CLkS_Rq_AR_Key_Sw4_Psd_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_Key_Sw4_Psd_LastState, _mCLkS_Rq_AR.Key_Sw4_Psd, 0 );
}

on EnvVar HMI_KeyLine
{
    _mCLkS_Rq_AR.KeyLine.phys = getValue(this);
    _CLkS_Rq_AR_KeyLine_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_KeyLine_LastState, _mCLkS_Rq_AR.KeyLine, 15 );
}

on EnvVar HMI_RemAlm_Rq_MPM
{
    _mCLkS_Rq_AR.RemAlm_Rq_MPM.phys = getValue(this);
    _CLkS_Rq_AR_RemAlm_Rq_MPM_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_RemAlm_Rq_MPM_LastState, _mCLkS_Rq_AR.RemAlm_Rq_MPM, 0 );
}

on EnvVar HMI_TDP_Sw_Cls_Rq_EIS
{
    _mCLkS_Rq_AR.TDP_Sw_Cls_Rq_EIS.phys = getValue(this);
    _CLkS_Rq_AR_TDP_Sw_Cls_Rq_EIS_LastState = CLkS_Rq_AR_Change( _CLkS_Rq_AR_TDP_Sw_Cls_Rq_EIS_LastState, _mCLkS_Rq_AR.TDP_Sw_Cls_Rq_EIS, 0 );
}

CLkS_State_AR_check_output()
{
    if( !getValue( HMI__STMSG_CLkS_State_AR ) )
    {
    //  message   CLkS_State_AR ID: 763 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _CLkS_State_AR_Cnt--;
        if( _CLkS_State_AR_Cnt < 1 )
        {
            CLkS_State_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _CLkS_State_AR_Cnt = _CLkS_State_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _CLkS_State_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _CLkS_State_AR_SpontanFlag)
        {
            CLkS_State_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _CLkS_State_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

CLkS_State_AR_init()
{   /* Botschaft CLkS_State_AR ID: 763 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 763 0;
BA_ "NmAsrMessage" BO_ 763 0;
BA_ "GenMsgMinAcceptLength" BO_ 763 8;
BA_ "GenMsgILSupport" BO_ 763 1;
BA_ "DiagState" BO_ 763 0;
BA_ "DiagRequest" BO_ 763 0;
BA_ "DiagResponse" BO_ 763 0;
BA_ "GenMsgStartValue" BO_ 763 "0";
BA_ "GenMsgStartDelayTime" BO_ 763 20;
BA_ "GenMsgDelayTime" BO_ 763 10;
BA_ "GenMsgNrOfRepetitions" BO_ 763 0;
BA_ "GenMsgCycleTime" BO_ 763 500;
BA_ "GenMsgSendType" BO_ 763 5;
    */
    _CLkS_State_AR_Timebase =         c_tDBKomTimer_20ms;
    _CLkS_State_AR_CycleCount =     500 / _CLkS_State_AR_Timebase;
    _CLkS_State_AR_StartDelay =      20 / _CLkS_State_AR_Timebase;
    _CLkS_State_AR_Cnt = _CLkS_State_AR_StartDelay;
    _CLkS_State_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CLkS_State_AR, _CLkS_State_AR_StartDelay * _CLkS_State_AR_Timebase );

    _mCLkS_State_AR.AutoDrLk_Rq_Src.phys = getValue( HMI_AutoDrLk_Rq_Src );
    _mCLkS_State_AR.AutoDrLk_Stat.phys = getValue( HMI_AutoDrLk_Stat );
    _mCLkS_State_AR.CLkS_DL_Stat.phys = getValue( HMI_CLkS_DL_Stat );
    _mCLkS_State_AR.CLkS_Dr_FL_Stat.phys = getValue( HMI_CLkS_Dr_FL_Stat );
    _mCLkS_State_AR.CLkS_Dr_FR_Stat.phys = getValue( HMI_CLkS_Dr_FR_Stat );
    _mCLkS_State_AR.CLkS_Dr_RL_Stat.phys = getValue( HMI_CLkS_Dr_RL_Stat );
    _mCLkS_State_AR.CLkS_Dr_RR_Stat.phys = getValue( HMI_CLkS_Dr_RR_Stat );
    _mCLkS_State_AR.CLkS_Dsabl.phys = getValue( HMI_CLkS_Dsabl );
    _mCLkS_State_AR.CLkS_Gas_Dr_Stat.phys = getValue( HMI_CLkS_Gas_Dr_Stat );
    _mCLkS_State_AR.CLkS_Key_Rq_Raw.phys = getValue( HMI_CLkS_Key_Rq_Raw );
    _mCLkS_State_AR.CLkS_LED_On_Rq.phys = getValue( HMI_CLkS_LED_On_Rq );
    _mCLkS_State_AR.CLkS_Lk_Stat3.phys = getValue( HMI_CLkS_Lk_Stat3 );
    _mCLkS_State_AR.CLkS_Ovruse_Prot_Actv.phys = getValue( HMI_CLkS_Ovruse_Prot_Actv );
    _mCLkS_State_AR.CLkS_SwLED_On_Rq.phys = getValue( HMI_CLkS_SwLED_On_Rq );
    _mCLkS_State_AR.CLkS_TransMd_Actv.phys = getValue( HMI_CLkS_TransMd_Actv );
    _mCLkS_State_AR.KeyId_V2.phys = getValue( HMI_KeyId_V2 );
}

CLkS_State_AR_output(void)
{
    output( _mCLkS_State_AR );
}

CLkS_State_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CLkS_State_AR\n", 27, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CLkS_State_AR := %X\n", getValue( HMI__STMSG_CLkS_State_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CLkS_State_AR := %X\n", getValue( HMI__STMSGT_CLkS_State_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AutoDrLk_Rq_Src := %X\n", getValue( HMI_AutoDrLk_Rq_Src ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AutoDrLk_Stat := %X\n", getValue( HMI_AutoDrLk_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_DL_Stat := %X\n", getValue( HMI_CLkS_DL_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Dr_FL_Stat := %X\n", getValue( HMI_CLkS_Dr_FL_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Dr_FR_Stat := %X\n", getValue( HMI_CLkS_Dr_FR_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Dr_RL_Stat := %X\n", getValue( HMI_CLkS_Dr_RL_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Dr_RR_Stat := %X\n", getValue( HMI_CLkS_Dr_RR_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Dsabl := %X\n", getValue( HMI_CLkS_Dsabl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Gas_Dr_Stat := %X\n", getValue( HMI_CLkS_Gas_Dr_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Key_Rq_Raw := %X\n", getValue( HMI_CLkS_Key_Rq_Raw ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_LED_On_Rq := %X\n", getValue( HMI_CLkS_LED_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Lk_Stat3 := %X\n", getValue( HMI_CLkS_Lk_Stat3 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_LED_On_Rq := %X\n", getValue( HMI_CLkS_LED_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Ovruse_Prot_Actv := %X\n", getValue( HMI_CLkS_Ovruse_Prot_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_SwLED_On_Rq := %X\n", getValue( HMI_CLkS_SwLED_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_SwLED_On_Rq := %X\n", getValue( HMI_CLkS_SwLED_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_TransMd_Actv := %X\n", getValue( HMI_CLkS_TransMd_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KeyId_V2 := %X\n", getValue( HMI_KeyId_V2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tCLkS_State_AR
{
    putValue( HMI__STMSG_CLkS_State_AR, 0 );
}

on EnvVar HMI__STMSG_CLkS_State_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CLkS_State_AR );
        if( tDelay > 0)    
            setTimer( _tCLkS_State_AR, tDelay );
        else
            putValue( HMI__STMSG_CLkS_State_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CLkS_State_AR
{
    if( getValue( this ) )
        openPanel("CLkS_State_AR");
}

on EnvVar HMI_AutoDrLk_Rq_Src
{
    _mCLkS_State_AR.AutoDrLk_Rq_Src.phys = getValue(this);
    _CLkS_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_AutoDrLk_Stat
{
    _mCLkS_State_AR.AutoDrLk_Stat.phys = getValue(this);
    _CLkS_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_CLkS_DL_Stat
{
    _mCLkS_State_AR.CLkS_DL_Stat.phys = getValue(this);
    _CLkS_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_CLkS_Dr_FL_Stat
{
    _mCLkS_State_AR.CLkS_Dr_FL_Stat.phys = getValue(this);
    _CLkS_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_CLkS_Dr_FR_Stat
{
    _mCLkS_State_AR.CLkS_Dr_FR_Stat.phys = getValue(this);
    _CLkS_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_CLkS_Dr_RL_Stat
{
    _mCLkS_State_AR.CLkS_Dr_RL_Stat.phys = getValue(this);
    _CLkS_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_CLkS_Dr_RR_Stat
{
    _mCLkS_State_AR.CLkS_Dr_RR_Stat.phys = getValue(this);
    _CLkS_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_CLkS_Dsabl
{
    _mCLkS_State_AR.CLkS_Dsabl.phys = getValue(this);
    _CLkS_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_CLkS_Gas_Dr_Stat
{
    _mCLkS_State_AR.CLkS_Gas_Dr_Stat.phys = getValue(this);
    _CLkS_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_CLkS_Key_Rq_Raw
{
    _mCLkS_State_AR.CLkS_Key_Rq_Raw.phys = getValue(this);
    _CLkS_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_CLkS_LED_On_Rq
{
    _mCLkS_State_AR.CLkS_LED_On_Rq.phys = getValue(this);
    _CLkS_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_CLkS_Lk_Stat3
{
    _mCLkS_State_AR.CLkS_Lk_Stat3.phys = getValue(this);
    _CLkS_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_CLkS_Ovruse_Prot_Actv
{
    _mCLkS_State_AR.CLkS_Ovruse_Prot_Actv.phys = getValue(this);
    _CLkS_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_CLkS_SwLED_On_Rq
{
    _mCLkS_State_AR.CLkS_SwLED_On_Rq.phys = getValue(this);
    _CLkS_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_CLkS_TransMd_Actv
{
    _mCLkS_State_AR.CLkS_TransMd_Actv.phys = getValue(this);
    _CLkS_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_KeyId_V2
{
    _mCLkS_State_AR.KeyId_V2.phys = getValue(this);
    _CLkS_State_AR_SpontanFlag = 1;
}

ClockSync_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_ClockSync_Stat_AR ) )
    {
    //  message   ClockSync_Stat_AR ID: 427 --- Sendeart 1 spontanX ---
        if( _ClockSync_Stat_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            ClockSync_Stat_AR_output();
            // Spontan-Flag zur�cksetzen
             _ClockSync_Stat_AR_SpontanFlag = 0;
        }
    }
}

ClockSync_Stat_AR_init()
{    /* Botschaft ClockSync_Stat_AR ID: 427 --- Sendeart 1 spontanX --- 
BA_ "ApplMessage" BO_ 427 0;
BA_ "NmAsrMessage" BO_ 427 0;
BA_ "GenMsgMinAcceptLength" BO_ 427 8;
BA_ "GenMsgILSupport" BO_ 427 0;
BA_ "DiagState" BO_ 427 0;
BA_ "DiagRequest" BO_ 427 0;
BA_ "DiagResponse" BO_ 427 0;
BA_ "GenMsgStartValue" BO_ 427 "0";
BA_ "GenMsgDelayTime" BO_ 427 40;
BA_ "GenMsgNrOfRepetitions" BO_ 427 0;
BA_ "GenMsgSendType" BO_ 427 1;
        */
    
    _ClockSync_Stat_AR_Timebase =        c_tDBKomTimer_20ms;
    _ClockSync_Stat_AR_CycleCount =     40 / c_tDBKomTimer_20ms;
    _ClockSync_Stat_AR_Cnt = 0;
    _ClockSync_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_ClockSync_Stat_AR, _ClockSync_Stat_AR_StartDelay * _ClockSync_Stat_AR_Timebase ); 

    _mClockSync_Stat_AR.ClockSync_MsgType.phys = getValue( HMI_ClockSync_MsgType );
    _mClockSync_Stat_AR.ClockSync_ReplaceECU.phys = getValue( HMI_ClockSync_ReplaceECU );
    _mClockSync_Stat_AR.ClockSync_Second.phys = getValue( HMI_ClockSync_Second );
    _mClockSync_Stat_AR.ClockSync_TmDiscont.phys = getValue( HMI_ClockSync_TmDiscont );
    _mClockSync_Stat_AR.ClockSync_TmDomain.phys = getValue( HMI_ClockSync_TmDomain );
    _mClockSync_Stat_AR.ClockSync_TmStartZero.phys = getValue( HMI_ClockSync_TmStartZero );
    _mClockSync_Stat_AR.ClockSync_User.phys = getValue( HMI_ClockSync_User );
    _mClockSync_Stat_AR.Rsrv1_ClockSync_Stat1.phys = getValue( HMI_Rsrv1_ClockSync_Stat1 );
    _mClockSync_Stat_AR.ClockSync_NanoSecond.phys = getValue( HMI_ClockSync_NanoSecond );
    _mClockSync_Stat_AR.ClockSync_OvrFlowTm.phys = getValue( HMI_ClockSync_OvrFlowTm );
    _mClockSync_Stat_AR.ClockSync_SyncTmGw.phys = getValue( HMI_ClockSync_SyncTmGw );
    _mClockSync_Stat_AR.ClockSync_TmDomain_FUP.phys = getValue( HMI_ClockSync_TmDomain_FUP );
    _mClockSync_Stat_AR.Rsrv1_ClockSync_Stat2.phys = getValue( HMI_Rsrv1_ClockSync_Stat2 );
}

ClockSync_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_ClockSync_Stat1 ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_ClockSync_Stat1_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _ClockSync_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _ClockSync_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_ClockSync_Stat1_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _ClockSync_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _ClockSync_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _ClockSync_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _ClockSync_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _ClockSync_Stat_AR_SQC_RepeatedCnt ) &&
            ( _ClockSync_Stat_AR_E2E_Armed == 1  )    )
        {
            _ClockSync_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_ClockSync_Stat1, SQC_help );
    }
    _mClockSync_Stat_AR.SQC_ClockSync_Stat1 = SQC_help;

    if( getValue( HMI_CRC_ClockSync_Stat1_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_ClockSync_Stat1_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable_profile02[ crc ^ _mClockSync_Stat_AR.byte( 0 ) ];  MUX
//            crc = crctable_profile02[ crc ^ _mClockSync_Stat_AR.byte( 1 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mClockSync_Stat_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mClockSync_Stat_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mClockSync_Stat_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mClockSync_Stat_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mClockSync_Stat_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mClockSync_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _ClockSync_Stat_AR_CRC_Offset[ _mClockSync_Stat_AR.SQC_ClockSync_Stat1 ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _ClockSync_Stat_AR_CRC_ErrorCnt   && ( _ClockSync_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_ClockSync_Stat1_Invalid )                                         )    )
            {
                crc++;
                if( _ClockSync_Stat_AR_CRC_ErrorCnt > 0 )
                    _ClockSync_Stat_AR_CRC_ErrorCnt--; 
            }
            _mClockSync_Stat_AR.CRC_ClockSync_Stat1 = crc;
            putValue( HMI_CRC_ClockSync_Stat1, crc );
        }
        else
            _mClockSync_Stat_AR.CRC_ClockSync_Stat1 = getValue( HMI_CRC_ClockSync_Stat1 );
    }
    else
    {
        if( !getValue( HMI_CRC_ClockSync_Stat1_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mClockSync_Stat_AR.byte( 0 ) ];  MUX
//            crc = crctable[ crc ^ _mClockSync_Stat_AR.byte( 1 ) ];  CRC
            crc = crctable[ crc ^ _mClockSync_Stat_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mClockSync_Stat_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mClockSync_Stat_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mClockSync_Stat_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mClockSync_Stat_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mClockSync_Stat_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _ClockSync_Stat_AR_CRC_ErrorCnt   && ( _ClockSync_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_ClockSync_Stat1_Invalid )                                         )    )
            {
                crc++;
                if( _ClockSync_Stat_AR_CRC_ErrorCnt > 0 )
                    _ClockSync_Stat_AR_CRC_ErrorCnt--; 
            }
            _mClockSync_Stat_AR.CRC_ClockSync_Stat1 = crc;
            putValue( HMI_CRC_ClockSync_Stat1, crc );
        }
        else
            _mClockSync_Stat_AR.CRC_ClockSync_Stat1 = getValue( HMI_CRC_ClockSync_Stat1);
    }
    if( ( _ClockSync_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _ClockSync_Stat_AR_E2E_Armed == 1  )    )
    {
        _ClockSync_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mClockSync_Stat_AR );
        
    if( _ClockSync_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _ClockSync_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _ClockSync_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _ClockSync_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _ClockSync_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _ClockSync_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_CMS_PI_Sd_Rt_Stat_State, 0 );
        }
    }
}

ClockSync_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: ClockSync_Stat_AR\n", 24, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_ClockSync_Stat_AR := %X\n", getValue( HMI__STMSG_ClockSync_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_ClockSync_Stat_AR := %X\n", getValue( HMI__STMSGT_ClockSync_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ClockSync_MsgType := %X\n", getValue( HMI_ClockSync_MsgType ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ClockSync_ReplaceECU := %X\n", getValue( HMI_ClockSync_ReplaceECU ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ClockSync_Second := %X\n", getValue( HMI_ClockSync_Second ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ClockSync_TmDiscont := %X\n", getValue( HMI_ClockSync_TmDiscont ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ClockSync_TmDomain := %X\n", getValue( HMI_ClockSync_TmDomain ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ClockSync_TmStartZero := %X\n", getValue( HMI_ClockSync_TmStartZero ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ClockSync_User := %X\n", getValue( HMI_ClockSync_User ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ClockSync_Stat1 := %X\n", getValue( HMI_CRC_ClockSync_Stat1 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ClockSync_Stat1_Auto := %X\n", getValue( HMI_CRC_ClockSync_Stat1_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ClockSync_Stat1_Profile_02 := %X\n", getValue( HMI_CRC_ClockSync_Stat1_Profile_02 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ClockSync_Stat1_Invalid := %X\n", getValue( HMI_CRC_ClockSync_Stat1_Invalid ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_ClockSync_Stat1 := %X\n", getValue( HMI_Rsrv1_ClockSync_Stat1 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_ClockSync_Stat1 := %X\n", getValue( HMI_SQC_ClockSync_Stat1 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_ClockSync_Stat1_Auto := %X\n", getValue( HMI_SQC_ClockSync_Stat1_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ClockSync_NanoSecond := %X\n", getValue( HMI_ClockSync_NanoSecond ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ClockSync_OvrFlowTm := %X\n", getValue( HMI_ClockSync_OvrFlowTm ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ClockSync_SyncTmGw := %X\n", getValue( HMI_ClockSync_SyncTmGw ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ClockSync_TmDomain_FUP := %X\n", getValue( HMI_ClockSync_TmDomain_FUP ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ClockSync_Stat2 := %X\n", getValue( HMI_CRC_ClockSync_Stat2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ClockSync_Stat2_Auto := %X\n", getValue( HMI_CRC_ClockSync_Stat2_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ClockSync_Stat2_Profile_02 := %X\n", getValue( HMI_CRC_ClockSync_Stat2_Profile_02 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ClockSync_Stat2_Invalid := %X\n", getValue( HMI_CRC_ClockSync_Stat2_Invalid ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_ClockSync_Stat2 := %X\n", getValue( HMI_Rsrv1_ClockSync_Stat2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_ClockSync_Stat2 := %X\n", getValue( HMI_SQC_ClockSync_Stat2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_ClockSync_Stat2_Auto := %X\n", getValue( HMI_SQC_ClockSync_Stat2_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tClockSync_Stat_AR
{
    putValue( HMI__STMSG_ClockSync_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_ClockSync_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_ClockSync_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tClockSync_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_ClockSync_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_ClockSync_Stat_AR
{
    if( getValue( this ) )
        openPanel("ClockSync_Stat_AR");
}

on envVar HMI_E2E_ClockSync_Stat2_Inject
{
    if( getValue( this ) )
    {
        _ClockSync_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_ClockSync_Stat2_ErrorCount );
        _ClockSync_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_ClockSync_Stat2_TriggerPosition );
        _ClockSync_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_ClockSync_Stat2_WrongSeq );
        _ClockSync_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_ClockSync_Stat2_Repeated );
        _ClockSync_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_ClockSync_Stat2_MSG_DropCnt );
        putValue( HMI_E2E_ClockSync_Stat2_State, 2 );
        _ClockSync_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_ClockSync_MsgType
{
    _mClockSync_Stat_AR.ClockSync_MsgType.phys = getValue(this);
    _ClockSync_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ClockSync_ReplaceECU
{
    _mClockSync_Stat_AR.ClockSync_ReplaceECU.phys = getValue(this);
    _ClockSync_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ClockSync_Second
{
    _mClockSync_Stat_AR.ClockSync_Second.phys = getValue(this);
    _ClockSync_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ClockSync_TmDiscont
{
    _mClockSync_Stat_AR.ClockSync_TmDiscont.phys = getValue(this);
    _ClockSync_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ClockSync_TmDomain
{
    _mClockSync_Stat_AR.ClockSync_TmDomain.phys = getValue(this);
    _ClockSync_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ClockSync_TmStartZero
{
    _mClockSync_Stat_AR.ClockSync_TmStartZero.phys = getValue(this);
    _ClockSync_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ClockSync_User
{
//    _mClockSync_Stat_AR.ClockSync_User.phys = getValue(this);
    _ClockSync_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_ClockSync_Stat1
{
    _mClockSync_Stat_AR.Rsrv1_ClockSync_Stat1.phys = getValue(this);
    _ClockSync_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ClockSync_NanoSecond
{
    _mClockSync_Stat_AR.ClockSync_NanoSecond.phys = getValue(this);
    _ClockSync_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ClockSync_OvrFlowTm
{
    _mClockSync_Stat_AR.ClockSync_OvrFlowTm.phys = getValue(this);
    _ClockSync_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ClockSync_SyncTmGw
{
    _mClockSync_Stat_AR.ClockSync_SyncTmGw.phys = getValue(this);
    _ClockSync_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ClockSync_TmDomain_FUP
{
    _mClockSync_Stat_AR.ClockSync_TmDomain_FUP.phys = getValue(this);
    _ClockSync_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_ClockSync_Stat2
{
    _mClockSync_Stat_AR.Rsrv1_ClockSync_Stat2.phys = getValue(this);
    _ClockSync_Stat_AR_SpontanFlag = 1;
}

CMS_PI_Sd_Stat_MMR_F1_AR_check_output()
{
    if( !getValue( HMI__STMSG_CMS_PI_Sd_Stat_MMR_F1_AR ) )
    {
    //  message   CMS_PI_Sd_Stat_MMR_F1_AR ID: 298 --- Sendeart 1 spontanX ---
        if( _CMS_PI_Sd_Stat_MMR_F1_AR_SpontanFlag)
        {
            CMS_PI_Sd_Stat_MMR_F1_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _CMS_PI_Sd_Stat_MMR_F1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

CMS_PI_Sd_Stat_MMR_F1_AR_init()
{   /* Botschaft CMS_PI_Sd_Stat_MMR_F1_AR ID: 298 --- Sendeart 1 Spontan --- 
BA_ "ApplMessage" BO_ 298 0;
BA_ "NmAsrMessage" BO_ 298 0;
BA_ "GenMsgMinAcceptLength" BO_ 298 4;
BA_ "GenMsgILSupport" BO_ 298 1;
BA_ "DiagState" BO_ 298 0;
BA_ "DiagRequest" BO_ 298 0;
BA_ "DiagResponse" BO_ 298 0;
BA_ "GenMsgStartValue" BO_ 298 "0";
BA_ "GenMsgDelayTime" BO_ 298 20;
BA_ "GenMsgNrOfRepetition" BO_ 298 0;
BA_ "GenMsgSendType" BO_ 298 1;
    */
    _CMS_PI_Sd_Stat_MMR_F1_AR_Timebase =            c_tDBKomTimer_20ms;
    _CMS_PI_Sd_Stat_MMR_F1_AR_CycleCount =         20 / _CMS_PI_Sd_Stat_MMR_F1_AR_Timebase;
    _CMS_PI_Sd_Stat_MMR_F1_AR_StartDelay =          0 / _CMS_PI_Sd_Stat_MMR_F1_AR_Timebase;
    _CMS_PI_Sd_Stat_MMR_F1_AR_Cnt = _CMS_PI_Sd_Stat_MMR_F1_AR_StartDelay;

    putValue( HMI__STMSGSD_CMS_PI_Sd_Stat_MMR_F1_AR, _CMS_PI_Sd_Stat_MMR_F1_AR_StartDelay * _CMS_PI_Sd_Stat_MMR_F1_AR_Timebase );

    _mCMS_PI_Sd_Stat_MMR_F1_AR.PI_Sd_Lt_Enbl.phys = getValue( HMI_PI_Sd_Lt_Enbl );
    _mCMS_PI_Sd_Stat_MMR_F1_AR.PI_Sd_Obj_Lt_RelSpd.phys = getValue( HMI_PI_Sd_Obj_Lt_RelSpd );
    _mCMS_PI_Sd_Stat_MMR_F1_AR.PI_Sd_RelsRcmmnd_Pyro_Lt.phys = getValue( HMI_PI_Sd_RelsRcmmnd_Pyro_Lt );
    _mCMS_PI_Sd_Stat_MMR_F1_AR.PI_Sd_RelsRcmmnd_Rev_Lt.phys = getValue( HMI_PI_Sd_RelsRcmmnd_Rev_Lt );
    _mCMS_PI_Sd_Stat_MMR_F1_AR.PI_Sd_TTI_Lt.phys = getValue( HMI_PI_Sd_TTI_Lt );
    _mCMS_PI_Sd_Stat_MMR_F1_AR.Rsrv1_CMS_PI_Sd_Lt_Stat.phys = getValue( HMI_Rsrv1_CMS_PI_Sd_Lt_Stat );
}

CMS_PI_Sd_Stat_MMR_F1_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_CMS_PI_Sd_Lt_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_CMS_PI_Sd_Lt_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _CMS_PI_Sd_Stat_MMR_F1_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _CMS_PI_Sd_Stat_MMR_F1_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_CMS_PI_Sd_Lt_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _CMS_PI_Sd_Stat_MMR_F1_AR_SQC_WrongSeqJump != 0 ) &&
            ( _CMS_PI_Sd_Stat_MMR_F1_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _CMS_PI_Sd_Stat_MMR_F1_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _CMS_PI_Sd_Stat_MMR_F1_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _CMS_PI_Sd_Stat_MMR_F1_AR_SQC_RepeatedCnt ) &&
            ( _CMS_PI_Sd_Stat_MMR_F1_AR_E2E_Armed == 1  )    )
        {
            _CMS_PI_Sd_Stat_MMR_F1_AR_SQC_RepeatedCnt--;
        }
        else
        {
           if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_CMS_PI_Sd_Lt_Stat, SQC_help );
    }
    _mCMS_PI_Sd_Stat_MMR_F1_AR.SQC_CMS_PI_Sd_Lt_Stat = SQC_help;

    if( getValue( HMI_CRC_CMS_PI_Sd_Lt_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_CMS_PI_Sd_Lt_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mCMS_PI_Sd_Stat_MMR_F1_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mCMS_PI_Sd_Stat_MMR_F1_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mCMS_PI_Sd_Stat_MMR_F1_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mCMS_PI_Sd_Stat_MMR_F1_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mCMS_PI_Sd_Stat_MMR_F1_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mCMS_PI_Sd_Stat_MMR_F1_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mCMS_PI_Sd_Stat_MMR_F1_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mCMS_PI_Sd_Stat_MMR_F1_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _CMS_PI_Sd_Stat_MMR_F1_AR_CRC_Offset[ _mCMS_PI_Sd_Stat_MMR_F1_AR.SQC_CMS_PI_Sd_Lt_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _CMS_PI_Sd_Stat_MMR_F1_AR_CRC_ErrorCnt   && ( _CMS_PI_Sd_Stat_MMR_F1_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_CMS_PI_Sd_Lt_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _CMS_PI_Sd_Stat_MMR_F1_AR_CRC_ErrorCnt > 0 )
                    _CMS_PI_Sd_Stat_MMR_F1_AR_CRC_ErrorCnt--; 
            }
            _mCMS_PI_Sd_Stat_MMR_F1_AR.CRC_CMS_PI_Sd_Lt_Stat = crc;
            putValue( HMI_CRC_CMS_PI_Sd_Lt_Stat, crc );
        }
        else
            _mCMS_PI_Sd_Stat_MMR_F1_AR.CRC_CMS_PI_Sd_Lt_Stat = getValue( HMI_CRC_CMS_PI_Sd_Lt_Stat );
    }
    else
    {
        if( !getValue( HMI_CRC_CMS_PI_Sd_Lt_Stat_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mCMS_PI_Sd_Stat_MMR_F1_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mCMS_PI_Sd_Stat_MMR_F1_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mCMS_PI_Sd_Stat_MMR_F1_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mCMS_PI_Sd_Stat_MMR_F1_AR.byte( 3 ) ];
//            crc = crctable[ crc ^ _mCMS_PI_Sd_Stat_MMR_F1_AR.byte( 4 ) ];
//            crc = crctable[ crc ^ _mCMS_PI_Sd_Stat_MMR_F1_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mCMS_PI_Sd_Stat_MMR_F1_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mCMS_PI_Sd_Stat_MMR_F1_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _CMS_PI_Sd_Stat_MMR_F1_AR_CRC_ErrorCnt   && ( _CMS_PI_Sd_Stat_MMR_F1_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_CMS_PI_Sd_Lt_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _CMS_PI_Sd_Stat_MMR_F1_AR_CRC_ErrorCnt > 0 )
                    _CMS_PI_Sd_Stat_MMR_F1_AR_CRC_ErrorCnt--; 
            }
            _mCMS_PI_Sd_Stat_MMR_F1_AR.CRC_CMS_PI_Sd_Lt_Stat = crc;
            putValue( HMI_CRC_CMS_PI_Sd_Lt_Stat, crc );
        }
        else
            _mCMS_PI_Sd_Stat_MMR_F1_AR.CRC_CMS_PI_Sd_Lt_Stat = getValue( HMI_CRC_CMS_PI_Sd_Lt_Stat );
    }
    if( ( _CMS_PI_Sd_Stat_MMR_F1_AR_MSG_DropCnt > 0 ) &&
        ( _CMS_PI_Sd_Stat_MMR_F1_AR_E2E_Armed == 1  )    )
    {
        _CMS_PI_Sd_Stat_MMR_F1_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mCMS_PI_Sd_Stat_MMR_F1_AR );
        
    if( _CMS_PI_Sd_Stat_MMR_F1_AR_E2E_Armed == 1 )
    {
        if ( ( _CMS_PI_Sd_Stat_MMR_F1_AR_MSG_DropCnt == 0      ) &&
             ( _CMS_PI_Sd_Stat_MMR_F1_AR_CRC_ErrorCnt == 0     ) &&
             ( _CMS_PI_Sd_Stat_MMR_F1_AR_SQC_RepeatedCnt == 0  ) &&
             ( _CMS_PI_Sd_Stat_MMR_F1_AR_SQC_WrongSeqJump == 0 )    )
        {
            _CMS_PI_Sd_Stat_MMR_F1_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_CMS_PI_Sd_Lt_Stat_State, 0 );
        }
    }
}

CMS_PI_Sd_Stat_MMR_F1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CMS_PI_Sd_Stat_MMR_F1_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CMS_PI_Sd_Stat_MMR_F1_AR := %X\n", getValue( HMI__STMSG_CMS_PI_Sd_Stat_MMR_F1_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CMS_PI_Sd_Stat_MMR_F1_AR := %X\n", getValue( HMI__STMSGT_CMS_PI_Sd_Stat_MMR_F1_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_CMS_PI_Sd_Lt_Stat := %X\n", getValue( HMI_CRC_CMS_PI_Sd_Lt_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_CMS_PI_Sd_Lt_Stat_Auto := %X\n", getValue( HMI_CRC_CMS_PI_Sd_Lt_Stat_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_CMS_PI_Sd_Lt_Stat_Profile_02 := %X\n", getValue( HMI_CRC_CMS_PI_Sd_Lt_Stat_Profile_02 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PI_Sd_Lt_Enbl := %X\n", getValue( HMI_PI_Sd_Lt_Enbl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PI_Sd_Obj_Lt_RelSpd := %X\n", getValue( HMI_PI_Sd_Obj_Lt_RelSpd ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PI_Sd_RelsRcmmnd_Pyro_Lt := %X\n", getValue( HMI_PI_Sd_RelsRcmmnd_Pyro_Lt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PI_Sd_RelsRcmmnd_Rev_Lt := %X\n", getValue( HMI_PI_Sd_RelsRcmmnd_Rev_Lt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PI_Sd_TTI_Lt := %X\n", getValue( HMI_PI_Sd_TTI_Lt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_CMS_PI_Sd_Lt_Stat := %X\n", getValue( HMI_Rsrv1_CMS_PI_Sd_Lt_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_CMS_PI_Sd_Lt_Stat := %X\n", getValue( HMI_SQC_CMS_PI_Sd_Lt_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_CMS_PI_Sd_Lt_Stat_Auto := %X\n", getValue( HMI_SQC_CMS_PI_Sd_Lt_Stat_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tCMS_PI_Sd_Stat_MMR_F1_AR
{
    putValue( HMI__STMSG_CMS_PI_Sd_Stat_MMR_F1_AR, 0 );
}

on EnvVar HMI__STMSG_CMS_PI_Sd_Stat_MMR_F1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CMS_PI_Sd_Stat_MMR_F1_AR );
        if( tDelay > 0)    
            setTimer( _tCMS_PI_Sd_Stat_MMR_F1_AR, tDelay );
        else
            putValue( HMI__STMSG_CMS_PI_Sd_Stat_MMR_F1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CMS_PI_Sd_Stat_MMR_F1_AR
{
    if( getValue( this ) )
        openPanel("CMS_PI_Sd_Stat_MMR_F1_AR");
}

on envVar HMI_E2E_CMS_PI_Sd_Lt_Stat_Inject
{
    if( getValue( this ) )
    {
        _CMS_PI_Sd_Stat_MMR_F1_AR_CRC_ErrorCnt = getValue( HMI_CRC_CMS_PI_Sd_Lt_Stat_ErrorCount );
        _CMS_PI_Sd_Stat_MMR_F1_AR_SQC_TriggPos = getValue( HMI_SQC_CMS_PI_Sd_Lt_Stat_TriggerPosition );
        _CMS_PI_Sd_Stat_MMR_F1_AR_SQC_WrongSeqJump = getValue( HMI_SQC_CMS_PI_Sd_Lt_Stat_WrongSeq );
        _CMS_PI_Sd_Stat_MMR_F1_AR_SQC_RepeatedCnt = getValue( HMI_SQC_CMS_PI_Sd_Lt_Stat_Repeated );
        _CMS_PI_Sd_Stat_MMR_F1_AR_MSG_DropCnt = getValue( HMI_SQC_CMS_PI_Sd_Lt_Stat_MSG_DropCnt );
        putValue( HMI_E2E_CMS_PI_Sd_Lt_Stat_State, 2 );
        _CMS_PI_Sd_Stat_MMR_F1_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI__ALLDEF_CMS_PI_Sd_Stat_MMR_F1_AR
{
    if( getValue(this) )
    {
        // alle signale auf default einstellen
        putValue( HMI_PI_Sd_Lt_Enbl, 0 );
        putValue( HMI_PI_Sd_Obj_Lt_RelSpd, 0 );
        putValue( HMI_PI_Sd_RelsRcmmnd_Pyro_Lt, 0 );
        putValue( HMI_PI_Sd_RelsRcmmnd_Rev_Lt, 0 );
        putValue( HMI_PI_Sd_TTI_Lt, 0 );
        putValue( HMI_Rsrv1_CMS_PI_Sd_Lt_Stat, 0 );
    }
}

on EnvVar HMI_PI_Sd_Lt_Enbl
{
    _mCMS_PI_Sd_Stat_MMR_F1_AR.PI_Sd_Lt_Enbl.phys = getValue(this);
    _CMS_PI_Sd_Stat_MMR_F1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PI_Sd_Obj_Lt_RelSpd
{
    _mCMS_PI_Sd_Stat_MMR_F1_AR.PI_Sd_Obj_Lt_RelSpd.phys = getValue(this);
    _CMS_PI_Sd_Stat_MMR_F1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PI_Sd_RelsRcmmnd_Pyro_Lt
{
    _mCMS_PI_Sd_Stat_MMR_F1_AR.PI_Sd_RelsRcmmnd_Pyro_Lt.phys = getValue(this);
    _CMS_PI_Sd_Stat_MMR_F1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PI_Sd_RelsRcmmnd_Rev_Lt
{
    _mCMS_PI_Sd_Stat_MMR_F1_AR.PI_Sd_RelsRcmmnd_Rev_Lt.phys = getValue(this);
    _CMS_PI_Sd_Stat_MMR_F1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PI_Sd_TTI_Lt
{
    _mCMS_PI_Sd_Stat_MMR_F1_AR.PI_Sd_TTI_Lt.phys = getValue(this);
    _CMS_PI_Sd_Stat_MMR_F1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_CMS_PI_Sd_Lt_Stat
{
    _mCMS_PI_Sd_Stat_MMR_F1_AR.Rsrv1_CMS_PI_Sd_Lt_Stat.phys = getValue(this);
    _CMS_PI_Sd_Stat_MMR_F1_AR_SpontanFlag = 1;
}

CMS_PI_Sd_Stat_MMR_F4_AR_check_output()
{
    if( !getValue( HMI__STMSG_CMS_PI_Sd_Stat_MMR_F4_AR ) )
    {
    //  message   CMS_PI_Sd_Stat_MMR_F4_AR ID: 300 --- Sendeart 1 spontanX --- 
        if( _CMS_PI_Sd_Stat_MMR_F4_AR_SpontanFlag)
        {
            CMS_PI_Sd_Stat_MMR_F4_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _CMS_PI_Sd_Stat_MMR_F4_AR_SpontanFlag = 0;  // Spontan-Flag zur�cksetzen
        }
    }
}

CMS_PI_Sd_Stat_MMR_F4_AR_init()
{   /* Botschaft CMS_PI_Sd_Stat_MMR_F1_AR ID: 300 --- Sendeart 1 Spontan --- 
BA_ "ApplMessage" BO_ 300 0;
BA_ "NmAsrMessage" BO_ 300 0;
BA_ "GenMsgMinAcceptLength" BO_ 300 4;
BA_ "GenMsgILSupport" BO_ 300 1;
BA_ "DiagState" BO_ 300 0;
BA_ "DiagRequest" BO_ 300 0;
BA_ "DiagResponse" BO_ 300 0;
BA_ "GenMsgStartValue" BO_ 300 "0";
BA_ "GenMsgDelayTime" BO_ 300 20;
BA_ "GenMsgNrOfRepetition" BO_ 300 0;
BA_ "GenMsgSendType" BO_ 300 1;
    */
    _CMS_PI_Sd_Stat_MMR_F4_AR_Timebase =            c_tDBKomTimer_20ms;
    _CMS_PI_Sd_Stat_MMR_F4_AR_CycleCount =         20 / _CMS_PI_Sd_Stat_MMR_F4_AR_Timebase;
    _CMS_PI_Sd_Stat_MMR_F4_AR_StartDelay =          0 / _CMS_PI_Sd_Stat_MMR_F4_AR_Timebase;
    _CMS_PI_Sd_Stat_MMR_F4_AR_Cnt = _CMS_PI_Sd_Stat_MMR_F4_AR_StartDelay;

    putValue( HMI__STMSGSD_CMS_PI_Sd_Stat_MMR_F4_AR, _CMS_PI_Sd_Stat_MMR_F4_AR_StartDelay * _CMS_PI_Sd_Stat_MMR_F4_AR_Timebase );

    _mCMS_PI_Sd_Stat_MMR_F4_AR.PI_Sd_Obj_Rt_RelSpd.phys = getValue( HMI_PI_Sd_Obj_Rt_RelSpd );
    _mCMS_PI_Sd_Stat_MMR_F4_AR.PI_Sd_RelsRcmmnd_Pyro_Rt.phys = getValue( HMI_PI_Sd_RelsRcmmnd_Pyro_Rt );
    _mCMS_PI_Sd_Stat_MMR_F4_AR.PI_Sd_RelsRcmmnd_Rev_Rt.phys = getValue( HMI_PI_Sd_RelsRcmmnd_Rev_Rt );
    _mCMS_PI_Sd_Stat_MMR_F4_AR.PI_Sd_Rt_Enbl.phys = getValue( HMI_PI_Sd_Rt_Enbl );
    _mCMS_PI_Sd_Stat_MMR_F4_AR.PI_Sd_TTI_Rt.phys = getValue( HMI_PI_Sd_TTI_Rt );
    _mCMS_PI_Sd_Stat_MMR_F4_AR.Rsrv1_CMS_PI_Sd_Rt_Stat.phys = getValue( HMI_Rsrv1_CMS_PI_Sd_Rt_Stat );
}

CMS_PI_Sd_Stat_MMR_F4_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_CMS_PI_Sd_Rt_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_CMS_PI_Sd_Rt_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _CMS_PI_Sd_Stat_MMR_F4_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _CMS_PI_Sd_Stat_MMR_F4_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_CMS_PI_Sd_Rt_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _CMS_PI_Sd_Stat_MMR_F4_AR_SQC_WrongSeqJump != 0 ) &&
            ( _CMS_PI_Sd_Stat_MMR_F4_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _CMS_PI_Sd_Stat_MMR_F4_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _CMS_PI_Sd_Stat_MMR_F4_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _CMS_PI_Sd_Stat_MMR_F4_AR_SQC_RepeatedCnt ) &&
            ( _CMS_PI_Sd_Stat_MMR_F4_AR_E2E_Armed == 1  )    )
        {
            _CMS_PI_Sd_Stat_MMR_F4_AR_SQC_RepeatedCnt--;
        }
        else
        {
           if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_CMS_PI_Sd_Rt_Stat, SQC_help );
    }
    _mCMS_PI_Sd_Stat_MMR_F4_AR.SQC_CMS_PI_Sd_Rt_Stat = SQC_help;

    if( getValue( HMI_CRC_CMS_PI_Sd_Rt_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_CMS_PI_Sd_Rt_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mCMS_PI_Sd_Stat_MMR_F4_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mCMS_PI_Sd_Stat_MMR_F4_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mCMS_PI_Sd_Stat_MMR_F4_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mCMS_PI_Sd_Stat_MMR_F4_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mCMS_PI_Sd_Stat_MMR_F4_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mCMS_PI_Sd_Stat_MMR_F4_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mCMS_PI_Sd_Stat_MMR_F4_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mCMS_PI_Sd_Stat_MMR_F4_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _CMS_PI_Sd_Stat_MMR_F4_AR_CRC_Offset[ _mCMS_PI_Sd_Stat_MMR_F4_AR.SQC_CMS_PI_Sd_Rt_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _CMS_PI_Sd_Stat_MMR_F4_AR_CRC_ErrorCnt   && ( _CMS_PI_Sd_Stat_MMR_F4_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_CMS_PI_Sd_Rt_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _CMS_PI_Sd_Stat_MMR_F4_AR_CRC_ErrorCnt > 0 )
                    _CMS_PI_Sd_Stat_MMR_F4_AR_CRC_ErrorCnt--; 
            }
            _mCMS_PI_Sd_Stat_MMR_F4_AR.CRC_CMS_PI_Sd_Rt_Stat = crc;
            putValue( HMI_CRC_CMS_PI_Sd_Rt_Stat, crc );
        }
        else
            _mCMS_PI_Sd_Stat_MMR_F4_AR.CRC_CMS_PI_Sd_Rt_Stat = getValue( HMI_CRC_CMS_PI_Sd_Rt_Stat );
    }
    else
    {
        if( !getValue( HMI_CRC_CMS_PI_Sd_Rt_Stat_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mCMS_PI_Sd_Stat_MMR_F4_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mCMS_PI_Sd_Stat_MMR_F4_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mCMS_PI_Sd_Stat_MMR_F4_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mCMS_PI_Sd_Stat_MMR_F4_AR.byte( 3 ) ];
//            crc = crctable[ crc ^ _mCMS_PI_Sd_Stat_MMR_F4_AR.byte( 4 ) ];
//            crc = crctable[ crc ^ _mCMS_PI_Sd_Stat_MMR_F4_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mCMS_PI_Sd_Stat_MMR_F4_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mCMS_PI_Sd_Stat_MMR_F4_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _CMS_PI_Sd_Stat_MMR_F4_AR_CRC_ErrorCnt   && ( _CMS_PI_Sd_Stat_MMR_F4_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_CMS_PI_Sd_Rt_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _CMS_PI_Sd_Stat_MMR_F4_AR_CRC_ErrorCnt > 0 )
                    _CMS_PI_Sd_Stat_MMR_F4_AR_CRC_ErrorCnt--; 
            }
            _mCMS_PI_Sd_Stat_MMR_F4_AR.CRC_CMS_PI_Sd_Rt_Stat = crc;
            putValue( HMI_CRC_CMS_PI_Sd_Rt_Stat, crc );
        }
        else
            _mCMS_PI_Sd_Stat_MMR_F4_AR.CRC_CMS_PI_Sd_Rt_Stat = getValue( HMI_CRC_CMS_PI_Sd_Rt_Stat );
    }
    if( ( _CMS_PI_Sd_Stat_MMR_F4_AR_MSG_DropCnt > 0 ) &&
        ( _CMS_PI_Sd_Stat_MMR_F4_AR_E2E_Armed == 1  )    )
    {
        _CMS_PI_Sd_Stat_MMR_F4_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mCMS_PI_Sd_Stat_MMR_F4_AR );
        
    if( _CMS_PI_Sd_Stat_MMR_F4_AR_E2E_Armed == 1 )
    {
        if ( ( _CMS_PI_Sd_Stat_MMR_F4_AR_MSG_DropCnt == 0      ) &&
             ( _CMS_PI_Sd_Stat_MMR_F4_AR_CRC_ErrorCnt == 0     ) &&
             ( _CMS_PI_Sd_Stat_MMR_F4_AR_SQC_RepeatedCnt == 0  ) &&
             ( _CMS_PI_Sd_Stat_MMR_F4_AR_SQC_WrongSeqJump == 0 )    )
        {
            _CMS_PI_Sd_Stat_MMR_F4_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_CMS_PI_Sd_Rt_Stat_State, 0 );
        }
    }
}

CMS_PI_Sd_Stat_MMR_F4_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CMS_PI_Sd_Stat_MMR_F4_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CMS_PI_Sd_Stat_MMR_F4_AR := %X\n", getValue( HMI__STMSG_CMS_PI_Sd_Stat_MMR_F4_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CMS_PI_Sd_Stat_MMR_F4_AR := %X\n", getValue( HMI__STMSGT_CMS_PI_Sd_Stat_MMR_F4_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_CMS_PI_Sd_Rt_Stat := %X\n", getValue( HMI_CRC_CMS_PI_Sd_Rt_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_CMS_PI_Sd_Rt_Stat_Auto := %X\n", getValue( HMI_CRC_CMS_PI_Sd_Rt_Stat_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_CMS_PI_Sd_Rt_Stat_Profile_02 := %X\n", getValue( HMI_CRC_CMS_PI_Sd_Rt_Stat_Profile_02 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PI_Sd_Obj_Rt_RelSpd := %X\n", getValue( HMI_PI_Sd_Obj_Rt_RelSpd ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PI_Sd_RelsRcmmnd_Pyro_Rt := %X\n", getValue( HMI_PI_Sd_RelsRcmmnd_Pyro_Rt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PI_Sd_RelsRcmmnd_Rev_Rt := %X\n", getValue( HMI_PI_Sd_RelsRcmmnd_Rev_Rt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PI_Sd_Rt_Enbl := %X\n", getValue( HMI_PI_Sd_Rt_Enbl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PI_Sd_TTI_Rt := %X\n", getValue( HMI_PI_Sd_TTI_Rt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_CMS_PI_Sd_Rt_Stat := %X\n", getValue( HMI_Rsrv1_CMS_PI_Sd_Rt_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_CMS_PI_Sd_Rt_Stat := %X\n", getValue( HMI_SQC_CMS_PI_Sd_Rt_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_CMS_PI_Sd_Rt_Stat_Auto := %X\n", getValue( HMI_SQC_CMS_PI_Sd_Rt_Stat_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tCMS_PI_Sd_Stat_MMR_F4_AR
{
    putValue( HMI__STMSG_CMS_PI_Sd_Stat_MMR_F4_AR, 0 );
}

on EnvVar HMI__STMSG_CMS_PI_Sd_Stat_MMR_F4_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CMS_PI_Sd_Stat_MMR_F4_AR );
        if( tDelay > 0)    
            setTimer( _tCMS_PI_Sd_Stat_MMR_F4_AR, tDelay );
        else
            putValue( HMI__STMSG_CMS_PI_Sd_Stat_MMR_F4_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CMS_PI_Sd_Stat_MMR_F4_AR
{
    if( getValue( this ) )
        openPanel("CMS_PI_Sd_Stat_MMR_F4_AR");
}

on envVar HMI_E2E_CMS_PI_Sd_Rt_Stat_Inject
{
    if( getValue( this ) )
    {
        _CMS_PI_Sd_Stat_MMR_F4_AR_CRC_ErrorCnt = getValue( HMI_CRC_CMS_PI_Sd_Rt_Stat_ErrorCount );
        _CMS_PI_Sd_Stat_MMR_F4_AR_SQC_TriggPos = getValue( HMI_SQC_CMS_PI_Sd_Rt_Stat_TriggerPosition );
        _CMS_PI_Sd_Stat_MMR_F4_AR_SQC_WrongSeqJump = getValue( HMI_SQC_CMS_PI_Sd_Rt_Stat_WrongSeq );
        _CMS_PI_Sd_Stat_MMR_F4_AR_SQC_RepeatedCnt = getValue( HMI_SQC_CMS_PI_Sd_Rt_Stat_Repeated );
        _CMS_PI_Sd_Stat_MMR_F4_AR_MSG_DropCnt = getValue( HMI_SQC_CMS_PI_Sd_Rt_Stat_MSG_DropCnt );
        putValue( HMI_E2E_CMS_PI_Sd_Rt_Stat_State, 2 );
        _CMS_PI_Sd_Stat_MMR_F4_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI__ALLDEF_CMS_PI_Sd_Stat_MMR_F4_AR
{
    if( getValue(this) )
    {
        // alle signale auf default einstellen
        putValue( HMI_PI_Sd_Obj_Rt_RelSpd, 0 );
        putValue( HMI_PI_Sd_RelsRcmmnd_Pyro_Rt, 0 );
        putValue( HMI_PI_Sd_RelsRcmmnd_Rev_Rt, 0 );
        putValue( HMI_PI_Sd_Rt_Enbl, 0 );
        putValue( HMI_PI_Sd_TTI_Rt, 0 );
        putValue( HMI_Rsrv1_CMS_PI_Sd_Rt_Stat, 0 );
    }
}

on EnvVar HMI_PI_Sd_Rt_Enbl
{
    _mCMS_PI_Sd_Stat_MMR_F4_AR.PI_Sd_Rt_Enbl.phys = getValue(this);
    _CMS_PI_Sd_Stat_MMR_F4_AR_SpontanFlag = 1;
}

on EnvVar HMI_PI_Sd_Obj_Rt_RelSpd
{
    _mCMS_PI_Sd_Stat_MMR_F4_AR.PI_Sd_Obj_Rt_RelSpd.phys = getValue(this);
    _CMS_PI_Sd_Stat_MMR_F4_AR_SpontanFlag = 1;
}

on EnvVar HMI_PI_Sd_RelsRcmmnd_Pyro_Rt
{
    _mCMS_PI_Sd_Stat_MMR_F4_AR.PI_Sd_RelsRcmmnd_Pyro_Rt.phys = getValue(this);
    _CMS_PI_Sd_Stat_MMR_F4_AR_SpontanFlag = 1;
}

on EnvVar HMI_PI_Sd_RelsRcmmnd_Rev_Rt
{
    _mCMS_PI_Sd_Stat_MMR_F4_AR.PI_Sd_RelsRcmmnd_Rev_Rt.phys = getValue(this);
    _CMS_PI_Sd_Stat_MMR_F4_AR_SpontanFlag = 1;
}

on EnvVar HMI_PI_Sd_TTI_Rt
{
    _mCMS_PI_Sd_Stat_MMR_F4_AR.PI_Sd_TTI_Rt.phys = getValue(this);
    _CMS_PI_Sd_Stat_MMR_F4_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_CMS_PI_Sd_Rt_Stat
{
    _mCMS_PI_Sd_Stat_MMR_F4_AR.Rsrv1_CMS_PI_Sd_Rt_Stat.phys = getValue(this);
    _CMS_PI_Sd_Stat_MMR_F4_AR_SpontanFlag = 1;
}

CMS_PI_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_CMS_PI_Stat_AR ) )
    {
    //  message   CMS_PI_Stat_AR ID: 165 --- Sendeart 0 cyclicX --- 
        _CMS_PI_Stat_AR_Cnt--;
        if( _CMS_PI_Stat_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            CMS_PI_Stat_AR_output();
            // Zyklus-Z�hler zur�cksetzen
            _CMS_PI_Stat_AR_Cnt = _CMS_PI_Stat_AR_CycleCount;
        }
    }
}

CMS_PI_Stat_AR_init()
{   /* Botschaft CMS_PI_Stat_AR ID: 165 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 165 0;
BA_ "NmAsrMessage" BO_ 165 0;
BA_ "GenMsgMinAcceptLength" BO_ 165 8;
BA_ "GenMsgILSupport" BO_ 165 1;
BA_ "DiagState" BO_ 165 0;
BA_ "DiagRequest" BO_ 165 0;
BA_ "DiagResponse" BO_ 165 0;
BA_ "GenMsgStartValue" BO_ 165 "0";
BA_ "GenMsgCycleTime" BO_ 165 20;
BA_ "GenMsgSendType" BO_ 165 0;
    */
    _CMS_PI_Stat_AR_Timebase =         c_tDBKomTimer_20ms;
    _CMS_PI_Stat_AR_CycleCount =      20 / _CMS_PI_Stat_AR_Timebase;
    _CMS_PI_Stat_AR_StartDelay =       0 / _CMS_PI_Stat_AR_Timebase;
    _CMS_PI_Stat_AR_Cnt = _CMS_PI_Stat_AR_StartDelay;

    putValue( HMI__STMSGSD_CMS_PI_Stat_AR, _CMS_PI_Stat_AR_StartDelay * _CMS_PI_Stat_AR_Timebase );

    _mCMS_PI_Stat_AR.CMS_Brk_Rq_V2.phys = getValue( HMI_CMS_Brk_Rq_V2 );
    _mCMS_PI_Stat_AR.CMS_R_Warn_Rq.phys = getValue( HMI_CMS_R_Warn_Rq );
    _mCMS_PI_Stat_AR.CMS_VehDecel_Rq.phys = getValue( HMI_CMS_VehDecel_Rq );
    _mCMS_PI_Stat_AR.CRC_CMS_PI_Stat.phys = getValue( HMI_CRC_CMS_PI_Stat );
    _mCMS_PI_Stat_AR.PI_Enbl.phys = getValue( HMI_PI_Enbl );
    _mCMS_PI_Stat_AR.PI_Obj_R_RelSpd.phys = getValue( HMI_PI_Obj_R_RelSpd );
    _mCMS_PI_Stat_AR.PI_ObjAhdRelSpd.phys = getValue( HMI_PI_ObjAhdRelSpd );
    _mCMS_PI_Stat_AR.PI_R_Enbl.phys = getValue( HMI_PI_R_Enbl );
    _mCMS_PI_Stat_AR.PI_RelsRcmmnd_Ft.phys = getValue( HMI_PI_RelsRcmmnd_Ft );
    _mCMS_PI_Stat_AR.PI_RelsRcmmnd_R.phys = getValue( HMI_PI_RelsRcmmnd_R );
    _mCMS_PI_Stat_AR.PI_TTI_Ft.phys = getValue( HMI_PI_TTI_Ft );
    _mCMS_PI_Stat_AR.PI_TTI_R.phys = getValue( HMI_PI_TTI_R );
    _mCMS_PI_Stat_AR.Rsrv1_CMS_PI_Stat.phys = getValue( HMI_Rsrv1_CMS_PI_Stat );
    _mCMS_PI_Stat_AR.SQC_CMS_PI_Stat .phys = getValue( HMI_SQC_CMS_PI_Stat  );
}

CMS_PI_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_CMS_PI_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_CMS_PI_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _CMS_PI_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _CMS_PI_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_CMS_PI_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _CMS_PI_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _CMS_PI_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _CMS_PI_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _CMS_PI_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _CMS_PI_Stat_AR_SQC_RepeatedCnt ) &&
            ( _CMS_PI_Stat_AR_E2E_Armed == 1  )    )
        {
            _CMS_PI_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_CMS_PI_Stat, SQC_help );
    }
    _mCMS_PI_Stat_AR.SQC_CMS_PI_Stat = SQC_help;

    if( getValue( HMI_CRC_CMS_PI_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_CMS_PI_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mCMS_PI_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mCMS_PI_Stat_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mCMS_PI_Stat_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mCMS_PI_Stat_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mCMS_PI_Stat_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mCMS_PI_Stat_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mCMS_PI_Stat_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mCMS_PI_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _CMS_PI_Stat_AR_CRC_Offset[ _mCMS_PI_Stat_AR.SQC_CMS_PI_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _CMS_PI_Stat_AR_CRC_ErrorCnt   && ( _CMS_PI_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_CMS_PI_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _CMS_PI_Stat_AR_CRC_ErrorCnt > 0 )
                    _CMS_PI_Stat_AR_CRC_ErrorCnt--; 
            }
            _mCMS_PI_Stat_AR.CRC_CMS_PI_Stat = crc;
            putValue( HMI_CRC_CMS_PI_Stat, crc );
        }
        else
            _mCMS_PI_Stat_AR.CRC_CMS_PI_Stat = getValue( HMI_CRC_CMS_PI_Stat );
    }
    else
    {
        if( !getValue( HMI_CRC_CMS_PI_Stat_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mCMS_PI_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mCMS_PI_Stat_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mCMS_PI_Stat_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mCMS_PI_Stat_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mCMS_PI_Stat_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mCMS_PI_Stat_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mCMS_PI_Stat_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mCMS_PI_Stat_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _CMS_PI_Stat_AR_CRC_ErrorCnt   && ( _CMS_PI_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_CMS_PI_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _CMS_PI_Stat_AR_CRC_ErrorCnt > 0 )
                    _CMS_PI_Stat_AR_CRC_ErrorCnt--; 
            }
            _mCMS_PI_Stat_AR.CRC_CMS_PI_Stat = crc;
            putValue( HMI_CRC_CMS_PI_Stat, crc );
        }
        else
            _mCMS_PI_Stat_AR.CRC_CMS_PI_Stat = getValue( HMI_CRC_CMS_PI_Stat );
    }
    if( ( _CMS_PI_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _CMS_PI_Stat_AR_E2E_Armed == 1  )    )
    {
        _CMS_PI_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mCMS_PI_Stat_AR );
        
    if( _CMS_PI_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _CMS_PI_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _CMS_PI_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _CMS_PI_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _CMS_PI_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _CMS_PI_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_CMS_PI_Stat_State, 0 );
        }
    }
}

CMS_PI_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CMS_PI_Stat_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CMS_PI_Stat_AR := %X\n", getValue( HMI__STMSG_CMS_PI_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CMS_PI_Stat_AR := %X\n", getValue( HMI__STMSGT_CMS_PI_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CMS_Brk_Rq_V2 := %X\n", getValue( HMI_CMS_Brk_Rq_V2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CMS_R_Warn_Rq := %X\n", getValue( HMI_CMS_R_Warn_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CMS_VehDecel_Rq := %X\n", getValue( HMI_CMS_VehDecel_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_CMS_PI_Stat := %X\n", getValue( HMI_CRC_CMS_PI_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_CMS_PI_Stat_Auto := %X\n", getValue( HMI_CRC_CMS_PI_Stat_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PI_Enbl := %X\n", getValue( HMI_PI_Enbl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PI_Obj_R_RelSpd := %X\n", getValue( HMI_PI_Obj_R_RelSpd ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PI_ObjAhdRelSpd := %X\n", getValue( HMI_PI_ObjAhdRelSpd ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PI_R_Enbl := %X\n", getValue( HMI_PI_R_Enbl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PI_RelsRcmmnd_Ft := %X\n", getValue( HMI_PI_RelsRcmmnd_Ft ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PI_RelsRcmmnd_R := %X\n", getValue( HMI_PI_RelsRcmmnd_R ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PI_TTI_Ft := %X\n", getValue( HMI_PI_TTI_Ft ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PI_TTI_R := %X\n", getValue( HMI_PI_TTI_R ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_CMS_PI_Stat := %X\n", getValue( HMI_Rsrv1_CMS_PI_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_CMS_PI_Stat  := %X\n", getValue( HMI_SQC_CMS_PI_Stat  ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_CMS_PI_Stat_Auto := %X\n", getValue( HMI_SQC_CMS_PI_Stat_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tCMS_PI_Stat_AR
{
    putValue( HMI__STMSG_CMS_PI_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_CMS_PI_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CMS_PI_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tCMS_PI_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_CMS_PI_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CMS_PI_Stat_AR
{
    if( getValue( this ) )
        openPanel("CMS_PI_Stat_AR");
}

on envVar HMI_E2E_CMS_PI_Stat_Inject
{
    if( getValue( this ) )
    {
        _CMS_PI_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_CMS_PI_Stat_ErrorCount );
        _CMS_PI_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_CMS_PI_Stat_TriggerPosition );
        _CMS_PI_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_CMS_PI_Stat_WrongSeq );
        _CMS_PI_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_CMS_PI_Stat_Repeated );
        _CMS_PI_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_CMS_PI_Stat_MSG_DropCnt );
        putValue( HMI_E2E_CMS_PI_Stat_State, 2 );
        _CMS_PI_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_Rsrv1_CMS_PI_Stat
{
    _mCMS_PI_Stat_AR.Rsrv1_CMS_PI_Stat.phys = getValue(this);
}

on EnvVar HMI_CMS_VehDecel_Rq
{
    _mCMS_PI_Stat_AR.CMS_VehDecel_Rq.phys = getValue(this);
}

on EnvVar HMI_CMS_Brk_Rq_V2
{
    _mCMS_PI_Stat_AR.CMS_Brk_Rq_V2.phys = getValue(this);
}

on EnvVar HMI_CMS_R_Warn_Rq
{
    _mCMS_PI_Stat_AR.CMS_R_Warn_Rq.phys = getValue(this);
}

CNG_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_CNG_Disp_Rq_AR ) )
    {
    //  message   CNG_Disp_Rq_AR ID: 733 --- Sendeart 5 cyclicAndSpontanWithDelay
        if( _CNG_Disp_Rq_AR_DelayCnt > 0) _CNG_Disp_Rq_AR_DelayCnt--; // Mindestsendeabstand
        _CNG_Disp_Rq_AR_Cnt--;
        if( _CNG_Disp_Rq_AR_Cnt < 1 )
        {
            if( _CNG_Disp_Rq_AR_DelayCnt < 1 )
            {
                CNG_Disp_Rq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                _CNG_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _CNG_Disp_Rq_AR_DelayCnt = _CNG_Disp_Rq_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _CNG_Disp_Rq_AR_SpontanFlag = 1;
            }
            _CNG_Disp_Rq_AR_Cnt = _CNG_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _CNG_Disp_Rq_AR_SpontanFlag)
        {
            if( _CNG_Disp_Rq_AR_DelayCnt < 1 )
            {
                CNG_Disp_Rq_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _CNG_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _CNG_Disp_Rq_AR_DelayCnt = _CNG_Disp_Rq_AR_MinDelay;
            }
        }
    }
}

CNG_Disp_Rq_AR_init()
{   /* Botschaft CNG_Disp_Rq_AR ID: 733 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 733 0;
BA_ "NmAsrMessage" BO_ 733 0;
BA_ "GenMsgMinAcceptLength" BO_ 733 8;
BA_ "GenMsgILSupport" BO_ 733 1;
BA_ "DiagState" BO_ 733 0;
BA_ "DiagRequest" BO_ 733 0;
BA_ "DiagResponse" BO_ 733 0;
BA_ "GenMsgStartValue" BO_ 733 "0";
BA_ "GenMsgDelayTime" BO_ 733 100;
BA_ "GenMsgNrOfRepetitions" BO_ 733 0;
BA_ "GenMsgCycleTime" BO_ 733 1000;
BA_ "GenMsgSendType" BO_ 733 5;
    */
    _CNG_Disp_Rq_AR_Timebase =         c_tDBKomTimer_20ms;
    _CNG_Disp_Rq_AR_CycleCount =    1000 / _CNG_Disp_Rq_AR_Timebase;
    _CNG_Disp_Rq_AR_StartDelay =       0 / _CNG_Disp_Rq_AR_Timebase;
    _CNG_Disp_Rq_AR_MinDelay =       100 / _CNG_Disp_Rq_AR_Timebase;
    _CNG_Disp_Rq_AR_Cnt = _CNG_Disp_Rq_AR_StartDelay;
    _CNG_Disp_Rq_AR_SpontanFlag = 0;
    _CNG_Disp_Rq_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_CNG_Disp_Rq_AR, _CNG_Disp_Rq_AR_StartDelay * _CNG_Disp_Rq_AR_Timebase );

    _mCNG_Disp_Rq_AR.CNG_FuelMd_Disp_Rq.phys = getValue( HMI_CNG_FuelMd_Disp_Rq );
    _mCNG_Disp_Rq_AR.CNG_FuelMd_Stat.phys = getValue( HMI_CNG_FuelMd_Stat );
    _mCNG_Disp_Rq_AR.CNG_FuelMdChg_Actv.phys = getValue( HMI_CNG_FuelMdChg_Actv );
    _mCNG_Disp_Rq_AR.CNG_FuelMdChg_Stat.phys = getValue( HMI_CNG_FuelMdChg_Stat );
    _mCNG_Disp_Rq_AR.CNG_FuelPress.phys = getValue( HMI_CNG_FuelPress );
    _mCNG_Disp_Rq_AR.CNG_Msg1_Disp_Rq.phys = getValue( HMI_CNG_Msg1_Disp_Rq );
    _mCNG_Disp_Rq_AR.CNG_Msg2_Disp_Rq.phys = getValue( HMI_CNG_Msg2_Disp_Rq );
    _mCNG_Disp_Rq_AR.CNG_Msg3_Disp_Rq.phys = getValue( HMI_CNG_Msg3_Disp_Rq );
    _mCNG_Disp_Rq_AR.CNG_Msg4_Disp_Rq.phys = getValue( HMI_CNG_Msg4_Disp_Rq );
    _mCNG_Disp_Rq_AR.CNG_Msg5_Disp_Rq.phys = getValue( HMI_CNG_Msg5_Disp_Rq );
    _mCNG_Disp_Rq_AR.CNG_Msg6_Disp_Rq.phys = getValue( HMI_CNG_Msg6_Disp_Rq );
    _mCNG_Disp_Rq_AR.CNG_Msg7_Disp_Rq.phys = getValue( HMI_CNG_Msg7_Disp_Rq );
    _mCNG_Disp_Rq_AR.CNG_Msg8_Disp_Rq.phys = getValue( HMI_CNG_Msg8_Disp_Rq );
    _mCNG_Disp_Rq_AR.CNG_Qual.phys = getValue( HMI_CNG_Qual );
    _mCNG_Disp_Rq_AR.CNG_TankCapIndLmp_On_Rq.phys = getValue( HMI_CNG_TankCapIndLmp_On_Rq );
    _mCNG_Disp_Rq_AR.CNG_TankLvl.phys = getValue( HMI_CNG_TankLvl );
    _mCNG_Disp_Rq_AR.CNG_TankLvl_Min.phys = getValue( HMI_CNG_TankLvl_Min );
    _mCNG_Disp_Rq_AR.Rsrv1_CNG_Disp_Rq.phys = getValue( HMI_Rsrv1_CNG_Disp_Rq );
    _mCNG_Disp_Rq_AR.Rsrv2_CNG_Disp_Rq.phys = getValue( HMI_Rsrv2_CNG_Disp_Rq );
}

CNG_Disp_Rq_AR_output(void)
{
    output( _mCNG_Disp_Rq_AR );
}

CNG_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CNG_Disp_Rq_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CNG_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_CNG_Disp_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CNG_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_CNG_Disp_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CNG_FuelMd_Disp_Rq := %X\n", getValue( HMI_CNG_FuelMd_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CNG_FuelMd_Stat := %X\n", getValue( HMI_CNG_FuelMd_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CNG_FuelMdChg_Actv := %X\n", getValue( HMI_CNG_FuelMdChg_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CNG_FuelMdChg_Stat := %X\n", getValue( HMI_CNG_FuelMdChg_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CNG_FuelPress := %X\n", getValue( HMI_CNG_FuelPress ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CNG_Msg1_Disp_Rq := %X\n", getValue( HMI_CNG_Msg1_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CNG_Msg2_Disp_Rq := %X\n", getValue( HMI_CNG_Msg2_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CNG_Msg3_Disp_Rq := %X\n", getValue( HMI_CNG_Msg3_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CNG_Msg4_Disp_Rq := %X\n", getValue( HMI_CNG_Msg4_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CNG_Msg5_Disp_Rq := %X\n", getValue( HMI_CNG_Msg5_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CNG_Msg6_Disp_Rq := %X\n", getValue( HMI_CNG_Msg6_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CNG_Msg7_Disp_Rq := %X\n", getValue( HMI_CNG_Msg7_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CNG_Msg8_Disp_Rq := %X\n", getValue( HMI_CNG_Msg8_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CNG_Qual := %X\n", getValue( HMI_CNG_Qual ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CNG_TankCapIndLmp_On_Rq := %X\n", getValue( HMI_CNG_TankCapIndLmp_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CNG_TankLvl := %X\n", getValue( HMI_CNG_TankLvl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CNG_TankLvl_Min := %X\n", getValue( HMI_CNG_TankLvl_Min ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_CNG_Disp_Rq := %X\n", getValue( HMI_Rsrv1_CNG_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_CNG_Disp_Rq := %X\n", getValue( HMI_Rsrv2_CNG_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tCNG_Disp_Rq_AR
{
    putValue( HMI__STMSG_CNG_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_CNG_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CNG_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tCNG_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_CNG_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CNG_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("CNG_Disp_Rq_AR");
}

on EnvVar HMI_CNG_FuelMd_Disp_Rq
{
    _mCNG_Disp_Rq_AR.CNG_FuelMd_Disp_Rq.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CNG_FuelMd_Stat
{
    _mCNG_Disp_Rq_AR.CNG_FuelMd_Stat.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CNG_FuelMdChg_Actv
{
    _mCNG_Disp_Rq_AR.CNG_FuelMdChg_Actv.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CNG_FuelMdChg_Stat
{
    _mCNG_Disp_Rq_AR.CNG_FuelMdChg_Stat.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CNG_FuelPress
{
    _mCNG_Disp_Rq_AR.CNG_FuelPress.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CNG_Msg1_Disp_Rq
{
    _mCNG_Disp_Rq_AR.CNG_Msg1_Disp_Rq.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CNG_Msg2_Disp_Rq
{
    _mCNG_Disp_Rq_AR.CNG_Msg2_Disp_Rq.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CNG_Msg3_Disp_Rq
{
    _mCNG_Disp_Rq_AR.CNG_Msg3_Disp_Rq.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CNG_Msg4_Disp_Rq
{
    _mCNG_Disp_Rq_AR.CNG_Msg4_Disp_Rq.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CNG_Msg5_Disp_Rq
{
    _mCNG_Disp_Rq_AR.CNG_Msg5_Disp_Rq.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CNG_Msg6_Disp_Rq
{
    _mCNG_Disp_Rq_AR.CNG_Msg6_Disp_Rq.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CNG_Msg7_Disp_Rq
{
    _mCNG_Disp_Rq_AR.CNG_Msg7_Disp_Rq.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CNG_Msg8_Disp_Rq
{
    _mCNG_Disp_Rq_AR.CNG_Msg8_Disp_Rq.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CNG_Qual
{
    _mCNG_Disp_Rq_AR.CNG_Qual.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CNG_TankCapIndLmp_On_Rq
{
    _mCNG_Disp_Rq_AR.CNG_TankCapIndLmp_On_Rq.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CNG_TankLvl
{
    _mCNG_Disp_Rq_AR.CNG_TankLvl.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CNG_TankLvl_Min
{
    _mCNG_Disp_Rq_AR.CNG_TankLvl_Min.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_CNG_Disp_Rq
{
    _mCNG_Disp_Rq_AR.Rsrv1_CNG_Disp_Rq.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv2_CNG_Disp_Rq
{
    _mCNG_Disp_Rq_AR.Rsrv2_CNG_Disp_Rq.phys = getValue(this);
    _CNG_Disp_Rq_AR_SpontanFlag = 1;
}

COM_Call_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_COM_Call_Stat_AR ) )
    {
    //  message   COM_Call_Stat_AR ID: 708 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _COM_Call_Stat_AR_Cnt--;
        if( _COM_Call_Stat_AR_Cnt < 1 )
        {
            COM_Call_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _COM_Call_Stat_AR_Cnt = _COM_Call_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _COM_Call_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _COM_Call_Stat_AR_SpontanFlag)
        {
            COM_Call_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _COM_Call_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

COM_Call_Stat_AR_init()
{   /* Botschaft COM_Call_Stat_AR ID: 708 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 708 0;
BA_ "NmAsrMessage" BO_ 708 0;
BA_ "GenMsgMinAcceptLength" BO_ 708 8;
BA_ "GenMsgILSupport" BO_ 708 1;
BA_ "DiagState" BO_ 708 0;
BA_ "DiagRequest" BO_ 708 0;
BA_ "DiagResponse" BO_ 708 0;
BA_ "GenMsgStartValue" BO_ 708 "0";
BA_ "GenMsgDelayTime" BO_ 708 20;
BA_ "GenMsgNrOfRepetitions" BO_ 708 0;
BA_ "GenMsgCycleTime" BO_ 708 500;
BA_ "GenMsgSendType" BO_ 708 5;
    */
    _COM_Call_Stat_AR_Timebase =         c_tDBKomTimer_20ms;
    _COM_Call_Stat_AR_CycleCount =      500 / _COM_Call_Stat_AR_Timebase;
    _COM_Call_Stat_AR_StartDelay =        0 / _COM_Call_Stat_AR_Timebase;
    _COM_Call_Stat_AR_Cnt = _COM_Call_Stat_AR_StartDelay;
    _COM_Call_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_COM_Call_Stat_AR, _COM_Call_Stat_AR_StartDelay * _COM_Call_Stat_AR_Timebase );

    _mCOM_Call_Stat_AR.ConnectMe_Icon_Stat.phys = getValue( HMI_ConnectMe_Icon_Stat );
	_mCOM_Call_Stat_AR.ECall_SOS_Rdy.phys = getValue( HMI_ECall_SOS_Rdy );
    _mCOM_Call_Stat_AR.MBCall_Call_Type.phys = getValue( HMI_MBCall_Call_Type );
    _mCOM_Call_Stat_AR.MBCall_CallScreen_Rq.phys = getValue( HMI_MBCall_CallScreen_Rq );
    _mCOM_Call_Stat_AR.MBCall_CellFieldStr.phys = getValue( HMI_MBCall_CellFieldStr );
    _mCOM_Call_Stat_AR.MBCall_Lat_Deg.phys = getValue( HMI_MBCall_Lat_Deg );
    _mCOM_Call_Stat_AR.MBCall_Lat_Min.phys = getValue( HMI_MBCall_Lat_Min );
    _mCOM_Call_Stat_AR.MBCall_Lat_N_S.phys = getValue( HMI_MBCall_Lat_N_S );
    _mCOM_Call_Stat_AR.MBCall_Lat_Sec.phys = getValue( HMI_MBCall_Lat_Sec );
    _mCOM_Call_Stat_AR.MBCall_Long_Deg.phys = getValue( HMI_MBCall_Long_Deg );
    _mCOM_Call_Stat_AR.MBCall_Long_Min.phys = getValue( HMI_MBCall_Long_Min );
    _mCOM_Call_Stat_AR.MBCall_Long_Sec.phys = getValue( HMI_MBCall_Long_Sec );
    _mCOM_Call_Stat_AR.MBCall_Long_W_E.phys = getValue( HMI_MBCall_Long_W_E );
    _mCOM_Call_Stat_AR.MBCall_Trck_Actv.phys = getValue( HMI_MBCall_Trck_Actv );	
	_mCOM_Call_Stat_AR.MBCall_TrckMd_Hidden.phys = getValue( HMI_MBCall_TrckMd_Hidden );	
    _mCOM_Call_Stat_AR.OfflineMd_Stat.phys = getValue( HMI_OfflineMd_Stat );
    _mCOM_Call_Stat_AR.ServCall_DPP_Msg_Rq.phys = getValue( HMI_ServCall_DPP_Msg_Rq );
    _mCOM_Call_Stat_AR.ServCall_MtPopupSupp.phys = getValue( HMI_ServCall_MtPopupSupp );
    _mCOM_Call_Stat_AR.UserDataReset_Rq.phys = getValue( HMI_UserDataReset_Rq );
}

COM_Call_Stat_AR_output()
{
    output( _mCOM_Call_Stat_AR );
}

COM_Call_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: COM_Call_Stat_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_COM_Call_Stat_AR := %X\n", getValue( HMI__STMSG_COM_Call_Stat_AR ) );            filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_COM_Call_Stat_AR := %X\n", getValue( HMI__STMSGT_COM_Call_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_ConnectMe_Icon_Stat := %X\n", getValue( HMI_ConnectMe_Icon_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ECall_SOS_Rdy := %X\n", getValue( HMI_ECall_SOS_Rdy ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MBCall_Call_Type := %X\n", getValue( HMI_MBCall_Call_Type ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MBCall_CallScreen_Rq := %X\n", getValue( HMI_MBCall_CallScreen_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MBCall_CellFieldStr := %X\n", getValue( HMI_MBCall_CellFieldStr ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MBCall_Lat_Deg := %X\n", getValue( HMI_MBCall_Lat_Deg ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MBCall_Lat_Min := %X\n", getValue( HMI_MBCall_Lat_Min ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MBCall_Lat_N_S := %X\n", getValue( HMI_MBCall_Lat_N_S ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MBCall_Lat_Sec := %X\n", getValue( HMI_MBCall_Lat_Sec ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MBCall_Long_Deg := %X\n", getValue( HMI_MBCall_Long_Deg ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MBCall_Long_Min := %X\n", getValue( HMI_MBCall_Long_Min ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MBCall_Long_Sec := %X\n", getValue( HMI_MBCall_Long_Sec ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MBCall_Long_W_E := %X\n", getValue( HMI_MBCall_Long_W_E ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MBCall_Trck_Actv := %X\n", getValue( HMI_MBCall_Trck_Actv ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_MBCall_TrckMd_Hidden := %X\n", getValue( HMI_MBCall_TrckMd_Hidden ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_OfflineMd_Stat := %X\n", getValue( HMI_OfflineMd_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ServCall_DPP_Msg_Rq := %X\n", getValue( HMI_ServCall_DPP_Msg_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ServCall_MtPopupSupp := %X\n", getValue( HMI_ServCall_MtPopupSupp ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_UserDataReset_Rq := %X\n", getValue( HMI_UserDataReset_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tCOM_Call_Stat_AR
{
    putValue( HMI__STMSG_COM_Call_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_COM_Call_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_COM_Call_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tCOM_Call_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_COM_Call_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_COM_Call_Stat_AR
{
    if( getValue( this ) )
        openPanel("COM_Call_Stat_AR");
}

on envVar HMI_ConnectMe_Icon_Stat
{
    _mCOM_Call_Stat_AR.ConnectMe_Icon_Stat.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_ECall_SOS_Rdy
{
    _mCOM_Call_Stat_AR.ECall_SOS_Rdy.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_MBCall_Call_Type
{
    _mCOM_Call_Stat_AR.MBCall_Call_Type.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_MBCall_CallScreen_Rq
{
    _mCOM_Call_Stat_AR.MBCall_CallScreen_Rq.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_MBCall_CellFieldStr
{
    _mCOM_Call_Stat_AR.MBCall_CellFieldStr.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_MBCall_Lat_Deg
{
    _mCOM_Call_Stat_AR.MBCall_Lat_Deg.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_MBCall_Lat_Min
{
    _mCOM_Call_Stat_AR.MBCall_Lat_Min.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_MBCall_Lat_N_S
{
    _mCOM_Call_Stat_AR.MBCall_Lat_N_S.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_MBCall_Lat_Sec
{
    _mCOM_Call_Stat_AR.MBCall_Lat_Sec.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_MBCall_Long_Deg
{
    _mCOM_Call_Stat_AR.MBCall_Long_Deg.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_MBCall_Long_Min
{
    _mCOM_Call_Stat_AR.MBCall_Long_Min.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_MBCall_Long_Sec
{
    _mCOM_Call_Stat_AR.MBCall_Long_Sec.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_MBCall_Long_W_E
{
    _mCOM_Call_Stat_AR.MBCall_Long_W_E.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_MBCall_TrckMd_Hidden
{
    _mCOM_Call_Stat_AR.MBCall_TrckMd_Hidden.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_MBCall_Trck_Actv
{
    _mCOM_Call_Stat_AR.MBCall_Trck_Actv.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_OfflineMd_Stat
{
    _mCOM_Call_Stat_AR.OfflineMd_Stat.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_ServCall_DPP_Msg_Rq
{
    _mCOM_Call_Stat_AR.ServCall_DPP_Msg_Rq.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_ServCall_MtPopupSupp
{
    _mCOM_Call_Stat_AR.ServCall_MtPopupSupp.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_UserDataReset_Rq
{
    _mCOM_Call_Stat_AR.UserDataReset_Rq.phys = getValue(this);
    _COM_Call_Stat_AR_SpontanFlag = 1;
}

COMM_EIS_WMI_ARR_check_output()
{
    if( !getValue( HMI__STMSG_COMM_EIS_WMI_AR ) )
    {
    //  message   COMM_EIS_WMI_AR ID: 122 --- Sendeart 1 spontanX --- 
        if( _COMM_EIS_WMI_AR_SpontanFlag )
        {
            COMM_EIS_WMI_AR_output(); // Nachricht wg. request ausgeben
            _COMM_EIS_WMI_AR_SpontanFlag = 0;
        }
    }
}

COMM_EIS_WMI_AR_getValue()
{
    _mCOMM_EIS_WMI_AR.byte( 0 ) = getValue( HMI_COMM_EIS_WMI_Data1 );
    _mCOMM_EIS_WMI_AR.byte( 1 ) = getValue( HMI_COMM_EIS_WMI_Data2 );
    _mCOMM_EIS_WMI_AR.byte( 2 ) = getValue( HMI_COMM_EIS_WMI_Data3 );
    _mCOMM_EIS_WMI_AR.byte( 3 ) = getValue( HMI_COMM_EIS_WMI_Data4 );
    _mCOMM_EIS_WMI_AR.byte( 4 ) = getValue( HMI_COMM_EIS_WMI_Data5 );
    _mCOMM_EIS_WMI_AR.byte( 5 ) = getValue( HMI_COMM_EIS_WMI_Data6 );
    _mCOMM_EIS_WMI_AR.byte( 6 ) = getValue( HMI_COMM_EIS_WMI_Data7 );
    _mCOMM_EIS_WMI_AR.byte( 7 ) = getValue( HMI_COMM_EIS_WMI_Data8 );
}

COMM_EIS_WMI_AR_init()
{   /* Botschaft COMM_EIS_WMI_AR ID: 122 --- Sendeart 1 spontanX --- 
BA_ "ApplMessage" BO_ 122 0;
BA_ "NmAsrMessage" BO_ 122 0;
BA_ "GenMsgMinAcceptLength" BO_ 122 8;
BA_ "GenMsgILSupport" BO_ 122 1;
BA_ "DiagState" BO_ 122 0;
BA_ "DiagRequest" BO_ 122 0;
BA_ "DiagResponse" BO_ 122 0;
BA_ "GenMsgStartValue" BO_ 122 "0";
BA_ "GenMsgDelayTime" BO_ 122 10;
BA_ "GenMsgNrOfRepetitions" BO_ 122 0;
BA_ "GenMsgSendType" BO_ 122 1;
    */
    _COMM_EIS_WMI_AR_Timebase =        c_tDBKomTimer_20ms;
    _COMM_EIS_WMI_AR_SpontanFlag = 0;

    _mCOMM_EIS_WMI_AR.byte( 0 ) = getValue( HMI_COMM_EIS_WMI_Data1 );
    _mCOMM_EIS_WMI_AR.byte( 1 ) = getValue( HMI_COMM_EIS_WMI_Data2 );
    _mCOMM_EIS_WMI_AR.byte( 2 ) = getValue( HMI_COMM_EIS_WMI_Data3 );
    _mCOMM_EIS_WMI_AR.byte( 3 ) = getValue( HMI_COMM_EIS_WMI_Data4 );
    _mCOMM_EIS_WMI_AR.byte( 4 ) = getValue( HMI_COMM_EIS_WMI_Data5 );
    _mCOMM_EIS_WMI_AR.byte( 5 ) = getValue( HMI_COMM_EIS_WMI_Data6 );
    _mCOMM_EIS_WMI_AR.byte( 6 ) = getValue( HMI_COMM_EIS_WMI_Data7 );
    _mCOMM_EIS_WMI_AR.byte( 7 ) = getValue( HMI_COMM_EIS_WMI_Data8 );
}

COMM_EIS_WMI_AR_output(void)
{
    output( _mCOMM_EIS_WMI_AR );
}

COMM_EIS_WMI_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: COMM_EIS_WMI_AR\n", 32, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_COMM_EIS_WMI_AR := %X\n", getValue( HMI__STMSG_COMM_EIS_WMI_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_COMM_EIS_WMI_AR := %X\n", getValue( HMI__STMSGT_COMM_EIS_WMI_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_COMM_EIS_WMI_Data1 := %X\n", getValue( HMI_COMM_EIS_WMI_Data1 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_COMM_EIS_WMI_Data2 := %X\n", getValue( HMI_COMM_EIS_WMI_Data2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_COMM_EIS_WMI_Data3 := %X\n", getValue( HMI_COMM_EIS_WMI_Data3 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_COMM_EIS_WMI_Data4 := %X\n", getValue( HMI_COMM_EIS_WMI_Data4 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_COMM_EIS_WMI_Data5 := %X\n", getValue( HMI_COMM_EIS_WMI_Data5 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_COMM_EIS_WMI_Data6 := %X\n", getValue( HMI_COMM_EIS_WMI_Data6 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_COMM_EIS_WMI_Data7 := %X\n", getValue( HMI_COMM_EIS_WMI_Data7 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_COMM_EIS_WMI_Data8 := %X\n", getValue( HMI_COMM_EIS_WMI_Data8 ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tCOMM_EIS_WMI_AR
{
    putValue( HMI__STMSG_COMM_EIS_WMI_AR, 0 );
}

on EnvVar HMI__STMSG_COMM_EIS_WMI_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_COMM_EIS_WMI_AR );
        if( tDelay > 0)    
            setTimer( _tCOMM_EIS_WMI_AR, tDelay );
        else
            putValue( HMI__STMSG_COMM_EIS_WMI_AR, 0 );
    }
}

on EnvVar HMI_COMM_EIS_WMI_AR_Send
{
    if( getValue( this ) )
    {
        COMM_EIS_WMI_AR_getValue();
    }
}

COMM_EIS_TGW_ARR_check_output()
{
    if( !getValue( HMI__STMSG_COMM_EIS_TGW_AR ) )
    {
    //  message   COMM_EIS_TGW_AR ID: 186 --- Sendeart 1 spontanX --- 
        if( _COMM_EIS_TGW_AR_SpontanFlag )
        {
            COMM_EIS_TGW_AR_output(); // Nachricht wg. request ausgeben
            _COMM_EIS_TGW_AR_SpontanFlag = 0;
        }
    }
}

COMM_EIS_TGW_AR_getValue()
{
    _mCOMM_EIS_TGW_AR.byte( 0 ) = getValue( HMI_COMM_EIS_TGW_Data1 );
    _mCOMM_EIS_TGW_AR.byte( 1 ) = getValue( HMI_COMM_EIS_TGW_Data2 );
    _mCOMM_EIS_TGW_AR.byte( 2 ) = getValue( HMI_COMM_EIS_TGW_Data3 );
    _mCOMM_EIS_TGW_AR.byte( 3 ) = getValue( HMI_COMM_EIS_TGW_Data4 );
    _mCOMM_EIS_TGW_AR.byte( 4 ) = getValue( HMI_COMM_EIS_TGW_Data5 );
    _mCOMM_EIS_TGW_AR.byte( 5 ) = getValue( HMI_COMM_EIS_TGW_Data6 );
    _mCOMM_EIS_TGW_AR.byte( 6 ) = getValue( HMI_COMM_EIS_TGW_Data7 );
    _mCOMM_EIS_TGW_AR.byte( 7 ) = getValue( HMI_COMM_EIS_TGW_Data8 );
}

COMM_EIS_TGW_AR_init()
{   /* Botschaft COMM_EIS_TGW_AR ID: 186 --- Sendeart 1 spontanX --- 
BA_ "ApplMessage" BO_ 186 0;
BA_ "NmAsrMessage" BO_ 186 0;
BA_ "GenMsgMinAcceptLength" BO_ 186 8;
BA_ "GenMsgILSupport" BO_ 186 1;
BA_ "DiagState" BO_ 186 0;
BA_ "DiagRequest" BO_ 186 0;
BA_ "DiagResponse" BO_ 186 0;
BA_ "GenMsgStartValue" BO_ 186 "0";
BA_ "GenMsgDelayTime" BO_ 186 10;
BA_ "GenMsgNrOfRepetition" BO_ 186 0;
BA_ "GenMsgSendType" BO_ 186 1;
    */
    _COMM_EIS_TGW_AR_Timebase =        c_tDBKomTimer_20ms;
    _COMM_EIS_TGW_AR_SpontanFlag = 0;

    _mCOMM_EIS_TGW_AR.byte( 0 ) = getValue( HMI_COMM_EIS_TGW_Data1 );
    _mCOMM_EIS_TGW_AR.byte( 1 ) = getValue( HMI_COMM_EIS_TGW_Data2 );
    _mCOMM_EIS_TGW_AR.byte( 2 ) = getValue( HMI_COMM_EIS_TGW_Data3 );
    _mCOMM_EIS_TGW_AR.byte( 3 ) = getValue( HMI_COMM_EIS_TGW_Data4 );
    _mCOMM_EIS_TGW_AR.byte( 4 ) = getValue( HMI_COMM_EIS_TGW_Data5 );
    _mCOMM_EIS_TGW_AR.byte( 5 ) = getValue( HMI_COMM_EIS_TGW_Data6 );
    _mCOMM_EIS_TGW_AR.byte( 6 ) = getValue( HMI_COMM_EIS_TGW_Data7 );
    _mCOMM_EIS_TGW_AR.byte( 7 ) = getValue( HMI_COMM_EIS_TGW_Data8 );
}

COMM_EIS_TGW_AR_output(void)
{
    output( _mCOMM_EIS_TGW_AR );
}

COMM_EIS_TGW_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: COMM_EIS_TGW_AR\n", 32, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_COMM_EIS_TGW_AR := %X\n", getValue( HMI__STMSG_COMM_EIS_TGW_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_COMM_EIS_TGW_AR := %X\n", getValue( HMI__STMSGT_COMM_EIS_TGW_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_COMM_EIS_TGW_Data1 := %X\n", getValue( HMI_COMM_EIS_TGW_Data1 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_COMM_EIS_TGW_Data2 := %X\n", getValue( HMI_COMM_EIS_TGW_Data2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_COMM_EIS_TGW_Data3 := %X\n", getValue( HMI_COMM_EIS_TGW_Data3 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_COMM_EIS_TGW_Data4 := %X\n", getValue( HMI_COMM_EIS_TGW_Data4 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_COMM_EIS_TGW_Data5 := %X\n", getValue( HMI_COMM_EIS_TGW_Data5 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_COMM_EIS_TGW_Data6 := %X\n", getValue( HMI_COMM_EIS_TGW_Data6 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_COMM_EIS_TGW_Data7 := %X\n", getValue( HMI_COMM_EIS_TGW_Data7 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_COMM_EIS_TGW_Data8 := %X\n", getValue( HMI_COMM_EIS_TGW_Data8 ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tCOMM_EIS_TGW_AR
{
    putValue( HMI__STMSG_COMM_EIS_TGW_AR, 0 );
}

on EnvVar HMI__STMSG_COMM_EIS_TGW_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_COMM_EIS_TGW_AR );
        if( tDelay > 0)    
            setTimer( _tCOMM_EIS_TGW_AR, tDelay );
        else
            putValue( HMI__STMSG_COMM_EIS_TGW_AR, 0 );
    }
}

on EnvVar HMI_COMM_EIS_TGW_AR_Send
{
    if( getValue( this ) )
    {
        COMM_EIS_TGW_AR_getValue();
    }
}

CRCM_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_CRCM_Disp_Rq_AR ) )
    {
    //  message   CRCM_Disp_Rq_AR ID: 1147 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _CRCM_Disp_Rq_AR_Cnt--;
        if( _CRCM_Disp_Rq_AR_Cnt < 1 )
        {
            CRCM_Disp_Rq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _CRCM_Disp_Rq_AR_Cnt = _CRCM_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _CRCM_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _CRCM_Disp_Rq_AR_SpontanFlag)
        {
            CRCM_Disp_Rq_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _CRCM_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

CRCM_Disp_Rq_AR_init()
{   /* Botschaft CRCM_Disp_Rq_AR ID: 1147 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1147 0;
BA_ "NmAsrMessage" BO_ 1147 0;
BA_ "GenMsgMinAcceptLength" BO_ 1147 3;
BA_ "GenMsgILSupport" BO_ 1147 1;
BA_ "DiagState" BO_ 1147 0;
BA_ "DiagRequest" BO_ 1147 0;
BA_ "DiagResponse" BO_ 1147 0;
BA_ "GenMsgStartValue" BO_ 1147 "0";
BA_ "GenMsgDelayTime" BO_ 1147 5;
BA_ "GenMsgNrOfRepetitions" BO_ 1147 0;
BA_ "GenMsgCycleTime" BO_ 1147 1000;
BA_ "GenMsgSendType" BO_ 1147 5;
    */
    _CRCM_Disp_Rq_AR_Timebase =           c_tDBKomTimer_20ms;
    _CRCM_Disp_Rq_AR_CycleCount =       1000 / _CRCM_Disp_Rq_AR_Timebase;
    _CRCM_Disp_Rq_AR_StartDelay =          0 / _CRCM_Disp_Rq_AR_Timebase;
    _CRCM_Disp_Rq_AR_Cnt = _CRCM_Disp_Rq_AR_StartDelay;
    _CRCM_Disp_Rq_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CRCM_Disp_Rq_AR, _CRCM_Disp_Rq_AR_StartDelay * _CRCM_Disp_Rq_AR_Timebase );

    _mCRCM_Disp_Rq_AR.CRCM_Msg0.phys = getValue( HMI_CRCM_Msg0 );
    _mCRCM_Disp_Rq_AR.CRCM_Msg1.phys = getValue( HMI_CRCM_Msg1 );
    _mCRCM_Disp_Rq_AR.CRCM_Msg2.phys = getValue( HMI_CRCM_Msg2 );
    _mCRCM_Disp_Rq_AR.CRCM_Msg3_V2.phys = getValue( HMI_CRCM_Msg3_V2 );
    _mCRCM_Disp_Rq_AR.CRCM_Msg4.phys = getValue( HMI_CRCM_Msg4 );
    _mCRCM_Disp_Rq_AR.CRCM_Msg5.phys = getValue( HMI_CRCM_Msg5 );
    _mCRCM_Disp_Rq_AR.CRCM_Msg6_V2.phys = getValue( HMI_CRCM_Msg6_V2 );
    _mCRCM_Disp_Rq_AR.CRCM_Msg7.phys = getValue( HMI_CRCM_Msg7 );
    _mCRCM_Disp_Rq_AR.CRCM_Msg8.phys = getValue( HMI_CRCM_Msg8 );
    _mCRCM_Disp_Rq_AR.CRCM_Msg9.phys = getValue( HMI_CRCM_Msg9 );
    _mCRCM_Disp_Rq_AR.CRCM_Msg10.phys = getValue( HMI_CRCM_Msg10 );
    _mCRCM_Disp_Rq_AR.CRCM_Msg11.phys = getValue( HMI_CRCM_Msg11 );
    _mCRCM_Disp_Rq_AR.CRCM_Msg12.phys = getValue( HMI_CRCM_Msg12 );
    _mCRCM_Disp_Rq_AR.CT_Stat_Img_Disp_Rq.phys = getValue( HMI_CT_Stat_Img_Disp_Rq );
}

CRCM_Disp_Rq_AR_output(void)
{
    output( _mCRCM_Disp_Rq_AR );
}

CRCM_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CRCM_Disp_Rq_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CRCM_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_CRCM_Disp_Rq_AR ) );            filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CRCM_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_CRCM_Disp_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRCM_Msg0 := %X\n", getValue( HMI_CRCM_Msg0 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRCM_Msg1 := %X\n", getValue( HMI_CRCM_Msg1 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRCM_Msg2 := %X\n", getValue( HMI_CRCM_Msg2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRCM_Msg3_V2 := %X\n", getValue( HMI_CRCM_Msg3_V2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRCM_Msg4 := %X\n", getValue( HMI_CRCM_Msg4 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRCM_Msg5 := %X\n", getValue( HMI_CRCM_Msg5 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRCM_Msg6_V2 := %X\n", getValue( HMI_CRCM_Msg6_V2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRCM_Msg7 := %X\n", getValue( HMI_CRCM_Msg7 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRCM_Msg8 := %X\n", getValue( HMI_CRCM_Msg8 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRCM_Msg9 := %X\n", getValue( HMI_CRCM_Msg9 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRCM_Msg10 := %X\n", getValue( HMI_CRCM_Msg10 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRCM_Msg11 := %X\n", getValue( HMI_CRCM_Msg11 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRCM_Msg12 := %X\n", getValue( HMI_CRCM_Msg12 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CT_Stat_Img_Disp_Rq := %X\n", getValue( HMI_CT_Stat_Img_Disp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tCRCM_Disp_Rq_AR
{
    putValue( HMI__STMSG_CRCM_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_CRCM_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CRCM_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tCRCM_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_CRCM_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CRCM_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("CRCM_Disp_Rq_AR");
}

on envVar HMI_CRCM_Msg0
{
    _mCRCM_Disp_Rq_AR.CRCM_Msg0.phys = getValue(this);
    _CRCM_Disp_Rq_AR_SpontanFlag = 1;
}

on envVar HMI_CRCM_Msg1
{
    _mCRCM_Disp_Rq_AR.CRCM_Msg1.phys = getValue(this);
    _CRCM_Disp_Rq_AR_SpontanFlag = 1;
}

on envVar HMI_CRCM_Msg2
{
    _mCRCM_Disp_Rq_AR.CRCM_Msg2.phys = getValue(this);
    _CRCM_Disp_Rq_AR_SpontanFlag = 1;
}

on envVar HMI_CRCM_Msg3_V2
{
    _mCRCM_Disp_Rq_AR.CRCM_Msg3_V2.phys = getValue(this);
    _CRCM_Disp_Rq_AR_SpontanFlag = 1;
}

on envVar HMI_CRCM_Msg4
{
    _mCRCM_Disp_Rq_AR.CRCM_Msg4.phys = getValue(this);
    _CRCM_Disp_Rq_AR_SpontanFlag = 1;
}

on envVar HMI_CRCM_Msg5
{
    _mCRCM_Disp_Rq_AR.CRCM_Msg5.phys = getValue(this);
    _CRCM_Disp_Rq_AR_SpontanFlag = 1;
}

on envVar HMI_CRCM_Msg6_V2
{
    _mCRCM_Disp_Rq_AR.CRCM_Msg6_V2.phys = getValue(this);
    _CRCM_Disp_Rq_AR_SpontanFlag = 1;
}

on envVar HMI_CRCM_Msg7
{
    _mCRCM_Disp_Rq_AR.CRCM_Msg7.phys = getValue(this);
    _CRCM_Disp_Rq_AR_SpontanFlag = 1;
}

on envVar HMI_CRCM_Msg8
{
    _mCRCM_Disp_Rq_AR.CRCM_Msg8.phys = getValue(this);
    _CRCM_Disp_Rq_AR_SpontanFlag = 1;
}

on envVar HMI_CRCM_Msg9
{
    _mCRCM_Disp_Rq_AR.CRCM_Msg9.phys = getValue(this);
    _CRCM_Disp_Rq_AR_SpontanFlag = 1;
}

on envVar HMI_CRCM_Msg10
{
    _mCRCM_Disp_Rq_AR.CRCM_Msg10.phys = getValue(this);
    _CRCM_Disp_Rq_AR_SpontanFlag = 1;
}

on envVar HMI_CT_Stat_Img_Disp_Rq
{
    _mCRCM_Disp_Rq_AR.CT_Stat_Img_Disp_Rq.phys = getValue(this);
    _CRCM_Disp_Rq_AR_SpontanFlag = 1;
}

on envVar HMI_CRCM_Msg11
{
    _mCRCM_Disp_Rq_AR.CRCM_Msg11.phys = getValue(this);
    _CRCM_Disp_Rq_AR_SpontanFlag = 1;
}

on envVar HMI_CRCM_Msg12
{
    _mCRCM_Disp_Rq_AR.CRCM_Msg12.phys = getValue(this);
    _CRCM_Disp_Rq_AR_SpontanFlag = 1;
}

CU_GNSS_Data1_AR_check_output()
{
    if( !getValue( HMI__STMSG_CU_GNSS_Data1_AR ) )
    {
    //  message   CU_GNSS_Data1_AR ID: 704 --- Sendeart 0 cyclicX --- 
        _CU_GNSS_Data1_AR_Cnt--;
        if( _CU_GNSS_Data1_AR_Cnt < 1 )
        {
            CU_GNSS_Data1_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _CU_GNSS_Data1_AR_Cnt = _CU_GNSS_Data1_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

CU_GNSS_Data1_AR_init()
{   /* Botschaft CU_GNSS_Data1_AR ID: 704 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 704 0;
BA_ "NmAsrMessage" BO_ 704 0;
BA_ "GenMsgMinAcceptLength" BO_ 704 8;
BA_ "GenMsgILSupport" BO_ 704 1;
BA_ "DiagState" BO_ 704 0;
BA_ "DiagRequest" BO_ 704 0;
BA_ "DiagResponse" BO_ 704 0;
BA_ "GenMsgStartValue" BO_ 704 "0";
BA_ "GenMsgCycleTime" BO_ 704 500;
BA_ "GenMsgSendType" BO_ 704 0;
    */
    _CU_GNSS_Data1_AR_Timebase =           c_tDBKomTimer_20ms;
    _CU_GNSS_Data1_AR_CycleCount =        500 / _CU_GNSS_Data1_AR_Timebase;
    _CU_GNSS_Data1_AR_StartDelay =          0 / _CU_GNSS_Data1_AR_Timebase;
    _CU_GNSS_Data1_AR_Cnt = _CU_GNSS_Data1_AR_StartDelay;
    _CU_GNSS_Data1_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CU_GNSS_Data1_AR, _CU_GNSS_Data1_AR_StartDelay * _CU_GNSS_Data1_AR_Timebase );

    _mCU_GNSS_Data1_AR.CU_Accur_GNSS.phys = getValue( HMI_CU_Accur_GNSS );
    _mCU_GNSS_Data1_AR.CU_Pos_Cnt4.phys = getValue( HMI_CU_Pos_Cnt4 );
    _mCU_GNSS_Data1_AR.CU_TrckSat_GNSS.phys = getValue( HMI_CU_TrckSat_GNSS );
    _mCU_GNSS_Data1_AR.CU_VelOvrGrnd_GNSS.phys = getValue( HMI_CU_VelOvrGrnd_GNSS );
    _mCU_GNSS_Data1_AR.CU_VsblSat_GNSS.phys = getValue( HMI_CU_VsblSat_GNSS );
}

CU_GNSS_Data1_AR_output(void)
{
    output( _mCU_GNSS_Data1_AR );
}

CU_GNSS_Data1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CU_GNSS_Data1_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CU_GNSS_Data1_AR := %X\n", getValue( HMI__STMSG_CU_GNSS_Data1_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CU_GNSS_Data1_AR := %X\n", getValue( HMI__STMSGT_CU_GNSS_Data1_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Accur_GNSS := %X\n", getValue( HMI_CU_Accur_GNSS ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Pos_Cnt4 := %X\n", getValue( HMI_CU_Pos_Cnt4 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_TrckSat_GNSS := %X\n", getValue( HMI_CU_TrckSat_GNSS ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_VelOvrGrnd_GNSS := %X\n", getValue( HMI_CU_VelOvrGrnd_GNSS ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_VsblSat_GNSS := %X\n", getValue( HMI_CU_VsblSat_GNSS ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tCU_GNSS_Data1_AR
{
    putValue( HMI__STMSG_CU_GNSS_Data1_AR, 0 );
}

on EnvVar HMI__STMSG_CU_GNSS_Data1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CU_GNSS_Data1_AR );
        if( tDelay > 0)    
            setTimer( _tCU_GNSS_Data1_AR, tDelay );
        else
            putValue( HMI__STMSG_CU_GNSS_Data1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CU_GNSS_Data1_AR
{
    if( getValue( this ) )
        openPanel("CU_GNSS_Data1_AR");
}

on EnvVar HMI_CU_Accur_GNSS
{
    _mCU_GNSS_Data1_AR.CU_Accur_GNSS.phys = getValue(this);
}

on EnvVar HMI_CU_Pos_Cnt4
{
    _mCU_GNSS_Data1_AR.CU_Pos_Cnt4.phys = getValue(this);
}

on EnvVar HMI_CU_TrckSat_GNSS
{
    _mCU_GNSS_Data1_AR.CU_TrckSat_GNSS.phys = getValue(this);
}

on EnvVar HMI_CU_VelOvrGrnd_GNSS
{
    _mCU_GNSS_Data1_AR.CU_VelOvrGrnd_GNSS.phys = getValue(this);
}

on EnvVar HMI_CU_VsblSat_GNSS
{
    _mCU_GNSS_Data1_AR.CU_VsblSat_GNSS.phys = getValue(this);
}

CU_Pos1_AR_check_output()
{
    if( !getValue( HMI__STMSG_CU_Pos1_AR ) )
        {
        //  message   CU_Pos1_AR ID: 880 --- Sendeart 0 cyclicX --- 
            _CU_Pos1_AR_Cnt--;
            if( _CU_Pos1_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                CU_Pos1_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _CU_Pos1_AR_Cnt = _CU_Pos1_AR_CycleCount;
            }
        }
}

CU_Pos1_AR_init()
{   /* Botschaft CU_Pos1_AR ID: 880 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 880 0;
BA_ "NmAsrMessage" BO_ 880 0;
BA_ "GenMsgMinAcceptLength" BO_ 880 8;
BA_ "GenMsgILSupport" BO_ 880 1;
BA_ "DiagState" BO_ 880 0;
BA_ "DiagRequest" BO_ 880 0;
BA_ "DiagResponse" BO_ 880 0;
BA_ "GenMsgStartValue" BO_ 880 "0";
BA_ "GenMsgStartDelayTime" BO_ 880 0;
BA_ "GenMsgCycleTime" BO_ 880 500;
BA_ "GenMsgSendType" BO_ 880 0;
    */
    _CU_Pos1_AR_Timebase =      c_tDBKomTimer_20ms;
    _CU_Pos1_AR_CycleCount =   500 / _CU_Pos1_AR_Timebase;
    _CU_Pos1_AR_StartDelay =      0 / _CU_Pos1_AR_Timebase;
    _CU_Pos1_AR_Cnt = _CU_Pos1_AR_StartDelay;
    _CU_Pos1_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CU_Pos1_AR, _CU_Pos1_AR_StartDelay * _CU_Pos1_AR_Timebase );

    _mCU_Pos1_AR.CU_Pos_Cnt1.phys = getValue( HMI_CU_Pos_Cnt1 );
    _mCU_Pos1_AR.CU_Pos_Lat_Deg.phys = getValue( HMI_CU_Pos_Lat_Deg );
    _mCU_Pos1_AR.CU_Pos_Lat_Min.phys = getValue( HMI_CU_Pos_Lat_Min );
    _mCU_Pos1_AR.CU_Pos_Lat_mSec.phys = getValue( HMI_CU_Pos_Lat_mSec );
	  _mCU_Pos1_AR.CU_Pos_Lat_N_S.phys = getValue( HMI_CU_Pos_Lat_N_S );
    _mCU_Pos1_AR.CU_Pos_Lat_Sec.phys = getValue( HMI_CU_Pos_Lat_Sec );
    _mCU_Pos1_AR.CU_Pos_Long_Deg.phys = getValue( HMI_CU_Pos_Long_Deg );
	  _mCU_Pos1_AR.CU_Pos_Long_Min.phys = getValue( HMI_CU_Pos_Long_Min );
    _mCU_Pos1_AR.CU_Pos_Long_mSec.phys = getValue( HMI_CU_Pos_Long_mSec );
    _mCU_Pos1_AR.CU_Pos_Long_Sec.phys = getValue( HMI_CU_Pos_Long_Sec );
	  _mCU_Pos1_AR.CU_Pos_Long_W_E.phys = getValue( HMI_CU_Pos_Long_W_E );
}

CU_Pos1_AR_output(void)
{
    output( _mCU_Pos1_AR );
}

CU_Pos1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CU_Pos1_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CU_Pos1_AR := %X\n", getValue( HMI__STMSG_CU_Pos1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CU_Pos1_AR := %X\n", getValue( HMI__STMSGT_CU_Pos1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Pos_Cnt1  := %X\n", getValue( HMI_CU_Pos_Cnt1 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Pos_Lat_Deg  := %X\n", getValue( HMI_CU_Pos_Lat_Deg ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Pos_Lat_Min  := %X\n", getValue( HMI_CU_Pos_Lat_Min ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Pos_Lat_mSec  := %X\n", getValue( HMI_CU_Pos_Lat_mSec ) );        filePutString ( buffer, elcount( buffer ), hFile );
	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Pos_Lat_N_S  := %X\n", getValue( HMI_CU_Pos_Lat_N_S ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Pos_Lat_Sec  := %X\n", getValue( HMI_CU_Pos_Lat_Sec ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Pos_Long_Deg  := %X\n", getValue( HMI_CU_Pos_Long_Deg ) );        filePutString ( buffer, elcount( buffer ), hFile );
	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Pos_Long_Min  := %X\n", getValue( HMI_CU_Pos_Long_Min ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Pos_Long_mSec  := %X\n", getValue( HMI_CU_Pos_Long_mSec ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Pos_Long_Sec  := %X\n", getValue( HMI_CU_Pos_Long_Sec ) );        filePutString ( buffer, elcount( buffer ), hFile );
	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Pos_Long_W_E  := %X\n", getValue( HMI_CU_Pos_Long_W_E ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tCU_Pos1_AR
{
    putValue( HMI__STMSG_CU_Pos1_AR, 0 );
}

on EnvVar HMI__STMSG_CU_Pos1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CU_Pos1_AR );
        if( tDelay > 0)    
            setTimer( _tCU_Pos1_AR, tDelay );
        else
            putValue( HMI__STMSG_CU_Pos1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CU_Pos1_AR
{
    if( getValue( this ) )
        openPanel("CU_Pos1_AR");
}

on EnvVar HMI_CU_Pos_Cnt1
{
    _mCU_Pos1_AR.CU_Pos_Cnt1.phys = getValue(this);
}

on EnvVar HMI_CU_Pos_Lat_Deg
{
    _mCU_Pos1_AR.CU_Pos_Lat_Deg.phys = getValue(this);
}

on EnvVar HMI_CU_Pos_Lat_Min
{
    _mCU_Pos1_AR.CU_Pos_Lat_Min.phys = getValue(this);
}

on EnvVar HMI_CU_Pos_Lat_mSec
{
    _mCU_Pos1_AR.CU_Pos_Lat_mSec.phys = getValue(this);
}

on EnvVar HMI_CU_Pos_Lat_N_S
{
    _mCU_Pos1_AR.CU_Pos_Lat_N_S.phys = getValue(this);
}

on EnvVar HMI_CU_Pos_Lat_Sec
{
    _mCU_Pos1_AR.CU_Pos_Lat_Sec.phys = getValue(this);
}

on EnvVar HMI_CU_Pos_Long_Deg
{
    _mCU_Pos1_AR.CU_Pos_Long_Deg.phys = getValue(this);
}

on EnvVar HMI_CU_Pos_Long_Min
{
    _mCU_Pos1_AR.CU_Pos_Long_Min.phys = getValue(this);
}

on EnvVar HMI_CU_Pos_Long_mSec
{
    _mCU_Pos1_AR.CU_Pos_Long_mSec.phys = getValue(this);
}

on EnvVar HMI_CU_Pos_Long_Sec
{
    _mCU_Pos1_AR.CU_Pos_Long_Sec.phys = getValue(this);
}

on EnvVar HMI_CU_Pos_Long_W_E
{
    _mCU_Pos1_AR.CU_Pos_Long_W_E.phys = getValue(this);
}

CU_Pos2_AR_check_output()
{
    if( !getValue( HMI__STMSG_CU_Pos2_AR ) )
        {
        //  message   CU_Pos2_AR ID: 960 --- Sendeart 0 cyclicX --- 
            _CU_Pos2_AR_Cnt--;
            if( _CU_Pos2_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                CU_Pos2_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _CU_Pos2_AR_Cnt = _CU_Pos2_AR_CycleCount;
            }
        }
}

CU_Pos2_AR_init()
{   /* Botschaft CU_Pos2_AR ID: 960 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 960 0;
BA_ "NmAsrMessage" BO_ 960 0;
BA_ "GenMsgMinAcceptLength" BO_ 960 8;
BA_ "GenMsgILSupport" BO_ 960 1;
BA_ "DiagState" BO_ 960 0;
BA_ "DiagRequest" BO_ 960 0;
BA_ "DiagResponse" BO_ 960 0;
BA_ "GenMsgStartValue" BO_ 960 "0";
BA_ "GenMsgStartDelayTime" BO_ 960 0;
BA_ "GenMsgCycleTime" BO_ 960 500;
BA_ "GenMsgSendType" BO_ 960 0;
    */
    _CU_Pos2_AR_Timebase =      c_tDBKomTimer_20ms;
    _CU_Pos2_AR_CycleCount =   500 / _CU_Pos2_AR_Timebase;
    _CU_Pos2_AR_StartDelay =      0 / _CU_Pos2_AR_Timebase;
    _CU_Pos2_AR_Cnt = _CU_Pos2_AR_StartDelay;
    _CU_Pos2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CU_Pos2_AR, _CU_Pos2_AR_StartDelay * _CU_Pos2_AR_Timebase );

    _mCU_Pos2_AR.CU_Pos_Alt.phys = getValue( HMI_CU_Pos_Alt );
    _mCU_Pos2_AR.CU_Pos_Cnt2.phys = getValue( HMI_CU_Pos_Cnt2 );
    _mCU_Pos2_AR.CU_Pos_Fix.phys = getValue( HMI_CU_Pos_Fix );
    _mCU_Pos2_AR.CU_Pos_Head.phys = getValue( HMI_CU_Pos_Head );

}

CU_Pos2_AR_output(void)
{
    output( _mCU_Pos2_AR );
}

CU_Pos2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CU_Pos2_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CU_Pos2_AR := %X\n", getValue( HMI__STMSG_CU_Pos2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CU_Pos2_AR := %X\n", getValue( HMI__STMSGT_CU_Pos2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Pos_Alt  := %X\n", getValue( HMI_CU_Pos_Alt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Pos_Cnt2  := %X\n", getValue( HMI_CU_Pos_Cnt2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Pos_Fix  := %X\n", getValue( HMI_CU_Pos_Fix ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Pos_Head  := %X\n", getValue( HMI_CU_Pos_Head ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tCU_Pos2_AR
{
    putValue( HMI__STMSG_CU_Pos2_AR, 0 );
}

on EnvVar HMI__STMSG_CU_Pos2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CU_Pos2_AR );
        if( tDelay > 0)    
            setTimer( _tCU_Pos2_AR, tDelay );
        else
            putValue( HMI__STMSG_CU_Pos2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CU_Pos2_AR
{
    if( getValue( this ) )
        openPanel("CU_Pos2_AR");
}

on EnvVar HMI_CU_Pos_Alt
{
    _mCU_Pos2_AR.CU_Pos_Alt.phys = getValue(this);
}

on EnvVar HMI_CU_Pos_Cnt2
{
    _mCU_Pos2_AR.CU_Pos_Cnt2.phys = getValue(this);
}

on EnvVar HMI_CU_Pos_Fix
{
    _mCU_Pos2_AR.CU_Pos_Fix.phys = getValue(this);
}

on EnvVar HMI_CU_Pos_Head
{
    _mCU_Pos2_AR.CU_Pos_Head.phys = getValue(this);
}

CU_RemFunc_Rq3_AR_check_output()
{
    if( !getValue( HMI__STMSG_CU_RemFunc_Rq3_AR ) )
    {
    //  message   CU_RemFunc_Rq3_AR ID: 956 --- Sendeart 5 cyclicAndSpontanWithDelay
        if( _CU_RemFunc_Rq3_AR_DelayCnt > 0) _CU_RemFunc_Rq3_AR_DelayCnt--; // Mindestsendeabstand
        _CU_RemFunc_Rq3_AR_Cnt--;
        if( _CU_RemFunc_Rq3_AR_Cnt < 1 )
        {
            if( _CU_RemFunc_Rq3_AR_DelayCnt < 1 )
            {
                CU_RemFunc_Rq3_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                _CU_RemFunc_Rq3_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _CU_RemFunc_Rq3_AR_DelayCnt = _CU_RemFunc_Rq3_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _CU_RemFunc_Rq3_AR_SpontanFlag = 1;
            }
            _CU_RemFunc_Rq3_AR_Cnt = _CU_RemFunc_Rq3_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _CU_RemFunc_Rq3_AR_SpontanFlag)
        {
            if( _CU_RemFunc_Rq3_AR_DelayCnt < 1 )
            {
                CU_RemFunc_Rq3_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _CU_RemFunc_Rq3_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _CU_RemFunc_Rq3_AR_DelayCnt = _CU_RemFunc_Rq3_AR_MinDelay;
            }
        }
    }
}

CU_RemFunc_Rq3_AR_init()
{   /* Botschaft CU_RemFunc_Rq3_AR ID: 956 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 956 0;
BA_ "NmAsrMessage" BO_ 956 0;
BA_ "GenMsgMinAcceptLength" BO_ 956 8;
BA_ "GenMsgILSupport" BO_ 956 1;
BA_ "DiagState" BO_ 956 0;
BA_ "DiagRequest" BO_ 956 0;
BA_ "DiagResponse" BO_ 956 0;
BA_ "GenMsgStartValue" BO_ 956 "0";
BA_ "GenMsgDelayTime" BO_ 956 100;
BA_ "GenMsgNrOfRepetition" BO_ 956 0;
BA_ "GenMsgCycleTime" BO_ 956 500;
BA_ "GenMsgSendType" BO_ 956 5;
    */
    _CU_RemFunc_Rq3_AR_Timebase =         c_tDBKomTimer_20ms;
    _CU_RemFunc_Rq3_AR_CycleCount =     500 / _CU_RemFunc_Rq3_AR_Timebase;
    _CU_RemFunc_Rq3_AR_StartDelay =       0 / _CU_RemFunc_Rq3_AR_Timebase;
    _CU_RemFunc_Rq3_AR_MinDelay =       100 / _CU_RemFunc_Rq3_AR_Timebase;
    _CU_RemFunc_Rq3_AR_Cnt = _CU_RemFunc_Rq3_AR_StartDelay;
    _CU_RemFunc_Rq3_AR_SpontanFlag = 0;
    _CU_RemFunc_Rq3_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_CU_RemFunc_Rq3_AR, _CU_RemFunc_Rq3_AR_StartDelay * _CU_RemFunc_Rq3_AR_Timebase );

	_mCU_RemFunc_Rq3_AR.Pers_MBConnectUserId_high_Rq.phys = getValue( HMI_Pers_MBConnectUserId_high_Rq );
	_mCU_RemFunc_Rq3_AR.Pers_MBConnectUserId_low_Rq.phys = getValue( HMI_Pers_MBConnectUserId_low_Rq );
    _mCU_RemFunc_Rq3_AR.Pers_RemUserDataCmd_Rq.phys = getValue( HMI_Pers_RemUserDataCmd_Rq );
    _mCU_RemFunc_Rq3_AR.Rental_Actv_CU.phys = getValue( HMI_Rental_Actv_CU );
    _mCU_RemFunc_Rq3_AR.TC_Rst_Reset_CU.phys = getValue( HMI_TC_Rst_Reset_CU );
    _mCU_RemFunc_Rq3_AR.TC_Rst_Start_CU.phys = getValue( HMI_TC_Rst_Start_CU );
}

CU_RemFunc_Rq3_AR_output(void)
{
    output( _mCU_RemFunc_Rq3_AR );
}

CU_RemFunc_Rq3_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CU_RemFunc_Rq3_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CU_RemFunc_Rq3_AR := %X\n", getValue( HMI__STMSG_CU_RemFunc_Rq3_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CU_RemFunc_Rq3_AR := %X\n", getValue( HMI__STMSGT_CU_RemFunc_Rq3_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Pers_MBConnectUserId_high_Rq := %X\n", getValue( HMI_Pers_MBConnectUserId_high_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Pers_MBConnectUserId_low_Rq := %X\n", getValue( HMI_Pers_MBConnectUserId_low_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Pers_RemUserDataCmd_Rq := %X\n", getValue( HMI_Pers_RemUserDataCmd_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rental_Actv_CU := %X\n", getValue( HMI_Rental_Actv_CU ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_Rst_Reset_CU := %X\n", getValue( HMI_TC_Rst_Reset_CU ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_Rst_Start_CU := %X\n", getValue( HMI_TC_Rst_Start_CU ) );    filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tCU_RemFunc_Rq3_AR
{
    putValue( HMI__STMSG_CU_RemFunc_Rq3_AR, 0 );
}

on EnvVar HMI__STMSG_CU_RemFunc_Rq3_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CU_RemFunc_Rq3_AR );
        if( tDelay > 0)    
            setTimer( _tCU_RemFunc_Rq3_AR, tDelay );
        else
            putValue( HMI__STMSG_CU_RemFunc_Rq3_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CU_RemFunc_Rq3_AR
{
    if( getValue( this ) )
        openPanel("CU_RemFunc_Rq3_AR");
}

on EnvVar HMI_Pers_MBConnectUserId_high_Rq
{
    _mCU_RemFunc_Rq3_AR.Pers_MBConnectUserId_high_Rq.phys = getValue(this);
}

on EnvVar HMI_Pers_MBConnectUserId_low_Rq
{
    _mCU_RemFunc_Rq3_AR.Pers_MBConnectUserId_low_Rq.phys = getValue(this);
}

on EnvVar HMI_Pers_RemUserDataCmd_Rq
{
    _mCU_RemFunc_Rq3_AR.Pers_RemUserDataCmd_Rq.phys = getValue(this);
}

on EnvVar HMI_Rental_Actv_CU
{
    _mCU_RemFunc_Rq3_AR.Rental_Actv_CU.phys = getValue(this);
}

on EnvVar HMI_TC_Rst_Reset_CU
{
    _mCU_RemFunc_Rq3_AR.TC_Rst_Reset_CU.phys = getValue(this);
}

on EnvVar HMI_TC_Rst_Start_CU
{
    _mCU_RemFunc_Rq3_AR.TC_Rst_Start_CU.phys = getValue(this);
}

////

D_RQ_GLOBAL_UDS_check_output()
{
    if( !getValue( HMI__STMSG_D_RQ_GLOBAL_UDS ) )
    {
    //  message   D_RQ_GLOBAL_UDS  --- Sendeart 1 spontanX --- 
        if( _D_RQ_GLOBAL_UDS_SpontanFlag)
        {
            D_RQ_GLOBAL_UDS_output(); // Nachricht wg. spontaner �nderung ausgeben
            _D_RQ_GLOBAL_UDS_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

D_RQ_GLOBAL_UDS_init()
{   // Botschaft D_RQ_GLOBAL_UDS  --- Sendeart 1 spontanX --- 

    _D_RQ_GLOBAL_UDS_Timebase =      c_tDBKomTimer_20ms;
    _D_RQ_GLOBAL_UDS_SpontanFlag = 0;

    _mD_RQ_GLOBAL_UDS.D_RQ_GLOBAL_UDS.phys = getValue( HMI_D_RQ_GLOBAL_UDS );

}

D_RQ_GLOBAL_UDS_output(void)
{
    output( _mD_RQ_GLOBAL_UDS );
}

D_RQ_GLOBAL_UDS_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: D_RQ_GLOBAL_UDS\n", 24, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_D_RQ_GLOBAL_UDS := %X\n", getValue( HMI__STMSG_VIN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_D_RQ_GLOBAL_UDS := %X\n", getValue( HMI__STMSGT_VIN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_D_RQ_GLOBAL_UDS := %X\n", getValue( HMI_VIN_Data1 ) );        filePutString( buffer, elcount( buffer ), hFile );  
}

on timer _tD_RQ_GLOBAL_UDS
{
    putValue( HMI__STMSG_D_RQ_GLOBAL_UDS, 0 );
}

on EnvVar HMI__STMSG_D_RQ_GLOBAL_UDS
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_D_RQ_GLOBAL_UDS );
        if( tDelay > 0)    
            setTimer( _tD_RQ_GLOBAL_UDS, tDelay );
        else
            putValue( HMI__STMSG_D_RQ_GLOBAL_UDS, 0 );
    }
}

on envVar HMI__STMSG_PO_D_RQ_GLOBAL_UDS
{
    if( getValue( this ) )
        openPanel("D_RQ_GLOBAL_UDS");
}

on EnvVar HMI_D_RQ_GLOBAL_UDS
{
    _mD_RQ_GLOBAL_UDS.D_RQ_GLOBAL_UDS.phys = getValue(this);
    _D_RQ_GLOBAL_UDS_SpontanFlag = 1;
}


D_RQ_IC_check_output()
{
    if( !getValue( HMI__STMSG_D_RQ_IC ) )
    {
    //  message   D_RQ_IC  --- Sendeart 1 spontanX --- 
        if( _D_RQ_IC_SpontanFlag)
        {
            D_RQ_IC_output(); // Nachricht wg. spontaner �nderung ausgeben
            _D_RQ_IC_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

D_RQ_IC_init()
{   // Botschaft D_RQ_IC  --- Sendeart 1 spontanX --- 

    _D_RQ_IC_Timebase =      c_tDBKomTimer_20ms;
    _D_RQ_IC_SpontanFlag = 0;

    _mD_RQ_IC.D_RQ_IC.phys = getValue( HMI_D_RQ_IC );

}

D_RQ_IC_output(void)
{
    output( _mD_RQ_IC );
}

D_RQ_IC_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: D_RQ_IC\n", 24, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_D_RQ_IC := %X\n", getValue( HMI__STMSG_VIN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_D_RQ_IC := %X\n", getValue( HMI__STMSGT_VIN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_D_RQ_IC := %X\n", getValue( HMI_VIN_Data1 ) );        filePutString( buffer, elcount( buffer ), hFile );  
}

on timer _tD_RQ_IC
{
    putValue( HMI__STMSG_D_RQ_IC, 0 );
}

on EnvVar HMI__STMSG_D_RQ_IC
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_D_RQ_IC );
        if( tDelay > 0)    
            setTimer( _tD_RQ_IC, tDelay );
        else
            putValue( HMI__STMSG_D_RQ_IC, 0 );
    }
}

on envVar HMI__STMSG_PO_D_RQ_IC
{
    if( getValue( this ) )
        openPanel("D_RQ_IC");
}

on EnvVar HMI_D_RQ_IC
{
    _mD_RQ_IC.D_RQ_IC.phys = getValue(this);
    _D_RQ_IC_SpontanFlag = 1;
}

D_RQ_TCO_check_output()
{
    if( !getValue( HMI__STMSG_D_RQ_TCO ) )
    {
    //  message   D_RQ_TCO  --- Sendeart 1 spontanX --- 
        if( _D_RQ_TCO_SpontanFlag)
        {
            D_RQ_TCO_output(); // Nachricht wg. spontaner �nderung ausgeben
            _D_RQ_TCO_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

D_RQ_TCO_init()
{   // Botschaft D_RQ_TCO  --- Sendeart 1 spontanX --- 

    _D_RQ_TCO_Timebase =      c_tDBKomTimer_20ms;
    _D_RQ_TCO_SpontanFlag = 0;

    _mD_RQ_TCO.D_RQ_TCO.phys = getValue( HMI_D_RQ_TCO );

}

D_RQ_TCO_output(void)
{
    output( _mD_RQ_TCO );
}

D_RQ_TCO_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: D_RQ_TCO\n", 24, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_D_RQ_TCO := %X\n", getValue( HMI__STMSG_VIN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_D_RQ_TCO := %X\n", getValue( HMI__STMSGT_VIN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_D_RQ_TCO := %X\n", getValue( HMI_VIN_Data1 ) );        filePutString( buffer, elcount( buffer ), hFile );  
}

on timer _tD_RQ_TCO
{
    putValue( HMI__STMSG_D_RQ_TCO, 0 );
}

on EnvVar HMI__STMSG_D_RQ_TCO
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_D_RQ_TCO );
        if( tDelay > 0)    
            setTimer( _tD_RQ_TCO, tDelay );
        else
            putValue( HMI__STMSG_D_RQ_TCO, 0 );
    }
}

on envVar HMI__STMSG_PO_D_RQ_TCO
{
    if( getValue( this ) )
        openPanel("D_RQ_TCO");
}

on EnvVar HMI_D_RQ_TCO
{
    _mD_RQ_TCO.D_RQ_TCO.phys = getValue(this);
    _D_RQ_TCO_SpontanFlag = 1;
}



////
DidA_MBContact_State_AR_check_output()
{
    if( !getValue( HMI__STMSG_DidA_MBContact_State_AR ) )
    {
    //  message   DidA_MBContact_State_AR ID: 1119 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _DidA_MBContact_State_AR_Cnt--;
        if( _DidA_MBContact_State_AR_Cnt < 1 )
        {
            DidA_MBContact_State_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _DidA_MBContact_State_AR_Cnt = _DidA_MBContact_State_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _DidA_MBContact_State_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _DidA_MBContact_State_AR_SpontanFlag)
        {
            DidA_MBContact_State_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _DidA_MBContact_State_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

DidA_MBContact_State_AR_init()
{   /* Botschaft DidA_MBContact_State_AR ID: 1119 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1119 0;
BA_ "NmAsrMessage" BO_ 1119 0;
BA_ "GenMsgMinAcceptLength" BO_ 1119 8;
BA_ "GenMsgILSupport" BO_ 1119 1;
BA_ "DiagState" BO_ 1119 0;
BA_ "DiagRequest" BO_ 1119 0;
BA_ "DiagResponse" BO_ 1119 0;
BA_ "GenMsgStartValue" BO_ 1119 "0";
BA_ "GenMsgStartDelayTime" BO_ 1119 70;
BA_ "GenMsgDelayTime" BO_ 1119 5;
BA_ "GenMsgNrOfRepetitions" BO_ 1119 0;
BA_ "GenMsgCycleTime" BO_ 1119 1000;
BA_ "GenMsgSendType" BO_ 1119 5;
    */
    _DidA_MBContact_State_AR_Timebase =          c_tDBKomTimer_20ms;
    _DidA_MBContact_State_AR_CycleCount =      1000 / _DidA_MBContact_State_AR_Timebase;
    _DidA_MBContact_State_AR_StartDelay =        70 / _DidA_MBContact_State_AR_Timebase;
    _DidA_MBContact_State_AR_Cnt = _DidA_MBContact_State_AR_StartDelay;
    _DidA_MBContact_State_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_DidA_MBContact_State_AR, _DidA_MBContact_State_AR_StartDelay * _DidA_MBContact_State_AR_Timebase );

    _mDidA_MBContact_State_AR.DidA_MBContact_DataCollected.phys = getValue( HMI_DidA_MBContact_DataCollected );
    _mDidA_MBContact_State_AR.DidA_MBContact_DataSent.phys = getValue( HMI_DidA_MBContact_DataSent );
    _mDidA_MBContact_State_AR.DidA_MBContact_Stat.phys = getValue( HMI_DidA_MBContact_Stat );
}

DidA_MBContact_State_AR_output(void)
{
    output( _mDidA_MBContact_State_AR );
}

DidA_MBContact_State_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: DidA_MBContact_State_AR\n", 37, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_EDidA_MBContact_State_AR := %X\n", getValue( HMI__STMSG_DidA_MBContact_State_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_DidA_MBContact_State_AR := %X\n", getValue( HMI__STMSGT_DidA_MBContact_State_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DidA_MBContact_DataCollected := %X\n", getValue( HMI_DidA_MBContact_DataCollected ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DidA_MBContact_DataSent := %X\n", getValue( HMI_DidA_MBContact_DataSent ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DidA_MBContact_Stat := %X\n", getValue( HMI_DidA_MBContact_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tDidA_MBContact_State_AR
{
    putValue( HMI__STMSG_DidA_MBContact_State_AR, 0 );
}

on EnvVar HMI__STMSG_DidA_MBContact_State_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_DidA_MBContact_State_AR );
        if( tDelay > 0)    
            setTimer( _tDidA_MBContact_State_AR, tDelay );
        else
            putValue( HMI__STMSG_DidA_MBContact_State_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_DidA_MBContact_State_AR
{
    if( getValue( this ) )
        openPanel("DidA_MBContact_State_AR");
}

on EnvVar HMI_DidA_MBContact_DataCollected
{
    _mDidA_MBContact_State_AR.DidA_MBContact_DataCollected.phys = getValue(this);
    _DidA_MBContact_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_DidA_MBContact_DataSent
{
    _mDidA_MBContact_State_AR.DidA_MBContact_DataSent.phys = getValue(this);
    _DidA_MBContact_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_DidA_MBContact_Stat
{
    _mDidA_MBContact_State_AR.DidA_MBContact_Stat.phys = getValue(this);
    _DidA_MBContact_State_AR_SpontanFlag = 1;
}

Door_FL_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_Door_FL_Stat_AR ) )
    {
    //  message   Door_FL_Stat_AR ID: 919 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _Door_FL_Stat_AR_DelayCnt > 0) _Door_FL_Stat_AR_DelayCnt--; // Mindestsendeabstand
        _Door_FL_Stat_AR_Cnt--;
        if( _Door_FL_Stat_AR_Cnt < 1 )
        {
            if( _Door_FL_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                Door_FL_Stat_AR_output();
                _Door_FL_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Door_FL_Stat_AR_DelayCnt = _Door_FL_Stat_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _Door_FL_Stat_AR_SpontanFlag = 1;
            }
            _Door_FL_Stat_AR_Cnt = _Door_FL_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _Door_FL_Stat_AR_SpontanFlag)
        {
            if( _Door_FL_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                Door_FL_Stat_AR_output();
                _Door_FL_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Door_FL_Stat_AR_DelayCnt = _Door_FL_Stat_AR_MinDelay;
            }
        }
    }
}

Door_FL_Stat_AR_init()
{   /* Botschaft Door_FL_Stat_AR ID: 919 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 919 0;
BA_ "NmAsrMessage" BO_ 919 0;
BA_ "GenMsgMinAcceptLength" BO_ 919 8;
BA_ "GenMsgILSupport" BO_ 919 1;
BA_ "DiagState" BO_ 919 0;
BA_ "DiagRequest" BO_ 919 0;
BA_ "DiagResponse" BO_ 919 0;
BA_ "GenMsgStartValue" BO_ 919 "0";
BA_ "GenMsgStartDelayTime" BO_ 919 0;
BA_ "GenMsgDelayTime" BO_ 919 5;
BA_ "GenMsgNrOfRepetitions" BO_ 919 0;
BA_ "GenMsgCycleTime" BO_ 919 500;
BA_ "GenMsgSendType" BO_ 919 5;
    */
    _Door_FL_Stat_AR_Timebase =           c_tDBKomTimer_20ms;
    _Door_FL_Stat_AR_CycleCount =       500 / _Door_FL_Stat_AR_Timebase;
    _Door_FL_Stat_AR_StartDelay =         0 / _Door_FL_Stat_AR_Timebase;
    _Door_FL_Stat_AR_MinDelay =           5 / _Door_FL_Stat_AR_Timebase;
    _Door_FL_Stat_AR_Cnt = _Door_FL_Stat_AR_StartDelay;
    _Door_FL_Stat_AR_SpontanFlag = 0;
    _Door_FL_Stat_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_Door_FL_Stat_AR, _Door_FL_Stat_AR_StartDelay * _Door_FL_Stat_AR_Timebase );

    _mDoor_FL_Stat_AR.AddTurnLmp_Lt_Flt.phys = getValue( HMI_AddTurnLmp_Lt_Flt );
    _mDoor_FL_Stat_AR.AutoDrLk_Rq_DM_FL.phys = getValue( HMI_AutoDrLk_Rq_DM_FL );
    _mDoor_FL_Stat_AR.BSM_WarnUnit_Lt_Stat.phys = getValue( HMI_BSM_WarnUnit_Lt_Stat );
    _mDoor_FL_Stat_AR.CLkS_Sw_FL_Psd.phys = getValue( HMI_CLkS_Sw_FL_Psd );
    _mDoor_FL_Stat_AR.DL_RemActn_LHD_Stat.phys = getValue( HMI_DL_RemActn_LHD_Stat );
    _mDoor_FL_Stat_AR.Door_FL_Stat_UB.phys = getValue( HMI_Door_FL_Stat_UB );
    _mDoor_FL_Stat_AR.DrPreLtch_FL_Engg.phys = getValue( HMI_DrPreLtch_FL_Engg );
    _mDoor_FL_Stat_AR.DrRLtch_FL_Stat.phys = getValue( HMI_DrRLtch_FL_Stat );
    _mDoor_FL_Stat_AR.ElecTrlrHtrch_Sw_Psd_FL.phys = getValue( HMI_ElecTrlrHtrch_Sw_Psd_FL );
    _mDoor_FL_Stat_AR.Mirr_FL_Bl.phys = getValue( HMI_Mirr_FL_Bl );
    _mDoor_FL_Stat_AR.MirrAdjSw_Stat_LHD_V2.phys = getValue( HMI_MirrAdjSw_Stat_LHD_V2 );
    _mDoor_FL_Stat_AR.MirrFld_Stat_LHD.phys = getValue( HMI_MirrFld_Stat_LHD );
    _mDoor_FL_Stat_AR.MirrFldPk_LHD_Stat.phys = getValue( HMI_MirrFldPk_LHD_Stat );
    _mDoor_FL_Stat_AR.PwrCls_FL_Actv.phys = getValue( HMI_PwrCls_FL_Actv );
    _mDoor_FL_Stat_AR.RemTank_Unlk_Sw_FL.phys = getValue( HMI_RemTank_Unlk_Sw_FL );
    _mDoor_FL_Stat_AR.Rsrv1_Door_FL_Stat.phys = getValue( HMI_Rsrv1_Door_FL_Stat );
    _mDoor_FL_Stat_AR.SeatAdj_P_LHD_Actv.phys = getValue( HMI_SeatAdj_P_LHD_Actv );
    _mDoor_FL_Stat_AR.Tweeter_FL_Posn_Stat.phys = getValue( HMI_Tweeter_FL_Posn_Stat );
}

Door_FL_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_Door_FL_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_Door_FL_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _Door_FL_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _Door_FL_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_Door_FL_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _Door_FL_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _Door_FL_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _Door_FL_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _Door_FL_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _Door_FL_Stat_AR_SQC_RepeatedCnt ) &&
            ( _Door_FL_Stat_AR_E2E_Armed == 1  )    )
        {
            _Door_FL_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_Door_FL_Stat, SQC_help );
    }
    _mDoor_FL_Stat_AR.SQC_Door_FL_Stat = SQC_help;

    if( getValue( HMI_CRC_Door_FL_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_Door_FL_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable_profile02[ crc ^ _mDoor_FL_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mDoor_FL_Stat_AR.byte( 1 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_FL_Stat_AR.byte( 2 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_FL_Stat_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_FL_Stat_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_FL_Stat_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_FL_Stat_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_FL_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _Door_FL_Stat_AR_CRC_Offset[ _mDoor_FL_Stat_AR.SQC_Door_FL_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _Door_FL_Stat_AR_CRC_ErrorCnt   && ( _Door_FL_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Door_FL_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _Door_FL_Stat_AR_CRC_ErrorCnt > 0 )
                    _Door_FL_Stat_AR_CRC_ErrorCnt--; 
            }
            _mDoor_FL_Stat_AR.CRC_Door_FL_Stat = crc;
            putValue( HMI_CRC_Door_FL_Stat, crc );
        }
        else
            _mDoor_FL_Stat_AR.CRC_Door_FL_Stat = getValue( HMI_CRC_Door_FL_Stat );
    }
    else
    {
        if( !getValue( HMI_CRC_Door_FL_Stat_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mDoor_FL_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mDoor_FL_Stat_AR.byte( 1 ) ];
//            crc = crctable[ crc ^ _mDoor_FL_Stat_AR.byte( 2 ) ];
//            crc = crctable[ crc ^ _mDoor_FL_Stat_AR.byte( 3 ) ];
//            crc = crctable[ crc ^ _mDoor_FL_Stat_AR.byte( 4 ) ];
//            crc = crctable[ crc ^ _mDoor_FL_Stat_AR.byte( 5 ) ];
