                ( getValue( HMI_CRC_CamLane_LaneAttr2_Invalid )                                         )    )
            {
                crc++;
                if( _CamLane_LaneAttr2_AR_CRC_ErrorCnt > 0 )
                    _CamLane_LaneAttr2_AR_CRC_ErrorCnt--; 
            }
            _mCamLane_LaneAttr2_AR.CRC_CamLane_LaneAttr2 = crc;
            putValue( HMI_CRC_CamLane_LaneAttr2, crc );
        }
        else
            _mCamLane_LaneAttr2_AR.CRC_CamLane_LaneAttr2 = getValue( HMI_CRC_CamLane_LaneAttr2 );
    }
    else
    {
        if( !getValue( HMI_CRC_CamLane_LaneAttr2_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mCamLane_LaneAttr2_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mCamLane_LaneAttr2_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mCamLane_LaneAttr2_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mCamLane_LaneAttr2_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mCamLane_LaneAttr2_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mCamLane_LaneAttr2_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mCamLane_LaneAttr2_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mCamLane_LaneAttr2_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _CamLane_LaneAttr2_AR_CRC_ErrorCnt   && ( _CamLane_LaneAttr2_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_CamLane_LaneAttr2_Invalid )                                         )    )
            {
                crc++;
                if( _CamLane_LaneAttr2_AR_CRC_ErrorCnt > 0 )
                    _CamLane_LaneAttr2_AR_CRC_ErrorCnt--; 
            }
            _mCamLane_LaneAttr2_AR.CRC_CamLane_LaneAttr2 = crc;
            putValue( HMI_CRC_CamLane_LaneAttr2, crc );
        }
        else
            _mCamLane_LaneAttr2_AR.CRC_CamLane_LaneAttr2 = getValue( HMI_CRC_CamLane_LaneAttr2 );
    }
    if( ( _CamLane_LaneAttr2_AR_MSG_DropCnt > 0 ) &&
        ( _CamLane_LaneAttr2_AR_E2E_Armed == 1  )    )
    {
        _CamLane_LaneAttr2_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mCamLane_LaneAttr2_AR );
        
    if( _CamLane_LaneAttr2_AR_E2E_Armed == 1 )
    {
        if ( ( _CamLane_LaneAttr2_AR_MSG_DropCnt == 0      ) &&
             ( _CamLane_LaneAttr2_AR_CRC_ErrorCnt == 0     ) &&
             ( _CamLane_LaneAttr2_AR_SQC_RepeatedCnt == 0  ) &&
             ( _CamLane_LaneAttr2_AR_SQC_WrongSeqJump == 0 )    )
        {
            _CamLane_LaneAttr2_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_CamLane_LaneAttr2_State, 0 );
        }
    }
}

CamLane_LaneAttr2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CamLane_LaneAttr2_AR_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CamLane_LaneAttr2_AR := %X\n", getValue( HMI__STMSG_CamLane_LaneAttr2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CamLane_LaneAttr2_AR := %X\n", getValue( HMI__STMSGT_CamLane_LaneAttr2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_2ndClothoid_C1_Lt := %X\n", getValue( HMI_CamLane_2ndClothoid_C1_Lt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_2ndClothoid_InitDist_Lt := %X\n", getValue( HMI_CamLane_2ndClothoid_InitDist_Lt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_2ndClothoid_Stat_Lt := %X\n", getValue( HMI_CamLane_2ndClothoid_Stat_Lt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneAttr2_Sync := %X\n", getValue( HMI_CamLane_LaneAttr2_Sync ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneHrztCrv_Lt := %X\n", getValue( HMI_CamLane_LaneHrztCrv_Lt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneMarkType_Lt := %X\n", getValue( HMI_CamLane_LaneMarkType_Lt ) );    filePutString( buffer, elcount( buffer ), hFile );
   // snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_CamLane_LaneAttr2 := %X\n", getValue( HMI_CRC_CamLane_LaneAttr2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_NghbrLaneMarkType_Lt := %X\n", getValue( HMI_NghbrLaneMarkType_Lt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_CAMLane_LaneAttr2 := %X\n", getValue( HMI_Rsrv2_CAMLane_LaneAttr2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    //snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_CamLane_LaneAttr2 := %X\n", getValue( HMI_SQC_CamLane_LaneAttr2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VLN_DtctDist_Lt := %X\n", getValue( HMI_VLN_DtctDist_Lt ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tCamLane_LaneAttr2_AR
{
    putValue( HMI__STMSG_CamLane_LaneAttr2_AR, 0 );
}

on EnvVar HMI__STMSG_CamLane_LaneAttr2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CamLane_LaneAttr2_AR );
        if( tDelay > 0)    
            setTimer( _tCamLane_LaneAttr2_AR, tDelay );
        else
            putValue( HMI__STMSG_CamLane_LaneAttr2_AR, 0 );
       }
}

//on EnvVar HMI__STMSGCT_CamLane_LaneAttr2_AR
//{
//    if( getValue( this ) > 0 )
 //   {
 //       _CamLane_LaneAttr2_AR_CycleCount = getValue( this ) / _CamLane_LaneAttr2_AR_Timebase;     // set cycle counter to initial value
//        _CamLane_LaneAttr2_AR_SpontanFlag = 1;
//    }
//}

on envVar HMI__STMSG_PO_CamLane_LaneAttr2_AR
{
    if( getValue( this ) )
        openPanel("CamLane_LaneAttr2_AR");
}

on EnvVar HMI_CamLane_2ndClothoid_C1_Lt
{
    _mCamLane_LaneAttr2_AR.CamLane_2ndClothoid_C1_Lt.phys = getValue(this);
}

on EnvVar HMI_CamLane_2ndClothoid_InitDist_Lt
{
    _mCamLane_LaneAttr2_AR.CamLane_2ndClothoid_InitDist_Lt.phys = getValue(this);
}

on EnvVar HMI_CamLane_2ndClothoid_Stat_Lt
{
    _mCamLane_LaneAttr2_AR.CamLane_2ndClothoid_Stat_Lt.phys = getValue(this);
}

on EnvVar HMI_CamLane_LaneAttr2_Sync
{
    _mCamLane_LaneAttr2_AR.CamLane_LaneAttr2_Sync.phys = getValue(this);
}

on EnvVar HMI_CamLane_LaneHrztCrv_Lt
{
    _mCamLane_LaneAttr2_AR.CamLane_LaneHrztCrv_Lt.phys = getValue(this);
}

on EnvVar HMI_CamLane_LaneMarkType_Lt
{
    _mCamLane_LaneAttr2_AR.CamLane_LaneMarkType_Lt.phys = getValue(this);
	_mCHASSISPERIPHERY_HMI_R1_AR.CamLane_LaneMarkType_Lt.phys = getValue(this);
//	_CHASSISPERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

//on EnvVar HMI_CRC_CamLane_LaneAttr2
//{
//    _mCamLane_LaneAttr2_AR.CRC_CamLane_LaneAttr2.phys = getValue(this);
//    _CamLane_LaneAttr2_AR_SpontanFlag = 1;
//}

on EnvVar HMI_NghbrLaneMarkType_Lt
{
    _mCamLane_LaneAttr2_AR.NghbrLaneMarkType_Lt.phys = getValue(this);
}

//on EnvVar HMI_Rsrv2_CAMLane_LaneAttr2
//{
//    _mCamLane_LaneAttr2_AR.Rsrv2_CAMLane_LaneAttr2.phys = getValue(this);
//    _CamLane_LaneAttr2_AR_SpontanFlag = 1;
//}

//on EnvVar HMI_SQC_CamLane_LaneAttr2
//{
//    _mCamLane_LaneAttr2_AR.SQC_CamLane_LaneAttr2.phys = getValue(this);
//    _CamLane_LaneAttr2_AR_SpontanFlag = 1;
//}

on EnvVar HMI_VLN_DtctDist_Lt
{
    //write("got value %d", getValue(this));
    _mCamLane_LaneAttr2_AR.VLN_DtctDist_Lt.phys = getValue(this);
    _CamLane_LaneAttr2_AR_SpontanFlag = 1;
}

CamLane_LaneAttr6_AR_check_output()
{
    if( !getValue( HMI__STMSG_CamLane_LaneAttr6_AR ) )
        {
        //  message   CamLane_LaneAttr6_AR ID: 486 --- Sendeart 0 cyclicX --- 
            _CamLane_LaneAttr6_AR_Cnt--;
            if( _CamLane_LaneAttr6_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                CamLane_LaneAttr6_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _CamLane_LaneAttr6_AR_Cnt = _CamLane_LaneAttr6_AR_CycleCount;
            }
        }
}

CamLane_LaneAttr6_AR_init()
{    /* Botschaft CamLane_LaneAttr6_AR ID: 488 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 213 0;
BA_ "NmAsrMessage" BO_ 213 0;
BA_ "GenMsgMinAcceptLength" BO_ 213 8;
BA_ "GenMsgILSupport" BO_ 213 1;
BA_ "DiagState" BO_ 213 0;
BA_ "DiagRequest" BO_ 213 0;
BA_ "DiagResponse" BO_ 213 0;
BA_ "GenMsgStartValue" BO_ 213 "0";
BA_ "GenMsgDelayTime" BO_ 213 50;
BA_ "GenMsgNrOfRepetitions" BO_ 213 0;
BA_ "GenMsgCycleTime" BO_ 213 200;
BA_ "GenMsgSendType" BO_ 213 5;
    */
    _CamLane_LaneAttr6_AR_Timebase =       c_tDBKomTimer_20ms;
    _CamLane_LaneAttr6_AR_CycleCount =    40 / _CamLane_LaneAttr6_AR_Timebase;
    _CamLane_LaneAttr6_AR_StartDelay =      0 / _CamLane_LaneAttr6_AR_Timebase;
    _CamLane_LaneAttr6_AR_Cnt = _CamLane_LaneAttr6_AR_StartDelay;
    _CamLane_LaneAttr6_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CamLane_LaneAttr6_AR, _CamLane_LaneAttr6_AR_StartDelay * _CamLane_LaneAttr6_AR_Timebase );

    _mCamLane_LaneAttr6_AR.CamLane_2ndClothoid_C1_Rt.phys = getValue( HMI_CamLane_2ndClothoid_C1_Rt );
    _mCamLane_LaneAttr6_AR.CamLane_2ndClothoid_InitDist_Rt.phys = getValue( HMI_CamLane_2ndClothoid_InitDist_Rt );
    _mCamLane_LaneAttr6_AR.CamLane_2ndClothoid_Stat_Rt.phys = getValue( HMI_CamLane_2ndClothoid_Stat_Rt );
    _mCamLane_LaneAttr6_AR.CamLane_LaneAttr6_Sync.phys = getValue( HMI_CamLane_LaneAttr6_Sync );
    _mCamLane_LaneAttr6_AR.CamLane_LaneHrztCrv_Rt.phys = getValue( HMI_CamLane_LaneHrztCrv_Rt );
    _mCamLane_LaneAttr6_AR.CamLane_LaneMarkType_Rt.phys = getValue( HMI_CamLane_LaneMarkType_Rt );
    _mCamLane_LaneAttr6_AR.CRC_CamLane_LaneAttr6.phys = getValue( HMI_CRC_CamLane_LaneAttr6 );
    _mCamLane_LaneAttr6_AR.NghbrLaneMarkType_Rt.phys = getValue( HMI_NghbrLaneMarkType_Rt );
    //_mCamLane_LaneAttr6_AR.Rsrv2_CAMLane_LaneAttr6t.phys = getValue( HMI_Rsrv2_CAMLane_LaneAttr6 );
    _mCamLane_LaneAttr6_AR.SQC_CamLane_LaneAttr6.phys = getValue( HMI_SQC_CamLane_LaneAttr6 );
    _mCamLane_LaneAttr6_AR.VLN_DtctDist_Rt.phys = getValue( HMI_VLN_DtctDist_Rt );
    
}

CamLane_LaneAttr6_AR_output(void)
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_CamLane_LaneAttr6 ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_CamLane_LaneAttr6_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _CamLane_LaneAttr6_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _CamLane_LaneAttr6_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_CamLane_LaneAttr6_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _CamLane_LaneAttr6_AR_SQC_WrongSeqJump != 0 ) &&
            ( _CamLane_LaneAttr6_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _CamLane_LaneAttr6_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _CamLane_LaneAttr6_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _CamLane_LaneAttr6_AR_SQC_RepeatedCnt ) &&
            ( _CamLane_LaneAttr6_AR_E2E_Armed == 1  )    )
        {
            _CamLane_LaneAttr6_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_CamLane_LaneAttr6, SQC_help );
    }
    _mCamLane_LaneAttr6_AR.SQC_CamLane_LaneAttr6 = SQC_help;

    if( getValue( HMI_CRC_CamLane_LaneAttr6_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_CamLane_LaneAttr6_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr6_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr6_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr6_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr6_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr6_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr6_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr6_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr6_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _CamLane_LaneAttr6_AR_CRC_Offset[ _mCamLane_LaneAttr6_AR.SQC_CamLane_LaneAttr6 ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _CamLane_LaneAttr6_AR_CRC_ErrorCnt   && ( _CamLane_LaneAttr6_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_CamLane_LaneAttr6_Invalid )                                         )    )
            {
                crc++;
                if( _CamLane_LaneAttr6_AR_CRC_ErrorCnt > 0 )
                    _CamLane_LaneAttr6_AR_CRC_ErrorCnt--; 
            }
            _mCamLane_LaneAttr6_AR.CRC_CamLane_LaneAttr6 = crc;
            putValue( HMI_CRC_CamLane_LaneAttr6, crc );
        }
        else
            _mCamLane_LaneAttr6_AR.CRC_CamLane_LaneAttr6 = getValue( HMI_CRC_CamLane_LaneAttr6 );
    }
    else
    {
        if( !getValue( HMI_CRC_CamLane_LaneAttr6_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mCamLane_LaneAttr6_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mCamLane_LaneAttr6_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mCamLane_LaneAttr6_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mCamLane_LaneAttr6_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mCamLane_LaneAttr6_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mCamLane_LaneAttr6_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mCamLane_LaneAttr6_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mCamLane_LaneAttr6_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _CamLane_LaneAttr6_AR_CRC_ErrorCnt   && ( _CamLane_LaneAttr6_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_CamLane_LaneAttr6_Invalid )                                         )    )
            {
                crc++;
                if( _CamLane_LaneAttr6_AR_CRC_ErrorCnt > 0 )
                    _CamLane_LaneAttr6_AR_CRC_ErrorCnt--; 
            }
            _mCamLane_LaneAttr6_AR.CRC_CamLane_LaneAttr6 = crc;
            putValue( HMI_CRC_CamLane_LaneAttr6, crc );
        }
        else
            _mCamLane_LaneAttr6_AR.CRC_CamLane_LaneAttr6 = getValue( HMI_CRC_CamLane_LaneAttr6 );
    }
    if( ( _CamLane_LaneAttr6_AR_MSG_DropCnt > 0 ) &&
        ( _CamLane_LaneAttr6_AR_E2E_Armed == 1  )    )
    {
        _CamLane_LaneAttr6_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mCamLane_LaneAttr6_AR );
        
    if( _CamLane_LaneAttr6_AR_E2E_Armed == 1 )
    {
        if ( ( _CamLane_LaneAttr6_AR_MSG_DropCnt == 0      ) &&
             ( _CamLane_LaneAttr6_AR_CRC_ErrorCnt == 0     ) &&
             ( _CamLane_LaneAttr6_AR_SQC_RepeatedCnt == 0  ) &&
             ( _CamLane_LaneAttr6_AR_SQC_WrongSeqJump == 0 )    )
        {
            _CamLane_LaneAttr6_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_CamLane_LaneAttr6_State, 0 );
        }
    }
}

CamLane_LaneAttr6_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CamLane_LaneAttr6_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CamLane_LaneAttr6_AR := %X\n", getValue( HMI__STMSG_CamLane_LaneAttr6_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CamLane_LaneAttr6_AR := %X\n", getValue( HMI__STMSGT_CamLane_LaneAttr6_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_2ndClothoid_C1_Rt := %X\n", getValue( HMI_CamLane_2ndClothoid_C1_Rt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_2ndClothoid_InitDist_Rt := %X\n", getValue( HMI_CamLane_2ndClothoid_InitDist_Rt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_2ndClothoid_Stat_Rt := %X\n", getValue( HMI_CamLane_2ndClothoid_Stat_Rt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneAttr6_Sync := %X\n", getValue( HMI_CamLane_LaneAttr6_Sync ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneHrztCrv_Rt := %X\n", getValue( HMI_CamLane_LaneHrztCrv_Rt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamLane_LaneMarkType_Rt := %X\n", getValue( HMI_CamLane_LaneMarkType_Rt ) );    filePutString( buffer, elcount( buffer ), hFile );
   // snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_CamLane_LaneAttr6 := %X\n", getValue( HMI_CRC_CamLane_LaneAttr6 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_NghbrLaneMarkType_Rt := %X\n", getValue( HMI_NghbrLaneMarkType_Rt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_CAMLane_LaneAttr6 := %X\n", getValue( HMI_Rsrv2_CAMLane_LaneAttr6 ) );    filePutString( buffer, elcount( buffer ), hFile );
   // snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_CamLane_LaneAttr6 := %X\n", getValue( HMI_SQC_CamLane_LaneAttr6 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VLN_DtctDist_Rt := %X\n", getValue( HMI_VLN_DtctDist_Rt ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tCamLane_LaneAttr6_AR
{
    putValue( HMI__STMSG_CamLane_LaneAttr6_AR, 0 );
}

on EnvVar HMI__STMSG_CamLane_LaneAttr6_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CamLane_LaneAttr6_AR );
        if( tDelay > 0)    
            setTimer( _tCamLane_LaneAttr6_AR, tDelay );
        else
            putValue( HMI__STMSG_CamLane_LaneAttr6_AR, 0 );
    }
}


on envVar HMI__STMSG_PO_CamLane_LaneAttr6_AR
{
    if( getValue( this ) )
        openPanel("CamLane_LaneAttr6_AR");
}

on EnvVar HMI_CamLane_2ndClothoid_C1_Rt
{
    _mCamLane_LaneAttr6_AR.CamLane_2ndClothoid_C1_Rt.phys = getValue(this);
}

on EnvVar HMI_CamLane_2ndClothoid_InitDist_Rt
{
    _mCamLane_LaneAttr6_AR.CamLane_2ndClothoid_InitDist_Rt.phys = getValue(this);
}

on EnvVar HMI_CamLane_2ndClothoid_Stat_Rt
{
    _mCamLane_LaneAttr6_AR.CamLane_2ndClothoid_Stat_Rt.phys = getValue(this);
}

on EnvVar HMI_CamLane_LaneAttr6_Sync
{
    _mCamLane_LaneAttr6_AR.CamLane_LaneAttr6_Sync.phys = getValue(this);
}

on EnvVar HMI_CamLane_LaneHrztCrv_Rt
{
    _mCamLane_LaneAttr6_AR.CamLane_LaneHrztCrv_Rt.phys = getValue(this);
}

on EnvVar HMI_CamLane_LaneMarkType_Rt
{
    _mCamLane_LaneAttr6_AR.CamLane_LaneMarkType_Rt.phys = getValue(this);
    _CamLane_LaneAttr6_AR_SpontanFlag = 1;
	_mCHASSISPERIPHERY_HMI_R1_AR.CamLane_LaneMarkType_Rt.phys = getValue(this);
//	_CHASSISPERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on EnvVar HMI_CRC_CamLane_LaneAttr6
{
    _mCamLane_LaneAttr6_AR.CRC_CamLane_LaneAttr6.phys = getValue(this);
}

on EnvVar HMI_NghbrLaneMarkType_Rt
{
    _mCamLane_LaneAttr6_AR.NghbrLaneMarkType_Rt.phys = getValue(this);
}



//on EnvVar HMI_Rsrv2_CAMLane_LaneAttr6
//{
 //   _mCamLane_LaneAttr6_AR.Rsrv2_CAMLane_LaneAttr6.phys = getValue(this);
//    _CamLane_LaneAttr6_AR_SpontanFlag = 1;
//}

on EnvVar HMI_SQC_CamLane_LaneAttr6
{
    _mCamLane_LaneAttr6_AR.SQC_CamLane_LaneAttr6.phys = getValue(this);
}

on EnvVar HMI_VLN_DtctDist_Rt
{
    _mCamLane_LaneAttr6_AR.VLN_DtctDist_Rt.phys = getValue(this);
}

DPC_MdSel_Rs_AMG_AR_check_output()
{
    if( !getValue( HMI__STMSG_DPC_MdSel_Rs_AMG_AR ) )
    {
    //  message   DPC_MdSel_Rs_AMG_AR ID: 988 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _DPC_MdSel_Rs_AMG_AR_DelayCnt > 0) _DPC_MdSel_Rs_AMG_AR_DelayCnt--; // Mindestsendeabstand
        _DPC_MdSel_Rs_AMG_AR_Cnt--;
        if( _DPC_MdSel_Rs_AMG_AR_Cnt < 1 )
        {
            if( _DPC_MdSel_Rs_AMG_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                DPC_MdSel_Rs_AMG_AR_output();
                 _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _DPC_MdSel_Rs_AMG_AR_DelayCnt = _DPC_MdSel_Rs_AMG_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
            }
            _DPC_MdSel_Rs_AMG_AR_Cnt = _DPC_MdSel_Rs_AMG_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _DPC_MdSel_Rs_AMG_AR_SpontanFlag)
        {
            if( _DPC_MdSel_Rs_AMG_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                DPC_MdSel_Rs_AMG_AR_output();
                _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _DPC_MdSel_Rs_AMG_AR_DelayCnt = _DPC_MdSel_Rs_AMG_AR_MinDelay;
            }
        }
    }
}

DPC_MdSel_Rs_AMG_AR_init()
{    /* Botschaft DPC_MdSel_Rs_AMG_AR ID: 988 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 213 0;
BA_ "NmAsrMessage" BO_ 213 0;
BA_ "GenMsgMinAcceptLength" BO_ 213 8;
BA_ "GenMsgILSupport" BO_ 213 1;
BA_ "DiagState" BO_ 213 0;
BA_ "DiagRequest" BO_ 213 0;
BA_ "DiagResponse" BO_ 213 0;
BA_ "GenMsgStartValue" BO_ 213 "0";
BA_ "GenMsgDelayTime" BO_ 213 50;
BA_ "GenMsgNrOfRepetitions" BO_ 213 0;
BA_ "GenMsgCycleTime" BO_ 213 200;
BA_ "GenMsgSendType" BO_ 213 5;
    */
    _DPC_MdSel_Rs_AMG_AR_Timebase =       c_tDBKomTimer_5ms;
    _DPC_MdSel_Rs_AMG_AR_CycleCount =    200 / _DPC_MdSel_Rs_AMG_AR_Timebase;
    _DPC_MdSel_Rs_AMG_AR_StartDelay =      0 / _DPC_MdSel_Rs_AMG_AR_Timebase;
    _DPC_MdSel_Rs_AMG_AR_MinDelay =       50 / _DPC_MdSel_Rs_AMG_AR_Timebase;
    _DPC_MdSel_Rs_AMG_AR_Cnt = _DPC_MdSel_Rs_AMG_AR_StartDelay;
    _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 0;
    _DPC_MdSel_Rs_AMG_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_DPC_MdSel_Rs_AMG_AR, _DPC_MdSel_Rs_AMG_AR_StartDelay * _DPC_MdSel_Rs_AMG_AR_Timebase );
    putValue( HMI__STMSGCT_DPC_MdSel_Rs_AMG_AR, _DPC_MdSel_Rs_AMG_AR_CycleCount * _DPC_MdSel_Rs_AMG_AR_Timebase );

    _mDPC_MdSel_Rs_AMG_AR.DPC_DefaultMd_Rs_HU.phys = getValue( HMI_DPC_DefaultMd_Rs_HU );
    _mDPC_MdSel_Rs_AMG_AR.DPC_DrvAttr_Stat_AMG.phys = getValue( HMI_DPC_DrvAttr_Stat_AMG );
    _mDPC_MdSel_Rs_AMG_AR.DPC_GlobalMd_Rs_HU_AMG.phys = getValue( HMI_DPC_GlobalMd_Rs_HU_AMG );
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_AS_Rs_HU.phys = getValue( HMI_DPC_Md_AS_Rs_HU );
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_ASX_Rs_HU.phys = getValue( HMI_DPC_Md_ASX_Rs_HU );
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_DrvDyn_Rs_HU_AMG.phys = getValue( HMI_DPC_Md_DrvDyn_Rs_HU_AMG );
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_ECO_Assist_Rs_HU.phys = getValue( HMI_DPC_Md_ECO_Assist_Rs_HU );
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_ESP_Rs_HU_AMG.phys = getValue( HMI_DPC_Md_ESP_Rs_HU_AMG );
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_Hybrid_Rs_HU.phys = getValue( HMI_DPC_Md_Hybrid_Rs_HU );
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_PT_Rs_HU.phys = getValue( HMI_DPC_Md_PT_Rs_HU );
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_PwrFreeD_Plus_Rs_HU.phys = getValue( HMI_DPC_Md_PwrFreeD_Plus_Rs_HU );
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_SSA_Rs_HU.phys = getValue( HMI_DPC_Md_SSA_Rs_HU );
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_St_Rs_HU.phys = getValue( HMI_DPC_Md_St_Rs_HU );
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_Susp_Rs_HU.phys = getValue( HMI_DPC_Md_Susp_Rs_HU );
	_mDPC_MdSel_Rs_AMG_AR.DPC_Md_SuspLvl_Rs_HU.phys = getValue( HMI_DPC_Md_SuspLvl_Rs_HU );
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_Tx_Rs_HU.phys = getValue( HMI_DPC_Md_Tx_Rs_HU );
    _mDPC_MdSel_Rs_AMG_AR.DPC_TrgRq_AMG_HU.phys = getValue( HMI_DPC_TrgRq_AMG_HU );
}


DPC_MdSel_Rs_AMG_AR_output()
{
    output( _mDPC_MdSel_Rs_AMG_AR );
}

DPC_MdSel_Rs_AMG_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: TSA_Disp_Rq3_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_DPC_MdSel_Rs_AMG_AR := %X\n", getValue( HMI__STMSG_DPC_MdSel_Rs_AMG_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_DPC_MdSel_Rs_AMG_AR := %X\n", getValue( HMI__STMSGT_DPC_MdSel_Rs_AMG_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_DefaultMd_Rs_HU := %X\n", getValue( HMI_DPC_DefaultMd_Rs_HU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_DrvAttr_Stat_AMG := %X\n", getValue( HMI_DPC_DrvAttr_Stat_AMG ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_GlobalMd_Rs_HU_AMG := %X\n", getValue( HMI_DPC_GlobalMd_Rs_HU_AMG ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_AS_Rs_HU := %X\n", getValue( HMI_DPC_Md_AS_Rs_HU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_ASX_Rs_HU := %X\n", getValue( HMI_DPC_Md_ASX_Rs_HU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_DrvDyn_Rs_HU_AMG := %X\n", getValue( HMI_DPC_Md_DrvDyn_Rs_HU_AMG ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_ECO_Assist_Rs_HU := %X\n", getValue( HMI_DPC_Md_ECO_Assist_Rs_HU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_ESP_Rs_HU_AMG := %X\n", getValue( HMI_DPC_Md_ESP_Rs_HU_AMG ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_ExhstFlap_Rs_HU := %X\n", getValue( HMI_DPC_Md_ExhstFlap_Rs_HU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_Hybrid_Rs_HU := %X\n", getValue( HMI_DPC_Md_Hybrid_Rs_HU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_PT_Rs_HU := %X\n", getValue( HMI_DPC_Md_PT_Rs_HU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_PwrFreeD_Plus_Rs_HU := %X\n", getValue( HMI_DPC_Md_PwrFreeD_Plus_Rs_HU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_SSA_Rs_HU := %X\n", getValue( HMI_DPC_Md_SSA_Rs_HU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_St_Rs_HU := %X\n", getValue( HMI_DPC_Md_St_Rs_HU ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_Susp_Rs_HU := %X\n", getValue( HMI_DPC_Md_Susp_Rs_HU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_SuspLvl_Rs_HU := %X\n", getValue( HMI_DPC_Md_SuspLvl_Rs_HU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_Tx_Rs_HU:= %X\n", getValue( HMI_DPC_Md_Tx_Rs_HU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_TrgRq_AMG_HU := %X\n", getValue( HMI_DPC_TrgRq_AMG_HU ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tDPC_MdSel_Rs_AMG_AR
{
    putValue( HMI__STMSG_DPC_MdSel_Rs_AMG_AR, 0 );
}

on EnvVar HMI__STMSG_DPC_MdSel_Rs_AMG_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_DPC_MdSel_Rs_AMG_AR );
        if( tDelay > 0)    
            setTimer( _tDPC_MdSel_Rs_AMG_AR, tDelay );
        else
            putValue( HMI__STMSG_DPC_MdSel_Rs_AMG_AR, 0 );
    }
}

on EnvVar HMI__STMSGCT_DPC_MdSel_Rs_AMG_AR
{
    if( getValue( this ) > 0 )
    {
        _DPC_MdSel_Rs_AMG_AR_CycleCount = getValue( this ) / _DPC_MdSel_Rs_AMG_AR_Timebase;     // set cycle counter to initial value
        _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
    }
}

on envVar HMI__STMSG_PO_DPC_MdSel_Rs_AMG_AR
{
    if( getValue( this ) )
        openPanel("DPC_MdSel_Rs_AMG_AR");
}

on EnvVar HMI_DPC_DefaultMd_Rs_HU
{
    _mDPC_MdSel_Rs_AMG_AR.DPC_DefaultMd_Rs_HU.phys = getValue(this);
    _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_DrvAttr_Stat_AMG
{
    _mDPC_MdSel_Rs_AMG_AR.DPC_DrvAttr_Stat_AMG.phys = getValue(this);
    _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_GlobalMd_Rs_HU_AMG
{
    _mDPC_MdSel_Rs_AMG_AR.DPC_GlobalMd_Rs_HU_AMG.phys = getValue(this);
    _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_AS_Rs_HU
{
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_AS_Rs_HU.phys = getValue(this);
    _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_ASX_Rs_HU
{
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_ASX_Rs_HU.phys = getValue(this);
    _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_DrvDyn_Rs_HU_AMG
{
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_DrvDyn_Rs_HU_AMG.phys = getValue(this);
    _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_ECO_Assist_Rs_HU
{
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_ECO_Assist_Rs_HU.phys = getValue(this);
    _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_ESP_Rs_HU_AMG
{
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_ESP_Rs_HU_AMG.phys = getValue(this);
    _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_ExhstFlap_Rs_HU
{
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_ExhstFlap_Rs_HU.phys = getValue(this);
    _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_Hybrid_Rs_HU
{
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_Hybrid_Rs_HU.phys = getValue(this);
    _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_PT_Rs_HU
{
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_PT_Rs_HU.phys = getValue(this);
    _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_PwrFreeD_Plus_Rs_HU
{
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_PwrFreeD_Plus_Rs_HU.phys = getValue(this);
    _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_SSA_Rs_HU
{
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_SSA_Rs_HU.phys = getValue(this);
    _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_St_Rs_HU
{
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_St_Rs_HU.phys = getValue(this);
    _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_Susp_Rs_HU
{
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_Susp_Rs_HU.phys = getValue(this);
    _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_SuspLvl_Rs_HU
{
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_SuspLvl_Rs_HU.phys = getValue(this);
    _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_Tx_Rs_HU
{
    _mDPC_MdSel_Rs_AMG_AR.DPC_Md_Tx_Rs_HU.phys = getValue(this);
    _DPC_MdSel_Rs_AMG_AR_SpontanFlag = 1;
}
WMI_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_WMI_Stat_AR ) )
    {
    //  message   WMI_Stat_AR ID: 1225 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _WMI_Stat_AR_DelayCnt > 0) _WMI_Stat_AR_DelayCnt--; // Mindestsendeabstand
        _WMI_Stat_AR_Cnt--;
        if( _WMI_Stat_AR_Cnt < 1 )
        {
            if( _WMI_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                WMI_Stat_AR_output();
                _WMI_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _WMI_Stat_AR_DelayCnt = _WMI_Stat_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _WMI_Stat_AR_SpontanFlag = 1;
            }
            _WMI_Stat_AR_Cnt = _WMI_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _WMI_Stat_AR_SpontanFlag)
        {
            if( _WMI_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                WMI_Stat_AR_output();
                _WMI_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _WMI_Stat_AR_DelayCnt = _WMI_Stat_AR_MinDelay;
            }
        }
    }
}

WMI_Stat_AR_init()
{   /* Botschaft WMI_Stat_AR ID: 1225   --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1225 0;
BA_ "NmAsrMessage" BO_ 1225 0;
BA_ "GenMsgMinAcceptLength" BO_ 1225 8;
BA_ "GenMsgILSupport" BO_ 1225 1;
BA_ "DiagState" BO_ 1225 0;
BA_ "DiagRequest" BO_ 1225 0;
BA_ "DiagResponse" BO_ 1225 0;
BA_ "GenMsgStartValue" BO_ 1225 "0";
BA_ "GenMsgDelayTime" BO_ 1225 100;
BA_ "GenMsgNrOfRepetitions" BO_ 1225 0;
BA_ "GenMsgCycleTime" BO_ 1225 500;
BA_ "GenMsgSendType" BO_ 1225 5;
    */
    _WMI_Stat_AR_Timebase =                c_tDBKomTimer_20ms;
    _WMI_Stat_AR_CycleCount =             500 / _WMI_Stat_AR_Timebase;
    _WMI_Stat_AR_StartDelay =               0 / _WMI_Stat_AR_Timebase;
    _WMI_Stat_AR_MinDelay =               100 / _WMI_Stat_AR_Timebase;
    _WMI_Stat_AR_Cnt = _WMI_Stat_AR_StartDelay;
    _WMI_Stat_AR_SpontanFlag = 0;
    _WMI_Stat_AR_DelayCnt = 0;
	
	putValue( HMI__STMSGSD_WMI_Stat_AR, _WMI_Stat_AR_StartDelay * _WMI_Stat_AR_Timebase );

    _mWMI_Stat_AR.Mobile_Chrg_Stat.phys = getValue( HMI_Mobile_Chrg_Stat );
    _mWMI_Stat_AR.Mobile_Device_Present_WMI.phys = getValue( HMI_Mobile_Device_Present_WMI );
    _mWMI_Stat_AR.Mobile_SOC.phys = getValue( HMI_Mobile_SOC );
    _mWMI_Stat_AR.MobilComp_Stat.phys = getValue( HMI_MobilComp_Stat );
    
 
} 	

WMI_Stat_AR_output(void)
{
    output( _mWMI_Stat_AR );
}

WMI_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: WMI_Stat_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_WMI_Stat_AR := %X\n", getValue( HMI__STMSG_WMI_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_WMI_Stat_AR := %X\n", getValue( HMI__STMSGT_WMI_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mobile_Chrg_Stat := %X\n", getValue( HMI_Mobile_Chrg_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mobile_Device_Present_WMI := %X\n", getValue( HMI_Mobile_Device_Present_WMI ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mobile_SOC := %X\n", getValue( HMI_Mobile_SOC ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MobilComp_Stat := %X\n", getValue( HMI_MobilComp_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
   
}

on timer _tWMI_Stat_AR
{
    putValue( HMI__STMSG_WMI_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_WMI_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_WMI_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tWMI_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_WMI_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_WMI_Stat_AR
{
    if( getValue( this ) )
        openPanel("WMI_Stat_AR");
}

on EnvVar HMI_Mobile_Chrg_Stat
{
    _mWMI_Stat_AR.Mobile_Chrg_Stat.phys = getValue(this);
    _WMI_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Mobile_Device_Present_WMI
{
    _mWMI_Stat_AR.Mobile_Device_Present_WMI.phys = getValue(this);
    _WMI_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Mobile_SOC
{
    _mWMI_Stat_AR.Mobile_SOC.phys = getValue(this);
    _WMI_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MobilComp_Stat
{
    _mWMI_Stat_AR.MobilComp_Stat.phys = getValue(this);
    _WMI_Stat_AR_SpontanFlag = 1;
}

//AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAaaa

BSM_M_Lat_FreeSp_AR_check_output()
{
    if( !getValue( HMI__STMSG_BSM_M_Lat_FreeSp_AR ) )
        {
        //  message   BSM_M_Lat_FreeSp_AR ID: 2360344576 --- Sendeart 0 cyclicX --- 
            _BSM_M_Lat_FreeSp_AR_Cnt--;
            if( _BSM_M_Lat_FreeSp_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                BSM_M_Lat_FreeSp_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _BSM_M_Lat_FreeSp_AR_Cnt = _BSM_M_Lat_FreeSp_AR_CycleCount;
            }
        }
}

BSM_M_Lat_FreeSp_AR_init()
{   /* Botschaft BSM_M_Lat_FreeSp_AR ID: 2360344576 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 2360344576 0;
BA_ "NmAsrMessage" BO_ 2360344576 0;
BA_ "GenMsgMinAcceptLength" BO_ 2360344576 8;
BA_ "GenMsgILSupport" BO_ 2360344576 1;
BA_ "DiagState" BO_ 2360344576 0;
BA_ "DiagRequest" BO_ 2360344576 0;
BA_ "DiagResponse" BO_ 2360344576 0;
BA_ "GenMsgStartValue" BO_ 2360344576 "0";
BA_ "GenMsgStartDelayTime" BO_ 2360344576 0;
BA_ "GenMsgDelayTime" BO_ 2360344576 5;
BA_ "GenMsgNrOfRepetitions" BO_ 2360344576 0;
BA_ "GenMsgCycleTime" BO_ 2360344576 500;
BA_ "GenMsgSendType" BO_ 2360344576 5;
    */
    _BSM_M_Lat_FreeSp_AR_Timebase =         c_tDBKomTimer_20ms;
    _BSM_M_Lat_FreeSp_AR_CycleCount =     500 / _BSM_M_Lat_FreeSp_AR_Timebase;
    _BSM_M_Lat_FreeSp_AR_StartDelay =       0 / _BSM_M_Lat_FreeSp_AR_Timebase;
    _BSM_M_Lat_FreeSp_AR_Cnt = _BSM_M_Lat_FreeSp_AR_StartDelay;
    _BSM_M_Lat_FreeSp_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_BSM_M_Lat_FreeSp_AR, _BSM_M_Lat_FreeSp_AR_StartDelay * _BSM_M_Lat_FreeSp_AR_Timebase );

    _mBSM_M_Lat_FreeSp_AR.BSM_M_Lat_FreeSp_AnglToEdgeCrgWay.phys = getValue( HMI_BSM_M_Lat_FreeSp_AnglToEdgeCrgWay );
    _mBSM_M_Lat_FreeSp_AR.BSM_M_Lat_FreeSp_BrdrType.phys = getValue( HMI_BSM_M_Lat_FreeSp_BrdrType );
    _mBSM_M_Lat_FreeSp_AR.BSM_M_Lat_FreeSp_DistToEdgeCrgWay.phys = getValue( HMI_BSM_M_Lat_FreeSp_DistToEdgeCrgWay );
    _mBSM_M_Lat_FreeSp_AR.BSM_M_Lat_FreeSp_DtctStat.phys = getValue( HMI_BSM_M_Lat_FreeSp_DtctStat );
    _mBSM_M_Lat_FreeSp_AR.BSM_M_Lat_FreeSp_StdDev.phys = getValue( HMI_BSM_M_Lat_FreeSp_StdDev );
    _mBSM_M_Lat_FreeSp_AR.BSM_M_Lat_FreeSp_TmStmp.phys = getValue( HMI_BSM_M_Lat_FreeSp_TmStmp );
    
}

BSM_M_Lat_FreeSp_AR_output(void)
{
    output( _mBSM_M_Lat_FreeSp_AR );
}

BSM_M_Lat_FreeSp_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS:BSM_M_Lat_FreeSp_AR\n", 27, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_BSM_M_Lat_FreeSp_AR := %X\n", getValue( HMI__STMSG_BSM_M_Lat_FreeSp_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_BSM_M_Lat_FreeSp_AR := %X\n", getValue( HMI__STMSGT_BSM_M_Lat_FreeSp_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_M_Lat_FreeSp_AnglToEdgeCrgWay := %X\n", getValue( HMI_BSM_M_Lat_FreeSp_AnglToEdgeCrgWay ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_M_Lat_FreeSp_BrdrType := %X\n", getValue( HMI_BSM_M_Lat_FreeSp_BrdrType ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_M_Lat_FreeSp_DistToEdgeCrgWay := %X\n", getValue( HMI_BSM_M_Lat_FreeSp_DistToEdgeCrgWay ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_M_Lat_FreeSp_DtctStat := %X\n", getValue( HMI_BSM_M_Lat_FreeSp_DtctStat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_M_Lat_FreeSp_StdDev := %X\n", getValue( HMI_BSM_M_Lat_FreeSp_StdDev ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_M_Lat_FreeSp_TmStmp := %X\n", getValue( HMI_BSM_M_Lat_FreeSp_TmStmp ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tBSM_M_Lat_FreeSp_AR
{
    putValue( HMI__STMSG_BSM_M_Lat_FreeSp_AR, 0 );
}

on EnvVar HMI__STMSG_BSM_M_Lat_FreeSp_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_BSM_M_Lat_FreeSp_AR );
        if( tDelay > 0)    
            setTimer( _tBSM_M_Lat_FreeSp_AR, tDelay );
        else
            putValue( HMI__STMSG_BSM_M_Lat_FreeSp_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_BSM_M_Lat_FreeSp_AR
{
    if( getValue( this ) )
        openPanel("BSM_M_Lat_FreeSp_AR");
}

on EnvVar HMI_BSM_M_Lat_FreeSp_AnglToEdgeCrgWay
{
    _mBSM_M_Lat_FreeSp_AR.BSM_M_Lat_FreeSp_AnglToEdgeCrgWay.phys = getValue(this);
}

on EnvVar HMI_BSM_M_Lat_FreeSp_BrdrType
{
    _mBSM_M_Lat_FreeSp_AR.BSM_M_Lat_FreeSp_BrdrType.phys = getValue(this);
}

on EnvVar HMI_BSM_M_Lat_FreeSp_DistToEdgeCrgWay
{
    _mBSM_M_Lat_FreeSp_AR.BSM_M_Lat_FreeSp_DistToEdgeCrgWay.phys = getValue(this);
}

on EnvVar HMI_BSM_M_Lat_FreeSp_DtctStat
{
    _mBSM_M_Lat_FreeSp_AR.BSM_M_Lat_FreeSp_DtctStat.phys = getValue(this);
}

on EnvVar HMI_BSM_M_Lat_FreeSp_StdDev
{
    _mBSM_M_Lat_FreeSp_AR.BSM_M_Lat_FreeSp_StdDev.phys = getValue(this);
}

on EnvVar HMI_BSM_M_Lat_FreeSp_TmStmp
{
    _mBSM_M_Lat_FreeSp_AR.BSM_M_Lat_FreeSp_TmStmp.phys = getValue(this);
}

BSM_S_Lat_FreeSp_AR_check_output()
{
    if( !getValue( HMI__STMSG_BSM_S_Lat_FreeSp_AR ) )
        {
        //  message   BSM_S_Lat_FreeSp_AR ID: 2360606720 --- Sendeart 0 cyclicX --- 
            _BSM_S_Lat_FreeSp_AR_Cnt--;
            if( _BSM_S_Lat_FreeSp_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                BSM_S_Lat_FreeSp_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _BSM_S_Lat_FreeSp_AR_Cnt = _BSM_S_Lat_FreeSp_AR_CycleCount;
            }
        }
}

BSM_S_Lat_FreeSp_AR_init()
{   /* Botschaft BSM_S_Lat_FreeSp_AR ID: 2360606720 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 2360606720 0;
BA_ "NmAsrMessage" BO_ 2360606720 0;
BA_ "GenMsgMinAcceptLength" BO_ 2360606720 8;
BA_ "GenMsgILSupport" BO_ 2360606720 1;
BA_ "DiagState" BO_ 2360606720 0;
BA_ "DiagRequest" BO_ 2360606720 0;
BA_ "DiagResponse" BO_ 2360606720 0;
BA_ "GenMsgStartValue" BO_ 2360606720 "0";
BA_ "GenMsgStartDelayTime" BO_ 2360606720 75;
BA_ "GenMsgCycleTime" BO_ 2360606720 500;
BA_ "GenMsgSendType" BO_ 2360606720 0;
    */
    _BSM_S_Lat_FreeSp_AR_Timebase =      c_tDBKomTimer_20ms;
    _BSM_S_Lat_FreeSp_AR_CycleCount =   100 / _BSM_S_Lat_FreeSp_AR_Timebase;
    _BSM_S_Lat_FreeSp_AR_StartDelay =      75 / _BSM_S_Lat_FreeSp_AR_Timebase;
    _BSM_S_Lat_FreeSp_AR_Cnt = _BSM_S_Lat_FreeSp_AR_StartDelay;
    _BSM_S_Lat_FreeSp_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_BSM_S_Lat_FreeSp_AR, _BSM_S_Lat_FreeSp_AR_StartDelay * _BSM_S_Lat_FreeSp_AR_Timebase );

    _mBSM_S_Lat_FreeSp_AR.BSM_S_Lat_FreeSp_AnglToEdgeCrgWay.phys = getValue( HMI_BSM_S_Lat_FreeSp_AnglToEdgeCrgWay );
    _mBSM_S_Lat_FreeSp_AR.BSM_S_Lat_FreeSp_BrdrType.phys = getValue( HMI_BSM_S_Lat_FreeSp_BrdrType );
    _mBSM_S_Lat_FreeSp_AR.BSM_S_Lat_FreeSp_DistToEdgeCrgWay.phys = getValue( HMI_BSM_S_Lat_FreeSp_DistToEdgeCrgWay );
	_mBSM_S_Lat_FreeSp_AR.BSM_S_Lat_FreeSp_DtctStat.phys = getValue( HMI_BSM_S_Lat_FreeSp_DtctStat );
    _mBSM_S_Lat_FreeSp_AR.BSM_S_Lat_FreeSp_StdDev.phys = getValue( HMI_BSM_S_Lat_FreeSp_StdDev );
	_mBSM_S_Lat_FreeSp_AR.BSM_S_Lat_FreeSp_TmStmp.phys = getValue( HMI_BSM_S_Lat_FreeSp_TmStmp );
}

BSM_S_Lat_FreeSp_AR_output(void)
{
    output( _mBSM_S_Lat_FreeSp_AR );
}

BSM_S_Lat_FreeSp_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: BSM_S_Lat_FreeSp_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_BSM_S_Lat_FreeSp_AR := %X\n", getValue( HMI__STMSG_BSM_S_Lat_FreeSp_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_BSM_S_Lat_FreeSp_AR := %X\n", getValue( HMI__STMSGT_BSM_S_Lat_FreeSp_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_S_Lat_FreeSp_AnglToEdgeCrgWay  := %X\n", getValue( HMI_BSM_S_Lat_FreeSp_AnglToEdgeCrgWay ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_S_Lat_FreeSp_BrdrType  := %X\n", getValue( HMI_BSM_S_Lat_FreeSp_BrdrType ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_S_Lat_FreeSp_DistToEdgeCrgWay  := %X\n", getValue( HMI_BSM_S_Lat_FreeSp_DistToEdgeCrgWay ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_S_Lat_FreeSp_DtctStat  := %X\n", getValue( HMI_BSM_S_Lat_FreeSp_DtctStat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_S_Lat_FreeSp_StdDev  := %X\n", getValue( HMI_BSM_S_Lat_FreeSp_StdDev ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_S_Lat_FreeSp_TmStmp  := %X\n", getValue( HMI_BSM_S_Lat_FreeSp_TmStmp ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tBSM_S_Lat_FreeSp_AR
{
    putValue( HMI__STMSG_BSM_S_Lat_FreeSp_AR, 0 );
}

on EnvVar HMI__STMSG_BSM_S_Lat_FreeSp_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_BSM_S_Lat_FreeSp_AR );
        if( tDelay > 0)    
            setTimer( _tBSM_S_Lat_FreeSp_AR, tDelay );
        else
            putValue( HMI__STMSG_BSM_S_Lat_FreeSp_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_BSM_S_Lat_FreeSp_AR
{
    if( getValue( this ) )
        openPanel("BSM_S_Lat_FreeSp_AR");
}

on EnvVar HMI_BSM_S_Lat_FreeSp_AnglToEdgeCrgWay
{
    _mBSM_S_Lat_FreeSp_AR.BSM_S_Lat_FreeSp_AnglToEdgeCrgWay.phys = getValue(this);
}

on EnvVar HMI_BSM_S_Lat_FreeSp_BrdrType
{
    _mBSM_S_Lat_FreeSp_AR.BSM_S_Lat_FreeSp_BrdrType.phys = getValue(this);
}

on EnvVar HMI_BSM_S_Lat_FreeSp_DistToEdgeCrgWay
{
    _mBSM_S_Lat_FreeSp_AR.BSM_S_Lat_FreeSp_DistToEdgeCrgWay.phys = getValue(this);
}

on EnvVar HMI_BSM_S_Lat_FreeSp_DtctStat
{
    _mBSM_S_Lat_FreeSp_AR.BSM_S_Lat_FreeSp_DtctStat.phys = getValue(this);
}

on EnvVar HMI_BSM_S_Lat_FreeSp_StdDev
{
    _mBSM_S_Lat_FreeSp_AR.BSM_S_Lat_FreeSp_StdDev.phys = getValue(this);
}

on EnvVar HMI_BSM_S_Lat_FreeSp_TmStmp
{
    _mBSM_S_Lat_FreeSp_AR.BSM_S_Lat_FreeSp_TmStmp.phys = getValue(this);
}

CHASSIS_HMI_DTR_R2_AR_check_output()
{
    if( !getValue( HMI__STMSG_CHASSIS_HMI_DTR_R2_AR ) )
        {
        //  message   CHASSIS_HMI_DTR_R2_AR ID: 2366636032 --- Sendeart 0 cyclicX --- 
            _CHASSIS_HMI_DTR_R2_AR_Cnt--;
            if( _CHASSIS_HMI_DTR_R2_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                CHASSIS_HMI_DTR_R2_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _CHASSIS_HMI_DTR_R2_AR_Cnt = _CHASSIS_HMI_DTR_R2_AR_CycleCount;
            }
        }
}

CHASSIS_HMI_DTR_R2_AR_init()
{   /* Botschaft CHASSIS_HMI_DTR_R2_AR ID: 2366636032 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 2366636032 0;
BA_ "NmAsrMessage" BO_ 2366636032 0;
BA_ "GenMsgMinAcceptLength" BO_ 2366636032 8;
BA_ "GenMsgILSupport" BO_ 2366636032 1;
BA_ "DiagState" BO_ 2366636032 0;
BA_ "DiagRequest" BO_ 2366636032 0;
BA_ "DiagResponse" BO_ 2366636032 0;
BA_ "GenMsgStartValue" BO_ 2366636032 "0";
BA_ "GenMsgStartDelayTime" BO_ 2366636032 75;
BA_ "GenMsgCycleTime" BO_ 2366636032 500;
BA_ "GenMsgSendType" BO_ 2366636032 0;
    */
    _CHASSIS_HMI_DTR_R2_AR_Timebase =      c_tDBKomTimer_20ms;
    _CHASSIS_HMI_DTR_R2_AR_CycleCount =   100 / _CHASSIS_HMI_DTR_R2_AR_Timebase;
    _CHASSIS_HMI_DTR_R2_AR_StartDelay =      75 / _CHASSIS_HMI_DTR_R2_AR_Timebase;
    _CHASSIS_HMI_DTR_R2_AR_Cnt = _CHASSIS_HMI_DTR_R2_AR_StartDelay;
    _CHASSIS_HMI_DTR_R2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CHASSIS_HMI_DTR_R2_AR, _CHASSIS_HMI_DTR_R2_AR_StartDelay * _CHASSIS_HMI_DTR_R2_AR_Timebase );

    _mCHASSIS_HMI_DTR_R2_AR.DTR_LaneHrztCrv.phys = getValue( HMI_DTR_LaneHrztCrv );
    _mCHASSIS_HMI_DTR_R2_AR.DTR_LaneYawAngl.phys = getValue( HMI_DTR_LaneYawAngl );
    _mCHASSIS_HMI_DTR_R2_AR.DTR_Obj_TmDelay.phys = getValue( HMI_DTR_Obj_TmDelay );
	_mCHASSIS_HMI_DTR_R2_AR.DTR_ObjStat_UB.phys = getValue( HMI_DTR_ObjStat_UB );
    _mCHASSIS_HMI_DTR_R2_AR.EM01_DC_Curr.phys = getValue( HMI_EM01_DC_Curr );

}

CHASSIS_HMI_DTR_R2_AR_output(void)
{
    output( _mCHASSIS_HMI_DTR_R2_AR );
}

CHASSIS_HMI_DTR_R2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: CHASSIS_HMI_DTR_R2_AR_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CHASSIS_HMI_DTR_R2_AR := %X\n", getValue( HMI__STMSG_CHASSIS_HMI_DTR_R2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CHASSIS_HMI_DTR_R2_AR := %X\n", getValue( HMI__STMSGT_CHASSIS_HMI_DTR_R2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_LaneHrztCrv  := %X\n", getValue( HMI_DTR_LaneHrztCrv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_LaneYawAngl  := %X\n", getValue( HMI_DTR_LaneYawAngl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_Obj_TmDelay  := %X\n", getValue( HMI_DTR_Obj_TmDelay ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_ObjStat_UB  := %X\n", getValue( HMI_DTR_ObjStat_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EM01_DC_Curr  := %X\n", getValue( HMI_EM01_DC_Curr ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tCHASSIS_HMI_DTR_R2_AR
{
    putValue( HMI__STMSG_CHASSIS_HMI_DTR_R2_AR, 0 );
}

on EnvVar HMI__STMSG_CHASSIS_HMI_DTR_R2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CHASSIS_HMI_DTR_R2_AR );
        if( tDelay > 0)    
            setTimer( _tCHASSIS_HMI_DTR_R2_AR, tDelay );
        else
            putValue( HMI__STMSG_CHASSIS_HMI_DTR_R2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_CHASSIS_HMI_DTR_R2_AR
{
    if( getValue( this ) )
        openPanel("CHASSIS_HMI_DTR_R2_AR");
}

on EnvVar HMI_DTR_LaneHrztCrv
{
    _mCHASSIS_HMI_DTR_R2_AR.DTR_LaneHrztCrv.phys = getValue(this);
}

on EnvVar HMI_DTR_LaneYawAngl
{
    _mCHASSIS_HMI_DTR_R2_AR.DTR_LaneYawAngl.phys = getValue(this);
}

on EnvVar HMI_DTR_Obj_TmDelay
{
    _mCHASSIS_HMI_DTR_R2_AR.DTR_Obj_TmDelay.phys = getValue(this);
}

on EnvVar HMI_DTR_ObjStat_UB
{
    _mCHASSIS_HMI_DTR_R2_AR.DTR_ObjStat_UB.phys = getValue(this);
}

on EnvVar HMI_EM01_DC_Curr
{
    _mCHASSIS_HMI_DTR_R2_AR.EM01_DC_Curr.phys = getValue(this);
}

HAD_MDC_CamLane_MapLrn_Attr1_AR_check_output()
{
    if( !getValue( HMI__STMSG_HAD_MDC_CamLane_MapLrn_Attr1_AR ) )
    {
    //  message   HAD_MDC_CamLane_MapLrn_Attr1_AR ID: 2434793472 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _HAD_MDC_CamLane_MapLrn_Attr1_AR_Cnt--;
        if( _HAD_MDC_CamLane_MapLrn_Attr1_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            HAD_MDC_CamLane_MapLrn_Attr1_AR_output();
            _HAD_MDC_CamLane_MapLrn_Attr1_AR_Cnt = _HAD_MDC_CamLane_MapLrn_Attr1_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _HAD_MDC_CamLane_MapLrn_Attr1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _HAD_MDC_CamLane_MapLrn_Attr1_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            HAD_MDC_CamLane_MapLrn_Attr1_AR_output();
            _HAD_MDC_CamLane_MapLrn_Attr1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

HAD_MDC_CamLane_MapLrn_Attr1_AR_init()
{   /* Botschaft HAD_MDC_CamLane_MapLrn_Attr1_AR ID: 2434793472 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 2434793472 0;
BA_ "NmAsrMessage" BO_ 2434793472 0;
BA_ "GenMsgMinAcceptLength" BO_ 2434793472 8;
BA_ "GenMsgILSupport" BO_ 2434793472 1;
BA_ "DiagState" BO_ 2434793472 0;
BA_ "DiagRequest" BO_ 2434793472 0;
BA_ "DiagResponse" BO_ 2434793472 0;
BA_ "GenMsgStartValue" BO_ 2434793472 "0";
BA_ "GenMsgStartDelayTime" BO_ 2434793472 0;
BA_ "GenMsgDelayTime" BO_ 2434793472 5;
BA_ "GenMsgNrOfRepetitions" BO_ 2434793472 0;
BA_ "GenMsgCycleTime" BO_ 2434793472 500;
BA_ "GenMsgSendType" BO_ 2434793472 5;
    */
    _HAD_MDC_CamLane_MapLrn_Attr1_AR_Timebase =         c_tDBKomTimer_20ms;
    _HAD_MDC_CamLane_MapLrn_Attr1_AR_CycleCount =     500 / _HAD_MDC_CamLane_MapLrn_Attr1_AR_Timebase;
    _HAD_MDC_CamLane_MapLrn_Attr1_AR_StartDelay =       0 / _HAD_MDC_CamLane_MapLrn_Attr1_AR_Timebase;
    _HAD_MDC_CamLane_MapLrn_Attr1_AR_Cnt = _HAD_MDC_CamLane_MapLrn_Attr1_AR_StartDelay;
    _HAD_MDC_CamLane_MapLrn_Attr1_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_HAD_MDC_CamLane_MapLrn_Attr1_AR, _HAD_MDC_CamLane_MapLrn_Attr1_AR_StartDelay * _HAD_MDC_CamLane_MapLrn_Attr1_AR_Timebase );

    _mHAD_MDC_CamLane_MapLrn_Attr1_AR.HAD_MDC_CamLane_MapLrn_LnMarkTyp_Mismtch.phys = getValue( HMI_HAD_MDC_CamLane_MapLrn_LnMarkTyp_Mismtch );
    _mHAD_MDC_CamLane_MapLrn_Attr1_AR.HAD_MDC_CamLane_MapLrn_LnMarkWidth_Mismtch.phys = getValue( HMI_HAD_MDC_CamLane_MapLrn_LnMarkWidth_Mismtch );
    _mHAD_MDC_CamLane_MapLrn_Attr1_AR.HAD_MDC_CamLane_MapLrn_LnWidth_Mismtch.phys = getValue( HMI_HAD_MDC_CamLane_MapLrn_LnWidth_Mismtch );
    _mHAD_MDC_CamLane_MapLrn_Attr1_AR.HAD_MDC_CamLane_MapLrn_TmStmp.phys = getValue( HMI_HAD_MDC_CamLane_MapLrn_TmStmp );
    _mHAD_MDC_CamLane_MapLrn_Attr1_AR.HAD_MDC_LocalObj_ID3.phys = getValue( HMI_HAD_MDC_LocalObj_ID3 );
    _mHAD_MDC_CamLane_MapLrn_Attr1_AR.HAD_MDC_LocalObj_PosXY_CorrCoeff.phys = getValue( HMI_HAD_MDC_LocalObj_PosXY_CorrCoeff );
	_mHAD_MDC_CamLane_MapLrn_Attr1_AR.HAD_MDC_LocalObj_PosXZ_CorrCoeff.phys = getValue( HMI_HAD_MDC_LocalObj_PosXZ_CorrCoeff );
	_mHAD_MDC_CamLane_MapLrn_Attr1_AR.HAD_MDC_LocalObj_PosYZ_CorrCoeff.phys = getValue( HMI_HAD_MDC_LocalObj_PosYZ_CorrCoeff );
    
}

HAD_MDC_CamLane_MapLrn_Attr1_AR_output(void)
{
    output( _mHAD_MDC_CamLane_MapLrn_Attr1_AR );
}

HAD_MDC_CamLane_MapLrn_Attr1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: HAD_MDC_CamLane_MapLrn_Attr1_AR\n", 27, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_HAD_MDC_CamLane_MapLrn_Attr1_AR := %X\n", getValue( HMI__STMSG_HAD_MDC_CamLane_MapLrn_Attr1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_HAD_MDC_CamLane_MapLrn_Attr1_AR := %X\n", getValue( HMI__STMSGT_HAD_MDC_CamLane_MapLrn_Attr1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_CamLane_MapLrn_LnMarkTyp_Mismtch := %X\n", getValue( HMI_HAD_MDC_CamLane_MapLrn_LnMarkTyp_Mismtch ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_CamLane_MapLrn_LnMarkWidth_Mismtch := %X\n", getValue( HMI_HAD_MDC_CamLane_MapLrn_LnMarkWidth_Mismtch ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_CamLane_MapLrn_LnWidth_Mismtch := %X\n", getValue( HMI_HAD_MDC_CamLane_MapLrn_LnWidth_Mismtch ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_CamLane_MapLrn_TmStmp := %X\n", getValue( HMI_HAD_MDC_CamLane_MapLrn_TmStmp ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_LocalObj_ID3 := %X\n", getValue( HMI_HAD_MDC_LocalObj_ID3 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_LocalObj_PosXY_CorrCoeff := %X\n", getValue( HMI_HAD_MDC_LocalObj_PosXY_CorrCoeff ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_LocalObj_PosXZ_CorrCoeff := %X\n", getValue( HMI_HAD_MDC_LocalObj_PosXZ_CorrCoeff ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_LocalObj_PosYZ_CorrCoeff := %X\n", getValue( HMI_HAD_MDC_LocalObj_PosYZ_CorrCoeff ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tHAD_MDC_CamLane_MapLrn_Attr1_AR
{
    putValue( HMI__STMSG_HAD_MDC_CamLane_MapLrn_Attr1_AR, 0 );
}

on EnvVar HMI__STMSG_HAD_MDC_CamLane_MapLrn_Attr1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_HAD_MDC_CamLane_MapLrn_Attr1_AR );
        if( tDelay > 0)    
            setTimer( _tHAD_MDC_CamLane_MapLrn_Attr1_AR, tDelay );
        else
            putValue( HMI__STMSG_HAD_MDC_CamLane_MapLrn_Attr1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_HAD_MDC_CamLane_MapLrn_Attr1_AR
{
    if( getValue( this ) )
        openPanel("HAD_MDC_CamLane_MapLrn_Attr1_AR");
}

on EnvVar HMI_HAD_MDC_CamLane_MapLrn_LnMarkTyp_Mismtch
{
    _mHAD_MDC_CamLane_MapLrn_Attr1_AR.HAD_MDC_CamLane_MapLrn_LnMarkTyp_Mismtch.phys = getValue(this);
    _HAD_MDC_CamLane_MapLrn_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_CamLane_MapLrn_LnMarkWidth_Mismtch
{
    _mHAD_MDC_CamLane_MapLrn_Attr1_AR.HAD_MDC_CamLane_MapLrn_LnMarkWidth_Mismtch.phys = getValue(this);
    _HAD_MDC_CamLane_MapLrn_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_CamLane_MapLrn_LnWidth_Mismtch
{
    _mHAD_MDC_CamLane_MapLrn_Attr1_AR.HAD_MDC_CamLane_MapLrn_LnWidth_Mismtch.phys = getValue(this);
    _HAD_MDC_CamLane_MapLrn_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_CamLane_MapLrn_TmStmp
{
    _mHAD_MDC_CamLane_MapLrn_Attr1_AR.HAD_MDC_CamLane_MapLrn_TmStmp.phys = getValue(this);
    _HAD_MDC_CamLane_MapLrn_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_LocalObj_ID3
{
    _mHAD_MDC_CamLane_MapLrn_Attr1_AR.HAD_MDC_LocalObj_ID3.phys = getValue(this);
    _HAD_MDC_CamLane_MapLrn_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_LocalObj_PosXY_CorrCoeff
{
    _mHAD_MDC_CamLane_MapLrn_Attr1_AR.HAD_MDC_LocalObj_PosXY_CorrCoeff.phys = getValue(this);
    _HAD_MDC_CamLane_MapLrn_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_LocalObj_PosXZ_CorrCoeff
{
    _mHAD_MDC_CamLane_MapLrn_Attr1_AR.HAD_MDC_LocalObj_PosXZ_CorrCoeff.phys = getValue(this);
    _HAD_MDC_CamLane_MapLrn_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_LocalObj_PosYZ_CorrCoeff
{
    _mHAD_MDC_CamLane_MapLrn_Attr1_AR.HAD_MDC_LocalObj_PosYZ_CorrCoeff.phys = getValue(this);
    _HAD_MDC_CamLane_MapLrn_Attr1_AR_SpontanFlag = 1;
}

HAD_MDC_CamObj_MapLrn_Attr1_AR_check_output()
{
    if( !getValue( HMI__STMSG_HAD_MDC_CamObj_MapLrn_Attr1_AR ) )
    {
    //  message   HAD_MDC_CamObj_MapLrn_Attr1_AR ID: 2371092480 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _HAD_MDC_CamObj_MapLrn_Attr1_AR_Cnt--;
        if( _HAD_MDC_CamObj_MapLrn_Attr1_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            HAD_MDC_CamObj_MapLrn_Attr1_AR_output();
            _HAD_MDC_CamObj_MapLrn_Attr1_AR_Cnt = _HAD_MDC_CamObj_MapLrn_Attr1_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _HAD_MDC_CamObj_MapLrn_Attr1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _HAD_MDC_CamObj_MapLrn_Attr1_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            HAD_MDC_CamObj_MapLrn_Attr1_AR_output();
            _HAD_MDC_CamObj_MapLrn_Attr1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

HAD_MDC_CamObj_MapLrn_Attr1_AR_init()
{   /* Botschaft HAD_MDC_CamObj_MapLrn_Attr1_AR ID: 2371092480 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 2371092480 0;
BA_ "NmAsrMessage" BO_ 2371092480 0;
BA_ "GenMsgMinAcceptLength" BO_ 2371092480 8;
BA_ "GenMsgILSupport" BO_ 2371092480 1;
BA_ "DiagState" BO_ 2371092480 0;
BA_ "DiagRequest" BO_ 2371092480 0;
BA_ "DiagResponse" BO_ 2371092480 0;
BA_ "GenMsgStartValue" BO_ 2371092480 "0";
BA_ "GenMsgStartDelayTime" BO_ 2371092480 0;
BA_ "GenMsgDelayTime" BO_ 2371092480 5;
BA_ "GenMsgNrOfRepetitions" BO_ 2371092480 0;
BA_ "GenMsgCycleTime" BO_ 2371092480 500;
BA_ "GenMsgSendType" BO_ 2371092480 5;
    */
    _HAD_MDC_CamObj_MapLrn_Attr1_AR_Timebase =         c_tDBKomTimer_20ms;
    _HAD_MDC_CamObj_MapLrn_Attr1_AR_CycleCount =     500 / _HAD_MDC_CamObj_MapLrn_Attr1_AR_Timebase;
    _HAD_MDC_CamObj_MapLrn_Attr1_AR_StartDelay =       0 / _HAD_MDC_CamObj_MapLrn_Attr1_AR_Timebase;
    _HAD_MDC_CamObj_MapLrn_Attr1_AR_Cnt = _HAD_MDC_CamObj_MapLrn_Attr1_AR_StartDelay;
    _HAD_MDC_CamObj_MapLrn_Attr1_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_HAD_MDC_CamObj_MapLrn_Attr1_AR, _HAD_MDC_CamObj_MapLrn_Attr1_AR_StartDelay * _HAD_MDC_CamObj_MapLrn_Attr1_AR_Timebase );

    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapEvent_ObstclOnShldr_Dtct.phys = getValue( HMI_HAD_MDC_CamObj_MapEvent_ObstclOnShldr_Dtct );
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapEvent_PplOnRoadway_Dtct.phys = getValue( HMI_HAD_MDC_CamObj_MapEvent_PplOnRoadway_Dtct );
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapEvent_RoadWork_Dtct.phys = getValue( HMI_HAD_MDC_CamObj_MapEvent_RoadWork_Dtct );
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapEvent_WrongWayDrv_Dtct.phys = getValue( HMI_HAD_MDC_CamObj_MapEvent_WrongWayDrv_Dtct );
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapLrn_LnEnd.phys = getValue( HMI_HAD_MDC_CamObj_MapLrn_LnEnd );
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapLrn_LnEnd_Mismtch.phys = getValue( HMI_HAD_MDC_CamObj_MapLrn_LnEnd_Mismtch );
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapLrn_TmStmp.phys = getValue( HMI_HAD_MDC_CamObj_MapLrn_TmStmp );
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapLrn_Tunnel_Dist.phys = getValue( HMI_HAD_MDC_CamObj_MapLrn_Tunnel_Dist );
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapLrn_Tunnel_Mismtch.phys = getValue( HMI_HAD_MDC_CamObj_MapLrn_Tunnel_Mismtch );
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapLrn_VsblRng.phys = getValue( HMI_HAD_MDC_CamObj_MapLrn_VsblRng );
}

HAD_MDC_CamObj_MapLrn_Attr1_AR_output(void)
{
    output( _mHAD_MDC_CamObj_MapLrn_Attr1_AR );
}

HAD_MDC_CamObj_MapLrn_Attr1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: BC_F_Stat2_AR\n", 27, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_HAD_MDC_CamObj_MapLrn_Attr1_AR := %X\n", getValue( HMI__STMSG_HAD_MDC_CamObj_MapLrn_Attr1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_HAD_MDC_CamObj_MapLrn_Attr1_AR := %X\n", getValue( HMI__STMSGT_HAD_MDC_CamObj_MapLrn_Attr1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_CamObj_MapEvent_ObstclOnShldr_Dtct := %X\n", getValue( HMI_HAD_MDC_CamObj_MapEvent_ObstclOnShldr_Dtct ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_CamObj_MapEvent_PplOnRoadway_Dtct := %X\n", getValue( HMI_HAD_MDC_CamObj_MapEvent_PplOnRoadway_Dtct ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_CamObj_MapEvent_RoadWork_Dtct := %X\n", getValue( HMI_HAD_MDC_CamObj_MapEvent_RoadWork_Dtct ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_CamObj_MapEvent_WrongWayDrv_Dtct := %X\n", getValue( HMI_HAD_MDC_CamObj_MapEvent_WrongWayDrv_Dtct ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_CamObj_MapLrn_LnEnd := %X\n", getValue( HMI_HAD_MDC_CamObj_MapLrn_LnEnd ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_CamObj_MapLrn_LnEnd_Mismtch := %X\n", getValue( HMI_HAD_MDC_CamObj_MapLrn_LnEnd_Mismtch ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_CamObj_MapLrn_TmStmp := %X\n", getValue( HMI_HAD_MDC_CamObj_MapLrn_TmStmp ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_CamObj_MapLrn_Tunnel_Dist := %X\n", getValue( HMI_HAD_MDC_CamObj_MapLrn_Tunnel_Dist ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_CamObj_MapLrn_Tunnel_Mismtch := %X\n", getValue( HMI_HAD_MDC_CamObj_MapLrn_Tunnel_Mismtch ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_CamObj_MapLrn_VsblRng := %X\n", getValue( HMI_HAD_MDC_CamObj_MapLrn_VsblRng) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tHAD_MDC_CamObj_MapLrn_Attr1_AR
{
    putValue( HMI__STMSG_HAD_MDC_CamObj_MapLrn_Attr1_AR, 0 );
}

on EnvVar HMI__STMSG_HAD_MDC_CamObj_MapLrn_Attr1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_HAD_MDC_CamObj_MapLrn_Attr1_AR );
        if( tDelay > 0)    
            setTimer( _tHAD_MDC_CamObj_MapLrn_Attr1_AR, tDelay );
        else
            putValue( HMI__STMSG_HAD_MDC_CamObj_MapLrn_Attr1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_HAD_MDC_CamObj_MapLrn_Attr1_AR
{
    if( getValue( this ) )
        openPanel("HAD_MDC_CamObj_MapLrn_Attr1_AR");
}

on EnvVar HMI_HAD_MDC_CamObj_MapEvent_ObstclOnShldr_Dtct
{
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapEvent_ObstclOnShldr_Dtct.phys = getValue(this);
    _HAD_MDC_CamObj_MapLrn_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_CamObj_MapEvent_PplOnRoadway_Dtct
{
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapEvent_PplOnRoadway_Dtct.phys = getValue(this);
    _HAD_MDC_CamObj_MapLrn_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_CamObj_MapEvent_RoadWork_Dtct
{
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapEvent_RoadWork_Dtct.phys = getValue(this);
    _HAD_MDC_CamObj_MapLrn_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_CamObj_MapEvent_WrongWayDrv_Dtct
{
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapEvent_WrongWayDrv_Dtct.phys = getValue(this);
    _HAD_MDC_CamObj_MapLrn_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_CamObj_MapLrn_LnEnd
{
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapLrn_LnEnd.phys = getValue(this);
    _HAD_MDC_CamObj_MapLrn_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_CamObj_MapLrn_LnEnd_Mismtch
{
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapLrn_LnEnd_Mismtch.phys = getValue(this);
    _HAD_MDC_CamObj_MapLrn_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_CamObj_MapLrn_TmStmp
{
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapLrn_TmStmp.phys = getValue(this);
    _HAD_MDC_CamObj_MapLrn_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_CamObj_MapLrn_Tunnel_Dist
{
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapLrn_Tunnel_Dist.phys = getValue(this);
    _HAD_MDC_CamObj_MapLrn_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_CamObj_MapLrn_Tunnel_Mismtch
{
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapLrn_Tunnel_Mismtch.phys = getValue(this);
    _HAD_MDC_CamObj_MapLrn_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_CamObj_MapLrn_VsblRng
{
    _mHAD_MDC_CamObj_MapLrn_Attr1_AR.HAD_MDC_CamObj_MapLrn_VsblRng.phys = getValue(this);
    _HAD_MDC_CamObj_MapLrn_Attr1_AR_SpontanFlag = 1;
}

HAD_MDC_MapData2_AR_check_output()
{
    if( !getValue( HMI__STMSG_HAD_MDC_MapData2_AR ) )
    {
    //  message   HAD_MDC_MapData2_AR ID: 2371354624 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _HAD_MDC_MapData2_AR_Cnt--;
        if( _HAD_MDC_MapData2_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            HAD_MDC_MapData2_AR_output();
            _HAD_MDC_MapData2_AR_Cnt = _HAD_MDC_MapData2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _HAD_MDC_MapData2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _HAD_MDC_MapData2_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            HAD_MDC_MapData2_AR_output();
            _HAD_MDC_MapData2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

HAD_MDC_MapData2_AR_init()
{   /* Botschaft HAD_MDC_MapData2_AR ID: 2371354624 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 2371354624 0;
BA_ "NmAsrMessage" BO_ 2371354624 0;
BA_ "GenMsgMinAcceptLength" BO_ 2371354624 8;
BA_ "GenMsgILSupport" BO_ 2371354624 1;
BA_ "DiagState" BO_ 2371354624 0;
BA_ "DiagRequest" BO_ 2371354624 0;
BA_ "DiagResponse" BO_ 2371354624 0;
BA_ "GenMsgStartValue" BO_ 2371354624 "0";
BA_ "GenMsgStartDelayTime" BO_ 2371354624 0;
BA_ "GenMsgDelayTime" BO_ 2371354624 5;
BA_ "GenMsgNrOfRepetitions" BO_ 2371354624 0;
BA_ "GenMsgCycleTime" BO_ 2371354624 500;
BA_ "GenMsgSendType" BO_ 2371354624 5;
    */
    _HAD_MDC_MapData2_AR_Timebase =         c_tDBKomTimer_20ms;
    _HAD_MDC_MapData2_AR_CycleCount =     500 / _HAD_MDC_MapData2_AR_Timebase;
    _HAD_MDC_MapData2_AR_StartDelay =       0 / _HAD_MDC_MapData2_AR_Timebase;
    _HAD_MDC_MapData2_AR_Cnt = _HAD_MDC_MapData2_AR_StartDelay;
    _HAD_MDC_MapData2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_HAD_MDC_MapData2_AR, _HAD_MDC_MapData2_AR_StartDelay * _HAD_MDC_MapData2_AR_Timebase );

    _mHAD_MDC_MapData2_AR.HAD_MDC_MapEvent_ObstclOnShldr_Dtct.phys = getValue( HMI_HAD_MDC_MapEvent_ObstclOnShldr_Dtct );
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapEvent_PplOnRoadway_Dtct.phys = getValue( HMI_HAD_MDC_MapEvent_PplOnRoadway_Dtct );
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapEvent_RoadWork_Dtct.phys = getValue( HMI_HAD_MDC_MapEvent_RoadWork_Dtct );
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapEvent_WrongWayDrv_Dtct.phys = getValue( HMI_HAD_MDC_MapEvent_WrongWayDrv_Dtct );
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapLrn_LnGeom.phys = getValue( HMI_HAD_MDC_MapLrn_LnGeom );
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapLrn_LnMarkType_Mismtch.phys = getValue( HMI_HAD_MDC_MapLrn_LnMarkType_Mismtch );
        _mHAD_MDC_MapData2_AR.HAD_MDC_MapLrn_LnMarkWidth_Mismtch.phys = getValue( HMI_HAD_MDC_MapLrn_LnMarkWidth_Mismtch );
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapLrn_LnWidth_Mismtch.phys = getValue( HMI_HAD_MDC_MapLrn_LnWidth_Mismtch );
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapLrn_TmStmp.phys = getValue( HMI_HAD_MDC_MapLrn_TmStmp );
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapLrn_Underdrivable_Dist_X.phys = getValue( HMI_HAD_MDC_MapLrn_Underdrivable_Dist_X );
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapLrn_Underdrivable_Dist_Y.phys = getValue( HMI_HAD_MDC_MapLrn_Underdrivable_Dist_Y );
}
HAD_MDC_MapData2_AR_output(void)
{
    output( _mHAD_MDC_MapData2_AR );
}

HAD_MDC_MapData2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: BC_F_Stat2_AR\n", 27, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_HAD_MDC_MapData2_AR := %X\n", getValue( HMI__STMSG_HAD_MDC_MapData2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_HAD_MDC_MapData2_AR := %X\n", getValue( HMI__STMSGT_HAD_MDC_MapData2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_MapEvent_ObstclOnShldr_Dtct := %X\n", getValue( HMI_HAD_MDC_MapEvent_ObstclOnShldr_Dtct ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_MapEvent_PplOnRoadway_Dtct := %X\n", getValue( HMI_HAD_MDC_MapEvent_PplOnRoadway_Dtct ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_MapEvent_RoadWork_Dtct := %X\n", getValue( HMI_HAD_MDC_MapEvent_RoadWork_Dtct ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_MapEvent_WrongWayDrv_Dtct := %X\n", getValue( HMI_HAD_MDC_MapEvent_WrongWayDrv_Dtct ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_MapLrn_LnGeom := %X\n", getValue( HMI_HAD_MDC_MapLrn_LnGeom ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_MapLrn_LnMarkType_Mismtch := %X\n", getValue( HMI_HAD_MDC_MapLrn_LnMarkType_Mismtch ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_MapLrn_LnMarkWidth_Mismtch := %X\n", getValue( HMI_HAD_MDC_MapLrn_LnMarkWidth_Mismtch ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_MapLrn_LnWidth_Mismtch := %X\n", getValue( HMI_HAD_MDC_MapLrn_LnWidth_Mismtch ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_MapLrn_TmStmp := %X\n", getValue( HMI_HAD_MDC_MapLrn_TmStmp ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_MapLrn_Underdrivable_Dist_X := %X\n", getValue( HMI_HAD_MDC_MapLrn_Underdrivable_Dist_X ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_MapLrn_Underdrivable_Dist_Y := %X\n", getValue( HMI_HAD_MDC_MapLrn_Underdrivable_Dist_Y ) );        filePutString ( buffer, elcount( buffer ), hFile );

}

on timer _tHAD_MDC_MapData2_AR
{
    putValue( HMI__STMSG_HAD_MDC_MapData2_AR, 0 );
}

on EnvVar HMI__STMSG_HAD_MDC_MapData2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_HAD_MDC_MapData2_AR );
        if( tDelay > 0)    
            setTimer( _tHAD_MDC_MapData2_AR, tDelay );
        else
            putValue( HMI__STMSG_HAD_MDC_MapData2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_HAD_MDC_MapData2_AR
{
    if( getValue( this ) )
        openPanel("HAD_MDC_MapData2_AR");
}

on EnvVar HMI_HAD_MDC_MapEvent_ObstclOnShldr_Dtct
{
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapEvent_ObstclOnShldr_Dtct.phys = getValue(this);
    _HAD_MDC_MapData2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_MapEvent_PplOnRoadway_Dtct
{
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapEvent_PplOnRoadway_Dtct.phys = getValue(this);
    _HAD_MDC_MapData2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_MapEvent_RoadWork_Dtct
{
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapEvent_RoadWork_Dtct.phys = getValue(this);
    _HAD_MDC_MapData2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_MapEvent_WrongWayDrv_Dtct
{
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapEvent_WrongWayDrv_Dtct.phys = getValue(this);
    _HAD_MDC_MapData2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_MapLrn_TmStmp
{
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapLrn_TmStmp.phys = getValue(this);
    _HAD_MDC_MapData2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_MapLrn_LnGeom
{
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapLrn_LnGeom.phys = getValue(this);
    _HAD_MDC_MapData2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_MapLrn_LnMarkType_Mismtch
{
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapLrn_LnMarkType_Mismtch.phys = getValue(this);
    _HAD_MDC_MapData2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_MapLrn_LnMarkWidth_Mismtch
{
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapLrn_LnMarkWidth_Mismtch.phys = getValue(this);
    _HAD_MDC_MapData2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_MapLrn_LnWidth_Mismtch
{
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapLrn_LnWidth_Mismtch.phys = getValue(this);
    _HAD_MDC_MapData2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_MapLrn_Underdrivable_Dist_X
{
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapLrn_Underdrivable_Dist_X.phys = getValue(this);
    _HAD_MDC_MapData2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_MapLrn_Underdrivable_Dist_Y
{
    _mHAD_MDC_MapData2_AR.HAD_MDC_MapLrn_Underdrivable_Dist_Y.phys = getValue(this);
    _HAD_MDC_MapData2_AR_SpontanFlag = 1;
}

HAD_MDC_MapLrn_Attr1_AR_check_output()
{
    if( !getValue( HMI__STMSG_HAD_MDC_MapLrn_Attr1_AR ) )
    {
    //  message   HAD_MDC_MapLrn_Attr1_AR ID: 2431647744 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _HAD_MDC_MapLrn_Attr1_AR_Cnt--;
        if( _HAD_MDC_MapLrn_Attr1_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            HAD_MDC_MapLrn_Attr1_AR_output();
            _HAD_MDC_MapLrn_Attr1_AR_Cnt = _HAD_MDC_MapLrn_Attr1_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _HAD_MDC_MapLrn_Attr1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _HAD_MDC_MapLrn_Attr1_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            HAD_MDC_MapLrn_Attr1_AR_output();
            _HAD_MDC_MapLrn_Attr1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

HAD_MDC_MapLrn_Attr1_AR_init()
{   /* Botschaft HAD_MDC_MapLrn_Attr1_AR ID: 2431647744 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 2431647744 0;
BA_ "NmAsrMessage" BO_ 2431647744 0;
BA_ "GenMsgMinAcceptLength" BO_ 2431647744 8;
BA_ "GenMsgILSupport" BO_ 2431647744 1;
BA_ "DiagState" BO_ 2431647744 0;
BA_ "DiagRequest" BO_ 2431647744 0;
BA_ "DiagResponse" BO_ 2431647744 0;
BA_ "GenMsgStartValue" BO_ 2431647744 "0";
BA_ "GenMsgStartDelayTime" BO_ 2431647744 0;
BA_ "GenMsgDelayTime" BO_ 2431647744 5;
BA_ "GenMsgNrOfRepetitions" BO_ 2431647744 0;
BA_ "GenMsgCycleTime" BO_ 2431647744 500;
BA_ "GenMsgSendType" BO_ 2431647744 5;
    */
    _HAD_MDC_MapLrn_Attr1_AR_Timebase =         c_tDBKomTimer_20ms;
    _HAD_MDC_MapLrn_Attr1_AR_CycleCount =     500 / _HAD_MDC_MapLrn_Attr1_AR_Timebase;
    _HAD_MDC_MapLrn_Attr1_AR_StartDelay =       0 / _HAD_MDC_MapLrn_Attr1_AR_Timebase;
    _HAD_MDC_MapLrn_Attr1_AR_Cnt = _HAD_MDC_MapLrn_Attr1_AR_StartDelay;
    _HAD_MDC_MapLrn_Attr1_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_HAD_MDC_MapLrn_Attr1_AR, _HAD_MDC_MapLrn_Attr1_AR_StartDelay * _HAD_MDC_MapLrn_Attr1_AR_Timebase );

    _mHAD_MDC_MapLrn_Attr1_AR.HAD_MDC_MapLrn_Border_Density_Lt.phys = getValue( HMI_HAD_MDC_MapLrn_Border_Density_Lt );
    _mHAD_MDC_MapLrn_Attr1_AR.HAD_MDC_MapLrn_Border_Density_Rt.phys = getValue( HMI_HAD_MDC_MapLrn_Border_Density_Rt );
    _mHAD_MDC_MapLrn_Attr1_AR.HAD_MDC_MapLrn_LnHrztCrv_Variance.phys = getValue( HMI_HAD_MDC_MapLrn_LnHrztCrv_Variance );
}

HAD_MDC_MapLrn_Attr1_AR_output(void)
{
    output( _mHAD_MDC_MapLrn_Attr1_AR );
}

HAD_MDC_MapLrn_Attr1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: HAD_MDC_MapLrn_Attr1_AR\n", 27, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_HAD_MDC_MapLrn_Attr1_AR := %X\n", getValue( HMI__STMSG_HAD_MDC_MapLrn_Attr1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_HAD_MDC_MapLrn_Attr1_AR := %X\n", getValue( HMI__STMSGT_HAD_MDC_MapLrn_Attr1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_MapLrn_Border_Density_Lt := %X\n", getValue( HMI_HAD_MDC_MapLrn_Border_Density_Lt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_MapLrn_Border_Density_Rt := %X\n", getValue( HMI_HAD_MDC_MapLrn_Border_Density_Rt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_MapLrn_LnHrztCrv_Variance := %X\n", getValue( HMI_HAD_MDC_MapLrn_LnHrztCrv_Variance ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tHAD_MDC_MapLrn_Attr1_AR
{
    putValue( HMI__STMSG_HAD_MDC_MapLrn_Attr1_AR, 0 );
}

on EnvVar HMI__STMSG_HAD_MDC_MapLrn_Attr1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_HAD_MDC_MapLrn_Attr1_AR );
        if( tDelay > 0)    
            setTimer( _tHAD_MDC_MapLrn_Attr1_AR, tDelay );
        else
            putValue( HMI__STMSG_HAD_MDC_MapLrn_Attr1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_HAD_MDC_MapLrn_Attr1_AR
{
    if( getValue( this ) )
        openPanel("HAD_MDC_MapLrn_Attr1_AR");
}

on EnvVar HMI_HAD_MDC_MapLrn_Border_Density_Lt
{
    _mHAD_MDC_MapLrn_Attr1_AR.HAD_MDC_MapLrn_Border_Density_Lt.phys = getValue(this);
    _HAD_MDC_MapLrn_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_MapLrn_Border_Density_Rt
{
    _mHAD_MDC_MapLrn_Attr1_AR.HAD_MDC_MapLrn_Border_Density_Rt.phys = getValue(this);
    _HAD_MDC_MapLrn_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_MapLrn_LnHrztCrv_Variance
{
    _mHAD_MDC_MapLrn_Attr1_AR.HAD_MDC_MapLrn_LnHrztCrv_Variance.phys = getValue(this);
    _HAD_MDC_MapLrn_Attr1_AR_SpontanFlag = 1;
}

HAD_MDC_TSR_Sign_Attr1_AR_check_output()
{
    if( !getValue( HMI__STMSG_HAD_MDC_TSR_Sign_Attr1_AR ) )
    {
    //  message   HAD_MDC_TSR_Sign_Attr1_AR ID: 1040 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _HAD_MDC_TSR_Sign_Attr1_AR_Cnt--;
        if( _HAD_MDC_TSR_Sign_Attr1_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            HAD_MDC_TSR_Sign_Attr1_AR_output();
            _HAD_MDC_TSR_Sign_Attr1_AR_Cnt = _HAD_MDC_TSR_Sign_Attr1_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _HAD_MDC_TSR_Sign_Attr1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _HAD_MDC_TSR_Sign_Attr1_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            HAD_MDC_TSR_Sign_Attr1_AR_output();
            _HAD_MDC_TSR_Sign_Attr1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

HAD_MDC_TSR_Sign_Attr1_AR_init()
{   /* Botschaft HAD_MDC_TSR_Sign_Attr1_AR ID: 1040 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1040 0;
BA_ "NmAsrMessage" BO_ 1040 0;
BA_ "GenMsgMinAcceptLength" BO_ 1040 8;
BA_ "GenMsgILSupport" BO_ 1040 1;
BA_ "DiagState" BO_ 1040 0;
BA_ "DiagRequest" BO_ 1040 0;
BA_ "DiagResponse" BO_ 1040 0;
BA_ "GenMsgStartValue" BO_ 1040 "0";
BA_ "GenMsgStartDelayTime" BO_ 1040 0;
BA_ "GenMsgDelayTime" BO_ 1040 5;
BA_ "GenMsgNrOfRepetitions" BO_ 1040 0;
BA_ "GenMsgCycleTime" BO_ 1040 500;
BA_ "GenMsgSendType" BO_ 1040 5;
    */
    _HAD_MDC_TSR_Sign_Attr1_AR_Timebase =         c_tDBKomTimer_20ms;
    _HAD_MDC_TSR_Sign_Attr1_AR_CycleCount =     500 / _HAD_MDC_TSR_Sign_Attr1_AR_Timebase;
    _HAD_MDC_TSR_Sign_Attr1_AR_StartDelay =       0 / _HAD_MDC_TSR_Sign_Attr1_AR_Timebase;
    _HAD_MDC_TSR_Sign_Attr1_AR_Cnt = _HAD_MDC_TSR_Sign_Attr1_AR_StartDelay;
    _HAD_MDC_TSR_Sign_Attr1_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_HAD_MDC_TSR_Sign_Attr1_AR, _HAD_MDC_TSR_Sign_Attr1_AR_StartDelay * _HAD_MDC_TSR_Sign_Attr1_AR_Timebase );

    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_ID1.phys = getValue( HMI_HAD_MDC_TSR_Sign_ID1 );
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_Inv.phys = getValue( HMI_HAD_MDC_TSR_Sign_Inv );
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_LED.phys = getValue( HMI_RainSens_Snsty_Stat );
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_Mismtch.phys = getValue( HMI_HAD_MDC_TSR_Sign_Mismtch );
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_Mn.phys = getValue( HMI_HAD_MDC_TSR_Sign_Mn );
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_PosX.phys = getValue( HMI_HAD_MDC_TSR_Sign_PosX );
	_mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_PosY.phys = getValue( HMI_HAD_MDC_TSR_Sign_PosY );
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_PosZ.phys = getValue( HMI_HAD_MDC_TSR_Sign_PosZ );
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_Qual.phys = getValue( HMI_HAD_MDC_TSR_Sign_Qual );
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_Spplmntry.phys = getValue( HMI_HAD_MDC_TSR_Sign_Spplmntry );
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_TmStmp.phys = getValue( HMI_HAD_MDC_TSR_Sign_TmStmp );
}

HAD_MDC_TSR_Sign_Attr1_AR_output(void)
{
    output( _mHAD_MDC_TSR_Sign_Attr1_AR );
}

HAD_MDC_TSR_Sign_Attr1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: HAD_MDC_TSR_Sign_Attr1_AR\n", 27, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_HAD_MDC_TSR_Sign_Attr1_AR := %X\n", getValue( HMI__STMSG_HAD_MDC_TSR_Sign_Attr1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_HAD_MDC_TSR_Sign_Attr1_AR := %X\n", getValue( HMI__STMSGT_HAD_MDC_TSR_Sign_Attr1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_TSR_Sign_ID1 := %X\n", getValue( HMI_HAD_MDC_TSR_Sign_ID1 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_TSR_Sign_Inv := %X\n", getValue( HMI_HAD_MDC_TSR_Sign_Inv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_TSR_Sign_LED := %X\n", getValue( HMI_HAD_MDC_TSR_Sign_LED ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_TSR_Sign_Mismtch := %X\n", getValue( HMI_HAD_MDC_TSR_Sign_Mismtch ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_TSR_Sign_Mn := %X\n", getValue( HMI_HAD_MDC_TSR_Sign_Mn ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_TSR_Sign_PosX := %X\n", getValue( HMI_HAD_MDC_TSR_Sign_PosX ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_TSR_Sign_PosY := %X\n", getValue( HMI_HAD_MDC_TSR_Sign_PosY ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_TSR_Sign_PosZ := %X\n", getValue( HMI_HAD_MDC_TSR_Sign_PosZ ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_TSR_Sign_Qual := %X\n", getValue( HMI_HAD_MDC_TSR_Sign_Qual ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_TSR_Sign_Spplmntry := %X\n", getValue( HMI_HAD_MDC_TSR_Sign_Spplmntry ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_TSR_Sign_TmStmp := %X\n", getValue( HMI_HAD_MDC_TSR_Sign_TmStmp ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tHAD_MDC_TSR_Sign_Attr1_AR
{
    putValue( HMI__STMSG_HAD_MDC_TSR_Sign_Attr1_AR, 0 );
}

on EnvVar HMI__STMSG_HAD_MDC_TSR_Sign_Attr1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_HAD_MDC_TSR_Sign_Attr1_AR );
        if( tDelay > 0)    
            setTimer( _tHAD_MDC_TSR_Sign_Attr1_AR, tDelay );
        else
            putValue( HMI__STMSG_HAD_MDC_TSR_Sign_Attr1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_HAD_MDC_TSR_Sign_Attr1_AR
{
    if( getValue( this ) )
        openPanel("HAD_MDC_TSR_Sign_Attr1_AR");
}

on EnvVar HMI_HAD_MDC_TSR_Sign_ID1
{
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_ID1.phys = getValue(this);
    _HAD_MDC_TSR_Sign_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_TSR_Sign_Inv
{
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_Inv.phys = getValue(this);
    _HAD_MDC_TSR_Sign_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_TSR_Sign_LED
{
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_LED.phys = getValue(this);
    _HAD_MDC_TSR_Sign_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_TSR_Sign_Mismtch
{
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_Mismtch.phys = getValue(this);
    _HAD_MDC_TSR_Sign_Attr1_AR_SpontanFlag = 1;
}

//on EnvVar HMI_HAD_MDC_TSR_Sign_ID1
//{
//    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_ID1.phys = getValue(this);
//   _HAD_MDC_TSR_Sign_Attr1_AR_SpontanFlag = 1;
//}

on EnvVar HMI_HAD_MDC_TSR_Sign_Mn
{
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_Mn.phys = getValue(this);
    _HAD_MDC_TSR_Sign_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_TSR_Sign_PosX
{
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_PosX.phys = getValue(this);
    _HAD_MDC_TSR_Sign_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_TSR_Sign_PosY
{
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_PosY.phys = getValue(this);
    _HAD_MDC_TSR_Sign_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_TSR_Sign_PosZ
{
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_PosZ.phys = getValue(this);
    _HAD_MDC_TSR_Sign_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_TSR_Sign_Qual
{
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_Qual.phys = getValue(this);
    _HAD_MDC_TSR_Sign_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_TSR_Sign_Spplmntry
{
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_Spplmntry.phys = getValue(this);
    _HAD_MDC_TSR_Sign_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_TSR_Sign_TmStmp
{
    _mHAD_MDC_TSR_Sign_Attr1_AR.HAD_MDC_TSR_Sign_TmStmp.phys = getValue(this);
    _HAD_MDC_TSR_Sign_Attr1_AR_SpontanFlag = 1;
}

HAD_MDC_TSR_Sign_Attr2_AR_check_output()
{
    if( !getValue( HMI__STMSG_HAD_MDC_TSR_Sign_Attr2_AR ) )
    {
    //  message   HAD_MDC_TSR_Sign_Attr2_AR ID: 2431909888 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _HAD_MDC_TSR_Sign_Attr2_AR_Cnt--;
        if( _HAD_MDC_TSR_Sign_Attr2_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            HAD_MDC_TSR_Sign_Attr2_AR_output();
            _HAD_MDC_TSR_Sign_Attr2_AR_Cnt = _HAD_MDC_TSR_Sign_Attr2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _HAD_MDC_TSR_Sign_Attr2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _HAD_MDC_TSR_Sign_Attr2_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            HAD_MDC_TSR_Sign_Attr2_AR_output();
            _HAD_MDC_TSR_Sign_Attr2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

HAD_MDC_TSR_Sign_Attr2_AR_init()
{   /* Botschaft HAD_MDC_TSR_Sign_Attr2_AR ID: 2431909888 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 2431909888 0;
BA_ "NmAsrMessage" BO_ 2431909888 0;
BA_ "GenMsgMinAcceptLength" BO_ 2431909888 8;
BA_ "GenMsgILSupport" BO_ 2431909888 1;
BA_ "DiagState" BO_ 2431909888 0;
BA_ "DiagRequest" BO_ 2431909888 0;
BA_ "DiagResponse" BO_ 2431909888 0;
BA_ "GenMsgStartValue" BO_ 2431909888 "0";
BA_ "GenMsgStartDelayTime" BO_ 2431909888 0;
BA_ "GenMsgDelayTime" BO_ 2431909888 5;
BA_ "GenMsgNrOfRepetitions" BO_ 2431909888 0;
BA_ "GenMsgCycleTime" BO_ 2431909888 500;
BA_ "GenMsgSendType" BO_ 2431909888 5;
    */
    _HAD_MDC_TSR_Sign_Attr2_AR_Timebase =         c_tDBKomTimer_20ms;
    _HAD_MDC_TSR_Sign_Attr2_AR_CycleCount =     500 / _HAD_MDC_TSR_Sign_Attr2_AR_Timebase;
    _HAD_MDC_TSR_Sign_Attr2_AR_StartDelay =       0 / _HAD_MDC_TSR_Sign_Attr2_AR_Timebase;
    _HAD_MDC_TSR_Sign_Attr2_AR_Cnt = _HAD_MDC_TSR_Sign_Attr2_AR_StartDelay;
    _HAD_MDC_TSR_Sign_Attr2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_HAD_MDC_TSR_Sign_Attr2_AR, _HAD_MDC_TSR_Sign_Attr2_AR_StartDelay * _HAD_MDC_TSR_Sign_Attr2_AR_Timebase );

    _mHAD_MDC_TSR_Sign_Attr2_AR.HAD_MDC_TSR_Sign_ID2.phys = getValue( HMI_HAD_MDC_TSR_Sign_ID2 );
    _mHAD_MDC_TSR_Sign_Attr2_AR.HAD_MDC_TSR_Sign_PosX_StdDev.phys = getValue( HMI_HAD_MDC_TSR_Sign_PosX_StdDev );
    _mHAD_MDC_TSR_Sign_Attr2_AR.HAD_MDC_TSR_Sign_PosXY_CorrCoeff.phys = getValue( HMI_HAD_MDC_TSR_Sign_PosXY_CorrCoeff );
    _mHAD_MDC_TSR_Sign_Attr2_AR.HAD_MDC_TSR_Sign_PosXZ_CorrCoeff.phys = getValue( HMI_HAD_MDC_TSR_Sign_PosXZ_CorrCoeff );
    _mHAD_MDC_TSR_Sign_Attr2_AR.HAD_MDC_TSR_Sign_PosY_StdDev.phys = getValue( HMI_HAD_MDC_TSR_Sign_PosY_StdDev );
    _mHAD_MDC_TSR_Sign_Attr2_AR.HAD_MDC_TSR_Sign_PosYZ_CorrCoeff.phys = getValue( HMI_HAD_MDC_TSR_Sign_PosYZ_CorrCoeff );
	_mHAD_MDC_TSR_Sign_Attr2_AR.HAD_MDC_TSR_Sign_PosZ_StdDev.phys = getValue( HMI_HAD_MDC_TSR_Sign_PosZ_StdDev );
}

HAD_MDC_TSR_Sign_Attr2_AR_output(void)
{
    output( _mHAD_MDC_TSR_Sign_Attr2_AR );
}

HAD_MDC_TSR_Sign_Attr2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: HAD_MDC_TSR_Sign_Attr2_AR\n", 27, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_HAD_MDC_TSR_Sign_Attr2_AR := %X\n", getValue( HMI__STMSG_HAD_MDC_TSR_Sign_Attr2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_HAD_MDC_TSR_Sign_Attr2_AR := %X\n", getValue( HMI__STMSGT_HAD_MDC_TSR_Sign_Attr2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_TSR_Sign_ID2 := %X\n", getValue( HMI_HAD_MDC_TSR_Sign_ID2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_TSR_Sign_PosX_StdDev := %X\n", getValue( HMI_HAD_MDC_TSR_Sign_PosX_StdDev ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_TSR_Sign_PosXY_CorrCoeff := %X\n", getValue( HMI_HAD_MDC_TSR_Sign_PosXY_CorrCoeff ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_TSR_Sign_PosXZ_CorrCoeff := %X\n", getValue( HMI_HAD_MDC_TSR_Sign_PosXZ_CorrCoeff ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_TSR_Sign_PosY_StdDev := %X\n", getValue( HMI_HAD_MDC_TSR_Sign_PosY_StdDev ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_TSR_Sign_PosYZ_CorrCoeff := %X\n", getValue( HMI_HAD_MDC_TSR_Sign_PosYZ_CorrCoeff ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_HAD_MDC_TSR_Sign_PosZ_StdDev := %X\n", getValue( HMI_HAD_MDC_TSR_Sign_PosZ_StdDev ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tHAD_MDC_TSR_Sign_Attr2_AR
{
    putValue( HMI__STMSG_HAD_MDC_TSR_Sign_Attr2_AR, 0 );
}

on EnvVar HMI__STMSG_HAD_MDC_TSR_Sign_Attr2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_HAD_MDC_TSR_Sign_Attr2_AR );
        if( tDelay > 0)    
            setTimer( _tHAD_MDC_TSR_Sign_Attr2_AR, tDelay );
        else
            putValue( HMI__STMSG_HAD_MDC_TSR_Sign_Attr2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_HAD_MDC_TSR_Sign_Attr2_AR
{
    if( getValue( this ) )
        openPanel("HAD_MDC_TSR_Sign_Attr2_AR");
}

on EnvVar HMI_HAD_MDC_TSR_Sign_ID2
{
    _mHAD_MDC_TSR_Sign_Attr2_AR.HAD_MDC_TSR_Sign_ID2.phys = getValue(this);
    _HAD_MDC_TSR_Sign_Attr2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_TSR_Sign_PosX_StdDev
{
    _mHAD_MDC_TSR_Sign_Attr2_AR.HAD_MDC_TSR_Sign_PosX_StdDev.phys = getValue(this);
    _HAD_MDC_TSR_Sign_Attr2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_TSR_Sign_PosXY_CorrCoeff
{
    _mHAD_MDC_TSR_Sign_Attr2_AR.HAD_MDC_TSR_Sign_PosXY_CorrCoeff.phys = getValue(this);
    _HAD_MDC_TSR_Sign_Attr2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_TSR_Sign_PosXZ_CorrCoeff
{
    _mHAD_MDC_TSR_Sign_Attr2_AR.HAD_MDC_TSR_Sign_PosXZ_CorrCoeff.phys = getValue(this);
    _HAD_MDC_TSR_Sign_Attr2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_TSR_Sign_PosYZ_CorrCoeff
{
    _mHAD_MDC_TSR_Sign_Attr2_AR.HAD_MDC_TSR_Sign_PosYZ_CorrCoeff.phys = getValue(this);
    _HAD_MDC_TSR_Sign_Attr2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_TSR_Sign_PosY_StdDev
{
    _mHAD_MDC_TSR_Sign_Attr2_AR.HAD_MDC_TSR_Sign_PosY_StdDev.phys = getValue(this);
    _HAD_MDC_TSR_Sign_Attr2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HAD_MDC_TSR_Sign_PosZ_StdDev
{
    _mHAD_MDC_TSR_Sign_Attr2_AR.HAD_MDC_TSR_Sign_PosZ_StdDev.phys = getValue(this);
    _HAD_MDC_TSR_Sign_Attr2_AR_SpontanFlag = 1;
}


TC_EEBBC_Energy_Cons_AR_check_output()
{
    if( !getValue( HMI__STMSG_TC_EEBBC_Energy_Cons_AR ) )
        {
        //  message   TC_EEBBC_Energy_Cons_AR ID: 2344615936 --- Sendeart 0 cyclicX --- 
            _TC_EEBBC_Energy_Cons_AR_Cnt--;
            if( _TC_EEBBC_Energy_Cons_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                TC_EEBBC_Energy_Cons_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _TC_EEBBC_Energy_Cons_AR_Cnt = _TC_EEBBC_Energy_Cons_AR_CycleCount;
            }
        }
}

TC_EEBBC_Energy_Cons_AR_init()
{   /* Botschaft CHASSIS_HMI_Radar_R1_AR ID: 2344615936 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 2344615936 0;
BA_ "NmAsrMessage" BO_ 2344615936 0;
BA_ "GenMsgMinAcceptLength" BO_ 2344615936 8;
BA_ "GenMsgILSupport" BO_ 2344615936 1;
BA_ "DiagState" BO_ 2344615936 0;
BA_ "DiagRequest" BO_ 2344615936 0;
BA_ "DiagResponse" BO_ 2344615936 0;
BA_ "GenMsgStartValue" BO_ 2344615936 "0";
BA_ "GenMsgStartDelayTime" BO_ 2344615936 75;
BA_ "GenMsgCycleTime" BO_ 2344615936 500;
BA_ "GenMsgSendType" BO_ 2344615936 0;
    */
    _TC_EEBBC_Energy_Cons_AR_Timebase =      c_tDBKomTimer_20ms;
    _TC_EEBBC_Energy_Cons_AR_CycleCount =   100 / _TC_EEBBC_Energy_Cons_AR_Timebase;
    _TC_EEBBC_Energy_Cons_AR_StartDelay =      75 / _TC_EEBBC_Energy_Cons_AR_Timebase;
    _TC_EEBBC_Energy_Cons_AR_Cnt = _TC_EEBBC_Energy_Cons_AR_StartDelay;
    _TC_EEBBC_Energy_Cons_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_TC_EEBBC_Energy_Cons_AR, _TC_EEBBC_Energy_Cons_AR_StartDelay * _TC_EEBBC_Energy_Cons_AR_Timebase );

    _mTC_EEBBC_Energy_Cons_AR.TC_EEBBC_Eng_Cons_Climate.phys = getValue( HMI_TC_EEBBC_Eng_Cons_Climate );
    _mTC_EEBBC_Energy_Cons_AR.TC_EEBBC_Eng_Cons_Drive.phys = getValue( HMI_TC_EEBBC_Eng_Cons_Drive );
    _mTC_EEBBC_Energy_Cons_AR.TC_EEBBC_MaxAvg_EnergyCons_Dest.phys = getValue( HMI_TC_EEBBC_MaxAvg_EnergyCons_Dest );
	_mTC_EEBBC_Energy_Cons_AR.TC_EEBBC_OptlAvg_EnergyCons.phys = getValue( HMI_TC_EEBBC_OptlAvg_EnergyCons );
}

TC_EEBBC_Energy_Cons_AR_output(void)
{
    output( _mTC_EEBBC_Energy_Cons_AR );
}

TC_EEBBC_Energy_Cons_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: TC_EEBBC_Energy_Cons_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_TC_EEBBC_Energy_Cons_AR := %X\n", getValue( HMI__STMSG_TC_EEBBC_Energy_Cons_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_TC_EEBBC_Energy_Cons_AR := %X\n", getValue( HMI__STMSGT_TC_EEBBC_Energy_Cons_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EEBBC_Eng_Cons_Climate  := %X\n", getValue( HMI_TC_EEBBC_Eng_Cons_Climate ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EEBBC_Eng_Cons_Drive  := %X\n", getValue( HMI_TC_EEBBC_Eng_Cons_Drive ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EEBBC_MaxAvg_EnergyCons_Dest  := %X\n", getValue( HMI_TC_EEBBC_MaxAvg_EnergyCons_Dest ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EEBBC_OptlAvg_EnergyCons  := %X\n", getValue( HMI_TC_EEBBC_OptlAvg_EnergyCons ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tTC_EEBBC_Energy_Cons_AR
{
    putValue( HMI__STMSG_TC_EEBBC_Energy_Cons_AR, 0 );
}

on EnvVar HMI__STMSG_TC_EEBBC_Energy_Cons_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_TC_EEBBC_Energy_Cons_AR );
        if( tDelay > 0)    
            setTimer( _tTC_EEBBC_Energy_Cons_AR, tDelay );
        else
            putValue( HMI__STMSG_TC_EEBBC_Energy_Cons_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_TC_EEBBC_Energy_Cons_AR
{
    if( getValue( this ) )
        openPanel("TC_EEBBC_Energy_Cons_AR");
}

on EnvVar HMI_TC_EEBBC_Eng_Cons_Climate
{
    _mTC_EEBBC_Energy_Cons_AR.TC_EEBBC_Eng_Cons_Climate.phys = getValue(this);
}

on EnvVar HMI_TC_EEBBC_Eng_Cons_Drive
{
    _mTC_EEBBC_Energy_Cons_AR.TC_EEBBC_Eng_Cons_Drive.phys = getValue(this);
}

on EnvVar HMI_TC_EEBBC_MaxAvg_EnergyCons_Dest
{
    _mTC_EEBBC_Energy_Cons_AR.TC_EEBBC_MaxAvg_EnergyCons_Dest.phys = getValue(this);
}

on EnvVar HMI_TC_EEBBC_OptlAvg_EnergyCons
{
    _mTC_EEBBC_Energy_Cons_AR.TC_EEBBC_OptlAvg_EnergyCons.phys = getValue(this);
}


//de aici
HMIG_Stat_AR_check_output()
{
      if( !getValue( HMI__STMSG_HMIG_Stat_AR ))
    {
    //  message   HMIG_Stat_AR ID: 2347761664 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _HMIG_Stat_AR_DelayCnt > 0) _HMIG_Stat_AR_DelayCnt--; // Mindestsendeabstand
        _HMIG_Stat_AR_Cnt--;
        if( _HMIG_Stat_AR_Cnt < 1 )
        {
            if( _HMIG_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                HMIG_Stat_AR_output();
                 _HMIG_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _HMIG_Stat_AR_DelayCnt = _HMIG_Stat_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _HMIG_Stat_AR_SpontanFlag = 1;
            }
            _HMIG_Stat_AR_Cnt = _HMIG_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _HMIG_Stat_AR_SpontanFlag )
        {
            if( _HMIG_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                HMIG_Stat_AR_output();
                _HMIG_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _HMIG_Stat_AR_DelayCnt = _HMIG_Stat_AR_MinDelay;
            }
        }
    }
}

HMIG_Stat_AR_init()
{    /* Botschaft HMIG_Stat_AR ID: 2347761664 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 2347761664 0;
BA_ "NmAsrMessage" BO_ 2347761664 0;
BA_ "GenMsgMinAcceptLength" BO_ 2347761664 8;
BA_ "GenMsgILSupport" BO_ 2347761664 1;
BA_ "DiagState" BO_ 2347761664 0;
BA_ "DiagRequest" BO_ 2347761664 0;
BA_ "DiagResponse" BO_ 2347761664 0;
BA_ "GenMsgStartValue" BO_ 2347761664 "0";
BA_ "GenMsgDelayTime" BO_ 2347761664 50;
BA_ "GenMsgNrOfRepetitions" BO_ 2347761664 0;
BA_ "GenMsgCycleTime" BO_ 2347761664 200;
BA_ "GenMsgSendType" BO_ 2347761664 5;
    */
    _HMIG_Stat_AR_Timebase =       c_tDBKomTimer_20ms;
    _HMIG_Stat_AR_CycleCount =    200 / _HMIG_Stat_AR_Timebase;
    _HMIG_Stat_AR_StartDelay =      0 / _HMIG_Stat_AR_Timebase;
    _HMIG_Stat_AR_Cnt = _HMIG_Stat_AR_StartDelay;
    _HMIG_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_HMIG_Stat_AR, _HMIG_Stat_AR_StartDelay * _HMIG_Stat_AR_Timebase );

    //_mHMIG_Stat_AR.EOS_Sw_Psd.phys = getValue( HMI_EOS_Sw_Psd );
    _mHMIG_Stat_AR.RLS_Posn_HMIG.phys = getValue( HMI_RLS_Posn_HMIG );
    _mHMIG_Stat_AR.RLS_Type.phys = getValue( HMI_RLS_Type );
    _mHMIG_Stat_AR.Rsrv0_HMIG_Stat.phys = getValue( HMI_Rsrv0_HMIG_Stat );
    //_mHMIG_Stat_AR.CRC_HMIG_Stat.phys = getValue( HMI_CRC_HMIG_Stat );
    //_mHMIG_Stat_AR.SQC_HMIG_Stat.phys = getValue( HMI_SQC_HMIG_Stat );
}

HMIG_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_HMIG_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_HMIG_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _HMIG_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _HMIG_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_HMIG_Stat_AR_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _HMIG_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _HMIG_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _HMIG_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _HMIG_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _HMIG_Stat_AR_SQC_RepeatedCnt > 0) &&
            ( _HMIG_Stat_AR_E2E_Armed == 1  )    )
        {
            _HMIG_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_HMIG_Stat, SQC_help );
    }
    _mHMIG_Stat_AR.SQC_HMIG_Stat = SQC_help;

    if( getValue( HMI_CRC_HMIG_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_HMIG_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable_profile02[ crc ^ _mHMIG_Stat_AR.byte( 0 ) ];
            crc = crctable_profile02[ crc ^ _mHMIG_Stat_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mHMIG_Stat_AR.byte( 2 ) ];
//            crc = crctable_profile02[ crc ^ _mHMIG_Stat_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mHMIG_Stat_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mHMIG_Stat_AR.byte( 5 ) ];  CRC
//            crc = crctable_profile02[ crc ^ _mHMIG_Stat_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mHMIG_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _HMIG_Stat_AR_CRC_Offset[ _mHMIG_Stat_AR.SQC_HMIG_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _HMIG_Stat_AR_CRC_ErrorCnt   && ( _HMIG_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_HMIG_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _HMIG_Stat_AR_CRC_ErrorCnt > 0 )
                    _HMIG_Stat_AR_CRC_ErrorCnt--; 
            }
            _mHMIG_Stat_AR.CRC_HMIG_Stat = crc;
            putValue( HMI_CRC_HMIG_Stat, crc );
        }
        else
            _mHMIG_Stat_AR.CRC_HMIG_Stat = getValue( HMI_CRC_HMIG_Stat );
    }
	
    else
    {
        if( !getValue( HMI_CRC_HMIG_Stat_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[crc ^ _mHMIG_Stat_AR.byte( 0 )];CRC
            crc = crctable[crc ^ _mHMIG_Stat_AR.byte( 1 )];
            crc = crctable[crc ^ _mHMIG_Stat_AR.byte( 2 )];
            crc = crctable[crc ^ _mHMIG_Stat_AR.byte( 3 )];
            crc = crctable[crc ^ _mHMIG_Stat_AR.byte( 4 )];
            crc = crctable[crc ^ _mHMIG_Stat_AR.byte( 5 )];  
            crc = crctable[crc ^ _mHMIG_Stat_AR.byte( 6 )];
            crc = crctable[crc ^ _mHMIG_Stat_AR.byte( 7 )];
            crc = (crc ^ 0xFF);
            if( ( _HMIG_Stat_AR_CRC_ErrorCnt   && ( _HMIG_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_HMIG_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _HMIG_Stat_AR_CRC_ErrorCnt > 0 )
                    _HMIG_Stat_AR_CRC_ErrorCnt--; 
            }
            _mHMIG_Stat_AR.CRC_HMIG_Stat = crc;
            putValue( HMI_CRC_HMIG_Stat, crc );
        }
        else
            _mHMIG_Stat_AR.CRC_HMIG_Stat = getValue( HMI_CRC_HMIG_Stat );
    }
	
	
    if( ( _HMIG_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _HMIG_Stat_AR_E2E_Armed == 1  )    )
    {
        _HMIG_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mHMIG_Stat_AR );
        
    if( _HMIG_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _HMIG_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _HMIG_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _HMIG_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _HMIG_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _HMIG_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_HMIG_Stat_AR_State, 0 );
        }
    }
}

void HMIG_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: HMIG_Stat_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_HMIG_Stat_AR := %X\n", getValue( HMI__STMSG_HMIG_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_HMIG_Stat_AR := %X\n", getValue( HMI__STMSGT_HMIG_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    //snprintf( buffer, elcount( buffer ), "0.0000 HMI_EOS_Sw_Psd := %X\n", getValue( HMI_EOS_Sw_Psd ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RLS_Posn_HMIG := %X\n", getValue( HMI_RLS_Posn_HMIG ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RLS_Type := %X\n", getValue( HMI_RLS_Type ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv0_HMIG_Stat := %X\n", getValue( HMI_Rsrv0_HMIG_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
   // snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_HMIG_Stat := %X\n", getValue( HMI_CRC_HMIG_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_HMIG_Stat := %X\n", getValue( HMI_SQC_HMIG_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_HMIG_Stat_Auto := %X\n", getValue( HMI_SQC_HMIG_Stat_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_HMIG_Stat := %X\n", getValue( HMI_CRC_HMIG_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_HMIG_Stat_Auto := %X\n", getValue( HMI_CRC_HMIG_Stat_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_HMIG_Stat_Profile_02 := %X\n", getValue( HMI_CRC_HMIG_Stat_Profile_02 ) );        filePutString( buffer, elcount( buffer ), hFile );
}
on timer _tHMIG_Stat_AR
{
    putValue( HMI__STMSG_HMIG_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_HMIG_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_HMIG_Stat_AR );
        if( tDelay > 0 )
            setTimer( _tHMIG_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_HMIG_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_HMIG_Stat_AR
{
    if( getValue( this ) )
        openPanel("HMIG_Stat_AR");
}

on EnvVar HMI_E2E_HMIG_Stat_AR_Inject
{
    if( getValue(this) )
    {
        _HMIG_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_HMIG_Stat_AR_ErrorCount );
        _HMIG_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_HMIG_Stat_AR_TriggerPosition );
        _HMIG_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_HMIG_Stat_AR_WrongSeq );
        _HMIG_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_HMIG_Stat_AR_Repeated );
        _HMIG_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_HMIG_Stat_AR_MSG_DropCnt );
        putValue( HMI_E2E_HMIG_Stat_AR_State, 2 );
        _HMIG_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_RLS_Posn_HMIG
{
    _mHMIG_Stat_AR.RLS_Posn_HMIG.phys = getValue(this);
    _HMIG_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_RLS_Type
{
    _mHMIG_Stat_AR.RLS_Type.phys = getValue(this);
    _HMIG_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv0_HMIG_Stat
{
    _mHMIG_Stat_AR.Rsrv0_HMIG_Stat.phys = getValue(this);
    _HMIG_Stat_AR_SpontanFlag = 1;
}

/*
on EnvVar HMI_CRC_HMIG_Stat
{
    _mHMIG_Stat_AR.CRC_HMIG_Stat.phys = getValue(this);
    _HMIG_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SQC_HMIG_Stat
{
    _mHMIG_Stat_AR.SQC_HMIG_Stat.phys = getValue(this);
    _HMIG_Stat_AR_SpontanFlag = 1;
}
*/

CU_UTC_AR2_check_output()
{
      if( !getValue( HMI__STMSG_CU_UTC_AR2 ) )
    {
        // Botschaft CU_UTC_AR2 ID: 992 --- Sendeart 0 cyclic --- 
        _CU_UTC_AR2_Cnt--;
        if( _CU_UTC_AR2_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            CU_UTC_AR2_output();
            // Zyklus-Z�hler zur�cksetzen
            _CU_UTC_AR2_Cnt = _CU_UTC_AR2_CycleCount;
        }
    }
}

CU_UTC_AR2_init()
{   /* Botschaft CU_UTC_AR2 ID: 992 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 992 0;
BA_ "NmAsrMessage" BO_ 992 0;
BA_ "GenMsgMinAcceptLength" BO_ 992 8;
BA_ "GenMsgILSupport" BO_ 992 1;
BA_ "DiagState" BO_ 992 0;
BA_ "DiagRequest" BO_ 992 0;
BA_ "DiagResponse" BO_ 992 0;
BA_ "GenMsgStartValue" BO_ 992 "0";
BA_ "GenMsgStartDelayTime" BO_ 992 0;
BA_ "GenMsgCycleTime" BO_ 992 1000;
BA_ "GenMsgSendType" BO_ 992 0;
    */
    _CU_UTC_AR2_Timebase =         c_tDBKomTimer_20ms;
    _CU_UTC_AR2_CycleCount =     1000 / _CU_UTC_AR2_Timebase;
    _CU_UTC_AR2_StartDelay =        0 / _CU_UTC_AR2_Timebase;
    _CU_UTC_AR2_Cnt = _CU_UTC_AR2_StartDelay;
    _CU_UTC_AR2_DelayCnt = 0;

    putValue( HMI__STMSGSD_CU_UTC_AR2, _CU_UTC_AR2_StartDelay * _CU_UTC_AR2_Timebase );

    _mCU_UTC_AR2.CU_DateTm_mSecond_UTC.phys = getValue( HMI_CU_DateTm_mSecond_UTC );
    _mCU_UTC_AR2.CU_DateTmDay_UTC.phys = getValue( HMI_CU_DateTmDay_UTC );
    _mCU_UTC_AR2.CU_DateTmHour_UTC.phys = getValue( HMI_CU_DateTmHour_UTC );
    _mCU_UTC_AR2.CU_DateTmMinute_UTC.phys = getValue( HMI_CU_DateTmMinute_UTC );
    _mCU_UTC_AR2.CU_DateTmMonth_UTC.phys = getValue( HMI_CU_DateTmMonth_UTC );
    _mCU_UTC_AR2.CU_DateTmSecond_UTC.phys = getValue( HMI_CU_DateTmSecond_UTC );
    _mCU_UTC_AR2.CU_DateTmYear_UTC.phys = getValue( HMI_CU_DateTmYear_UTC );
    _mCU_UTC_AR2.CU_Pos_Cnt3.phys = getValue( HMI_CU_Pos_Cnt3 );
}

void CU_UTC_AR2_output(void)
{
    output( _mCU_UTC_AR2 );
}

void CU_UTC_AR2_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Seat_D_Stat_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_CU_UTC_AR2 := %X\n", getValue( HMI__STMSG_CU_UTC_AR2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_CU_UTC_AR2 := %X\n", getValue( HMI__STMSGT_CU_UTC_AR2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_DateTm_mSecond_UTC := %X\n", getValue( HMI_CU_DateTm_mSecond_UTC ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_DateTmDay_UTC := %X\n", getValue( HMI_CU_DateTmDay_UTC ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_DateTmHour_UTC := %X\n", getValue( HMI_CU_DateTmHour_UTC ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_DateTmMinute_UTC := %X\n", getValue( HMI_CU_DateTmMinute_UTC ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_DateTmMonth_UTC := %X\n", getValue( HMI_CU_DateTmMonth_UTC ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_DateTmSecond_UTC := %X\n", getValue( HMI_CU_DateTmSecond_UTC ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_DateTmYear_UTC := %X\n", getValue( HMI_CU_DateTmYear_UTC ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Pos_Cnt3 := %X\n", getValue( HMI_CU_Pos_Cnt3 ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tCU_UTC_AR2
{
    putValue( HMI__STMSG_CU_UTC_AR2, 0 );
}

on EnvVar HMI__STMSG_CU_UTC_AR2
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_CU_UTC_AR2 );
        if( tDelay > 0)    
            setTimer( _tCU_UTC_AR2, tDelay );
        else
            putValue( HMI__STMSG_CU_UTC_AR2, 0 );
    }
}

on EnvVar HMI_CU_DateTm_mSecond_UTC
{
    _mCU_UTC_AR2.CU_DateTm_mSecond_UTC.phys = getValue(this);
    _CU_UTC_AR2_SpontanFlag = 1;
}

on EnvVar HMI_CU_DateTmDay_UTC
{
    _mCU_UTC_AR2.CU_DateTmDay_UTC.phys = getValue(this);
    _CU_UTC_AR2_SpontanFlag = 1;
}

on EnvVar HMI_CU_DateTmHour_UTC
{
    _mCU_UTC_AR2.CU_DateTmHour_UTC.phys = getValue(this);
    _CU_UTC_AR2_SpontanFlag = 1;
}

on EnvVar HMI_CU_DateTmMinute_UTC
{
    _mCU_UTC_AR2.CU_DateTmMinute_UTC.phys = getValue(this);
    _CU_UTC_AR2_SpontanFlag = 1;
}

on EnvVar HMI_CU_DateTmMonth_UTC
{
    _mCU_UTC_AR2.CU_DateTmMonth_UTC.phys = getValue(this);
    _CU_UTC_AR2_SpontanFlag = 1;
}

on EnvVar HMI_CU_DateTmSecond_UTC
{
    _mCU_UTC_AR2.CU_DateTmSecond_UTC.phys = getValue(this);
    _CU_UTC_AR2_SpontanFlag = 1;
}

on EnvVar HMI_CU_DateTmYear_UTC
{
    _mCU_UTC_AR2.CU_DateTmYear_UTC.phys = getValue(this);
    _CU_UTC_AR2_SpontanFlag = 1;
}

on EnvVar HMI_CU_Pos_Cnt3
{
    _mCU_UTC_AR2.CU_Pos_Cnt3.phys = getValue(this);
    _CU_UTC_AR2_SpontanFlag = 1;
}

TC_Disp_Rq2_AR2_check_output()
{
    if( !getValue( HMI__STMSG_TC_Disp_Rq2_AR2))
    {
        // Botschaft TC_Disp_Rq2_AR2 ID: 2348810240 --- Sendeart 0 cyclicX --- 
        _TC_Disp_Rq2_AR2_Cnt--;
        if( _TC_Disp_Rq2_AR2_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            output( _mTC_Disp_Rq2_AR2 );
            // Zyklus-Z�hler zur�cksetzen
            _TC_Disp_Rq2_AR2_Cnt = _TC_Disp_Rq2_AR2_CycleCount;
        }
    }
}



TC_Disp_Rq2_AR2_init()
{   /* Botschaft TC_Disp_Rq2_AR2 ID: 2348810240 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 2348810240 0;
BA_ "NmAsrMessage" BO_ 2348810240 0;
BA_ "GenMsgMinAcceptLength" BO_ 2348810240 8;
BA_ "GenMsgILSupport" BO_ 2348810240 1;
BA_ "DiagState" BO_ 2348810240 0;
BA_ "DiagRequest" BO_ 2348810240 0;
BA_ "DiagResponse" BO_ 2348810240 0;
BA_ "GenMsgStartValue" BO_ 2348810240 "0";
BA_ "GenMsgStartDelayTime" BO_ 2348810240 270;
BA_ "GenMsgCycleTime" BO_ 2348810240 1000;
BA_ "GenMsgSendType" BO_ 2348810240 0;
    */
    _TC_Disp_Rq2_AR2_Timebase =          c_tDBKomTimer_20ms;
    _TC_Disp_Rq2_AR2_CycleCount =      1000 / _TC_Disp_Rq2_AR2_Timebase;
    _TC_Disp_Rq2_AR2_StartDelay =       270 / _TC_Disp_Rq2_AR2_Timebase;
    _TC_Disp_Rq2_AR2_Cnt = _TC_Disp_Rq2_AR2_StartDelay;
    
    putValue( HMI__STMSGSD_TC_Disp_Rq2_AR2, _TC_Disp_Rq2_AR2_StartDelay * _TC_Disp_Rq2_AR2_Timebase );

    _mTC_Disp_Rq2_AR2.TC_ElecEnergyRngMax.phys = getValue( HMI_TC_ElecEnergyRngMax );
    _mTC_Disp_Rq2_AR2.TC_ElecEnergyRngMin.phys = getValue( HMI_TC_ElecEnergyRngMin );
    _mTC_Disp_Rq2_AR2.TC_ElecEnergyRngTrnd .phys = getValue( HMI_TC_ElecEnergyRngTrnd );
    _mTC_Disp_Rq2_AR2.TC_ElecEnergyRngTrnd_V2 .phys = getValue( HMI_TC_ElecEnergyRngTrnd_V2 );
}



TC_Disp_Rq2_AR2_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten TGW: TC_Disp_Rq2_AR2\n", 26, hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI__STMSG_TC_Disp_Rq2_AR2 := %X\n", getValue( HMI__STMSG_TC_Disp_Rq2_AR2 ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI__STMSGT_TC_Disp_Rq2_AR2 := %X\n", getValue( HMI__STMSGT_TC_Disp_Rq2_AR2 ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_TC_ElecEnergyRngMax := %X\n", getValue( HMI_TC_ElecEnergyRngMax ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_TC_ElecEnergyRngMin := %X\n", getValue( HMI_TC_ElecEnergyRngMin ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_TC_ElecEnergyRngTrnd := %X\n", getValue( HMI_TC_ElecEnergyRngTrnd ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_TC_ElecEnergyRngTrnd_V2 := %X\n", getValue( HMI_TC_ElecEnergyRngTrnd_V2 ) );        filePutString( buffer, elcount(buffer), hFile);
}



on timer _tTC_Disp_Rq2_AR2
{
    putValue( HMI__STMSG_TC_Disp_Rq2_AR2, 0 );
}

on EnvVar HMI__STMSG_TC_Disp_Rq2_AR2
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_TC_Disp_Rq2_AR2 );
        if( tDelay > 0 )    
            setTimer( _tTC_Disp_Rq2_AR2, tDelay );
        else
            putValue( HMI__STMSG_TC_Disp_Rq2_AR2, 0 );
    }
}



on EnvVar HMI_TC_ElecEnergyRngMax
{
    _mTC_Disp_Rq2_AR2.TC_ElecEnergyRngMax.phys = getValue(this);
	_TC_Disp_Rq2_AR2_SpontanFlag = 1;
}
on EnvVar HMI_TC_ElecEnergyRngMin
{
    _mTC_Disp_Rq2_AR2.TC_ElecEnergyRngMin.phys = getValue(this);
	_TC_Disp_Rq2_AR2_SpontanFlag = 1;
}
on EnvVar HMI_TC_ElecEnergyRngTrnd
{
    _mTC_Disp_Rq2_AR2.TC_ElecEnergyRngTrnd.phys = getValue(this);
	_TC_Disp_Rq2_AR2_SpontanFlag = 1;
}
on EnvVar HMI_TC_ElecEnergyRngTrnd_V2
{
    _mTC_Disp_Rq2_AR2.TC_ElecEnergyRngTrnd_V2.phys = getValue(this);
	_TC_Disp_Rq2_AR2_SpontanFlag = 1;
}


LDP_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_LDP_Disp_Rq_AR ) )
        {
        //  message   LDP_Disp_Rq_AR ID: 2222981120 --- Sendeart 0 cyclicX --- 
            _LDP_Disp_Rq_AR_Cnt--;
            if( _LDP_Disp_Rq_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                LDP_Disp_Rq_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _LDP_Disp_Rq_AR_Cnt = _LDP_Disp_Rq_AR_CycleCount;
            }
        }
}

LDP_Disp_Rq_AR_init()
{    /* Botschaft LDP_Disp_Rq_AR ID: 2222981120 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 2222981120 0;
BA_ "NmAsrMessage" BO_ 2222981120 0;
BA_ "GenMsgMinAcceptLength" BO_ 2222981120 8;
BA_ "GenMsgILSupport" BO_ 2222981120 1;
BA_ "DiagState" BO_ 2222981120 0;
BA_ "DiagRequest" BO_ 2222981120 0;
BA_ "DiagResponse" BO_ 2222981120 0;
BA_ "GenMsgStartValue" BO_ 2222981120 "0";
BA_ "GenMsgCycleTime" BO_ 2222981120 40;
BA_ "GenMsgSendType" BO_ 2222981120 0;
    */
    _LDP_Disp_Rq_AR_Timebase =      c_tDBKomTimer_20ms;
    _LDP_Disp_Rq_AR_CycleCount =     40 / _LDP_Disp_Rq_AR_Timebase;
    _LDP_Disp_Rq_AR_StartDelay =      0 / _LDP_Disp_Rq_AR_Timebase;
    _LDP_Disp_Rq_AR_Cnt = _LDP_Disp_Rq_AR_StartDelay;
    _LDP_Disp_Rq_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_LDP_Disp_Rq_AR, _LDP_Disp_Rq_AR_StartDelay * _LDP_Disp_Rq_AR_Timebase );

    _mLDP_Disp_Rq_AR.LDP_IndLmp_SwLED_CI_Rq_MPC_Lt_V2.phys = getValue( HMI_LDP_IndLmp_SwLED_CI_Rq_MPC_Lt_V2 );
    _mLDP_Disp_Rq_AR.LDP_IndLmp_SwLED_CI_Rq_MPC_Rt_V2.phys = getValue( HMI_LDP_IndLmp_SwLED_CI_Rq_MPC_Rt_V2 );
    _mLDP_Disp_Rq_AR.LDP_Md_V2.phys = getValue( HMI_LDP_Md_V2 );
	_mLDP_Disp_Rq_AR.LDP_MPC_Ctrl_Stat.phys = getValue( HMI_LDP_MPC_Ctrl_Stat );
    _mLDP_Disp_Rq_AR.LDP_MPC_MsgDisp_Rq_V2.phys = getValue( HMI_LDP_MPC_MsgDisp_Rq_V2 );
    _mLDP_Disp_Rq_AR.LDP_Sens_Md_Stat_V2.phys = getValue( HMI_LDP_Sens_Md_Stat_V2 );
	_mLDP_Disp_Rq_AR.Rsrv0_LDP_Disp_Rq.phys = getValue( HMI_Rsrv0_LDP_Disp_Rq );
	
}

LDP_Disp_Rq_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_LDP_Disp_Rq ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_LDP_Disp_Rq_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _LDP_Disp_Rq_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _LDP_Disp_Rq_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_LDP_Disp_Rq_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _LDP_Disp_Rq_AR_SQC_WrongSeqJump != 0 ) &&
            ( _LDP_Disp_Rq_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _LDP_Disp_Rq_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _LDP_Disp_Rq_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _LDP_Disp_Rq_AR_SQC_RepeatedCnt ) &&
            ( _LDP_Disp_Rq_AR_E2E_Armed == 1  )    )
        {
            _LDP_Disp_Rq_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_LDP_Disp_Rq, SQC_help );
    }
    _mLDP_Disp_Rq_AR.SQC_LDP_Disp_Rq = SQC_help;

    if( getValue( HMI_CRC_LDP_Disp_Rq_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_LDP_Disp_Rq_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mLDP_Disp_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mLDP_Disp_Rq_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mLDP_Disp_Rq_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mLDP_Disp_Rq_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mLDP_Disp_Rq_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mLDP_Disp_Rq_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mLDP_Disp_Rq_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mLDP_Disp_Rq_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _LDP_Disp_Rq_AR_CRC_Offset[ _mLDP_Disp_Rq_AR.SQC_LDP_Disp_Rq ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _LDP_Disp_Rq_AR_CRC_ErrorCnt   && ( _LDP_Disp_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_LDP_Disp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _LDP_Disp_Rq_AR_CRC_ErrorCnt > 0 )
                    _LDP_Disp_Rq_AR_CRC_ErrorCnt--; 
            }
            _mLDP_Disp_Rq_AR.CRC_LDP_Disp_Rq = crc;
            putValue( HMI_CRC_LDP_Disp_Rq, crc );
        }
        else
            _mLDP_Disp_Rq_AR.CRC_LDP_Disp_Rq = getValue( HMI_CRC_LDP_Disp_Rq );
    }
    else
    {
        if( !getValue( HMI_CRC_LDP_Disp_Rq_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mLDP_Disp_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mLDP_Disp_Rq_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mLDP_Disp_Rq_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mLDP_Disp_Rq_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mLDP_Disp_Rq_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mLDP_Disp_Rq_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mLDP_Disp_Rq_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mLDP_Disp_Rq_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _LDP_Disp_Rq_AR_CRC_ErrorCnt   && ( _LDP_Disp_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_LDP_Disp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _LDP_Disp_Rq_AR_CRC_ErrorCnt > 0 )
                    _LDP_Disp_Rq_AR_CRC_ErrorCnt--; 
            }
            _mLDP_Disp_Rq_AR.CRC_LDP_Disp_Rq = crc;
            putValue( HMI_CRC_LDP_Disp_Rq, crc );
        }
        else
            _mLDP_Disp_Rq_AR.CRC_LDP_Disp_Rq = getValue( HMI_CRC_LDP_Disp_Rq );
    }
    if( ( _LDP_Disp_Rq_AR_MSG_DropCnt > 0 ) &&
        ( _LDP_Disp_Rq_AR_E2E_Armed == 1  )    )
    {
        _LDP_Disp_Rq_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mLDP_Disp_Rq_AR );
        
    if( _LDP_Disp_Rq_AR_E2E_Armed == 1 )
    {
        if ( ( _LDP_Disp_Rq_AR_MSG_DropCnt == 0      ) &&
             ( _LDP_Disp_Rq_AR_CRC_ErrorCnt == 0     ) &&
             ( _LDP_Disp_Rq_AR_SQC_RepeatedCnt == 0  ) &&
             ( _LDP_Disp_Rq_AR_SQC_WrongSeqJump == 0 )    )
        {
            _LDP_Disp_Rq_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_LDP_Disp_Rq_State, 0 );
        }
    }
}

LDP_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: LDP_Disp_Rq_AR_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_LDP_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_LDP_Disp_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_LDP_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_LDP_Disp_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_IndLmp_SwLED_CI_Rq_MPC_Lt_V2 := %X\n", getValue( HMI_LDP_IndLmp_SwLED_CI_Rq_MPC_Lt_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_MPC_MsgDisp_Rq_V2 := %X\n", getValue( HMI_LDP_MPC_MsgDisp_Rq_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_IndLmp_SwLED_CI_Rq_MPC_Rt_V2 := %X\n", getValue( HMI_LDP_IndLmp_SwLED_CI_Rq_MPC_Rt_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_Sens_Md_Stat_V2 := %X\n", getValue( HMI_LDP_Sens_Md_Stat_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv0_LDP_Disp_Rq := %X\n", getValue( HMI_Rsrv0_LDP_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_LDP_Disp_Rq := %X\n", getValue( HMI_CRC_LDP_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_Md_V2 := %X\n", getValue( HMI_LDP_Md_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_LDP_Disp_Rq := %X\n", getValue( HMI_SQC_LDP_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_MPC_Ctrl_Stat := %X\n", getValue( HMI_LDP_MPC_Ctrl_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tLDP_Disp_Rq_AR
{
    putValue( HMI__STMSG_LDP_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_LDP_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_LDP_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tLDP_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_LDP_Disp_Rq_AR, 0 );
       }
}

//on EnvVar HMI__STMSGCT_LDP_Disp_Rq_AR
//{
//    if( getValue( this ) > 0 )
//    {
//        _LDP_Disp_Rq_AR_CycleCount = getValue( this ) / _LDP_Disp_Rq_AR_Timebase;     // set cycle counter to initial value
//        _LDP_Disp_Rq_AR_SpontanFlag = 1;
//   }
//}

on envVar HMI__STMSG_PO_LDP_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("LDP_Disp_Rq_AR");
}

on EnvVar HMI_LDP_IndLmp_SwLED_CI_Rq_MPC_Lt_V2
{
    _mLDP_Disp_Rq_AR.LDP_IndLmp_SwLED_CI_Rq_MPC_Lt_V2.phys = getValue(this);
}

on EnvVar HMI_LDP_MPC_Ctrl_Stat
{
    _mLDP_Disp_Rq_AR.LDP_MPC_Ctrl_Stat.phys = getValue(this);
}

on EnvVar HMI_LDP_Md_V2
{
    _mLDP_Disp_Rq_AR.LDP_Md_V2.phys = getValue(this);
}

on EnvVar HMI_LDP_MPC_MsgDisp_Rq_V2
{
    _mLDP_Disp_Rq_AR.LDP_MPC_MsgDisp_Rq_V2.phys = getValue(this);
}

on EnvVar HMI_LDP_IndLmp_SwLED_CI_Rq_MPC_Rt_V2
{
    _mLDP_Disp_Rq_AR.LDP_IndLmp_SwLED_CI_Rq_MPC_Rt_V2.phys = getValue(this);
}

on EnvVar HMI_LDP_Sens_Md_Stat_V2
{
    _mLDP_Disp_Rq_AR.LDP_Sens_Md_Stat_V2.phys = getValue(this);
}

on message Disp_IC_Rq_AR
{
  int i;
  word ResetCauseResp;
  ResetCauseResp = (getRawSignal(Rsrv2_DISP_IC_Rq) << 8) | getRawSignal(Rsrv3_DISP_IC_Rq);
  
  for (i = 0; i < elcount(RstReasons); i++)
      {
        if (ResetCauseResp == RstReasons[i].rstCode)
        {
          putValue(Env_ResetCause, RstReasons[i].rstMessage);
          break;
        }
        else
        {
          putValue(Env_ResetCause, RstReasons[elcount(RstReasons) - 1].rstMessage);
        }
      }
}