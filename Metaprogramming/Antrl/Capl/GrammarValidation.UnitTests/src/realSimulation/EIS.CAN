//            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_33_64_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _EVC_CfgBit_33_64_AR_CRC_Offset[ _mEVC_CfgBit_33_64_AR.SQC_EVC_CfgBit_33_64 ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _EVC_CfgBit_33_64_AR_CRC_ErrorCnt   && ( _EVC_CfgBit_33_64_AR_E2E_Armed == 1   ) ) ||
                ( _EVC_CfgBit_33_64_AR_CRC_ErrorCnt > 0                                                )    )
            {
                crc++;
                if( _EVC_CfgBit_33_64_AR_CRC_ErrorCnt > 0 )
                    _EVC_CfgBit_33_64_AR_CRC_ErrorCnt--; 
            }
            _mEVC_CfgBit_33_64_AR.CRC_EVC_CfgBit_33_64 = crc;
            putValue( HMI_CRC_EVC_CfgBit_33_64, crc );
        }
        else
            _mEVC_CfgBit_33_64_AR.CRC_EVC_CfgBit_33_64 = getValue( HMI_CRC_EVC_CfgBit_33_64 );
    }
    else
    {
        if( !getValue( HMI_CRC_EVC_CfgBit_33_64_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mEVC_CfgBit_33_64_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mEVC_CfgBit_33_64_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_33_64_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_33_64_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_33_64_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_33_64_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_33_64_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_33_64_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _EVC_CfgBit_33_64_AR_CRC_ErrorCnt   && ( _EVC_CfgBit_33_64_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EVC_CfgBit_33_64_Invalid )                                         )    )
            {
                crc++;
                if( _EVC_CfgBit_33_64_AR_CRC_ErrorCnt > 0 )
                    _EVC_CfgBit_33_64_AR_CRC_ErrorCnt--; 
            }
            _mEVC_CfgBit_33_64_AR.CRC_EVC_CfgBit_33_64 = crc;
            putValue( HMI_CRC_EVC_CfgBit_33_64, crc );
        }
        else
            _mEVC_CfgBit_33_64_AR.CRC_EVC_CfgBit_33_64 = getValue( HMI_CRC_EVC_CfgBit_33_64 );
    }

    if( ( _EVC_CfgBit_33_64_AR_MSG_DropCnt > 0 ) &&
        ( _EVC_CfgBit_33_64_AR_E2E_Armed == 1  )    )
    {
        _EVC_CfgBit_33_64_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mEVC_CfgBit_33_64_AR );
        
    if( _EVC_CfgBit_33_64_AR_E2E_Armed == 1 )
    {
        if ( ( _EVC_CfgBit_33_64_AR_MSG_DropCnt == 0      ) &&
             ( _EVC_CfgBit_33_64_AR_CRC_ErrorCnt == 0     ) &&
             ( _EVC_CfgBit_33_64_AR_SQC_RepeatedCnt == 0  ) &&
             ( _EVC_CfgBit_33_64_AR_SQC_WrongSeqJump == 0 )    )
        {
            _EVC_CfgBit_33_64_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_EVC_CfgBit_33_64_State, 0 );
        }
    }
}

EVC_CfgBit_33_64_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: EVC_CfgBit_33_64_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_EVC_CfgBit_33_64 := %X\n", getValue( HMI__STMSG_EVC_CfgBit_33_64_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_EVC_CfgBit_33_64 := %X\n", getValue( HMI__STMSGT_EVC_CfgBit_33_64_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EVC_CfgBit_33_64 := %X\n", getValue( HMI_CRC_EVC_CfgBit_33_64 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EVC_CfgBit_33_64_Auto := %X\n", getValue( HMI_CRC_EVC_CfgBit_33_64_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_33_EmgOpn_F_Avl := %X\n", getValue( HMI_EVC_33_EmgOpn_F_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_34_Curtain_F_Avl := %X\n", getValue( HMI_EVC_34_Curtain_F_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_35_EmgOpn_Inact := %X\n", getValue( HMI_EVC_35_EmgOpn_Inact ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_36_SpecVehPW_FL_Avl := %X\n", getValue( HMI_EVC_36_SpecVehPW_FL_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_37_SpecVehPW_FR_Avl := %X\n", getValue( HMI_EVC_37_SpecVehPW_FR_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_38_SpecVehPW_RL_Avl := %X\n", getValue( HMI_EVC_38_SpecVehPW_RL_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_39_SpecVehPW_RR_Avl := %X\n", getValue( HMI_EVC_39_SpecVehPW_RR_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_3A_RB_F_Avl := %X\n", getValue( HMI_EVC_3A_RB_F_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_3B_RB_R_Avl := %X\n", getValue( HMI_EVC_3B_RB_R_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_3C_SeatDrvDyn_Ft_Avl := %X\n", getValue( HMI_EVC_3C_SeatDrvDyn_Ft_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_3D_ComfHdRst_Ft_Avl := %X\n", getValue( HMI_EVC_3D_ComfHdRst_Ft_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_3E_SeatMultiCont_Ft_Avl := %X\n", getValue( HMI_EVC_3E_SeatMultiCont_Ft_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_3F_SeatHt_Ft_Avl := %X\n", getValue( HMI_EVC_3F_SeatHt_Ft_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_40_SeatClim_Ft_Avl := %X\n", getValue( HMI_EVC_40_SeatClim_Ft_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_41_SeatMem_LHD_Avl := %X\n", getValue( HMI_EVC_41_SeatMem_LHD_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_42_SeatMem_RHD_Avl := %X\n", getValue( HMI_EVC_42_SeatMem_RHD_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_43_SeatMemPk_Avl := %X\n", getValue( HMI_EVC_43_SeatMemPk_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_44_ReclSeat_Avl := %X\n", getValue( HMI_EVC_44_ReclSeat_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_45_SeatMultiCont_R_Avl := %X\n", getValue( HMI_EVC_45_SeatMultiCont_R_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_46_SeatBkRstAdj_R_Avl := %X\n", getValue( HMI_EVC_46_SeatBkRstAdj_R_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_47_SeatHt_R_Avl := %X\n", getValue( HMI_EVC_47_SeatHt_R_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_48_SeatClim_R_Avl := %X\n", getValue( HMI_EVC_48_SeatClim_R_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_49_WShWashHt_Avl := %X\n", getValue( HMI_EVC_49_WShWashHt_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_4A_TaxiPwrSup_Avl := %X\n", getValue( HMI_EVC_4A_TaxiPwrSup_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_4B_TaxiRoofLmpCon_Avl := %X\n", getValue( HMI_EVC_4B_TaxiRoofLmpCon_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_4C_TaxiEmgAlm_Avl := %X\n", getValue( HMI_EVC_4C_TaxiEmgAlm_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_4D_RadioHdFree_Avl := %X\n", getValue( HMI_EVC_4D_RadioHdFree_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_4E_GAS_Avl := %X\n", getValue( HMI_EVC_4E_GAS_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_4F_CtrlU_MultiFunc_Avl := %X\n", getValue( HMI_EVC_4F_CtrlU_MultiFunc_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_50_TaxInMirr_Avl := %X\n", getValue( HMI_EVC_50_TaxInMirr_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_51_DistRecInMirr_Avl := %X\n", getValue( HMI_EVC_51_DistRecInMirr_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_52_PreInstRad_Avl := %X\n", getValue( HMI_EVC_52_PreInstRad_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_53_EVC_53_RetrofitRemCtrl_Avl := %X\n", getValue( HMI_EVC_53_VehHandi_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_54_PanelHt_Ft_Avl := %X\n", getValue( HMI_EVC_54_PanelHt_Ft_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_55_SeatComfHt_Ft_Avl := %X\n", getValue( HMI_EVC_55_SeatComfHt_Ft_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_56_SeatComfHt_R_Avl := %X\n", getValue( HMI_EVC_56_SeatComfHt_R_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_57_IntFoldHdRst_Ft_Avl := %X\n", getValue( HMI_EVC_57_IntFoldHdRst_Ft_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_58_SeatInd_R_Avl := %X\n", getValue( HMI_EVC_58_SeatInd_R_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_59_SeatChauffPos_P_Avl := %X\n", getValue( HMI_EVC_59_SeatChauffPos_P_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_5A_SeatMContMass_Ft_Avl := %X\n", getValue( HMI_EVC_5A_SeatMContMass_Ft_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_EVC_5B_PanelHt_R_Avl_Avl := %X\n", getValue( HMI_EVC_5B_PanelHt_R_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_5C_Airscarf_Ft_Avl := %X\n", getValue( HMI_EVC_5C_Airscarf_Ft_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_5D_SeatLimit_P_Avl := %X\n", getValue( HMI_EVC_5D_SeatLimit_P_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_5E_TaxiRoofLmp_Avl := %X\n", getValue( HMI_EVC_5E_TaxiRoofLmp_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_5F_SeatElAdj_LHD_Avl := %X\n", getValue( HMI_EVC_5F_SeatElAdj_LHD_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_60_SeatElAdj_RHD_Avl := %X\n", getValue( HMI_EVC_60_SeatElAdj_RHD_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_61_AMGPerfSusp_Avl := %X\n", getValue( HMI_EVC_61_AMGPerfSusp_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_62_ShiftExhstSys_Avl := %X\n", getValue( HMI_EVC_62_ShiftExhstSys_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_63_ActvLDA_MPC_Avl := %X\n", getValue( HMI_EVC_63_ActvLDA_MPC_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_64_EAS_Avl := %X\n", getValue( HMI_EVC_64_EAS_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgBit_33_64_Stat := %X\n", getValue( HMI_EVC_CfgBit_33_64_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EVC_CfgBit_33_64 := %X\n", getValue( HMI_SQC_EVC_CfgBit_33_64 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EVC_CfgBit_33_64_Auto := %X\n", getValue( HMI_SQC_EVC_CfgBit_33_64_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tEVC_CfgBit_33_64_AR
{
    putValue( HMI__STMSG_EVC_CfgBit_33_64_AR, 0 );
}

on EnvVar HMI__STMSG_EVC_CfgBit_33_64_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_EVC_CfgBit_33_64_AR );
        if( tDelay > 0)    
            setTimer( _tEVC_CfgBit_33_64_AR, tDelay );
        else
            putValue( HMI__STMSG_EVC_CfgBit_33_64_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_EVC_CfgBit_33_64_AR
{
    if( getValue( this ) )
        openPanel("EVC_CfgBit_33_64_AR");
}

on envVar HMI_E2E_EVC_CfgBit_33_64_Inject
{
    if( getValue( this ) )
    {
        _EVC_CfgBit_33_64_AR_CRC_ErrorCnt = getValue( HMI_CRC_EVC_CfgBit_33_64_ErrorCount );
        _EVC_CfgBit_33_64_AR_SQC_TriggPos = getValue( HMI_SQC_EVC_CfgBit_33_64_TriggerPosition );
        _EVC_CfgBit_33_64_AR_SQC_WrongSeqJump = getValue( HMI_SQC_EVC_CfgBit_33_64_WrongSeq );
        _EVC_CfgBit_33_64_AR_SQC_RepeatedCnt = getValue( HMI_SQC_EVC_CfgBit_33_64_Repeated );
        _EVC_CfgBit_33_64_AR_MSG_DropCnt = getValue( HMI_SQC_EVC_CfgBit_33_64_MSG_DropCnt );
        putValue( HMI_E2E_EVC_CfgBit_33_64_State, 2 );
        _EVC_CfgBit_33_64_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_EVC_33_EmgOpn_F_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_33_EmgOpn_F_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_34_Curtain_F_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_34_Curtain_F_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_35_EmgOpn_Inact
{
    _mEVC_CfgBit_33_64_AR.EVC_35_EmgOpn_Inact.phys = getValue(this);
}

on EnvVar HMI_EVC_36_SpecVehPW_FL_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_36_SpecVehPW_FL_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_37_SpecVehPW_FR_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_37_SpecVehPW_FR_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_38_SpecVehPW_RL_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_38_SpecVehPW_RL_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_39_SpecVehPW_RR_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_39_SpecVehPW_RR_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_3A_RB_F_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_3A_RB_F_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_3B_RB_R_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_3B_RB_R_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_3C_SeatDrvDyn_Ft_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_3C_SeatDrvDyn_Ft_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_3D_ComfHdRst_Ft_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_3D_ComfHdRst_Ft_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_3E_SeatMultiCont_Ft_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_3E_SeatMultiCont_Ft_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_3F_SeatHt_Ft_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_3F_SeatHt_Ft_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_40_SeatClim_Ft_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_40_SeatClim_Ft_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_41_SeatMem_LHD_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_41_SeatMem_LHD_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_42_SeatMem_RHD_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_42_SeatMem_RHD_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_43_SeatMemPk_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_43_SeatMemPk_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_44_ReclSeat_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_44_ReclSeat_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_45_SeatMultiCont_R_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_45_SeatMultiCont_R_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_46_SeatBkRstAdj_R_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_46_SeatBkRstAdj_R_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_47_SeatHt_R_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_47_SeatHt_R_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_48_SeatClim_R_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_48_SeatClim_R_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_49_WShWashHt_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_49_WShWashHt_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_4A_TaxiPwrSup_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_4A_TaxiPwrSup_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_4B_TaxiRoofLmpCon_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_4B_TaxiRoofLmpCon_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_4C_TaxiEmgAlm_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_4C_TaxiEmgAlm_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_4D_RadioHdFree_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_4D_RadioHdFree_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_4E_GAS_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_4E_GAS_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_4F_CtrlU_MultiFunc_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_4F_CtrlU_MultiFunc_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_50_TaxInMirr_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_50_TaxInMirr_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_51_DistRecInMirr_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_51_DistRecInMirr_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_52_PreInstRad_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_52_PreInstRad_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_53_VehHandi_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_53_RetrofitRemCtrl_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_54_PanelHt_Ft_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_54_PanelHt_Ft_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_55_SeatComfHt_Ft_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_55_SeatComfHt_Ft_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_56_SeatComfHt_R_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_56_SeatComfHt_R_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_57_IntFoldHdRst_Ft_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_57_IntFoldHdRst_Ft_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_58_SeatInd_R_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_58_SeatInd_R_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_59_SeatChauffPos_P_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_59_SeatChauffPos_P_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_5A_SeatMContMass_Ft_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_5A_SeatMContMass_Ft_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_5B_PanelHt_R_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_5B_PanelHt_R_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_5C_Airscarf_Ft_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_5C_Airscarf_Ft_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_5D_SeatLimit_P_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_5D_SeatLimit_P_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_5E_TaxiRoofLmp_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_5E_TaxiRoofLmp_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_5F_SeatElAdj_LHD_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_5F_SeatElAdj_LHD_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_60_SeatElAdj_RHD_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_60_SeatElAdj_RHD_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_61_AMGPerfSusp_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_61_AMGPerfSusp_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_62_ShiftExhstSys_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_62_ShiftExhstSys_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_63_ActvLDA_MPC_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_63_ActvLDA_MPC_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_64_EAS_Avl
{
    _mEVC_CfgBit_33_64_AR.EVC_64_EAS_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgBit_33_64_Stat
{
    _mEVC_CfgBit_33_64_AR.EVC_CfgBit_33_64_Stat.phys = getValue(this);
}

EVC_CfgBit_65_96_AR_check_output()
{
    if( !getValue( HMI__STMSG_EVC_CfgBit_65_96_AR ) )
    {
    //  message   EVC_CfgBit_65_96_AR ID: 757 --- Sendeart 0 cyclicX --- 
        _EVC_CfgBit_65_96_AR_Cnt--;
        if( _EVC_CfgBit_65_96_AR_Cnt < 1 )
        {
            EVC_CfgBit_65_96_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _EVC_CfgBit_65_96_AR_Cnt = _EVC_CfgBit_65_96_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

EVC_CfgBit_65_96_AR_init()
{   /* Botschaft EVC_CfgBit_65_96_AR ID: 757 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 757 0;
BA_ "NmAsrMessage" BO_ 757 0;
BA_ "GenMsgMinAcceptLength" BO_ 757 8;
BA_ "GenMsgILSupport" BO_ 757 1;
BA_ "DiagState" BO_ 757 0;
BA_ "DiagRequest" BO_ 757 0;
BA_ "DiagResponse" BO_ 757 0;
BA_ "GenMsgStartValue" BO_ 757 "0";
BA_ "GenMsgStartDelayTime" BO_ 757 145;
BA_ "GenMsgCycleTime" BO_ 757 1000;
BA_ "GenMsgSendType" BO_ 757 0;
    */
    _EVC_CfgBit_65_96_AR_Timebase =        c_tDBKomTimer_20ms;
    _EVC_CfgBit_65_96_AR_CycleCount =    1000 / _EVC_CfgBit_65_96_AR_Timebase;
    _EVC_CfgBit_65_96_AR_StartDelay =     145 / _EVC_CfgBit_65_96_AR_Timebase;
    _EVC_CfgBit_65_96_AR_Cnt = _EVC_CfgBit_65_96_AR_StartDelay;

    putValue( HMI__STMSGSD_EVC_CfgBit_65_96_AR, _EVC_CfgBit_65_96_AR_StartDelay * _EVC_CfgBit_65_96_AR_Timebase );

    _mEVC_CfgBit_65_96_AR.EVC_65_CruiseCtrl_Avl.phys = getValue( HMI_EVC_65_CruiseCtrl_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_66_OffRoadPk_Avl.phys = getValue( HMI_EVC_66_OffRoadPk_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_67_CMS_Avl.phys = getValue( HMI_EVC_67_CMS_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_68_CMS_R_Avl.phys = getValue( HMI_EVC_68_CMS_R_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_69_BrkEngg_PP_Avl.phys = getValue( HMI_EVC_69_BrkEngg_PP_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_6A_BasExtd_Avl.phys = getValue( HMI_EVC_6A_BasExtd_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_6B_MirrFld_Avl.phys = getValue( HMI_EVC_6B_MirrFld_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_6C_BSM_Avl.phys = getValue( HMI_EVC_6C_BSM_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_6D_ActvBSM_Avl.phys = getValue( HMI_EVC_6D_ActvBSM_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_6E_TurnAss_Avl.phys = getValue( HMI_EVC_6E_TurnAss_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_6F_ADTR_Avl.phys = getValue( HMI_EVC_6F_ADTR_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_70_DTR_Pro_Avl.phys = getValue( HMI_EVC_70_DTR_Pro_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_71_ALS_Avl.phys = getValue( HMI_EVC_71_ALS_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_72_ActvLDA_Avl.phys = getValue( HMI_EVC_72_ActvLDA_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_73_FCW_Avl.phys = getValue( HMI_EVC_73_FCW_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_74_LaneRec_Avl.phys = getValue( HMI_EVC_74_LaneRec_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_75_NV_Avl.phys = getValue( HMI_EVC_75_NV_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_76_RoadSignDtct_Avl.phys = getValue( HMI_EVC_76_RoadSignDtct_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_77_RVC_Avl.phys = getValue( HMI_EVC_77_RVC_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_78_SurrView_Avl.phys = getValue( HMI_EVC_78_SurrView_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_79_PTS_Avl.phys = getValue( HMI_EVC_79_PTS_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_7A_APG_Avl.phys = getValue( HMI_EVC_7A_APG_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_7B_ActPKAS_Avl .phys = getValue( HMI_EVC_7B_ActPKAS_Avl  );
    _mEVC_CfgBit_65_96_AR.EVC_7C_IHC_Avl.phys = getValue( HMI_EVC_7C_IHC_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_7D_IHC_Plus_Avl.phys = getValue( HMI_EVC_7D_IHC_Plus_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_7E_BasPlusQ_Avl.phys = getValue( HMI_EVC_7E_BasPlusQ_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_7F_ECO_St_Avl.phys = getValue( HMI_EVC_7F_ECO_St_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_80_PSTS_Avl.phys = getValue( HMI_EVC_80_PSTS_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_81_ABC_Avl.phys = getValue( HMI_EVC_81_ABC_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_82_SteelAirSusp_Avl.phys = getValue( HMI_EVC_82_SteelAirSusp_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_83_AirSemiActv_Susp_Avl.phys = getValue( HMI_EVC_83_AirSemiActv_Susp_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_84_SportSusp_Avl.phys = getValue( HMI_EVC_84_SportSusp_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_85_SportPk_AMG_Avl.phys = getValue( HMI_EVC_85_SportPk_AMG_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_86_SportPk_Avl.phys = getValue( HMI_EVC_86_SportPk_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_87_SportPk_Ext_Avl.phys = getValue( HMI_EVC_87_SportPk_Ext_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_88_DualView_Avl.phys = getValue( HMI_EVC_88_DualView_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_89_Entertain_R_Avl.phys = getValue( HMI_EVC_89_Entertain_R_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_8A_DigTV_Avl.phys = getValue( HMI_EVC_8A_DigTV_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_8B_DAB_Tun_Avl.phys = getValue( HMI_EVC_8B_DAB_Tun_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_8C_MTUS_Avl.phys = getValue( HMI_EVC_8C_MTUS_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_8D_UCI_Avl.phys = getValue( HMI_EVC_8D_UCI_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_8E_SndSys_Avl.phys = getValue( HMI_EVC_8E_SndSys_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_8F_WShViewWin_Avl.phys = getValue( HMI_EVC_8F_WShViewWin_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_90_WSh_Clr_Avl.phys = getValue( HMI_EVC_90_WSh_Clr_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_91_WSh_Ht_Avl.phys = getValue( HMI_EVC_91_WSh_Ht_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_92_WShBL_Prot_Avl.phys = getValue( HMI_EVC_92_WShBL_Prot_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_93_WSh_Ht_Lcut_Avl.phys = getValue( HMI_EVC_93_WSh_Ht_Lcut_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_94_OptPack_Clas_Avl.phys = getValue( HMI_EVC_94_OptPack_Clas_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_95_OptPack_Avan_Avl.phys = getValue( HMI_EVC_95_OptPack_Avan_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_96_OptPack_Eleg_Avl.phys = getValue( HMI_EVC_96_OptPack_Eleg_Avl );
    _mEVC_CfgBit_65_96_AR.EVC_CfgBit_65_96_Stat.phys = getValue( HMI_EVC_CfgBit_65_96_Stat );
}

EVC_CfgBit_65_96_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_EVC_CfgBit_65_96 ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_EVC_CfgBit_65_96_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _EVC_CfgBit_65_96_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _EVC_CfgBit_65_96_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_EVC_CfgBit_65_96_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _EVC_CfgBit_65_96_AR_SQC_WrongSeqJump != 0 ) &&
            ( _EVC_CfgBit_65_96_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _EVC_CfgBit_65_96_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _EVC_CfgBit_65_96_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _EVC_CfgBit_65_96_AR_SQC_RepeatedCnt ) &&
            ( _EVC_CfgBit_65_96_AR_E2E_Armed == 1  )    )
        {
            _EVC_CfgBit_65_96_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_EVC_CfgBit_65_96, SQC_help );
    }
    _mEVC_CfgBit_65_96_AR.SQC_EVC_CfgBit_65_96 = SQC_help;

    if( getValue( HMI_CRC_EVC_CfgBit_65_96_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_EVC_CfgBit_65_96_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mEVC_CfgBit_65_96_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_65_96_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_65_96_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_65_96_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_65_96_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_65_96_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_65_96_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_65_96_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _EVC_CfgBit_65_96_AR_CRC_Offset[ _mEVC_CfgBit_65_96_AR.SQC_EVC_CfgBit_65_96 ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _EVC_CfgBit_65_96_AR_CRC_ErrorCnt   && ( _EVC_CfgBit_65_96_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EVC_CfgBit_65_96_Invalid )                                         )    )
            {
                crc++;
                if( _EVC_CfgBit_65_96_AR_CRC_ErrorCnt > 0 )
                    _EVC_CfgBit_65_96_AR_CRC_ErrorCnt--; 
            }
            _mEVC_CfgBit_65_96_AR.CRC_EVC_CfgBit_65_96 = crc;
            putValue( HMI_CRC_EVC_CfgBit_65_96, crc );
        }
        else
            _mEVC_CfgBit_65_96_AR.CRC_EVC_CfgBit_65_96 = getValue( HMI_CRC_EVC_CfgBit_65_96 );
    }
    else
    {
        if( !getValue( HMI_CRC_EVC_CfgBit_65_96_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mEVC_CfgBit_65_96_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mEVC_CfgBit_65_96_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_65_96_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_65_96_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_65_96_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_65_96_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_65_96_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_65_96_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _EVC_CfgBit_65_96_AR_CRC_ErrorCnt   && ( _EVC_CfgBit_65_96_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EVC_CfgBit_65_96_Invalid )                                         )    )
            {
                crc++;
                if( _EVC_CfgBit_65_96_AR_CRC_ErrorCnt > 0 )
                    _EVC_CfgBit_65_96_AR_CRC_ErrorCnt--; 
            }
            _mEVC_CfgBit_65_96_AR.CRC_EVC_CfgBit_65_96 = crc;
            putValue( HMI_CRC_EVC_CfgBit_65_96, crc );
        }
        else
            _mEVC_CfgBit_65_96_AR.CRC_EVC_CfgBit_65_96 = getValue( HMI_CRC_EVC_CfgBit_65_96 );
    }
    if( ( _EVC_CfgBit_65_96_AR_MSG_DropCnt > 0 ) &&
        ( _EVC_CfgBit_65_96_AR_E2E_Armed == 1  )    )
    {
        _EVC_CfgBit_65_96_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mEVC_CfgBit_65_96_AR );
        
    if( _EVC_CfgBit_65_96_AR_E2E_Armed == 1 )
    {
        if ( ( _EVC_CfgBit_65_96_AR_MSG_DropCnt == 0      ) &&
             ( _EVC_CfgBit_65_96_AR_CRC_ErrorCnt == 0     ) &&
             ( _EVC_CfgBit_65_96_AR_SQC_RepeatedCnt == 0  ) &&
             ( _EVC_CfgBit_65_96_AR_SQC_WrongSeqJump == 0 )    )
        {
            _EVC_CfgBit_65_96_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_EVC_CfgBit_65_96_State, 0 );
        }
    }
}

EVC_CfgBit_65_96_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: EVC_CfgBit_65_96_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_EVC_CfgBit_65_96 := %X\n", getValue( HMI__STMSG_EVC_CfgBit_65_96_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_EVC_CfgBit_65_96 := %X\n", getValue( HMI__STMSGT_EVC_CfgBit_65_96_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EVC_CfgBit_65_96 := %X\n", getValue( HMI_CRC_EVC_CfgBit_65_96 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EVC_CfgBit_65_96_Auto := %X\n", getValue( HMI_CRC_EVC_CfgBit_65_96_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_65_CruiseCtrl_Avl := %X\n", getValue( HMI_EVC_65_CruiseCtrl_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_66_OffRoadPk_Avl := %X\n", getValue( HMI_EVC_66_OffRoadPk_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_67_CMS_Avl := %X\n", getValue( HMI_EVC_67_CMS_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_68_CMS_R_Avl := %X\n", getValue( HMI_EVC_68_CMS_R_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_69_BrkEngg_PP_Avl := %X\n", getValue( HMI_EVC_69_BrkEngg_PP_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_6A_BasExtd_Avl := %X\n", getValue( HMI_EVC_6A_BasExtd_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_6B_MirrFld_Avl := %X\n", getValue( HMI_EVC_6B_MirrFld_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_6C_BSM_Avl := %X\n", getValue( HMI_EVC_6C_BSM_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_6D_ActvBSM_Avl := %X\n", getValue( HMI_EVC_6D_ActvBSM_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_6E_TurnAss_Avl := %X\n", getValue( HMI_EVC_6E_TurnAss_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_6F_ADTR_Avl := %X\n", getValue( HMI_EVC_6F_ADTR_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_70_DTR_Pro_Avl := %X\n", getValue( HMI_EVC_70_DTR_Pro_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_71_ALS_Avl := %X\n", getValue( HMI_EVC_71_ALS_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_72_ActvLDA_Avl := %X\n", getValue( HMI_EVC_72_ActvLDA_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_73_FCW_Avl := %X\n", getValue( HMI_EVC_73_FCW_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_74_LaneRec_Avl := %X\n", getValue( HMI_EVC_74_LaneRec_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_75_NV_Avl := %X\n", getValue( HMI_EVC_75_NV_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_76_RoadSignDtct_Avl := %X\n", getValue( HMI_EVC_76_RoadSignDtct_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_77_RVC_Avl := %X\n", getValue( HMI_EVC_77_RVC_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_78_SurrView_Avl := %X\n", getValue( HMI_EVC_78_SurrView_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_79_PTS_Avl := %X\n", getValue( HMI_EVC_79_PTS_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_7A_APG_Avl := %X\n", getValue( HMI_EVC_7A_APG_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_7B_ActPKAS_Avl  := %X\n", getValue( HMI_EVC_7B_ActPKAS_Avl  ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_7C_IHC_Avl := %X\n", getValue( HMI_EVC_7C_IHC_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_7D_IHC_Plus_Avl := %X\n", getValue( HMI_EVC_7D_IHC_Plus_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_7E_BasPlusQ_Avl := %X\n", getValue( HMI_EVC_7E_BasPlusQ_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_7F_ECO_St_Avl := %X\n", getValue( HMI_EVC_7F_ECO_St_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_80_PSTS_Avl := %X\n", getValue( HMI_EVC_80_PSTS_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_81_ABC_Avl := %X\n", getValue( HMI_EVC_81_ABC_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_82_SteelAirSusp_Avl := %X\n", getValue( HMI_EVC_82_SteelAirSusp_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_83_AirSemiActv_Susp_Avl := %X\n", getValue( HMI_EVC_83_AirSemiActv_Susp_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_84_SportSusp_Avl := %X\n", getValue( HMI_EVC_84_SportSusp_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_85_SportPk_AMG_Avl := %X\n", getValue( HMI_EVC_85_SportPk_AMG_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_86_SportPk_Avl := %X\n", getValue( HMI_EVC_86_SportPk_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_87_SportPk_Ext_Avl := %X\n", getValue( HMI_EVC_87_SportPk_Ext_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_88_DualView_Avl := %X\n", getValue( HMI_EVC_88_DualView_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_89_Entertain_R_Avl := %X\n", getValue( HMI_EVC_89_Entertain_R_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_8A_DigTV_Avl := %X\n", getValue( HMI_EVC_8A_DigTV_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_8B_DAB_Tun_Avl := %X\n", getValue( HMI_EVC_8B_DAB_Tun_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_8C_MTUS_Avl := %X\n", getValue( HMI_EVC_8C_MTUS_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_8D_UCI_Avl := %X\n", getValue( HMI_EVC_8D_UCI_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_8E_SndSys_Avl := %X\n", getValue( HMI_EVC_8E_SndSys_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_8F_WShViewWin_Avl := %X\n", getValue( HMI_EVC_8F_WShViewWin_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_90_WSh_Clr_Avl := %X\n", getValue( HMI_EVC_90_WSh_Clr_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_91_WSh_Ht_Avl := %X\n", getValue( HMI_EVC_91_WSh_Ht_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_92_WShBL_Prot_Avl := %X\n", getValue( HMI_EVC_92_WShBL_Prot_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_93_WSh_Ht_Lcut_Avl := %X\n", getValue( HMI_EVC_93_WSh_Ht_Lcut_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_94_OptPack_Clas_Avl := %X\n", getValue( HMI_EVC_94_OptPack_Clas_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_95_OptPack_Avan_Avl := %X\n", getValue( HMI_EVC_95_OptPack_Avan_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_96_OptPack_Eleg_Avl := %X\n", getValue( HMI_EVC_96_OptPack_Eleg_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgBit_65_96_Stat := %X\n", getValue( HMI_EVC_CfgBit_65_96_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EVC_CfgBit_65_96 := %X\n", getValue( HMI_SQC_EVC_CfgBit_65_96 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EVC_CfgBit_65_96_Auto := %X\n", getValue( HMI_SQC_EVC_CfgBit_65_96_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tEVC_CfgBit_65_96_AR
{
    putValue( HMI__STMSG_EVC_CfgBit_65_96_AR, 0 );
}

on EnvVar HMI__STMSG_EVC_CfgBit_65_96_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_EVC_CfgBit_65_96_AR );
        if( tDelay > 0)    
            setTimer( _tEVC_CfgBit_65_96_AR, tDelay );
        else
            putValue( HMI__STMSG_EVC_CfgBit_65_96_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_EVC_CfgBit_65_96_AR
{
    if( getValue( this ) )
        openPanel("EVC_CfgBit_65_96_AR");
}

on envVar HMI_E2E_EVC_CfgBit_65_96_Inject
{
    if( getValue( this ) )
    {
        _EVC_CfgBit_65_96_AR_CRC_ErrorCnt = getValue( HMI_CRC_EVC_CfgBit_65_96_ErrorCount );
        _EVC_CfgBit_65_96_AR_SQC_TriggPos = getValue( HMI_SQC_EVC_CfgBit_65_96_TriggerPosition );
        _EVC_CfgBit_65_96_AR_SQC_WrongSeqJump = getValue( HMI_SQC_EVC_CfgBit_65_96_WrongSeq );
        _EVC_CfgBit_65_96_AR_SQC_RepeatedCnt = getValue( HMI_SQC_EVC_CfgBit_65_96_Repeated );
        _EVC_CfgBit_65_96_AR_MSG_DropCnt = getValue( HMI_SQC_EVC_CfgBit_65_96_MSG_DropCnt );
        putValue( HMI_E2E_EVC_CfgBit_65_96_State, 2 );
        _EVC_CfgBit_65_96_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_EVC_65_CruiseCtrl_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_65_CruiseCtrl_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_66_OffRoadPk_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_66_OffRoadPk_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_67_CMS_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_67_CMS_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_68_CMS_R_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_68_CMS_R_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_69_BrkEngg_PP_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_69_BrkEngg_PP_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_6A_BasExtd_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_6A_BasExtd_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_6B_MirrFld_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_6B_MirrFld_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_6C_BSM_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_6C_BSM_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_6D_ActvBSM_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_6D_ActvBSM_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_6E_TurnAss_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_6E_TurnAss_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_6F_ADTR_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_6F_ADTR_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_70_DTR_Pro_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_70_DTR_Pro_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_71_ALS_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_71_ALS_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_72_ActvLDA_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_72_ActvLDA_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_73_FCW_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_73_FCW_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_74_LaneRec_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_74_LaneRec_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_75_NV_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_75_NV_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_76_RoadSignDtct_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_76_RoadSignDtct_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_77_RVC_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_77_RVC_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_78_SurrView_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_78_SurrView_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_79_PTS_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_79_PTS_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_7A_APG_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_7A_APG_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_7B_ActPKAS_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_7B_ActPKAS_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_7C_IHC_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_7C_IHC_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_7D_IHC_Plus_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_7D_IHC_Plus_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_7E_BasPlusQ_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_7E_BasPlusQ_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_7F_ECO_St_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_7F_ECO_St_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_80_PSTS_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_80_PSTS_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_81_ABC_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_81_ABC_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_82_SteelAirSusp_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_82_SteelAirSusp_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_83_AirSemiActv_Susp_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_83_AirSemiActv_Susp_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_84_SportSusp_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_84_SportSusp_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_85_SportPk_AMG_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_85_SportPk_AMG_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_86_SportPk_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_86_SportPk_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_87_SportPk_Ext_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_87_SportPk_Ext_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_88_DualView_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_88_DualView_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_89_Entertain_R_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_89_Entertain_R_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_8A_DigTV_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_8A_DigTV_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_8B_DAB_Tun_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_8B_DAB_Tun_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_8C_MTUS_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_8C_MTUS_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_8D_UCI_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_8D_UCI_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_8E_SndSys_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_8E_SndSys_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_8F_WShViewWin_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_8F_WShViewWin_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_90_WSh_Clr_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_90_WSh_Clr_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_91_WSh_Ht_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_91_WSh_Ht_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_92_WShBL_Prot_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_92_WShBL_Prot_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_93_WSh_Ht_Lcut_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_93_WSh_Ht_Lcut_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_94_OptPack_Clas_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_94_OptPack_Clas_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_95_OptPack_Avan_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_95_OptPack_Avan_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_96_OptPack_Eleg_Avl
{
    _mEVC_CfgBit_65_96_AR.EVC_96_OptPack_Eleg_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgBit_65_96_Stat
{
    _mEVC_CfgBit_65_96_AR.EVC_CfgBit_65_96_Stat.phys = getValue(this);
}

EVC_CfgBit_97_C8_AR_check_output()
{
    if( !getValue( HMI__STMSG_EVC_CfgBit_97_C8_AR ) )
    {
    //  message   EVC_CfgBit_97_C8_AR ID: 910 --- Sendeart 0 cyclicX --- 
        _EVC_CfgBit_97_C8_AR_Cnt--;
        if( _EVC_CfgBit_97_C8_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            EVC_CfgBit_97_C8_AR_output();
            // Zyklus-Z�hler zur�cksetzen
            _EVC_CfgBit_97_C8_AR_Cnt = _EVC_CfgBit_97_C8_AR_CycleCount;
        }
    }
}

EVC_CfgBit_97_C8_AR_init()
{   /* Botschaft EVC_CfgBit_97_C8_AR ID: 910 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 910 0;
BA_ "NmAsrMessage" BO_ 910 0;
BA_ "GenMsgMinAcceptLength" BO_ 910 8;
BA_ "GenMsgILSupport" BO_ 910 1;
BA_ "DiagState" BO_ 910 0;
BA_ "DiagRequest" BO_ 910 0;
BA_ "DiagResponse" BO_ 910 0;
BA_ "GenMsgStartValue" BO_ 910 "0";
BA_ "GenMsgStartDelayTime" BO_ 910 245;
BA_ "GenMsgCycleTime" BO_ 910 1000;
BA_ "GenMsgSendType" BO_ 910 0;
    */
    _EVC_CfgBit_97_C8_AR_Timebase =        c_tDBKomTimer_20ms;
    _EVC_CfgBit_97_C8_AR_CycleCount =    1000 / _EVC_CfgBit_97_C8_AR_Timebase;
    _EVC_CfgBit_97_C8_AR_StartDelay =     245 / _EVC_CfgBit_97_C8_AR_Timebase;
    _EVC_CfgBit_97_C8_AR_Cnt = _EVC_CfgBit_97_C8_AR_StartDelay;

    putValue( HMI__STMSGSD_EVC_CfgBit_97_C8_AR, _EVC_CfgBit_97_C8_AR_StartDelay * _EVC_CfgBit_97_C8_AR_Timebase );

    _mEVC_CfgBit_97_C8_AR.EVC_97_ConvStWhlOp_AssSys_Avl.phys = getValue( HMI_EVC_97_ConvStWhlOp_AssSys_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_98_AMG_PerfSeat_Avl.phys = getValue( HMI_EVC_98_AMG_PerfSeat_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_99_RemPark_Avl.phys = getValue( HMI_EVC_99_RemPark_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_9A_PresfImpls_Sd_Avl.phys = getValue( HMI_EVC_9A_PresfImpls_Sd_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_9B_ADSPlus_Avl.phys = getValue( HMI_EVC_9B_ADSPlus_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_9C_PullmanGuard_Avl.phys = getValue( HMI_EVC_9C_PullmanGuard_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_9D_Allroad_Avl.phys = getValue( HMI_EVC_9D_Allroad_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_9E_ActvRollStabil_Avl.phys = getValue( HMI_EVC_9E_ActvRollStabil_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_9F_SpdLmtRec_Avl.phys = getValue( HMI_EVC_9F_SpdLmtRec_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_A0_FondComfPk_Avl.phys = getValue( HMI_EVC_A0_FondComfPk_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_A1_eSuspension_Airmatic_Avl.phys = getValue( HMI_EVC_A1_eSuspension_Airmatic_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_A2_OffroadSuspension_Avl.phys = getValue( HMI_EVC_A2_OffroadSuspension_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_A3_ADSPlus_Airmatic_Avl.phys = getValue( HMI_EVC_A3_ADSPlus_Airmatic_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_A4_SeatVario_R_Avl.phys = getValue( HMI_EVC_A4_SeatVario_R_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_A5_7Seater_R3_Avl.phys = getValue( HMI_EVC_A5_7Seater_R3_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_A6_PreInstEntertain_Avl.phys = getValue( HMI_EVC_A6_PreInstEntertain_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_A7_EngHiPerfInc_Avl.phys = getValue( HMI_EVC_A7_EngHiPerfInc_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_A8_SeatElAdj_HghtHdRst_NoMem_Avl.phys = getValue( HMI_EVC_A8_SeatElAdj_HghtHdRst_NoMem_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_A9_SemiActvRollStabil_Avl.phys = getValue( HMI_EVC_A9_SemiActvRollStabil_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_AA_LaneCorrWithStIntrvntn_Avl.phys = getValue( HMI_EVC_AA_LaneCorrWithStIntrvntn_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_AB_AddEquip_Avl.phys = getValue( HMI_EVC_AB_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_AC_AddEquip_Avl.phys = getValue( HMI_EVC_AC_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_AD_AddEquip_Avl.phys = getValue( HMI_EVC_AD_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_AE_AddEquip_Avl.phys = getValue( HMI_EVC_AE_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_AF_AddEquip_Avl.phys = getValue( HMI_EVC_AF_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_B0_AddEquip_Avl.phys = getValue( HMI_EVC_B0_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_B1_AddEquip_Avl.phys = getValue( HMI_EVC_B1_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_B2_AddEquip_Avl.phys = getValue( HMI_EVC_B2_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_B3_AddEquip_Avl.phys = getValue( HMI_EVC_B3_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_B4_AddEquip_Avl.phys = getValue( HMI_EVC_B4_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_B5_AddEquip_Avl.phys = getValue( HMI_EVC_B5_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_B6_AddEquip_Avl.phys = getValue( HMI_EVC_B6_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_B7_AddEquip_Avl.phys = getValue( HMI_EVC_B7_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_B8_AddEquip_Avl.phys = getValue( HMI_EVC_B8_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_B9_AddEquip_Avl.phys = getValue( HMI_EVC_B9_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_BA_AddEquip_Avl.phys = getValue( HMI_EVC_BA_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_BB_AddEquip_Avl.phys = getValue( HMI_EVC_BB_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_BC_AddEquip_Avl.phys = getValue( HMI_EVC_BC_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_BD_AddEquip_Avl.phys = getValue( HMI_EVC_BD_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_BE_AddEquip_Avl.phys = getValue( HMI_EVC_BE_AddEquip_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_BF_AEJx0_2_Avl.phys = getValue( HMI_EVC_BF_AEJx0_2_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_C0_AEJx1_2_Avl.phys = getValue( HMI_EVC_C0_AEJx1_2_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_C1_AEJx2_2_Avl.phys = getValue( HMI_EVC_C1_AEJx2_2_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_C2_AEJx3_2_Avl.phys = getValue( HMI_EVC_C2_AEJx3_2_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_C3_AEJx4_2_Avl.phys = getValue( HMI_EVC_C3_AEJx4_2_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_C4_AEJx5_2_Avl.phys = getValue( HMI_EVC_C4_AEJx5_2_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_C5_AEJx6_2_Avl.phys = getValue( HMI_EVC_C5_AEJx6_2_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_C6_AEJx7_2_Avl.phys = getValue( HMI_EVC_C6_AEJx7_2_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_C7_AEJx8_2_Avl.phys = getValue( HMI_EVC_C7_AEJx8_2_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_C8_AEJx9_2_Avl.phys = getValue( HMI_EVC_C8_AEJx9_2_Avl );
    _mEVC_CfgBit_97_C8_AR.EVC_CfgBit_97_C8_Stat.phys = getValue( HMI_EVC_CfgBit_97_C8_Stat );
}

EVC_CfgBit_97_C8_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_EVC_CfgBit_97_C8 ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_EVC_CfgBit_97_C8_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _EVC_CfgBit_97_C8_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _EVC_CfgBit_97_C8_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_EVC_CfgBit_97_C8_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _EVC_CfgBit_97_C8_AR_SQC_WrongSeqJump != 0 ) &&
            ( _EVC_CfgBit_97_C8_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _EVC_CfgBit_97_C8_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _EVC_CfgBit_97_C8_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _EVC_CfgBit_97_C8_AR_SQC_RepeatedCnt ) &&
            ( _EVC_CfgBit_97_C8_AR_E2E_Armed == 1  )    )
        {
            _EVC_CfgBit_97_C8_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_EVC_CfgBit_97_C8, SQC_help );
    }
    _mEVC_CfgBit_97_C8_AR.SQC_EVC_CfgBit_97_C8 = SQC_help;

    if( getValue( HMI_CRC_EVC_CfgBit_97_C8_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_EVC_CfgBit_97_C8_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mEVC_CfgBit_97_C8_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_97_C8_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_97_C8_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_97_C8_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_97_C8_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_97_C8_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_97_C8_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_97_C8_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _EVC_CfgBit_97_C8_AR_CRC_Offset[ _mEVC_CfgBit_97_C8_AR.SQC_EVC_CfgBit_97_C8 ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _EVC_CfgBit_97_C8_AR_CRC_ErrorCnt   && ( _EVC_CfgBit_97_C8_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EVC_CfgBit_97_C8_Invalid )                                         )    )
            {
                crc++;
                if( _EVC_CfgBit_97_C8_AR_CRC_ErrorCnt > 0 )
                    _EVC_CfgBit_97_C8_AR_CRC_ErrorCnt--; 
            }
            _mEVC_CfgBit_97_C8_AR.CRC_EVC_CfgBit_97_C8 = crc;
            putValue( HMI_CRC_EVC_CfgBit_97_C8, crc );
        }
        else
            _mEVC_CfgBit_97_C8_AR.CRC_EVC_CfgBit_97_C8 = getValue( HMI_CRC_EVC_CfgBit_97_C8 );
    }
    else
    {
        if( !getValue( HMI_CRC_EVC_CfgBit_97_C8_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mEVC_CfgBit_97_C8_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mEVC_CfgBit_97_C8_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_97_C8_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_97_C8_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_97_C8_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_97_C8_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_97_C8_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_97_C8_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _EVC_CfgBit_97_C8_AR_CRC_ErrorCnt   && ( _EVC_CfgBit_97_C8_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EVC_CfgBit_97_C8_Invalid )                                         )    )
            {
                crc++;
                if( _EVC_CfgBit_97_C8_AR_CRC_ErrorCnt > 0 )
                    _EVC_CfgBit_97_C8_AR_CRC_ErrorCnt--; 
            }
            _mEVC_CfgBit_97_C8_AR.CRC_EVC_CfgBit_97_C8 = crc;
            putValue( HMI_CRC_EVC_CfgBit_97_C8, crc );
        }
        else
            _mEVC_CfgBit_97_C8_AR.CRC_EVC_CfgBit_97_C8 = getValue( HMI_CRC_EVC_CfgBit_97_C8 );
    }
    if( ( _EVC_CfgBit_97_C8_AR_MSG_DropCnt > 0 ) &&
        ( _EVC_CfgBit_97_C8_AR_E2E_Armed == 1  )    )
    {
        _EVC_CfgBit_97_C8_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mEVC_CfgBit_97_C8_AR );
        
    if( _EVC_CfgBit_97_C8_AR_E2E_Armed == 1 )
    {
        if ( ( _EVC_CfgBit_97_C8_AR_MSG_DropCnt == 0      ) &&
             ( _EVC_CfgBit_97_C8_AR_CRC_ErrorCnt == 0     ) &&
             ( _EVC_CfgBit_97_C8_AR_SQC_RepeatedCnt == 0  ) &&
             ( _EVC_CfgBit_97_C8_AR_SQC_WrongSeqJump == 0 )    )
        {
            _EVC_CfgBit_97_C8_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_EVC_CfgBit_97_C8_State, 0 );
        }
    }
}

EVC_CfgBit_97_C8_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: EVC_CfgBit_97_C8_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_EVC_CfgBit_97_C8 := %X\n", getValue( HMI__STMSG_EVC_CfgBit_97_C8_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_EVC_CfgBit_97_C8 := %X\n", getValue( HMI__STMSGT_EVC_CfgBit_97_C8_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EVC_CfgBit_97_C8 := %X\n", getValue( HMI_CRC_EVC_CfgBit_97_C8 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EVC_CfgBit_97_C8_Auto := %X\n", getValue( HMI_CRC_EVC_CfgBit_97_C8_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_97_ConvStWhlOp_AssSys_Avl := %X\n", getValue( HMI_EVC_97_ConvStWhlOp_AssSys_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_98_AMG_PerfSeat_Avl := %X\n", getValue( HMI_EVC_98_AMG_PerfSeat_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_99_RemPark_Avl := %X\n", getValue( HMI_EVC_99_RemPark_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_9A_PresfImpls_Sd_Avl := %X\n", getValue( HMI_EVC_9A_PresfImpls_Sd_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_9B_ADSPlus_Avl := %X\n", getValue( HMI_EVC_9B_ADSPlus_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_9C_PullmanGuard_Avl := %X\n", getValue( HMI_EVC_9C_PullmanGuard_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_9D_Allroad_Avl := %X\n", getValue( HMI_EVC_9D_Allroad_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_9E_ActvRollStabil_Avl := %X\n", getValue( HMI_EVC_9E_ActvRollStabil_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_9F_SpdLmtRec_Avl := %X\n", getValue( HMI_EVC_9F_SpdLmtRec_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_2F_RetrofitFuelcell_Avl := %X\n", getValue( HMI_EVC_2F_RetrofitFuelcell_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_A1_eSuspension_Airmatic_Avl := %X\n", getValue( HMI_EVC_A1_eSuspension_Airmatic_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_A2_OffroadSuspension_Avl := %X\n", getValue( HMI_EVC_A2_OffroadSuspension_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_A3_ADSPlus_Airmatic_Avl := %X\n", getValue( HMI_EVC_A3_ADSPlus_Airmatic_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_A4_SeatVario_R_Avl := %X\n", getValue( HMI_EVC_A4_SeatVario_R_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_A5_7Seater_R3_Avl := %X\n", getValue( HMI_EVC_A5_7Seater_R3_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_A6_PreInstEntertain_Avl := %X\n", getValue( HMI_EVC_A6_PreInstEntertain_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_A7_EngHiPerfInc_Avl := %X\n", getValue( HMI_EVC_A7_EngHiPerfInc_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_A8_SeatElAdj_HghtHdRst_NoMem_Avl := %X\n", getValue( HMI_EVC_A8_SeatElAdj_HghtHdRst_NoMem_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_A9_SemiActvRollStabil_Avl := %X\n", getValue( HMI_EVC_A9_SemiActvRollStabil_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_AA_LaneCorrWithStIntrvntn_Avl := %X\n", getValue( HMI_EVC_AA_LaneCorrWithStIntrvntn_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_AB_AddEquip_Avl := %X\n", getValue( HMI_EVC_AB_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_AC_AddEquip_Avl := %X\n", getValue( HMI_EVC_AC_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_AD_AddEquip_Avl := %X\n", getValue( HMI_EVC_AD_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_AE_AddEquip_Avl := %X\n", getValue( HMI_EVC_AE_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_AF_AddEquip_Avl := %X\n", getValue( HMI_EVC_AF_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_B0_AddEquip_Avl := %X\n", getValue( HMI_EVC_B0_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_B1_AddEquip_Avl := %X\n", getValue( HMI_EVC_B1_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_B2_AddEquip_Avl := %X\n", getValue( HMI_EVC_B2_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_B3_AddEquip_Avl := %X\n", getValue( HMI_EVC_B3_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_B4_AddEquip_Avl := %X\n", getValue( HMI_EVC_B4_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_B5_AddEquip_Avl := %X\n", getValue( HMI_EVC_B5_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_B6_AddEquip_Avl := %X\n", getValue( HMI_EVC_B6_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_B7_AddEquip_Avl := %X\n", getValue( HMI_EVC_B7_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_B8_AddEquip_Avl := %X\n", getValue( HMI_EVC_B8_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_B9_AddEquip_Avl := %X\n", getValue( HMI_EVC_B9_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_BA_AddEquip_Avl := %X\n", getValue( HMI_EVC_BA_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_BB_AddEquip_Avl := %X\n", getValue( HMI_EVC_BB_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_BC_AddEquip_Avl := %X\n", getValue( HMI_EVC_BC_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_BD_AddEquip_Avl := %X\n", getValue( HMI_EVC_BD_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_BE_AddEquip_Avl := %X\n", getValue( HMI_EVC_BE_AddEquip_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_BF_AEJx0_2_Avl := %X\n", getValue( HMI_EVC_BF_AEJx0_2_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_C0_AEJx1_2_Avl := %X\n", getValue( HMI_EVC_C0_AEJx1_2_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_C1_AEJx2_2_Avl := %X\n", getValue( HMI_EVC_C1_AEJx2_2_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_C2_AEJx3_2_Avl := %X\n", getValue( HMI_EVC_C2_AEJx3_2_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_C3_AEJx4_2_Avl := %X\n", getValue( HMI_EVC_C3_AEJx4_2_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_C4_AEJx5_2_Avl := %X\n", getValue( HMI_EVC_C4_AEJx5_2_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_C5_AEJx6_2_Avl := %X\n", getValue( HMI_EVC_C5_AEJx6_2_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_C6_AEJx7_2_Avl := %X\n", getValue( HMI_EVC_C6_AEJx7_2_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_C7_AEJx8_2_Avl := %X\n", getValue( HMI_EVC_C7_AEJx8_2_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_C8_AEJx9_2_Avl := %X\n", getValue( HMI_EVC_C8_AEJx9_2_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgBit_97_C8_Stat := %X\n", getValue( HMI_EVC_CfgBit_97_C8_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EVC_CfgBit_97_C8 := %X\n", getValue( HMI_SQC_EVC_CfgBit_97_C8 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EVC_CfgBit_97_C8_Auto := %X\n", getValue( HMI_SQC_EVC_CfgBit_97_C8_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tEVC_CfgBit_97_C8_AR
{
    putValue( HMI__STMSG_EVC_CfgBit_97_C8_AR, 0 );
}

on EnvVar HMI__STMSG_EVC_CfgBit_97_C8_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_EVC_CfgBit_97_C8_AR );
        if( tDelay > 0)    
            setTimer( _tEVC_CfgBit_97_C8_AR, tDelay );
        else
            putValue( HMI__STMSG_EVC_CfgBit_97_C8_AR, 0 );
    }
}

on envVar HMI_E2E_EVC_CfgBit_97_C8_Inject
{
    if( getValue( this ) )
    {
        _EVC_CfgBit_97_C8_AR_CRC_ErrorCnt = getValue( HMI_CRC_EVC_CfgBit_97_C8_ErrorCount );
        _EVC_CfgBit_97_C8_AR_SQC_TriggPos = getValue( HMI_SQC_EVC_CfgBit_97_C8_TriggerPosition );
        _EVC_CfgBit_97_C8_AR_SQC_WrongSeqJump = getValue( HMI_SQC_EVC_CfgBit_97_C8_WrongSeq );
        _EVC_CfgBit_97_C8_AR_SQC_RepeatedCnt = getValue( HMI_SQC_EVC_CfgBit_97_C8_Repeated );
        _EVC_CfgBit_97_C8_AR_MSG_DropCnt = getValue( HMI_SQC_EVC_CfgBit_97_C8_MSG_DropCnt );
        putValue( HMI_E2E_EVC_CfgBit_97_C8_State, 2 );
        _EVC_CfgBit_97_C8_AR_E2E_Armed = 2;  //armed
    }
}

on envVar HMI__STMSG_PO_EVC_CfgBit_97_C8_AR
{
    if( getValue( this ) )
        openPanel("EVC_CfgBit_97_C8_AR");
}

on EnvVar HMI_EVC_97_ConvStWhlOp_AssSys_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_97_ConvStWhlOp_AssSys_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_98_AMG_PerfSeat_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_98_AMG_PerfSeat_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_99_RemPark_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_99_RemPark_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_9A_PresfImpls_Sd_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_9A_PresfImpls_Sd_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_9B_ADSPlus_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_9B_ADSPlus_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_9C_PullmanGuard_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_9C_PullmanGuard_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_9D_Allroad_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_9D_Allroad_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_9E_ActvRollStabil_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_9E_ActvRollStabil_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_9F_SpdLmtRec_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_9F_SpdLmtRec_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_A0_FondComfPk_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_A0_FondComfPk_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_A1_eSuspension_Airmatic_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_A1_eSuspension_Airmatic_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_A2_OffroadSuspension_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_A2_OffroadSuspension_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_A3_ADSPlus_Airmatic_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_A3_ADSPlus_Airmatic_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_A4_SeatVario_R_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_A4_SeatVario_R_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_A5_7Seater_R3_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_A5_7Seater_R3_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_A6_PreInstEntertain_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_A6_PreInstEntertain_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_A7_EngHiPerfInc_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_A7_EngHiPerfInc_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_A8_SeatElAdj_HghtHdRst_NoMem_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_A8_SeatElAdj_HghtHdRst_NoMem_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_A9_SemiActvRollStabil_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_A9_SemiActvRollStabil_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_AA_LaneCorrWithStIntrvntn_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_AA_LaneCorrWithStIntrvntn_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_AB_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_AB_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_AC_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_AC_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_AD_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_AD_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_AE_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_AE_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_AF_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_AF_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_B0_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_B0_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_B1_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_B1_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_B2_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_B2_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_B3_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_B3_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_B4_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_B4_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_B5_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_B5_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_B6_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_B6_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_B7_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_B7_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_B8_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_B8_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_B9_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_B9_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_BA_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_BA_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_BB_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_BB_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_BC_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_BC_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_BD_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_BD_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_BE_AddEquip_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_BE_AddEquip_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_BF_AEJx0_2_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_BF_AEJx0_2_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_C0_AEJx1_2_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_C0_AEJx1_2_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_C1_AEJx2_2_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_C1_AEJx2_2_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_C2_AEJx3_2_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_C2_AEJx3_2_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_C3_AEJx4_2_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_C3_AEJx4_2_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_C4_AEJx5_2_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_C4_AEJx5_2_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_C5_AEJx6_2_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_C5_AEJx6_2_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_C6_AEJx7_2_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_C6_AEJx7_2_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_C7_AEJx8_2_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_C7_AEJx8_2_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_C8_AEJx9_2_Avl
{
    _mEVC_CfgBit_97_C8_AR.EVC_C8_AEJx9_2_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgBit_97_C8_Stat
{
    _mEVC_CfgBit_97_C8_AR.EVC_CfgBit_97_C8_Stat.phys = getValue(this);
}

EVC_CfgList_01_0C_AR_check_output()
{
    if( !getValue( HMI__STMSG_EVC_CfgList_01_0C_AR ) )
    {
    //  message   EVC_CfgList_01_0C_AR ID: 759 --- Sendeart 0 cyclicX --- 
        _EVC_CfgList_01_0C_AR_Cnt--;
        if( _EVC_CfgList_01_0C_AR_Cnt < 1 )
        {
            EVC_CfgList_01_0C_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _EVC_CfgList_01_0C_AR_Cnt = _EVC_CfgList_01_0C_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

EVC_CfgList_01_0C_AR_init()
{   /* Botschaft EVC_CfgList_01_0C_AR ID: 759 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 759 0;
BA_ "NmAsrMessage" BO_ 759 0;
BA_ "GenMsgMinAcceptLength" BO_ 759 8;
BA_ "GenMsgILSupport" BO_ 759 1;
BA_ "DiagState" BO_ 759 0;
BA_ "DiagRequest" BO_ 759 0;
BA_ "DiagResponse" BO_ 759 0;
BA_ "GenMsgStartValue" BO_ 759 "0";
BA_ "GenMsgStartDelayTime" BO_ 759 295;
BA_ "GenMsgCycleTime" BO_ 759 1000;
BA_ "GenMsgSendType" BO_ 759 0;
    */
    _EVC_CfgList_01_0C_AR_Timebase =      c_tDBKomTimer_20ms;
    _EVC_CfgList_01_0C_AR_CycleCount =   1000 / _EVC_CfgList_01_0C_AR_Timebase;
    _EVC_CfgList_01_0C_AR_StartDelay =    295 / _EVC_CfgList_01_0C_AR_Timebase;
    _EVC_CfgList_01_0C_AR_Cnt = _EVC_CfgList_01_0C_AR_StartDelay;

    putValue( HMI__STMSGSD_EVC_CfgList_01_0C_AR, _EVC_CfgList_01_0C_AR_StartDelay * _EVC_CfgList_01_0C_AR_Timebase );

    _mEVC_CfgList_01_0C_AR.EVC_CfgList_01_0C_Stat.phys = getValue( HMI_EVC_CfgList_01_0C_Stat );
    _mEVC_CfgList_01_0C_AR.EVC_List01_StStyle.phys = getValue( HMI_EVC_List01_StStyle );
    _mEVC_CfgList_01_0C_AR.EVC_List02_BodyStyle.phys = getValue( HMI_EVC_List02_BodyStyle );
    _mEVC_CfgList_01_0C_AR.EVC_List03_RoofStyle.phys = getValue( HMI_EVC_List03_RoofStyle );
    _mEVC_CfgList_01_0C_AR.EVC_List04_HL_Style.phys = getValue( HMI_EVC_List04_HL_Style );
    _mEVC_CfgList_01_0C_AR.EVC_List05_TxStyle.phys = getValue( HMI_EVC_List05_TxStyle );
    _mEVC_CfgList_01_0C_AR.EVC_List06_VehLineYear.phys = getValue( HMI_EVC_List06_VehLineYear );
    _mEVC_CfgList_01_0C_AR.EVC_List07_HVAC_Style.phys = getValue( HMI_EVC_List07_HVAC_Style );
    _mEVC_CfgList_01_0C_AR.EVC_List08_Country.phys = getValue( HMI_EVC_List08_Country );
    _mEVC_CfgList_01_0C_AR.EVC_List09_HU_Style.phys = getValue( HMI_EVC_List09_HU_Style );
    _mEVC_CfgList_01_0C_AR.EVC_List0A_TPM_Style.phys = getValue( HMI_EVC_List0A_TPM_Style );
    _mEVC_CfgList_01_0C_AR.EVC_List0B_AddEquip.phys = getValue( HMI_EVC_List0B_AddEquip );
    _mEVC_CfgList_01_0C_AR.EVC_List0C_VehLine.phys = getValue( HMI_EVC_List0C_VehLine );
    //putValue ( HMI_SQC_EVC_CfgList_01_0C_Auto, 1 );
}

EVC_CfgList_01_0C_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_EVC_CfgList_01_0C ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_EVC_CfgList_01_0C_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _EVC_CfgList_01_0C_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _EVC_CfgList_01_0C_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_EVC_CfgList_01_0C_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _EVC_CfgList_01_0C_AR_SQC_WrongSeqJump != 0 ) &&
            ( _EVC_CfgList_01_0C_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _EVC_CfgList_01_0C_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _EVC_CfgList_01_0C_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _EVC_CfgList_01_0C_AR_SQC_RepeatedCnt ) &&
            ( _EVC_CfgList_01_0C_AR_E2E_Armed == 1  )    )
        {
            _EVC_CfgList_01_0C_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_EVC_CfgList_01_0C, SQC_help );
    }
    _mEVC_CfgList_01_0C_AR.SQC_EVC_CfgList_01_0C = SQC_help;

    if( getValue( HMI_CRC_EVC_CfgList_01_0C_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_EVC_CfgList_01_0C_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mEVC_CfgList_01_0C_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mEVC_CfgList_01_0C_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgList_01_0C_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgList_01_0C_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgList_01_0C_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgList_01_0C_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgList_01_0C_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgList_01_0C_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _EVC_CfgList_01_0C_AR_CRC_Offset[ _mEVC_CfgList_01_0C_AR.SQC_EVC_CfgList_01_0C ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _EVC_CfgList_01_0C_AR_CRC_ErrorCnt   && ( _EVC_CfgList_01_0C_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EVC_CfgList_01_0C_Invalid )                                         )    )
            {
                crc++;
                if( _EVC_CfgList_01_0C_AR_CRC_ErrorCnt > 0 )
                    _EVC_CfgList_01_0C_AR_CRC_ErrorCnt--; 
            }
            _mEVC_CfgList_01_0C_AR.CRC_EVC_CfgList_01_0C = crc;
            putValue( HMI_CRC_EVC_CfgList_01_0C, crc );
        }
        else
            _mEVC_CfgList_01_0C_AR.CRC_EVC_CfgList_01_0C = getValue( HMI_CRC_EVC_CfgList_01_0C );
    }
    else
    {
        if( !getValue( HMI_CRC_EVC_CfgList_01_0C_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mEVC_CfgList_01_0C_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mEVC_CfgList_01_0C_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mEVC_CfgList_01_0C_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mEVC_CfgList_01_0C_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mEVC_CfgList_01_0C_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mEVC_CfgList_01_0C_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mEVC_CfgList_01_0C_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mEVC_CfgList_01_0C_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _EVC_CfgList_01_0C_AR_CRC_ErrorCnt   && ( _EVC_CfgList_01_0C_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EVC_CfgList_01_0C_Invalid )                                         )    )
            {
                crc++;
                if( _EVC_CfgList_01_0C_AR_CRC_ErrorCnt > 0 )
                    _EVC_CfgList_01_0C_AR_CRC_ErrorCnt--; 
            }
            _mEVC_CfgList_01_0C_AR.CRC_EVC_CfgList_01_0C = crc;
            putValue( HMI_CRC_EVC_CfgList_01_0C, crc );
        }
        else
            _mEVC_CfgList_01_0C_AR.CRC_EVC_CfgList_01_0C = getValue( HMI_CRC_EVC_CfgList_01_0C );
    }
    if( ( _EVC_CfgList_01_0C_AR_MSG_DropCnt > 0 ) &&
        ( _EVC_CfgList_01_0C_AR_E2E_Armed == 1  )    )
    {
        _EVC_CfgList_01_0C_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mEVC_CfgList_01_0C_AR );
        
    if( _EVC_CfgList_01_0C_AR_E2E_Armed == 1 )
    {
        if ( ( _EVC_CfgList_01_0C_AR_MSG_DropCnt == 0      ) &&
             ( _EVC_CfgList_01_0C_AR_CRC_ErrorCnt == 0     ) &&
             ( _EVC_CfgList_01_0C_AR_SQC_RepeatedCnt == 0  ) &&
             ( _EVC_CfgList_01_0C_AR_SQC_WrongSeqJump == 0 )    )
        {
            _EVC_CfgList_01_0C_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_EVC_CfgList_01_0C_State, 0 );
        }
    }
}

EVC_CfgList_01_0C_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: EVC_CfgList_01_0C_AR\n", 34, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_EVC_CfgList_01_0B := %X\n", getValue( HMI__STMSG_EVC_CfgList_01_0C_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_EVC_CfgList_01_0B := %X\n", getValue( HMI__STMSGT_EVC_CfgList_01_0C_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EVC_CfgList_01_0C := %X\n", getValue( HMI_CRC_EVC_CfgList_01_0C ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EVC_CfgList_01_0C_Auto := %X\n", getValue( HMI_CRC_EVC_CfgList_01_0C_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgList_01_0C_Stat := %X\n", getValue( HMI_EVC_CfgList_01_0C_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_List01_StStyle := %X\n", getValue( HMI_EVC_List01_StStyle ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_List02_BodyStyle := %X\n", getValue( HMI_EVC_List02_BodyStyle ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_List03_RoofStyle := %X\n", getValue( HMI_EVC_List03_RoofStyle ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_List04_HL_Style := %X\n", getValue( HMI_EVC_List04_HL_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_List05_TxStyle := %X\n", getValue( HMI_EVC_List05_TxStyle ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_List06_VehLineYear := %X\n", getValue( HMI_EVC_List06_VehLineYear ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_List07_HVAC_Style := %X\n", getValue( HMI_EVC_List07_HVAC_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_List08_Country := %X\n", getValue( HMI_EVC_List08_Country ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_List09_HU_Style := %X\n", getValue( HMI_EVC_List09_HU_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_List0A_TPM_Style := %X\n", getValue( HMI_EVC_List0A_TPM_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_List0B_AddEquip := %X\n", getValue( HMI_EVC_List0B_AddEquip ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_List0C_VehLine := %X\n", getValue( HMI_EVC_List0C_VehLine ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EVC_CfgList_01_0C := %X\n", getValue( HMI_SQC_EVC_CfgList_01_0C ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EVC_CfgList_01_0C_Auto := %X\n", getValue( HMI_SQC_EVC_CfgList_01_0C_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tEVC_CfgList_01_0C_AR
{
    putValue( HMI__STMSG_EVC_CfgList_01_0C_AR, 0 );
}

on EnvVar HMI__STMSG_EVC_CfgList_01_0C_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_EVC_CfgList_01_0C_AR );
        if( tDelay > 0 )    
            setTimer( _tEVC_CfgList_01_0C_AR, tDelay );
        else
            putValue( HMI__STMSG_EVC_CfgList_01_0C_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_EVC_CfgList_01_0C_AR
{
    if( getValue( this ) )
        openPanel("EVC_CfgList_01_0C_AR");
}

on envVar HMI_E2E_EVC_CfgList_01_0C_Inject
{
    if( getValue( this ) )
    {
        _EVC_CfgList_01_0C_AR_CRC_ErrorCnt = getValue( HMI_CRC_EVC_CfgList_01_0C_ErrorCount );
        _EVC_CfgList_01_0C_AR_SQC_TriggPos = getValue( HMI_SQC_EVC_CfgList_01_0C_TriggerPosition );
        _EVC_CfgList_01_0C_AR_SQC_WrongSeqJump = getValue( HMI_SQC_EVC_CfgList_01_0C_WrongSeq );
        _EVC_CfgList_01_0C_AR_SQC_RepeatedCnt = getValue( HMI_SQC_EVC_CfgList_01_0C_Repeated );
        _EVC_CfgList_01_0C_AR_MSG_DropCnt = getValue( HMI_SQC_EVC_CfgList_01_0C_MSG_DropCnt );
        putValue( HMI_E2E_EVC_CfgList_01_0C_State, 2 );
        _EVC_CfgList_01_0C_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_EVC_CfgList_01_0C_Stat
{
    _mEVC_CfgList_01_0C_AR.EVC_CfgList_01_0C_Stat.phys = getValue(this);
}

on EnvVar HMI_EVC_List01_StStyle
{
    _mEVC_CfgList_01_0C_AR.EVC_List01_StStyle.phys = getValue(this);
}

on EnvVar HMI_EVC_List02_BodyStyle
{
    _mEVC_CfgList_01_0C_AR.EVC_List02_BodyStyle.phys = getValue(this);
}

on EnvVar HMI_EVC_List03_RoofStyle
{
    _mEVC_CfgList_01_0C_AR.EVC_List03_RoofStyle.phys = getValue(this);
}

on EnvVar HMI_EVC_List04_HL_Style
{
    _mEVC_CfgList_01_0C_AR.EVC_List04_HL_Style.phys = getValue(this);
}

on EnvVar HMI_EVC_List05_TxStyle
{
    _mEVC_CfgList_01_0C_AR.EVC_List05_TxStyle.phys = getValue(this);
}

on EnvVar HMI_EVC_List06_VehLineYear
{
    _mEVC_CfgList_01_0C_AR.EVC_List06_VehLineYear.phys = getValue(this);
}

on EnvVar HMI_EVC_List07_HVAC_Style
{
    _mEVC_CfgList_01_0C_AR.EVC_List07_HVAC_Style.phys = getValue(this);
}

on EnvVar HMI_EVC_List08_Country
{
    _mEVC_CfgList_01_0C_AR.EVC_List08_Country.phys = getValue(this);
}

on EnvVar HMI_EVC_List09_HU_Style
{
    _mEVC_CfgList_01_0C_AR.EVC_List09_HU_Style.phys = getValue(this);
}

on EnvVar HMI_EVC_List0A_TPM_Style
{
    _mEVC_CfgList_01_0C_AR.EVC_List0A_TPM_Style.phys = getValue(this);
}

on EnvVar HMI_EVC_List0B_AddEquip
{
    _mEVC_CfgList_01_0C_AR.EVC_List0B_AddEquip.phys = getValue(this);
}


on EnvVar HMI_EVC_List0C_VehLine
{
    _mEVC_CfgList_01_0C_AR.EVC_List0C_VehLine.phys = getValue(this);
		if(_mEVC_CfgList_01_0C_AR.EVC_List0C_VehLine == 62)
		{
			putValue(Env_KZahl, 0x5E83);
		}
		else if(_mEVC_CfgList_01_0C_AR.EVC_List0C_VehLine == 37)
		{
			putValue(Env_KZahl, 0x4D49);
		}
		else if(_mEVC_CfgList_01_0C_AR.EVC_List0C_VehLine == 44)
		{
			putValue(Env_KZahl, 0x56A6);
		}
		else putValue(Env_KZahl, 0x3a98);
		
}

EVC_CfgVAN_AR_check_output()
{
    if( !getValue( HMI__STMSG_EVC_CfgVAN_AR ) )
    {
    //  message   EVC_CfgVAN_AR ID:994 --- Sendeart 0 cyclicX --- 
        _EVC_CfgVAN_AR_Cnt--;
        if( _EVC_CfgVAN_AR_Cnt < 1 )
        {
            EVC_CfgVAN_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _EVC_CfgVAN_AR_Cnt = _EVC_CfgVAN_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

EVC_CfgVAN_AR_init()
{   /* Botschaft EVC_CfgVAN_AR ID: 994 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 994 0;
BA_ "NmAsrMessage" BO_ 994 0;
BA_ "GenMsgMinAcceptLength" BO_ 994 8;
BA_ "GenMsgILSupport" BO_ 994 1;
BA_ "DiagState" BO_ 994 0;
BA_ "DiagRequest" BO_ 994 0;
BA_ "DiagResponse" BO_ 994 0;
BA_ "GenMsgStartValue" BO_ 994 "0";
BA_ "GenMsgStartDelayTime" BO_ 994 290;
BA_ "GenMsgCycleTime" BO_ 994 1000;
BA_ "GenMsgSendType" BO_ 994 0;
    */
    _EVC_CfgVAN_AR_Timebase =           c_tDBKomTimer_20ms;
    _EVC_CfgVAN_AR_CycleCount =       1000 / _EVC_CfgVAN_AR_Timebase;
    _EVC_CfgVAN_AR_StartDelay =        290 / _EVC_CfgVAN_AR_Timebase;
    _EVC_CfgVAN_AR_Cnt = _EVC_CfgVAN_AR_StartDelay;
    
    putValue( HMI__STMSGSD_EVC_CfgVAN_AR, _EVC_CfgVAN_AR_StartDelay * _EVC_CfgVAN_AR_Timebase );

    _mEVC_CfgVAN_AR.EVC_CfgVAN_ABS_Dsabl_Avl.phys = getValue( HMI_EVC_CfgVAN_ABS_Dsabl_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_AddBodyStyle.phys = getValue( HMI_EVC_CfgVAN_AddBodyStyle );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_AddRoofStyle.phys = getValue( HMI_EVC_CfgVAN_AddRoofStyle );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_D_FL_Avl.phys = getValue( HMI_EVC_CfgVAN_D_FL_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_D_FR_Avl.phys = getValue( HMI_EVC_CfgVAN_D_FR_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_DL_Avl.phys = getValue( HMI_EVC_CfgVAN_DL_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_DL_FW_Avl.phys = getValue( HMI_EVC_CfgVAN_DL_FW_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_Drv_Style.phys = getValue( HMI_EVC_CfgVAN_Drv_Style );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_ESP_Avl.phys = getValue( HMI_EVC_CfgVAN_ESP_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_ESP_Dsabl_Avl.phys = getValue( HMI_EVC_CfgVAN_ESP_Dsabl_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_EStep_FL_Avl.phys = getValue( HMI_EVC_CfgVAN_EStep_FL_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_EStep_FR_Avl.phys = getValue( HMI_EVC_CfgVAN_EStep_FR_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_EStep_RL_Avl.phys = getValue( HMI_EVC_CfgVAN_EStep_RL_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_EStep_RR_Avl.phys = getValue( HMI_EVC_CfgVAN_EStep_RR_Avl );  
    _mEVC_CfgVAN_AR.EVC_CfgVAN_MaxAuthWeight.phys = getValue( HMI_EVC_CfgVAN_MaxAuthWeight );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_MSR_Avl.phys = getValue( HMI_EVC_CfgVAN_MSR_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_OpSpdCtrl_Avl.phys = getValue( HMI_EVC_CfgVAN_OpSpdCtrl_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_PkBrk_Style.phys = getValue( HMI_EVC_CfgVAN_PkBrk_Style );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_PS_Style.phys = getValue( HMI_EVC_CfgVAN_PS_Style );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_PSD_L_Avl.phys = getValue( HMI_EVC_CfgVAN_PSD_L_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_PSD_R_Avl.phys = getValue( HMI_EVC_CfgVAN_PSD_R_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_PwrCls_SD_L_Avl.phys = getValue( HMI_EVC_CfgVAN_PwrCls_SD_L_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_PwrCls_SD_R_Avl.phys = getValue( HMI_EVC_CfgVAN_PwrCls_SD_R_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_RCD_Avl.phys = getValue( HMI_EVC_CfgVAN_RCD_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_Retarder_Avl.phys = getValue( HMI_EVC_CfgVAN_Retarder_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_SD_L_Avl.phys = getValue( HMI_EVC_CfgVAN_SD_L_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_SD_R_Avl.phys = getValue( HMI_EVC_CfgVAN_SD_R_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_Stat.phys = getValue( HMI_EVC_CfgVAN_Stat );
	_mEVC_CfgVAN_AR.EVC_CfgVAN_SUS_Avl.phys = getValue( HMI_EVC_CfgVAN_SUS_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_TCO_Avl.phys = getValue( HMI_EVC_CfgVAN_TCO_Avl );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_WhlBase.phys = getValue( HMI_EVC_CfgVAN_WhlBase );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_PartWall_Avl.phys = getValue( HMI_EVC_CfgVAN_PartWall_Avl );
    _mEVC_CfgVAN_AR.Rsrv3_EVC_CfgVAN.phys = getValue( HMI_Rsrv3_EVC_CfgVAN );
    _mEVC_CfgVAN_AR.EVC_CfgVAN_Spkr_Cfg.phys = getValue( HMI_EVC_CfgVAN_Spkr_Cfg );
}

EVC_CfgVAN_AR_output(void)
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_EVC_CfgVAN ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_EVC_CfgVAN_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _EVC_CfgVAN_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _EVC_CfgVAN_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_EVC_CfgVAN_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _EVC_CfgVAN_AR_SQC_WrongSeqJump != 0 ) &&
            ( _EVC_CfgVAN_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _EVC_CfgVAN_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _EVC_CfgVAN_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _EVC_CfgVAN_AR_SQC_RepeatedCnt ) &&
            ( _EVC_CfgVAN_AR_E2E_Armed == 1  )    )
        {
            _EVC_CfgVAN_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_EVC_CfgVAN, SQC_help );
    }
    _mEVC_CfgVAN_AR.SQC_EVC_CfgVAN = SQC_help;

    if( getValue( HMI_CRC_EVC_CfgVAN_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_EVC_CfgVAN_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mEVC_CfgVAN_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mEVC_CfgVAN_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgVAN_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgVAN_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgVAN_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgVAN_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgVAN_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgVAN_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _EVC_CfgVAN_AR_CRC_Offset[ _mEVC_CfgVAN_AR.SQC_EVC_CfgVAN ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _EVC_CfgVAN_AR_CRC_ErrorCnt   && ( _EVC_CfgVAN_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EVC_CfgVAN_Invalid )                                         )    )
            {
                crc++;
                if( _EVC_CfgVAN_AR_CRC_ErrorCnt > 0 )
                    _EVC_CfgVAN_AR_CRC_ErrorCnt--; 
            }
            _mEVC_CfgVAN_AR.CRC_EVC_CfgVAN = crc;
            putValue( HMI_CRC_EVC_CfgVAN, crc );
        }
        else
            _mEVC_CfgVAN_AR.CRC_EVC_CfgVAN = getValue( HMI_CRC_EVC_CfgVAN );
    }
    else
    {
        if( !getValue( HMI_CRC_EVC_CfgVAN_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mEVC_CfgVAN_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mEVC_CfgVAN_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mEVC_CfgVAN_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mEVC_CfgVAN_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mEVC_CfgVAN_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mEVC_CfgVAN_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mEVC_CfgVAN_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mEVC_CfgVAN_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _EVC_CfgVAN_AR_CRC_ErrorCnt   && ( _EVC_CfgVAN_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EVC_CfgVAN_Invalid )                                         )    )
            {
                crc++;
                if( _EVC_CfgVAN_AR_CRC_ErrorCnt > 0 )
                    _EVC_CfgVAN_AR_CRC_ErrorCnt--; 
            }
            _mEVC_CfgVAN_AR.CRC_EVC_CfgVAN = crc;
            putValue( HMI_CRC_EVC_CfgVAN, crc );
        }
        else
            _mEVC_CfgVAN_AR.CRC_EVC_CfgVAN = getValue( HMI_CRC_EVC_CfgVAN );
    }
    if( ( _EVC_CfgVAN_AR_MSG_DropCnt > 0 ) &&
        ( _EVC_CfgVAN_AR_E2E_Armed == 1  )    )
    {
        _EVC_CfgVAN_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mEVC_CfgVAN_AR );
        
    if( _EVC_CfgVAN_AR_E2E_Armed == 1 )
    {
        if ( ( _EVC_CfgVAN_AR_MSG_DropCnt == 0      ) &&
             ( _EVC_CfgVAN_AR_CRC_ErrorCnt == 0     ) &&
             ( _EVC_CfgVAN_AR_SQC_RepeatedCnt == 0  ) &&
             ( _EVC_CfgVAN_AR_SQC_WrongSeqJump == 0 )    )
        {
            _EVC_CfgVAN_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_EVC_CfgVAN_State, 0 );
        }
    }
}

EVC_CfgVAN_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: EVC_CfgVAN_AR\n", 26, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_EVC_CfgVAN_AR := %X\n", getValue( HMI__STMSG_EVC_CfgVAN_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_EVC_CfgVAN_AR := %X\n", getValue( HMI__STMSGT_EVC_CfgVAN_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EVC_CfgVAN := %X\n", getValue( HMI_CRC_EVC_CfgVAN ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EVC_CfgVAN_Auto := %X\n", getValue( HMI_CRC_EVC_CfgVAN_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_ABS_Dsabl_Avl := %X\n", getValue( HMI_EVC_CfgVAN_ABS_Dsabl_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_AddBodyStyle := %X\n", getValue( HMI_EVC_CfgVAN_AddBodyStyle ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_AddRoofStyle := %X\n", getValue( HMI_EVC_CfgVAN_AddRoofStyle ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_D_FL_Avl := %X\n", getValue( HMI_EVC_CfgVAN_D_FL_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_D_FR_Avl := %X\n", getValue( HMI_EVC_CfgVAN_D_FR_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_DL_Avl := %X\n", getValue( HMI_EVC_CfgVAN_DL_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_DL_FW_Avl := %X\n", getValue( HMI_EVC_CfgVAN_DL_FW_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_Drv_Style := %X\n", getValue( HMI_EVC_CfgVAN_Drv_Style ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_ESP_Avl := %X\n", getValue( HMI_EVC_CfgVAN_ESP_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_ESP_Dsabl_Avl := %X\n", getValue( HMI_EVC_CfgVAN_ESP_Dsabl_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_EStep_FL_Avl := %X\n", getValue( HMI_EVC_CfgVAN_EStep_FL_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_EStep_FR_Avl := %X\n", getValue( HMI_EVC_CfgVAN_EStep_FR_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_EStep_RL_Avl := %X\n", getValue( HMI_EVC_CfgVAN_EStep_RL_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_EStep_RR_Avl := %X\n", getValue( HMI_EVC_CfgVAN_EStep_RR_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_HBC_Avl := %X\n", getValue( HMI_EVC_CfgVAN_HBC_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_MaxAuthWeight := %X\n", getValue( HMI_EVC_CfgVAN_MaxAuthWeight ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_MSR_Avl := %X\n", getValue( HMI_EVC_CfgVAN_MSR_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_OpSpdCtrl_Avl := %X\n", getValue( HMI_EVC_CfgVAN_OpSpdCtrl_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_PkBrk_Style := %X\n", getValue( HMI_EVC_CfgVAN_PkBrk_Style ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_PS_Style := %X\n", getValue( HMI_EVC_CfgVAN_PS_Style ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_PSD_L_Avl := %X\n", getValue( HMI_EVC_CfgVAN_PSD_L_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_PSD_R_Avl := %X\n", getValue( HMI_EVC_CfgVAN_PSD_R_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_PwrCls_SD_L_Avl := %X\n", getValue( HMI_EVC_CfgVAN_PwrCls_SD_L_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_PwrCls_SD_R_Avl := %X\n", getValue( HMI_EVC_CfgVAN_PwrCls_SD_R_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_RCD_Avl := %X\n", getValue( HMI_EVC_CfgVAN_RCD_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_Retarder_Avl := %X\n", getValue( HMI_EVC_CfgVAN_Retarder_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_SD_L_Avl := %X\n", getValue( HMI_EVC_CfgVAN_SD_L_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_SD_R_Avl := %X\n", getValue( HMI_EVC_CfgVAN_SD_R_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_Stat := %X\n", getValue( HMI_EVC_CfgVAN_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_SUS_Avl := %X\n", getValue( HMI_EVC_CfgVAN_SUS_Avl ) ); filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_TCO_Avl := %X\n", getValue( HMI_EVC_CfgVAN_TCO_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_WhlBase := %X\n", getValue( HMI_EVC_CfgVAN_WhlBase ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_PartWall_Avl := %X\n", getValue( HMI_EVC_CfgVAN_PartWall_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv3_EVC_CfgVAN := %X\n", getValue( HMI_Rsrv3_EVC_CfgVAN ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgVAN_Spkr_Cfg := %X\n", getValue( HMI_EVC_CfgVAN_Spkr_Cfg ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EVC_CfgVAN := %X\n", getValue( HMI_SQC_EVC_CfgVAN ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EVC_CfgVAN_Auto := %X\n", getValue( HMI_SQC_EVC_CfgVAN_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EVC_CfgVAN_Profile_02 := %X\n", getValue( HMI_CRC_EVC_CfgVAN_Profile_02 ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tEVC_CfgVAN_AR
{
    putValue( HMI__STMSG_EVC_CfgVAN_AR, 0 );
}

on EnvVar HMI__STMSG_EVC_CfgVAN_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_EVC_CfgVAN_AR );
        if( tDelay > 0)    
            setTimer( _tEVC_CfgVAN_AR, tDelay );
        else
            putValue( HMI__STMSG_EVC_CfgVAN_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_EVC_CfgVAN_AR
{
    if( getValue( this ) )
        openPanel("EVC_CfgVAN_AR");
}

on EnvVar HMI_EVC_CfgVAN_ABS_Dsabl_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_ABS_Dsabl_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_AddBodyStyle
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_AddBodyStyle.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_AddRoofStyle
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_AddRoofStyle.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_D_FL_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_D_FL_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_D_FR_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_D_FR_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_DL_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_DL_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_DL_FW_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_DL_FW_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_Drv_Style
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_Drv_Style.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_ESP_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_ESP_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_ESP_Dsabl_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_ESP_Dsabl_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_HBC_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_HBC_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_MaxAuthWeight
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_MaxAuthWeight.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_MSR_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_MSR_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_OpSpdCtrl_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_OpSpdCtrl_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_PkBrk_Style
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_PkBrk_Style.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_PS_Style
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_PS_Style.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_PSD_L_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_PSD_L_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_PSD_R_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_PSD_R_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_PwrCls_SD_L_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_PwrCls_SD_L_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_PwrCls_SD_R_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_PwrCls_SD_R_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_RCD_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_RCD_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_Retarder_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_Retarder_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_SD_L_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_SD_L_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_SUS_Avl
{
	_mEVC_CfgVAN_AR.EVC_CfgVAN_SUS_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_SD_R_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_SD_R_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_Stat
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_Stat.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_TCO_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_TCO_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_WhlBase
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_WhlBase.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgVAN_PartWall_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_PartWall_Avl.phys = getValue(this);
}

on EnvVar HMI_Rsrv3_EVC_CfgVAN
{
    _mEVC_CfgVAN_AR.Rsrv3_EVC_CfgVAN.phys = getValue(this); 
}

on EnvVar HMI_EVC_CfgVAN_EStep_FL_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_EStep_FL_Avl.phys = getValue(this); 
}

on EnvVar HMI_EVC_CfgVAN_EStep_FR_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_EStep_FR_Avl.phys = getValue(this); 
}

on EnvVar HMI_EVC_CfgVAN_EStep_RL_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_EStep_RL_Avl.phys = getValue(this); 
}

on EnvVar HMI_EVC_CfgVAN_EStep_RR_Avl
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_EStep_RR_Avl.phys = getValue(this); 
}

on EnvVar HMI_EVC_CfgVAN_Spkr_Cfg
{
    _mEVC_CfgVAN_AR.EVC_CfgVAN_Spkr_Cfg.phys = getValue(this); 
}

ExitWarn_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_ExitWarn_Disp_Rq_AR ) )
    {
    //  message   ExitWarn_Disp_Rq_AR ID: 819 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _ExitWarn_Disp_Rq_AR_DelayCnt > 0) _ExitWarn_Disp_Rq_AR_DelayCnt--; // Mindestsendeabstand
        _ExitWarn_Disp_Rq_AR_Cnt--;
        if( _ExitWarn_Disp_Rq_AR_Cnt < 1 )
        {
            if( _ExitWarn_Disp_Rq_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                ExitWarn_Disp_Rq_AR_output();
                 _ExitWarn_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _ExitWarn_Disp_Rq_AR_DelayCnt = _ExitWarn_Disp_Rq_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _ExitWarn_Disp_Rq_AR_SpontanFlag = 1;
            }
            _ExitWarn_Disp_Rq_AR_Cnt = ( getValue( HMI__STMSG_ExitWarn_Disp_Rq_AR ) / _ExitWarn_Disp_Rq_AR_Timebase ); //_ExitWarn_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _ExitWarn_Disp_Rq_AR_SpontanFlag)
        {
            if( _ExitWarn_Disp_Rq_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                ExitWarn_Disp_Rq_AR_output();
                _ExitWarn_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _ExitWarn_Disp_Rq_AR_DelayCnt = _ExitWarn_Disp_Rq_AR_MinDelay;
            }
        }
    }
}

ExitWarn_Disp_Rq_AR_init()
{   /* Botschaft ExitWarn_Disp_Rq_AR ID: 1008 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1008 0;
BA_ "NmAsrMessage" BO_ 1008 0;
BA_ "GenMsgMinAcceptLength" BO_ 1008 8;
BA_ "GenMsgILSupport" BO_ 1008 1;
BA_ "DiagState" BO_ 1008 0;
BA_ "DiagRequest" BO_ 1008 0;
BA_ "DiagResponse" BO_ 1008 0;
BA_ "GenMsgStartValue" BO_ 1008 "0";
BA_ "GenMsgStartDelayTime" BO_ 1008 0;
BA_ "GenMsgDelayTime" BO_ 1008 40;
BA_ "GenMsgNrOfRepetition" BO_ 1008 0;
BA_ "GenMsgCycleTime" BO_ 1008 1000;
BA_ "GenMsgSendType" BO_ 1008 5;
    */
    _ExitWarn_Disp_Rq_AR_Timebase =             c_tDBKomTimer_20ms;
    _ExitWarn_Disp_Rq_AR_CycleCount =          1000 / _ExitWarn_Disp_Rq_AR_Timebase;
    _ExitWarn_Disp_Rq_AR_StartDelay =            0 / _ExitWarn_Disp_Rq_AR_Timebase;
    _ExitWarn_Disp_Rq_AR_MinDelay =              40 / _ExitWarn_Disp_Rq_AR_Timebase;
    _ExitWarn_Disp_Rq_AR_Cnt = _ExitWarn_Disp_Rq_AR_StartDelay;
    _ExitWarn_Disp_Rq_AR_SpontanFlag = 0;
    _ExitWarn_Disp_Rq_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_ExitWarn_Disp_Rq_AR, _ExitWarn_Disp_Rq_AR_StartDelay * _ExitWarn_Disp_Rq_AR_Timebase );
    
    _mExitWarn_Disp_Rq_AR.ExitWarn_AcustWarn_Rq.phys = getValue( HMI_ExitWarn_AcustWarn_Rq );
    _mExitWarn_Disp_Rq_AR.ExitWarn_ALC_FL_Rq.phys = getValue( HMI_ExitWarn_ALC_FL_Rq );
    _mExitWarn_Disp_Rq_AR.ExitWarn_ALC_FR_Rq.phys = getValue( HMI_ExitWarn_ALC_FR_Rq );
    _mExitWarn_Disp_Rq_AR.ExitWarn_ALC_RL_Rq.phys = getValue( HMI_ExitWarn_ALC_RL_Rq );
    _mExitWarn_Disp_Rq_AR.ExitWarn_ALC_RR_Rq.phys = getValue( HMI_ExitWarn_ALC_RR_Rq );
    _mExitWarn_Disp_Rq_AR.ExitWarn_Lt_Rq.phys = getValue( HMI_ExitWarn_Lt_Rq );
    _mExitWarn_Disp_Rq_AR.ExitWarn_MsgDisp_Rq.phys = getValue( HMI_ExitWarn_MsgDisp_Rq );
    _mExitWarn_Disp_Rq_AR.ExitWarn_Rt_Rq.phys = getValue( HMI_ExitWarn_Rt_Rq );
    _mExitWarn_Disp_Rq_AR.ExitWarn_Stat.phys = getValue( HMI_ExitWarn_Stat );
    
}

void ExitWarn_Disp_Rq_AR_output(void)
{
    output( _mExitWarn_Disp_Rq_AR );
}

ExitWarn_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: ExitWarn_Disp_Rq_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_ExitWarn_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_ExitWarn_Disp_Rq_AR ) );            filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_ExitWarn_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_ExitWarn_Disp_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ExitWarn_AcustWarn_Rq := %X\n", getValue( HMI_ExitWarn_AcustWarn_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ExitWarn_ALC_FL_Rq := %X\n", getValue( HMI_ExitWarn_ALC_FL_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ExitWarn_ALC_FR_Rq := %X\n", getValue( HMI_ExitWarn_ALC_FR_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ExitWarn_ALC_RL_Rq := %X\n", getValue( HMI_ExitWarn_ALC_RL_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ExitWarn_ALC_RR_Rq := %X\n", getValue( HMI_ExitWarn_ALC_RR_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ExitWarn_Lt_Rq := %X\n", getValue( HMI_ExitWarn_Lt_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ExitWarn_MsgDisp_Rq := %X\n", getValue( HMI_ExitWarn_MsgDisp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ExitWarn_Rt_Rq := %X\n", getValue( HMI_ExitWarn_Rt_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ExitWarn_Stat := %X\n", getValue( HMI_ExitWarn_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    
}

on timer _tExitWarn_Disp_Rq_AR
{
    putValue( HMI__STMSG_ExitWarn_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_ExitWarn_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_ExitWarn_Disp_Rq_AR );
        if( tDelay > 0 )
            setTimer( _tExitWarn_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_ExitWarn_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_ExitWarn_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("ExitWarn_Disp_Rq_AR");
}

on EnvVar HMI_ExitWarn_AcustWarn_Rq
{

   _mExitWarn_Disp_Rq_AR.ExitWarn_AcustWarn_Rq.phys = getValue(this);
    _ExitWarn_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ExitWarn_ALC_FL_Rq
{

   _mExitWarn_Disp_Rq_AR.ExitWarn_ALC_FL_Rq.phys = getValue(this);
    _ExitWarn_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ExitWarn_ALC_FR_Rq
{

   _mExitWarn_Disp_Rq_AR.ExitWarn_ALC_FR_Rq.phys = getValue(this);
    _ExitWarn_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ExitWarn_ALC_RL_Rq
{

   _mExitWarn_Disp_Rq_AR.ExitWarn_ALC_RL_Rq.phys = getValue(this);
    _ExitWarn_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ExitWarn_ALC_RR_Rq
{

   _mExitWarn_Disp_Rq_AR.ExitWarn_ALC_RR_Rq.phys = getValue(this);
    _ExitWarn_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ExitWarn_Lt_Rq
{

   _mExitWarn_Disp_Rq_AR.ExitWarn_Lt_Rq.phys = getValue(this);
    _ExitWarn_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ExitWarn_MsgDisp_Rq
{

   _mExitWarn_Disp_Rq_AR.ExitWarn_MsgDisp_Rq.phys = getValue(this);
    _ExitWarn_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ExitWarn_Rt_Rq
{

   _mExitWarn_Disp_Rq_AR.ExitWarn_Rt_Rq.phys = getValue(this);
    _ExitWarn_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ExitWarn_Stat
{

   _mExitWarn_Disp_Rq_AR.ExitWarn_Stat.phys = getValue(this);
    _ExitWarn_Disp_Rq_AR_SpontanFlag = 1;
}

FBL_CFG_Star2_AR_check_output()
{
    if( !getValue( HMI__STMSG_FBL_CFG_Star2_AR ) )
    {
    //  message   FBL_CFG_Star2_AR ID:104 --- Sendeart 0 cyclicX --- 
        _FBL_CFG_Star2_AR_Cnt--;
        if( _FBL_CFG_Star2_AR_Cnt < 1 )
        {
            FBL_CFG_Star2_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _FBL_CFG_Star2_AR_Cnt = _FBL_CFG_Star2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

FBL_CFG_Star2_AR_init()
{   /* Botschaft FBL_CFG_Star2_AR ID: 104 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 104 0;
BA_ "NmAsrMessage" BO_ 104 0;
BA_ "GenMsgMinAcceptLength" BO_ 104 1;
BA_ "GenMsgILSupport" BO_ 104 1;
BA_ "DiagState" BO_ 104 0;
BA_ "DiagRequest" BO_ 104 0;
BA_ "DiagResponse" BO_ 104 0;
BA_ "GenMsgStartValue" BO_ 104 "0";
BA_ "GenMsgStartDelayTime" BO_ 104 15;
BA_ "GenMsgCycleTime" BO_ 104 200;
BA_ "GenMsgSendType" BO_ 104 0;
    */
    _FBL_CFG_Star2_AR_Timebase =           c_tDBKomTimer_20ms;
    _FBL_CFG_Star2_AR_CycleCount =        200 / _FBL_CFG_Star2_AR_Timebase;
    _FBL_CFG_Star2_AR_StartDelay =         15 / _FBL_CFG_Star2_AR_Timebase;
    _FBL_CFG_Star2_AR_Cnt = _FBL_CFG_Star2_AR_StartDelay;
    
    putValue( HMI__STMSGSD_FBL_CFG_Star2_AR, _FBL_CFG_Star2_AR_StartDelay * _FBL_CFG_Star2_AR_Timebase );

    _mFBL_CFG_Star2_AR.Platform_Stat_Star2.phys = getValue( HMI_Platform_Stat_Star2 );
}

FBL_CFG_Star2_AR_output(void)
{
    output( _mFBL_CFG_Star2_AR );
}

FBL_CFG_Star2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: FBL_CFG_Star2_AR\n", 26, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_FBL_CFG_Star2_AR := %X\n", getValue( HMI__STMSG_FBL_CFG_Star2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_FBL_CFG_Star2_AR := %X\n", getValue( HMI__STMSGT_FBL_CFG_Star2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Platform_Stat_Star2 := %X\n", getValue( HMI_Platform_Stat_Star2 ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tFBL_CFG_Star2_AR
{
    putValue( HMI__STMSG_FBL_CFG_Star2_AR, 0 );
}

on EnvVar HMI__STMSG_FBL_CFG_Star2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_FBL_CFG_Star2_AR );
        if( tDelay > 0)    
            setTimer( _tFBL_CFG_Star2_AR, tDelay );
        else
            putValue( HMI__STMSG_FBL_CFG_Star2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_FBL_CFG_Star2_AR
{
    if( getValue( this ) )
        openPanel("FBL_CFG_Star2_AR");
}

on EnvVar HMI_Platform_Stat_Star2
{
    _mFBL_CFG_Star2_AR.Platform_Stat_Star2.phys = getValue(this);
}

FCW_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_FCW_Disp_Rq_AR ) )
    {
    //  message   FCW_Disp_Rq_AR ID: 1173 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _FCW_Disp_Rq_AR_DelayCnt > 0) _FCW_Disp_Rq_AR_DelayCnt--; // Mindestsendeabstand
        _FCW_Disp_Rq_AR_Cnt--;
        if( _FCW_Disp_Rq_AR_Cnt < 1 )
        {
            if( _FCW_Disp_Rq_AR_DelayCnt < 1 )
            {
                FCW_Disp_Rq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                _FCW_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _FCW_Disp_Rq_AR_DelayCnt = _FCW_Disp_Rq_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _FCW_Disp_Rq_AR_SpontanFlag = 1;
            }
            _FCW_Disp_Rq_AR_Cnt = _FCW_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _FCW_Disp_Rq_AR_SpontanFlag)
        {
            if( _FCW_Disp_Rq_AR_DelayCnt < 1 )
            {
                FCW_Disp_Rq_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _FCW_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _FCW_Disp_Rq_AR_DelayCnt = _FCW_Disp_Rq_AR_MinDelay;
            }
        }
    }
}

FCW_Disp_Rq_AR_init()
{   /* Botschaft FCW_Disp_Rq_AR ID: 1173 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1173 0;
BA_ "NmAsrMessage" BO_ 1173 0;
BA_ "GenMsgMinAcceptLength" BO_ 1173 8;
BA_ "GenMsgILSupport" BO_ 1173 1;
BA_ "DiagState" BO_ 1173 0;
BA_ "DiagRequest" BO_ 1173 0;
BA_ "DiagResponse" BO_ 1173 0;
BA_ "GenMsgStartValue" BO_ 1173 "0";
BA_ "GenMsgStartDelayTime" BO_ 1173 0;
BA_ "GenMsgDelayTime" BO_ 1173 5;
BA_ "GenMsgNrOfRepetitions" BO_ 1173 0;
BA_ "GenMsgCycleTime" BO_ 1173 200;
BA_ "GenMsgSendType" BO_ 1173 5;
    */
    _FCW_Disp_Rq_AR_Timebase =             c_tDBKomTimer_20ms;
    _FCW_Disp_Rq_AR_CycleCount =          200 / _FCW_Disp_Rq_AR_Timebase;
    _FCW_Disp_Rq_AR_StartDelay =            0 / _FCW_Disp_Rq_AR_Timebase;
    _FCW_Disp_Rq_AR_MinDelay =              5 / _FCW_Disp_Rq_AR_Timebase;
    _FCW_Disp_Rq_AR_Cnt = _FCW_Disp_Rq_AR_StartDelay;
    _FCW_Disp_Rq_AR_SpontanFlag = 0;
    _FCW_Disp_Rq_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_FCW_Disp_Rq_AR, _FCW_Disp_Rq_AR_StartDelay * _FCW_Disp_Rq_AR_Timebase );

    _mFCW_Disp_Rq_AR.FCW_AcustWarn_Rq.phys = getValue( HMI_FCW_AcustWarn_Rq );
    _mFCW_Disp_Rq_AR.FCW_IndLmp_On_Rq.phys = getValue( HMI_FCW_IndLmp_On_Rq );
    _mFCW_Disp_Rq_AR.FCW_MsgDisp_Rq.phys = getValue( HMI_FCW_MsgDisp_Rq );
    _mFCW_Disp_Rq_AR.FCW_ObjIntrstDist.phys = getValue( HMI_FCW_ObjIntrstDist );
    _mFCW_Disp_Rq_AR.FCW_ObjIntrstDist_SPEEDO1.phys = getValue( HMI_FCW_ObjIntrstDist_SPEEDO1 );
    _mFCW_Disp_Rq_AR.FCW_ObjIntrstDist_SPEEDO2.phys = getValue( HMI_FCW_ObjIntrstDist_SPEEDO2 );
    _mFCW_Disp_Rq_AR.FCW_Stat.phys = getValue( HMI_FCW_Stat );
    _mFCW_Disp_Rq_AR.PN14_ElecPwr_Rq_AS.phys = getValue( HMI_PN14_ElecPwr_Rq_AS );
}

FCW_Disp_Rq_AR_output(void)
{
    output( _mFCW_Disp_Rq_AR );
}

FCW_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: FCW_Disp_Rq_AR\n", 26, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_FCW_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_FCW_Disp_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_FCW_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_FCW_Disp_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FCW_AcustWarn_Rq := %X\n", getValue( HMI_FCW_AcustWarn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FCW_IndLmp_On_Rq := %X\n", getValue( HMI_FCW_IndLmp_On_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FCW_MsgDisp_Rq := %X\n", getValue( HMI_FCW_MsgDisp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FCW_ObjIntrstDist := %X\n", getValue( HMI_FCW_ObjIntrstDist ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FCW_ObjIntrstDist_SPEEDO1 := %X\n", getValue( HMI_FCW_ObjIntrstDist_SPEEDO1 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FCW_ObjIntrstDist_SPEEDO2 := %X\n", getValue( HMI_FCW_ObjIntrstDist_SPEEDO2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FCW_Stat := %X\n", getValue( HMI_FCW_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_ElecPwr_Rq_AS := %X\n", getValue( HMI_PN14_ElecPwr_Rq_AS ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tFCW_Disp_Rq_AR
{
    putValue( HMI__STMSG_FCW_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_FCW_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_FCW_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tFCW_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_FCW_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_FCW_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("FCW_Disp_Rq_AR");
}

on EnvVar HMI_FCW_AcustWarn_Rq
{
    _mFCW_Disp_Rq_AR.FCW_AcustWarn_Rq.phys = getValue(this);
    _FCW_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FCW_IndLmp_On_Rq
{
    _mFCW_Disp_Rq_AR.FCW_IndLmp_On_Rq.phys = getValue(this);
    _FCW_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FCW_MsgDisp_Rq
{
    _mFCW_Disp_Rq_AR.FCW_MsgDisp_Rq.phys = getValue(this);
    _FCW_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FCW_ObjIntrstDist
{
    _mFCW_Disp_Rq_AR.FCW_ObjIntrstDist.phys = getValue(this);
    _FCW_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FCW_ObjIntrstDist_SPEEDO1
{
    _mFCW_Disp_Rq_AR.FCW_ObjIntrstDist_SPEEDO1.phys = getValue(this);
    _FCW_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FCW_ObjIntrstDist_SPEEDO2
{
    _mFCW_Disp_Rq_AR.FCW_ObjIntrstDist_SPEEDO2.phys = getValue(this);
    _FCW_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FCW_Stat
{
    _mFCW_Disp_Rq_AR.FCW_Stat.phys = getValue(this);
    _FCW_Disp_Rq_AR_SpontanFlag = 1;
}

FDC_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_FDC_Disp_Rq_AR ) )
    {
    //  message   FDC_Disp_Rq_AR ID: 2223505408 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _FDC_Disp_Rq_AR_DelayCnt > 0) _FDC_Disp_Rq_AR_DelayCnt--; // Mindestsendeabstand
        _FDC_Disp_Rq_AR_Cnt--;
        if( _FDC_Disp_Rq_AR_Cnt < 1 )
        {
            if( _FDC_Disp_Rq_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                FDC_Disp_Rq_AR_output();
                 _FDC_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _FDC_Disp_Rq_AR_DelayCnt = _FDC_Disp_Rq_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _FDC_Disp_Rq_AR_SpontanFlag = 1;
            }
            _FDC_Disp_Rq_AR_Cnt = _FDC_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _FDC_Disp_Rq_AR_SpontanFlag)
        {
            if( _FDC_Disp_Rq_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                FDC_Disp_Rq_AR_output();
                _FDC_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _FDC_Disp_Rq_AR_DelayCnt = _FDC_Disp_Rq_AR_MinDelay;
            }
        }
    }
}

FDC_Disp_Rq_AR_init()
{   /* Botschaft FDC_Disp_Rq_AR  ID: 2223505408 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 2223505408 0;
BA_ "NmAsrMessage" BO_ 2223505408 0;
BA_ "GenMsgMinAcceptLength" BO_ 2223505408 8;
BA_ "GenMsgILSupport" BO_ 2223505408 1;
BA_ "DiagState" BO_ 2223505408 0;
BA_ "DiagRequest" BO_ 2223505408 0;
BA_ "DiagResponse" BO_ 2223505408 0;
BA_ "GenMsgStartValue" BO_ 2223505408 "0";
BA_ "GenMsgStartDelayTime" BO_ 2223505408 55;
BA_ "GenMsgDelayTime" BO_ 2223505408 20;
BA_ "GenMsgNrOfRepetition" BO_ 2223505408 0;
BA_ "GenMsgCycleTime" BO_ 2223505408 100;
BA_ "GenMsgSendType" BO_ 2223505408 5;
    */

	
    _FDC_Disp_Rq_AR_Timebase =             c_tDBKomTimer_20ms;
    _FDC_Disp_Rq_AR_CycleCount =          100 / _FDC_Disp_Rq_AR_Timebase;
    _FDC_Disp_Rq_AR_StartDelay =           55 / _FDC_Disp_Rq_AR_Timebase;
    _FDC_Disp_Rq_AR_MinDelay =             20 / _FDC_Disp_Rq_AR_Timebase;
    _FDC_Disp_Rq_AR_Cnt = _FDC_Disp_Rq_AR_StartDelay;
    _FDC_Disp_Rq_AR_SpontanFlag = 0;
    _FDC_Disp_Rq_AR_DelayCnt = 0;
    putValue( HMI__STMSGSD_FDC_Disp_Rq_AR, _FDC_Disp_Rq_AR_StartDelay * _FDC_Disp_Rq_AR_Timebase);
    
    _mFDC_Disp_Rq_AR.FDC_Actv_Stat.phys = getValue( HMI_FDC_Actv_Stat );
	_mFDC_Disp_Rq_AR.FDC_Actv_Stat_V2.phys = getValue( HMI_FDC_Actv_Stat_V2 );
    _mFDC_Disp_Rq_AR.FDC_Acust_EmgWarn_Rq.phys = getValue( HMI_FDC_Acust_EmgWarn_Rq );
    _mFDC_Disp_Rq_AR.FDC_AcustWarn1_Rq.phys = getValue( HMI_FDC_AcustWarn1_Rq );
    _mFDC_Disp_Rq_AR.FDC_AcustWarn2_Rq.phys = getValue( HMI_FDC_AcustWarn2_Rq );
    _mFDC_Disp_Rq_AR.FDC_AcustWarn3_Rq.phys = getValue( HMI_FDC_AcustWarn3_Rq );
    _mFDC_Disp_Rq_AR.FDC_FltMsgDisp_Rq.phys = getValue( HMI_FDC_FltMsgDisp_Rq );
    _mFDC_Disp_Rq_AR.FDC_Md_Stat.phys = getValue( HMI_FDC_Md_Stat );
    _mFDC_Disp_Rq_AR.FDC_Msg_TkOvr_Rq.phys = getValue( HMI_FDC_Msg_TkOvr_Rq );	
	  _mFDC_Disp_Rq_AR.FDC_MsgDisp_Func_Avl_RDU.phys = getValue( HMI_FDC_MsgDisp_Func_Avl_RDU );
	  _mFDC_Disp_Rq_AR.FDC_MsgDisp_Rq.phys = getValue( HMI_FDC_MsgDisp_Rq );
	  _mFDC_Disp_Rq_AR.FDC_Warn_MsgDisp_Rq.phys = getValue( HMI_FDC_Warn_MsgDisp_Rq );
	  _mFDC_Disp_Rq_AR.Rsrv7_FDC_Disp_Rq.phys = getValue( HMI_Rsrv7_FDC_Disp_Rq );
	  _mFDC_Disp_Rq_AR.FDC_ActvOffer_MsgDisp_Rq.phys = getValue( HMI_FDC_ActvOffer_MsgDisp_Rq );

}

FDC_Disp_Rq_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_FDC_Disp_Rq ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_FDC_Disp_Rq_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _FDC_Disp_Rq_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _FDC_Disp_Rq_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_FDC_Disp_Rq_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _FDC_Disp_Rq_AR_SQC_WrongSeqJump != 0 ) &&
            ( _FDC_Disp_Rq_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _FDC_Disp_Rq_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _FDC_Disp_Rq_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _FDC_Disp_Rq_AR_SQC_RepeatedCnt ) &&
            ( _FDC_Disp_Rq_AR_E2E_Armed == 1  )    )
        {
            _FDC_Disp_Rq_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_FDC_Disp_Rq, SQC_help );
    }
    _mFDC_Disp_Rq_AR.SQC_FDC_Disp_Rq = SQC_help;

    if( getValue( HMI_CRC_FDC_Disp_Rq_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_FDC_Disp_Rq_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable_profile02[ crc ^ _mFDC_Disp_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mFDC_Disp_Rq_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mFDC_Disp_Rq_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mFDC_Disp_Rq_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mFDC_Disp_Rq_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mFDC_Disp_Rq_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mFDC_Disp_Rq_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mFDC_Disp_Rq_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _FDC_Disp_Rq_AR_CRC_Offset[ _mFDC_Disp_Rq_AR.SQC_FDC_Disp_Rq ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _FDC_Disp_Rq_AR_CRC_ErrorCnt   && ( _FDC_Disp_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_FDC_Disp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _FDC_Disp_Rq_AR_CRC_ErrorCnt > 0 )
                    _FDC_Disp_Rq_AR_CRC_ErrorCnt--; 
            }
            _mFDC_Disp_Rq_AR.CRC_FDC_Disp_Rq = crc;
            putValue( HMI_CRC_FDC_Disp_Rq, crc );
        }
        else
            _mFDC_Disp_Rq_AR.CRC_FDC_Disp_Rq = getValue( HMI_CRC_FDC_Disp_Rq );
    }
    else
    {
        if( !getValue( HMI_CRC_FDC_Disp_Rq_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mFDC_Disp_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mFDC_Disp_Rq_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mFDC_Disp_Rq_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mFDC_Disp_Rq_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mFDC_Disp_Rq_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mFDC_Disp_Rq_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mFDC_Disp_Rq_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mFDC_Disp_Rq_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _FDC_Disp_Rq_AR_CRC_ErrorCnt   && ( _FDC_Disp_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_FDC_Disp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _FDC_Disp_Rq_AR_CRC_ErrorCnt > 0 )
                    _FDC_Disp_Rq_AR_CRC_ErrorCnt--; 
            }
            _mFDC_Disp_Rq_AR.CRC_FDC_Disp_Rq = crc;
            putValue( HMI_CRC_FDC_Disp_Rq, crc );
        }
        else
            _mFDC_Disp_Rq_AR.CRC_FDC_Disp_Rq = getValue( HMI_CRC_FDC_Disp_Rq );
    }
    if( ( _FDC_Disp_Rq_AR_MSG_DropCnt > 0 ) &&
        ( _FDC_Disp_Rq_AR_E2E_Armed == 1  )    )
    {
        _FDC_Disp_Rq_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mFDC_Disp_Rq_AR );
        
    if( _FDC_Disp_Rq_AR_E2E_Armed == 1 )
    {
        if ( ( _FDC_Disp_Rq_AR_MSG_DropCnt == 0      ) &&
             ( _FDC_Disp_Rq_AR_CRC_ErrorCnt == 0     ) &&
             ( _FDC_Disp_Rq_AR_SQC_RepeatedCnt == 0  ) &&
             ( _FDC_Disp_Rq_AR_SQC_WrongSeqJump == 0 )    )
        {
            _FDC_Disp_Rq_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_FDC_Disp_Rq_State, 0 );
        }
    }
}

FDC_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: FDC_Disp_Rq_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_FDC_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_FDC_Disp_Rq_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_FDC_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_FDC_Disp_Rq_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_FDC_Disp_Rq := %X\n", getValue( HMI_CRC_FDC_Disp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_FDC_Disp_Rq_Auto := %X\n", getValue( HMI_CRC_FDC_Disp_Rq_Auto ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_FDC_Disp_Rq_Profile_02 := %X\n", getValue( HMI_CRC_FDC_Disp_Rq_Profile_02 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FDC_Actv_Stat := %X\n", getValue( HMI_FDC_Actv_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FDC_Actv_Stat_V2 := %X\n", getValue( HMI_FDC_Actv_Stat_V2 ) ); filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_FDC_Acust_EmgWarn_Rq_ := %X\n", getValue( HMI_FDC_Acust_EmgWarn_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FDC_AcustWarn1_Rq_ := %X\n", getValue( HMI_FDC_AcustWarn1_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FDC_AcustWarn2_Rq := %X\n", getValue( HMI_FDC_AcustWarn2_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FDC_AcustWarn3_Rq := %X\n", getValue( HMI_FDC_AcustWarn3_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FDC_FltMsgDisp_Rq := %X\n", getValue( HMI_FDC_FltMsgDisp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FDC_Md_Stat := %X\n", getValue( HMI_FDC_Md_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FDC_Msg_TkOvr_Rq := %X\n", getValue( HMI_FDC_Msg_TkOvr_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_FDC_Disp_Rq := %X\n", getValue( HMI_SQC_FDC_Disp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_FDC_Disp_Rq_Auto := %X\n", getValue( HMI_SQC_FDC_Disp_Rq_Auto ) );    filePutString ( buffer, elcount( buffer ), hFile );	
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_FDC_MsgDisp_Func_Avl_RDU := %X\n", getValue( HMI_FDC_MsgDisp_Func_Avl_RDU ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_FDC_MsgDisp_Rq := %X\n", getValue( HMI_FDC_MsgDisp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_FDC_Warn_MsgDisp_Rq := %X\n", getValue( HMI_FDC_Warn_MsgDisp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv7_FDC_Disp_Rq := %X\n", getValue( HMI_Rsrv7_FDC_Disp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_FDC_ActvOffer_MsgDisp_Rq := %X\n", getValue( HMI_FDC_ActvOffer_MsgDisp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    }

on timer _tFDC_Disp_Rq_AR
{
    putValue( HMI__STMSG_FDC_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_FDC_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_FDC_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tFDC_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_FDC_Disp_Rq_AR, 0 );
    }
}

on envVar HMI_E2E_FDC_Disp_Rq_Inject
{
    if( getValue( this ) )
    {
        _FDC_Disp_Rq_AR_CRC_ErrorCnt = getValue( HMI_CRC_FDC_Disp_Rq_ErrorCount );
        _FDC_Disp_Rq_AR_SQC_TriggPos = getValue( HMI_SQC_FDC_Disp_Rq_TriggerPosition );
        _FDC_Disp_Rq_AR_SQC_WrongSeqJump = getValue( HMI_SQC_FDC_Disp_Rq_WrongSeq );
        _FDC_Disp_Rq_AR_SQC_RepeatedCnt = getValue( HMI_SQC_FDC_Disp_Rq_Repeated );
        _FDC_Disp_Rq_AR_MSG_DropCnt = getValue( HMI_SQC_FDC_Disp_Rq_MSG_DropCnt );
        putValue( HMI_E2E_FDC_Disp_Rq_State, 2 );
        _FDC_Disp_Rq_AR_E2E_Armed = 2;  //armed
    }
}

on envVar HMI__STMSG_PO_FDC_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("FDC_Disp_Rq_AR");
}

on EnvVar HMI_FDC_Actv_Stat
{
    _mFDC_Disp_Rq_AR.FDC_Actv_Stat.phys = getValue(this);
    _FDC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FDC_Acust_EmgWarn_Rq
{
    _mFDC_Disp_Rq_AR.FDC_Acust_EmgWarn_Rq.phys = getValue(this);
    _FDC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FDC_AcustWarn1_Rq
{
    _mFDC_Disp_Rq_AR.FDC_AcustWarn1_Rq.phys = getValue(this);
    _FDC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FDC_AcustWarn2_Rq
{
    _mFDC_Disp_Rq_AR.FDC_AcustWarn2_Rq.phys = getValue(this);
    _FDC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FDC_AcustWarn3_Rq
{
    _mFDC_Disp_Rq_AR.FDC_AcustWarn3_Rq.phys = getValue(this);
    _FDC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FDC_Actv_Stat_V2
{
	_mFDC_Disp_Rq_AR.FDC_Actv_Stat_V2.phys = getValue(this);
	_FDC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FDC_FltMsgDisp_Rq
{
    _mFDC_Disp_Rq_AR.FDC_FltMsgDisp_Rq.phys = getValue(this);
    _FDC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FDC_Md_Stat
{
    _mFDC_Disp_Rq_AR.FDC_Md_Stat.phys = getValue(this);
    _FDC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FDC_Msg_TkOvr_Rq
{
    _mFDC_Disp_Rq_AR.FDC_Msg_TkOvr_Rq.phys = getValue(this);
    _FDC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FDC_MsgDisp_Func_Avl_RDU
{
    _mFDC_Disp_Rq_AR.FDC_MsgDisp_Func_Avl_RDU.phys = getValue(this);
    _FDC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FDC_MsgDisp_Rq
{
    _mFDC_Disp_Rq_AR.FDC_MsgDisp_Rq.phys = getValue(this);
    _FDC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FDC_Warn_MsgDisp_Rq
{
    _mFDC_Disp_Rq_AR.FDC_Warn_MsgDisp_Rq.phys = getValue(this);
    _FDC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv7_FDC_Disp_Rq
{
    _mFDC_Disp_Rq_AR.Rsrv7_FDC_Disp_Rq.phys = getValue(this);
    _FDC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FDC_ActvOffer_MsgDisp_Rq
{
    _mFDC_Disp_Rq_AR.FDC_ActvOffer_MsgDisp_Rq.phys = getValue(this);
    _FDC_Disp_Rq_AR_SpontanFlag = 1;
}

FlashOverTheAir_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_FlashOverTheAir_Stat_AR ) )
    {
    //  Botschaft FlashOverTheAir_Stat_AR ID: 1160 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _FlashOverTheAir_Stat_AR_DelayCnt > 0) _FlashOverTheAir_Stat_AR_DelayCnt--; // Mindestsendeabstand
        _FlashOverTheAir_Stat_AR_Cnt--;
        if( _FlashOverTheAir_Stat_AR_Cnt < 1 )
        {
            if( _FlashOverTheAir_Stat_AR_DelayCnt < 1 )
            {
                FlashOverTheAir_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                _FlashOverTheAir_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _FlashOverTheAir_Stat_AR_DelayCnt = _FlashOverTheAir_Stat_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _FlashOverTheAir_Stat_AR_SpontanFlag = 1;
            }
            _FlashOverTheAir_Stat_AR_Cnt = _FlashOverTheAir_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _FlashOverTheAir_Stat_AR_SpontanFlag)
        {
            if( _FlashOverTheAir_Stat_AR_DelayCnt < 1 )
            {
                FlashOverTheAir_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _FlashOverTheAir_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _FlashOverTheAir_Stat_AR_DelayCnt = _FlashOverTheAir_Stat_AR_MinDelay;
            }
        }
    }
}

FlashOverTheAir_Stat_AR_init()
{   /* Botschaft FlashOverTheAir_Stat_AR ID: 1160 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1160 0;
BA_ "NmAsrMessage" BO_ 1160 0;
BA_ "GenMsgMinAcceptLength" BO_ 1160 2;
BA_ "GenMsgILSupport" BO_ 1160 1;
BA_ "DiagState" BO_ 1160 0;
BA_ "DiagRequest" BO_ 1160 0;
BA_ "DiagResponse" BO_ 1160 0;
BA_ "GenMsgStartValue" BO_ 1160 "0";
BA_ "GenMsgDelayTime" BO_ 1160 100;
BA_ "GenMsgNrOfRepetition" BO_ 1160 0;
BA_ "GenMsgCycleTime" BO_ 1160 1000;
BA_ "GenMsgSendType" BO_ 1160 5;
    */
    _FlashOverTheAir_Stat_AR_Timebase =             c_tDBKomTimer_20ms;
    _FlashOverTheAir_Stat_AR_CycleCount =         1000 / _FlashOverTheAir_Stat_AR_Timebase;
    _FlashOverTheAir_Stat_AR_StartDelay =            0 / _FlashOverTheAir_Stat_AR_Timebase;
    _FlashOverTheAir_Stat_AR_MinDelay =            100 / _FlashOverTheAir_Stat_AR_Timebase;
    _FlashOverTheAir_Stat_AR_Cnt = _FlashOverTheAir_Stat_AR_StartDelay;
    _FlashOverTheAir_Stat_AR_SpontanFlag = 0;
    _FlashOverTheAir_Stat_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_FlashOverTheAir_Stat_AR, _FlashOverTheAir_Stat_AR_StartDelay * _FlashOverTheAir_Stat_AR_Timebase );

    _mFlashOverTheAir_Stat_AR.FOTA_Interaction_Stat.phys = getValue( HMI_FOTA_Interaction_Stat );
    _mFlashOverTheAir_Stat_AR.FOTA_Stat.phys = getValue( HMI_FOTA_Stat );
    _mFlashOverTheAir_Stat_AR.RepairshopMode_Stat.phys = getValue( HMI_RepairshopMode_Stat );
    _mFlashOverTheAir_Stat_AR.CU_Prohibit_TDP_Rq.phys = getValue( HMI_CU_Prohibit_TDP_Rq );
    _mFlashOverTheAir_Stat_AR.FOTA_SafeMd_Stat.phys = getValue( HMI_FOTA_SafeMd_Stat );
    _mFlashOverTheAir_Stat_AR.FOTA_ReProg_Stat.phys = getValue( HMI_FOTA_ReProg_Stat );
}

FlashOverTheAir_Stat_AR_output(void)
{
    output( _mFlashOverTheAir_Stat_AR );
}

FlashOverTheAir_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: FlashOverTheAir_Stat_AR\n", 26, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_FlashOverTheAir_Stat_AR := %X\n", getValue( HMI__STMSG_FlashOverTheAir_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_FlashOverTheAir_Stat_AR := %X\n", getValue( HMI__STMSGT_FlashOverTheAir_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FOTA_Interaction_Stat := %X\n", getValue( HMI_FOTA_Interaction_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FOTA_Stat := %X\n", getValue( HMI_FOTA_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RepairshopMode_Stat := %X\n", getValue( HMI_RepairshopMode_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CU_Prohibit_TDP_Rq := %X\n", getValue( HMI_CU_Prohibit_TDP_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FOTA_ReProg_Stat := %X\n", getValue( HMI_FOTA_ReProg_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FOTA_SafeMd_Stat := %X\n", getValue( HMI_FOTA_SafeMd_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tFlashOverTheAir_Stat_AR
{
    putValue( HMI__STMSG_FlashOverTheAir_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_FlashOverTheAir_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_FlashOverTheAir_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tFlashOverTheAir_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_FlashOverTheAir_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_FlashOverTheAir_Stat_AR
{
    if( getValue( this ) )
        openPanel("FlashOverTheAir_Stat_AR");
}

on EnvVar HMI_FOTA_Interaction_Stat
{
    _mFlashOverTheAir_Stat_AR.FOTA_Interaction_Stat.phys = getValue(this);
    _FlashOverTheAir_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FOTA_Stat
{
    _mFlashOverTheAir_Stat_AR.FOTA_Stat.phys = getValue(this);
    _FlashOverTheAir_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_RepairshopMode_Stat
{
    _mFlashOverTheAir_Stat_AR.RepairshopMode_Stat.phys = getValue(this);
    _FlashOverTheAir_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_CU_Prohibit_TDP_Rq
{
    _mFlashOverTheAir_Stat_AR.CU_Prohibit_TDP_Rq.phys = getValue(this);
    _FlashOverTheAir_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FOTA_ReProg_Stat
{
    _mFlashOverTheAir_Stat_AR.FOTA_ReProg_Stat.phys = getValue(this);
    _FlashOverTheAir_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FOTA_SafeMd_Stat
{
    _mFlashOverTheAir_Stat_AR.FOTA_SafeMd_Stat.phys = getValue(this);
    _FlashOverTheAir_Stat_AR_SpontanFlag = 1;
}

FuelLvl_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_FuelLvl_Stat_AR ) )
    {
    //  message   FuelLvl_Stat_AR ID: 766 --- Sendeart 0 cyclicX --- 
        _FuelLvl_Stat_AR_Cnt--;
        if( _FuelLvl_Stat_AR_Cnt < 1 )
        {
            FuelLvl_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _FuelLvl_Stat_AR_Cnt = _FuelLvl_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

FuelLvl_Stat_AR_init()
{   /* Botschaft FuelLvl_Stat_AR ID: 766 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 766 0;
BA_ "NmAsrMessage" BO_ 766 0;
BA_ "GenMsgMinAcceptLength" BO_ 766 8;
BA_ "GenMsgILSupport" BO_ 766 1;
BA_ "DiagState" BO_ 766 0;
BA_ "DiagRequest" BO_ 766 0;
BA_ "DiagResponse" BO_ 766 0;
BA_ "GenMsgStartValue" BO_ 766 "0";
BA_ "GenMsgCycleTime" BO_ 766 1000;
BA_ "GenMsgSendType" BO_ 766 0;
    */
    _FuelLvl_Stat_AR_Timebase =          c_tDBKomTimer_20ms;
    _FuelLvl_Stat_AR_CycleCount =     1000 / _FuelLvl_Stat_AR_Timebase;
    _FuelLvl_Stat_AR_StartDelay =        0 / _FuelLvl_Stat_AR_Timebase;
    _FuelLvl_Stat_AR_Cnt = _FuelLvl_Stat_AR_StartDelay;

    putValue( HMI__STMSGSD_FuelLvl_Stat_AR, _FuelLvl_Stat_AR_StartDelay * _FuelLvl_Stat_AR_Timebase );

    putValue( HMI_TankLvl, 50 ); // Tank halb voll
    _mFuelLvl_Stat_AR.FSCM_FuelRefillEvent_Dtct.phys = getValue( HMI_FSCM_FuelRefillEvent_Dtct );
    _mFuelLvl_Stat_AR.FSCM_TankLvl_Min_50.phys = getValue( HMI_FSCM_TankLvl_Min_50 );
    _mFuelLvl_Stat_AR.Fuel_Lvl_Critic.phys = getValue( HMI_Fuel_Lvl_Critic );
    _mFuelLvl_Stat_AR.FuelTemp.phys = getValue( HMI_FuelTemp );
    _mFuelLvl_Stat_AR.MIL_On_Rq_FSCM.phys = getValue( HMI_MIL_On_Rq_FSCM );
    _mFuelLvl_Stat_AR.TankLvl.phys = getValue( HMI_TankLvl );
    _mFuelLvl_Stat_AR.TankLvl_Disp_V2.phys = getValue( HMI_TankLvl_Disp_V2 );
    _mFuelLvl_Stat_AR.TankLvl_Max.phys = getValue( HMI_TankLvl_Max );
    _mFuelLvl_Stat_AR.TankLvl_Min.phys = getValue( HMI_TankLvl_Min );
    _mFuelLvl_Stat_AR.TankRes.phys = getValue( HMI_TankRes );
	
}

FuelLvl_Stat_AR_output(void)
{
    output( _mFuelLvl_Stat_AR );
}

FuelLvl_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: FuelLvl_Stat_AR\n", 26, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_FuelLvl_Stat_AR := %X\n", getValue( HMI__STMSG_FuelLvl_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_FuelLvl_Stat_AR := %X\n", getValue( HMI__STMSGT_FuelLvl_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FSCM_FuelRefillEvent_Dtct := %X\n", getValue( HMI_FSCM_FuelRefillEvent_Dtct ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FSCM_TankLvl_Min_50 := %X\n", getValue( HMI_FSCM_TankLvl_Min_50 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Fuel_Lvl_Critic := %X\n", getValue( HMI_Fuel_Lvl_Critic ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FuelTemp := %X\n", getValue( HMI_FuelTemp ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MIL_On_Rq_FSCM := %X\n", getValue( HMI_MIL_On_Rq_FSCM ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TankLvl := %X\n", getValue( HMI_TankLvl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TankLvl_Disp_V2 := %X\n", getValue( HMI_TankLvl_Disp_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TankLvl_Max := %X\n", getValue( HMI_TankLvl_Max ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TankLvl_Min := %X\n", getValue( HMI_TankLvl_Min ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TankRes := %X\n", getValue( HMI_TankRes ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tFuelLvl_Stat_AR
{
    putValue( HMI__STMSG_FuelLvl_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_FuelLvl_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_FuelLvl_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tFuelLvl_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_FuelLvl_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_FuelLvl_Stat_AR
{
    if( getValue( this ) )
        openPanel("FuelLvl_Stat_AR");
}

on EnvVar HMI_FSCM_FuelRefillEvent_Dtct
{
    _mFuelLvl_Stat_AR.FSCM_FuelRefillEvent_Dtct.phys = getValue(this);
}

on EnvVar HMI_FSCM_TankLvl_Min_50
{
    _mFuelLvl_Stat_AR.FSCM_TankLvl_Min_50.phys = getValue(this);
}

on EnvVar HMI_Fuel_Lvl_Critic
{
    _mFuelLvl_Stat_AR.Fuel_Lvl_Critic.phys = getValue(this);
}

on EnvVar HMI_FuelTemp
{
    _mFuelLvl_Stat_AR.FuelTemp.phys = getValue(this);
}

on EnvVar HMI_MIL_On_Rq_FSCM
{
    _mFuelLvl_Stat_AR.MIL_On_Rq_FSCM.phys = getValue(this);
}

on EnvVar HMI_TankLvl
{
    _mFuelLvl_Stat_AR.TankLvl.phys = getValue(this);
}

on EnvVar HMI_TankLvl_Disp_V2
{
    _mFuelLvl_Stat_AR.TankLvl_Disp_V2.phys = getValue(this);
}

on EnvVar HMI_TankLvl_Max
{
    _mFuelLvl_Stat_AR.TankLvl_Max.phys = getValue(this);
}

on EnvVar HMI_TankLvl_Min
{
    _mFuelLvl_Stat_AR.TankLvl_Min.phys = getValue(this);
}

on EnvVar HMI_TankRes
{
    _mFuelLvl_Stat_AR.TankRes.phys = getValue(this);
}

Fuel_Stat2_AR_check_output()
{
    if( !getValue( HMI__STMSG_Fuel_Stat2_AR ) )
    {
    //  message   Fuel_Stat2_AR --- Sendeart 0 cyclicX
        _Fuel_Stat2_AR_Cnt--;
        if( _Fuel_Stat2_AR_Cnt < 1 )
        {
            Fuel_Stat2_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _Fuel_Stat2_AR_Cnt = _Fuel_Stat2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

Fuel_Stat2_AR_init()
{   /* Botschaft Fuel_Stat2_AR ID: 1190 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 1190 0;
BA_ "NmAsrMessage" BO_ 1190 0;
BA_ "GenMsgMinAcceptLength" BO_ 1190 8;
BA_ "GenMsgILSupport" BO_ 1190 1;
BA_ "DiagState" BO_ 1190 0;
BA_ "DiagRequest" BO_ 1190 0;
BA_ "DiagResponse" BO_ 1190 0;
BA_ "GenMsgStartValue" BO_ 1190 "0";
BA_ "GenMsgCycleTime" BO_ 1190 500;
BA_ "GenMsgSendType" BO_ 1190 0;
    */
    _Fuel_Stat2_AR_Timebase =          c_tDBKomTimer_20ms;
    _Fuel_Stat2_AR_CycleCount =      500 / _Fuel_Stat2_AR_Timebase;
    _Fuel_Stat2_AR_StartDelay =        0 / _Fuel_Stat2_AR_Timebase;
    _Fuel_Stat2_AR_Cnt = _Fuel_Stat2_AR_StartDelay;

    putValue( HMI__STMSGSD_Fuel_Stat2_AR, _Fuel_Stat2_AR_StartDelay * _Fuel_Stat2_AR_Timebase );

    _mFuel_Stat2_AR.CNG_Style.phys = getValue( HMI_CNG_Style );
    _mFuel_Stat2_AR.FuelType_AdBlue_Avl.phys = getValue( HMI_FuelType_AdBlue_Avl );
    _mFuel_Stat2_AR.FuelType_CNG_Avl.phys = getValue( HMI_FuelType_CNG_Avl );
    _mFuel_Stat2_AR.FuelType_Diesel_Avl.phys = getValue( HMI_FuelType_Diesel_Avl );
    _mFuel_Stat2_AR.FuelType_ElecPlugIn_Avl.phys = getValue( HMI_FuelType_ElecPlugIn_Avl );
    _mFuel_Stat2_AR.PT4_PTCoor_DrvPwrMin_Disp.phys = getValue( HMI_PT4_PTCoor_DrvPwrMin_Disp );
    _mFuel_Stat2_AR.PT4_PTCoor_DrvTrqMin_Disp.phys = getValue( HMI_PT4_PTCoor_DrvTrqMin_Disp );
    _mFuel_Stat2_AR.FuelType_Ethanol_Avl.phys = getValue( HMI_FuelType_Ethanol_Avl );
    _mFuel_Stat2_AR.FuelType_Gasoline_Avl.phys = getValue( HMI_FuelType_Gasoline_Avl );
    _mFuel_Stat2_AR.FuelType_Hydrogen_Avl.phys = getValue( HMI_FuelType_Hydrogen_Avl );
    _mFuel_Stat2_AR.FuelTypeCfg_Vld.phys = getValue( HMI_FuelTypeCfg_Vld );
    _mFuel_Stat2_AR.HybDrv_Avl.phys = getValue( HMI_HybDrv_Avl );
    _mFuel_Stat2_AR.PNHV_Avl.phys = getValue( HMI_PNHV_Avl );
    _mFuel_Stat2_AR.TankRng.phys = getValue( HMI_TankRng );
}

Fuel_Stat2_AR_output(void)
{
    output( _mFuel_Stat2_AR );
}

Fuel_Stat2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Fuel_Stat2_AR\n", 26, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Fuel_Stat2_AR := %X\n", getValue( HMI__STMSG_Fuel_Stat2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Fuel_Stat2_AR := %X\n", getValue( HMI__STMSGT_Fuel_Stat2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CNG_Style := %X\n", getValue( HMI_CNG_Style ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FuelType_AdBlue_Avl := %X\n", getValue( HMI_FuelType_AdBlue_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FuelType_CNG_Avl := %X\n", getValue( HMI_FuelType_CNG_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FuelType_Diesel_Avl := %X\n", getValue( HMI_FuelType_Diesel_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FuelType_ElecPlugIn_Avl := %X\n", getValue( HMI_FuelType_ElecPlugIn_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT4_PTCoor_DrvPwrMin_Disp := %X\n", getValue( HMI_PT4_PTCoor_DrvPwrMin_Disp ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT4_PTCoor_DrvTrqMin_Disp := %X\n", getValue( HMI_PT4_PTCoor_DrvTrqMin_Disp ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FuelType_Ethanol_Avl := %X\n", getValue( HMI_FuelType_Ethanol_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FuelType_Gasoline_Avl := %X\n", getValue( HMI_FuelType_Gasoline_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FuelType_Hydrogen_Avl := %X\n", getValue( HMI_FuelType_Hydrogen_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FuelTypeCfg_Vld := %X\n", getValue( HMI_FuelTypeCfg_Vld ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HybDrv_Avl := %X\n", getValue( HMI_HybDrv_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_Avl := %X\n", getValue( HMI_PNHV_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TankRng := %X\n", getValue( HMI_TankRng ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tFuel_Stat2_AR
{
    putValue( HMI__STMSG_Fuel_Stat2_AR, 0 );
}

on EnvVar HMI__STMSG_Fuel_Stat2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Fuel_Stat2_AR );
        if( tDelay > 0)    
            setTimer( _tFuel_Stat2_AR, tDelay );
        else
            putValue( HMI__STMSG_Fuel_Stat2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Fuel_Stat2_AR
{
    if( getValue( this ) )
        openPanel("Fuel_Stat2_AR");
}

on EnvVar HMI_CNG_Style
{
   _mFuel_Stat2_AR.CNG_Style.phys = getValue(this);
}

on EnvVar HMI_FuelType_AdBlue_Avl
{
   _mFuel_Stat2_AR.FuelType_AdBlue_Avl.phys = getValue(this);
}

on EnvVar HMI_FuelType_CNG_Avl
{
   _mFuel_Stat2_AR.FuelType_CNG_Avl.phys = getValue(this);
}

on EnvVar HMI_FuelType_Diesel_Avl
{
   _mFuel_Stat2_AR.FuelType_Diesel_Avl.phys = getValue(this);
}

on EnvVar HMI_FuelType_ElecPlugIn_Avl
{
   _mFuel_Stat2_AR.FuelType_ElecPlugIn_Avl.phys = getValue(this);
}

on EnvVar HMI_PT4_PTCoor_DrvPwrMin_Disp
{
   _mFuel_Stat2_AR.PT4_PTCoor_DrvPwrMin_Disp.phys = getValue(this);
}

on EnvVar HMI_PT4_PTCoor_DrvTrqMin_Disp
{
   _mFuel_Stat2_AR.PT4_PTCoor_DrvTrqMin_Disp.phys = getValue(this);
}

on EnvVar HMI_FuelType_Ethanol_Avl
{
   _mFuel_Stat2_AR.FuelType_Ethanol_Avl.phys = getValue(this);
}

on EnvVar HMI_FuelType_Gasoline_Avl
{
   _mFuel_Stat2_AR.FuelType_Gasoline_Avl.phys = getValue(this);
}

on EnvVar HMI_FuelType_Hydrogen_Avl
{
   _mFuel_Stat2_AR.FuelType_Hydrogen_Avl.phys = getValue(this);
}

on EnvVar HMI_FuelTypeCfg_Vld
{
   _mFuel_Stat2_AR.FuelTypeCfg_Vld.phys = getValue(this);
}

on EnvVar HMI_HybDrv_Avl
{
   _mFuel_Stat2_AR.HybDrv_Avl.phys = getValue(this);
}

on EnvVar HMI_PNHV_Avl
{
   _mFuel_Stat2_AR.PNHV_Avl.phys = getValue(this);
}

on EnvVar HMI_TankRng
{
   _mFuel_Stat2_AR.TankRng.phys = getValue(this);
}

FWLP_D_AR_check_output()
{
    if( !getValue( HMI__STMSG_FWLP_D_AR ) )
    {
    //  message   FWLP_D_AR ID: 1191 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _FWLP_D_AR_DelayCnt > 0) _FWLP_D_AR_DelayCnt--; // Mindestsendeabstand
        _FWLP_D_AR_Cnt--;
        if( _FWLP_D_AR_Cnt < 1 )
        {
            if( _FWLP_D_AR_DelayCnt < 1 )
            {
                FWLP_D_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                _FWLP_D_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _FWLP_D_AR_DelayCnt = _FWLP_D_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _FWLP_D_AR_SpontanFlag = 1;
            }
            _FWLP_D_AR_Cnt = _FWLP_D_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _FWLP_D_AR_SpontanFlag)
        {
            if( _FWLP_D_AR_DelayCnt < 1 )
            {
                FWLP_D_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _FWLP_D_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _FWLP_D_AR_DelayCnt = _FWLP_D_AR_MinDelay;
            }
        }
    }
}

FWLP_D_AR_init()
{   /* Botschaft FWLP_D_AR ID: 1191 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1191 0;
BA_ "NmAsrMessage" BO_ 1191 0;
BA_ "GenMsgMinAcceptLength" BO_ 1191 5;
BA_ "GenMsgILSupport" BO_ 1191 1;
BA_ "DiagState" BO_ 1191 0;
BA_ "DiagRequest" BO_ 1191 0;
BA_ "DiagResponse" BO_ 1191 0;
BA_ "GenMsgStartValue" BO_ 1191 "0";
BA_ "GenMsgDelayTime" BO_ 1191 100;
BA_ "GenMsgNrOfRepetitions" BO_ 1191 0;
BA_ "GenMsgCycleTime" BO_ 1191 1000;
BA_ "GenMsgSendType" BO_ 1191 5;
    */
    _FWLP_D_AR_Timebase =             c_tDBKomTimer_20ms;
    _FWLP_D_AR_CycleCount =         1000 / _FWLP_D_AR_Timebase;
    _FWLP_D_AR_StartDelay =            0 / _FWLP_D_AR_Timebase;
    _FWLP_D_AR_MinDelay =            100 / _FWLP_D_AR_Timebase;
    _FWLP_D_AR_Cnt = _FWLP_D_AR_StartDelay;
    _FWLP_D_AR_SpontanFlag = 0;
    _FWLP_D_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_FWLP_D_AR, _FWLP_D_AR_StartDelay * _FWLP_D_AR_Timebase );

    _mFWLP_D_AR.FWLP_AirCons_On_D.phys = getValue( HMI_FWLP_AirCons_On_D );
    _mFWLP_D_AR.FWLP_LumPad_D.phys = getValue( HMI_FWLP_LumPad_D );
    _mFWLP_D_AR.FWLP_LumPad_Stat_D.phys = getValue( HMI_FWLP_LumPad_Stat_D );
    _mFWLP_D_AR.FWLP_LumPosn_D.phys = getValue( HMI_FWLP_LumPosn_D );
    _mFWLP_D_AR.FWLP_LumPosn_Stat_D.phys = getValue( HMI_FWLP_LumPosn_Stat_D );
}

FWLP_D_AR_output(void)
{
    output( _mFWLP_D_AR );
}

FWLP_D_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: FWLP_D_AR\n", 23, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_FWLP_D_AR := %X\n", getValue( HMI__STMSG_FWLP_D_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_FWLP_D_AR := %X\n", getValue( HMI__STMSGT_FWLP_D_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FWLP_AirCons_On_D := %X\n", getValue( HMI_FWLP_AirCons_On_D ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FWLP_LumPad_D := %X\n", getValue( HMI_FWLP_LumPad_D ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FWLP_LumPad_Stat_D := %X\n", getValue( HMI_FWLP_LumPad_Stat_D ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FWLP_LumPosn_D := %X\n", getValue( HMI_FWLP_LumPosn_D ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FWLP_LumPosn_Stat_D := %X\n", getValue( HMI_FWLP_LumPosn_Stat_D ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tFWLP_D_AR
{
    putValue( HMI__STMSG_FWLP_D_AR, 0 );
}

on EnvVar HMI__STMSG_FWLP_D_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_FWLP_D_AR );
        if( tDelay > 0)    
            setTimer( _tFWLP_D_AR, tDelay );
        else
            putValue( HMI__STMSG_FWLP_D_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_FWLP_D_AR
{
    if( getValue( this ) )
        openPanel("FWLP_D_AR");
}

on EnvVar HMI_FWLP_AirCons_On_D
{
    _mFWLP_D_AR.FWLP_AirCons_On_D.phys = getValue(this);
    _FWLP_D_AR_SpontanFlag = 1;
}

on EnvVar HMI_FWLP_LumPad_D
{
    _mFWLP_D_AR.FWLP_LumPad_D.phys = getValue(this);
    _FWLP_D_AR_SpontanFlag = 1;
}

on EnvVar HMI_FWLP_LumPad_Stat_D
{
    _mFWLP_D_AR.FWLP_LumPad_Stat_D.phys = getValue(this);
    _FWLP_D_AR_SpontanFlag = 1;
}

on EnvVar HMI_FWLP_LumPosn_D
{
    _mFWLP_D_AR.FWLP_LumPosn_D.phys = getValue(this);
    _FWLP_D_AR_SpontanFlag = 1;
}

on EnvVar HMI_FWLP_LumPosn_Stat_D
{
    _mFWLP_D_AR.FWLP_LumPosn_Stat_D.phys = getValue(this);
    _FWLP_D_AR_SpontanFlag = 1;
}

FWLP_P_AR_check_output()
{
    if( !getValue( HMI__STMSG_FWLP_P_AR ) )
    {
    //  message   FWLP_P_AR ID: 1189 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _FWLP_P_AR_DelayCnt > 0) _FWLP_P_AR_DelayCnt--; // Mindestsendeabstand
        _FWLP_P_AR_Cnt--;
        if( _FWLP_P_AR_Cnt < 1 )
        {
            if( _FWLP_P_AR_DelayCnt < 1 )
            {
                FWLP_P_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                _FWLP_P_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _FWLP_P_AR_DelayCnt = _FWLP_P_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _FWLP_P_AR_SpontanFlag = 1;
            }
            _FWLP_P_AR_Cnt = _FWLP_P_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _FWLP_P_AR_SpontanFlag)
        {
            if( _FWLP_P_AR_DelayCnt < 1 )
            {
                FWLP_P_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _FWLP_P_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _FWLP_P_AR_DelayCnt = _FWLP_P_AR_MinDelay;
            }
        }
    }
}

FWLP_P_AR_init()
{   /* Botschaft FWLP_P_AR ID: 1189 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1189 0;
BA_ "NmAsrMessage" BO_ 1189 0;
BA_ "GenMsgMinAcceptLength" BO_ 1189 5;
BA_ "GenMsgILSupport" BO_ 1189 1;
BA_ "DiagState" BO_ 1189 0;
BA_ "DiagRequest" BO_ 1189 0;
BA_ "DiagResponse" BO_ 1189 0;
BA_ "GenMsgStartValue" BO_ 1189 "0";
BA_ "GenMsgDelayTime" BO_ 1189 100;
BA_ "GenMsgNrOfRepetitions" BO_ 1189 0;
BA_ "GenMsgCycleTime" BO_ 1189 1000;
BA_ "GenMsgSendType" BO_ 1189 5;
    */
    _FWLP_P_AR_Timebase =             c_tDBKomTimer_20ms;
    _FWLP_P_AR_CycleCount =         1000 / _FWLP_P_AR_Timebase;
    _FWLP_P_AR_StartDelay =            0 / _FWLP_P_AR_Timebase;
    _FWLP_P_AR_MinDelay =            100 / _FWLP_P_AR_Timebase;
    _FWLP_P_AR_Cnt = _FWLP_P_AR_StartDelay;
    _FWLP_P_AR_SpontanFlag = 0;
    _FWLP_P_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_FWLP_P_AR, _FWLP_P_AR_StartDelay * _FWLP_P_AR_Timebase );

    _mFWLP_P_AR.FWLP_AirCons_On_P.phys = getValue( HMI_FWLP_AirCons_On_P );
    _mFWLP_P_AR.FWLP_LumPad_P.phys = getValue( HMI_FWLP_LumPad_P );
    _mFWLP_P_AR.FWLP_LumPad_Stat_P.phys = getValue( HMI_FWLP_LumPad_Stat_P );
    _mFWLP_P_AR.FWLP_LumPosn_P.phys = getValue( HMI_FWLP_LumPosn_P );
    _mFWLP_P_AR.FWLP_LumPosn_Stat_P.phys = getValue( HMI_FWLP_LumPosn_Stat_P );
}

FWLP_P_AR_output(void)
{
    output( _mFWLP_P_AR );
}

FWLP_P_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: FWLP_P_AR\n", 23, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_FWLP_P_AR := %X\n", getValue( HMI__STMSG_FWLP_P_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_FWLP_P_AR := %X\n", getValue( HMI__STMSGT_FWLP_P_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FWLP_AirCons_On_P := %X\n", getValue( HMI_FWLP_AirCons_On_P ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FWLP_LumPad_P := %X\n", getValue( HMI_FWLP_LumPad_P ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FWLP_LumPad_Stat_P := %X\n", getValue( HMI_FWLP_LumPad_Stat_P ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FWLP_LumPosn_P := %X\n", getValue( HMI_FWLP_LumPosn_P ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FWLP_LumPosn_Stat_P := %X\n", getValue( HMI_FWLP_LumPosn_Stat_P ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tFWLP_P_AR
{
    putValue( HMI__STMSG_FWLP_P_AR, 0 );
}

on EnvVar HMI__STMSG_FWLP_P_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_FWLP_P_AR );
        if( tDelay > 0)    
            setTimer( _tFWLP_P_AR, tDelay );
        else
            putValue( HMI__STMSG_FWLP_P_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_FWLP_P_AR
{
    if( getValue( this ) )
        openPanel("FWLP_P_AR");
}

on EnvVar HMI_FWLP_AirCons_On_P
{
    _mFWLP_P_AR.FWLP_AirCons_On_P.phys = getValue(this);
    _FWLP_P_AR_SpontanFlag = 1;
}

on EnvVar HMI_FWLP_LumPad_P
{
    _mFWLP_P_AR.FWLP_LumPad_P.phys = getValue(this);
    _FWLP_P_AR_SpontanFlag = 1;
}

on EnvVar HMI_FWLP_LumPad_Stat_P
{
    _mFWLP_P_AR.FWLP_LumPad_Stat_P.phys = getValue(this);
    _FWLP_P_AR_SpontanFlag = 1;
}

on EnvVar HMI_FWLP_LumPosn_P
{
    _mFWLP_P_AR.FWLP_LumPosn_P.phys = getValue(this);
    _FWLP_P_AR_SpontanFlag = 1;
}

on EnvVar HMI_FWLP_LumPosn_Stat_P
{
    _mFWLP_P_AR.FWLP_LumPosn_Stat_P.phys = getValue(this);
    _FWLP_P_AR_SpontanFlag = 1;
}

HFP_R5_AR2_DAI_check_output()
{
    if( !getValue( HMI__STMSG_HFP_R5_AR2_DAI ) )
    {
    //  message   HFP_R5_AR2_DAI ID: 2430074880 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _HFP_R5_AR2_DAI_Cnt--;
        if( _HFP_R5_AR2_DAI_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            HFP_R5_AR2_DAI_output();
            _HFP_R5_AR2_DAI_Cnt = _HFP_R5_AR2_DAI_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _HFP_R5_AR2_DAI_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _HFP_R5_AR2_DAI_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            HFP_R5_AR2_DAI_output();
            _HFP_R5_AR2_DAI_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

HFP_R5_AR2_DAI_init()
{   /* Botschaft HFP_R5_AR2_DAI ID: 2430074880 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 821 0;
BA_ "NmAsrMessage" BO_ 821 0;
BA_ "GenMsgMinAcceptLength" BO_ 821 8;
BA_ "GenMsgILSupport" BO_ 821 1;
BA_ "DiagState" BO_ 821 0;
BA_ "DiagRequest" BO_ 821 0;
BA_ "DiagResponse" BO_ 821 0;
BA_ "GenMsgStartValue" BO_ 821 "0";
BA_ "GenMsgStartDelayTime" BO_ 821 0;
BA_ "GenMsgDelayTime" BO_ 821 5;
BA_ "GenMsgNrOfRepetitions" BO_ 821 0;
BA_ "GenMsgCycleTime" BO_ 821 500;
BA_ "GenMsgSendType" BO_ 821 5;
    */
    _HFP_R5_AR2_DAI_Timebase =         c_tDBKomTimer_20ms;
    _HFP_R5_AR2_DAI_CycleCount =     500 / _FWLP_P_AR_Timebase;
    _HFP_R5_AR2_DAI_StartDelay =       0 / _FWLP_P_AR_Timebase;
    _HFP_R5_AR2_DAI_Cnt = _HFP_R5_AR2_DAI_StartDelay;
    _HFP_R5_AR2_DAI_SpontanFlag = 0;

    putValue( HMI__STMSGSD_HFP_R5_AR2_DAI, _HFP_R5_AR2_DAI_StartDelay * _FWLP_P_AR_Timebase );

    _mHFP_R5_AR2_DAI.DetectedSlotLeft_Selection.phys = getValue( HMI_DetectedSlotLeft_Selection );
    _mHFP_R5_AR2_DAI.DetectedSlotLeft_Suitable.phys = getValue( HMI_DetectedSlotLeft_Suitable  );
    _mHFP_R5_AR2_DAI.DetectedSlotRight_Selection.phys = getValue( HMI_DetectedSlotRight_Selection );
    _mHFP_R5_AR2_DAI.DetectedSlotRight_Suitable.phys = getValue( HMI_DetectedSlotRight_Suitable );
    _mHFP_R5_AR2_DAI.HFP_DefaultManeuverType .phys = getValue( HMI_HFP_DefaultManeuverType );
    _mHFP_R5_AR2_DAI.HFP_ExtendedInstrContentDisplay .phys = getValue( HMI_HFP_ExtendedInstrContentDisplay );
	_mHFP_R5_AR2_DAI.HFP_InfoContentDisplay.phys = getValue( HMI_HFP_InfoContentDisplay  );
    _mHFP_R5_AR2_DAI.HFP_ManeuverChoiceDisplayRequest.phys = getValue( HMI_HFP_ManeuverChoiceDisplayRequest   );
    _mHFP_R5_AR2_DAI.HFP_ManeuverCompletion.phys = getValue( HMI_HFP_ManeuverCompletion );
    _mHFP_R5_AR2_DAI.HFP_ManeuverMove.phys = getValue( HMI_HFP_ManeuverMove );
    _mHFP_R5_AR2_DAI.HFP_MapContentDisplay.phys = getValue( HMI_HFP_MapContentDisplay );
    _mHFP_R5_AR2_DAI.HFP_SelectedManeuverType.phys = getValue( HMI_HFP_SelectedManeuverType );
    _mHFP_R5_AR2_DAI.HFP_SoundRequest.phys = getValue( HMI_HFP_SoundRequest );
    _mHFP_R5_AR2_DAI.HFP_WarningDisplayRequest.phys = getValue( HMI_HFP_WarningDisplayRequest );
    _mHFP_R5_AR2_DAI.HFPMalfunction.phys = getValue( HMI_HFPMalfunction  );
    _mHFP_R5_AR2_DAI.ScanningSide.phys = getValue( HMI_ScanningSide );
}

HFP_R5_AR2_DAI_output(void)
{
    output( _mHFP_R5_AR2_DAI );
}

HFP_R5_AR2_DAI_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: HFP_R5_AR2_DAI\n", 27, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_HFP_R5_AR2_DAI := %X\n", getValue( HMI__STMSG_HFP_R5_AR2_DAI ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_HFP_R5_AR2_DAI := %X\n", getValue( HMI__STMSGT_HFP_R5_AR2_DAI ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DetectedSlotLeft_Selection := %X\n", getValue( HMI_DetectedSlotLeft_Selection ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DetectedSlotLeft_Suitable := %X\n", getValue( HMI_DetectedSlotLeft_Suitable ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DetectedSlotRight_Selection := %X\n", getValue( HMI_DetectedSlotRight_Selection ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DetectedSlotRight_Suitable := %X\n", getValue( HMI_DetectedSlotRight_Suitable ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HFP_DefaultManeuverType := %X\n", getValue( HMI_HFP_DefaultManeuverType ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HFP_ExtendedInstrContentDisplay := %X\n", getValue( HMI_HFP_ExtendedInstrContentDisplay ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_HFP_InfoContentDisplay := %X\n", getValue( HMI_HFP_InfoContentDisplay ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HFP_ManeuverChoiceDisplayRequest := %X\n", getValue( HMI_HFP_ManeuverChoiceDisplayRequest ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HFP_ManeuverCompletion := %X\n", getValue( HMI_HFP_ManeuverCompletion ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HFP_ManeuverMove := %X\n", getValue( HMI_HFP_ManeuverMove ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HFP_MapContentDisplay := %X\n", getValue( HMI_HFP_MapContentDisplay ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HFP_SelectedManeuverType := %X\n", getValue( HMI_HFP_SelectedManeuverType ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HFP_SoundRequest := %X\n", getValue( HMI_HFP_SoundRequest ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HFP_WarningDisplayRequest := %X\n", getValue( HMI_HFP_WarningDisplayRequest ) );        filePutString ( buffer, elcount( buffer ), hFile );
	   snprintf( buffer, elcount( buffer ), "0.0000 HMI_HFPMalfunction := %X\n", getValue( HMI_HFPMalfunction ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ScanningSide := %X\n", getValue( HMI_ScanningSide ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tHFP_R5_AR2_DAI
{
    putValue( HMI__STMSG_HFP_R5_AR2_DAI, 0 );
}

on EnvVar HMI__STMSG_HFP_R5_AR2_DAI
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_HFP_R5_AR2_DAI );
        if( tDelay > 0)    
            setTimer( _tHFP_R5_AR2_DAI, tDelay );
        else
            putValue( HMI__STMSG_HFP_R5_AR2_DAI, 0 );
    }
}

on envVar HMI__STMSG_PO_HFP_R5_AR2_DAI
{
    if( getValue( this ) )
        openPanel("HFP_R5_AR2_DAI");
}

on EnvVar HMI_DetectedSlotLeft_Selection
{
    _mHFP_R5_AR2_DAI.DetectedSlotLeft_Selection.phys = getValue(this);
    _HFP_R5_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_DetectedSlotLeft_Suitable
{
    _mHFP_R5_AR2_DAI.DetectedSlotLeft_Suitable.phys = getValue(this);
    _HFP_R5_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_DetectedSlotRight_Selection
{
    _mHFP_R5_AR2_DAI.DetectedSlotRight_Selection.phys = getValue(this);
    _HFP_R5_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_DetectedSlotRight_Suitable
{
    _mHFP_R5_AR2_DAI.DetectedSlotRight_Suitable.phys = getValue(this);
    _HFP_R5_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_HFP_DefaultManeuverType
{
    _mHFP_R5_AR2_DAI.HFP_DefaultManeuverType.phys = getValue(this);
    _HFP_R5_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_HFP_ExtendedInstrContentDisplay
{
    _mHFP_R5_AR2_DAI.HFP_ExtendedInstrContentDisplay.phys = getValue(this);
    _HFP_R5_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_HFP_InfoContentDisplay
{
    _mHFP_R5_AR2_DAI.HFP_InfoContentDisplay.phys = getValue(this);
    _HFP_R5_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_HFP_ManeuverChoiceDisplayRequest
{
    _mHFP_R5_AR2_DAI.HFP_ManeuverChoiceDisplayRequest.phys = getValue(this);
    _HFP_R5_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_HFP_ManeuverCompletion
{
    _mHFP_R5_AR2_DAI.HFP_ManeuverCompletion.phys = getValue(this);
    _HFP_R5_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_HFP_ManeuverMove
{
    _mHFP_R5_AR2_DAI.HFP_ManeuverMove.phys = getValue(this);
    _HFP_R5_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_HFP_MapContentDisplay
{
    _mHFP_R5_AR2_DAI.HFP_MapContentDisplay.phys = getValue(this);
    _HFP_R5_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_HFP_SelectedManeuverType
{
    _mHFP_R5_AR2_DAI.HFP_SelectedManeuverType.phys = getValue(this);
    _HFP_R5_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_HFP_SoundRequest
{
    _mHFP_R5_AR2_DAI.HFP_SoundRequest.phys = getValue(this);
    _HFP_R5_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_HFP_WarningDisplayRequest
{
    _mHFP_R5_AR2_DAI.HFP_WarningDisplayRequest.phys = getValue(this);
    _HFP_R5_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_HFPMalfunction
{
    _mHFP_R5_AR2_DAI.HFPMalfunction.phys = getValue(this);
    _HFP_R5_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_ScanningSide
{
    _mHFP_R5_AR2_DAI.ScanningSide.phys = getValue(this);
    _HFP_R5_AR2_DAI_SpontanFlag = 1;
}


HumanMachineIfc_AR_check_output()
{
    if( !getValue( HMI__STMSG_HumanMachineIfc_AR ) )
    {
    //  message   HumanMachineIfc_AR ID: 489 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _HumanMachineIfc_AR_Cnt--;
        if( _HumanMachineIfc_AR_Cnt < 1 )
        {
            HumanMachineIfc_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _HumanMachineIfc_AR_Cnt = _HumanMachineIfc_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _HumanMachineIfc_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _HumanMachineIfc_AR_SpontanFlag )
        {
            HumanMachineIfc_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _HumanMachineIfc_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

HumanMachineIfc_AR_init()
{   /* Botschaft HumanMachineIfc_AR ID:489 --- Sendeart 5 cyclicX --- 
BA_ "ApplMessage" BO_ 489 0;
BA_ "NmAsrMessage" BO_ 489 0;
BA_ "GenMsgMinAcceptLength" BO_ 489 8;
BA_ "GenMsgILSupport" BO_ 489 1;
BA_ "DiagState" BO_ 489 0;
BA_ "DiagRequest" BO_ 489 0;
BA_ "DiagResponse" BO_ 489 0;
BA_ "GenMsgStartValue" BO_ 489 "0";
BA_ "GenMsgDelayTime" BO_ 489 10;
BA_ "GenMsgNrOfRepetition" BO_ 489 0;
BA_ "GenMsgCycleTime" BO_ 489 100;
BA_ "GenMsgSendType" BO_ 489 5;
    */
    _HumanMachineIfc_AR_Timebase =            c_tDBKomTimer_20ms;
    _HumanMachineIfc_AR_CycleCount =        100 / _HumanMachineIfc_AR_Timebase;
    _HumanMachineIfc_AR_StartDelay =          0 / _HumanMachineIfc_AR_Timebase;
    _HumanMachineIfc_AR_Cnt = _HumanMachineIfc_AR_StartDelay;
    _HumanMachineIfc_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_HumanMachineIfc_AR, _HumanMachineIfc_AR_StartDelay * _HumanMachineIfc_AR_Timebase );

    _mHumanMachineIfc_AR.ClutchCoolDn_WaitTm_Minute_Disp_Rq.phys = getValue( HMI_ClutchCoolDn_WaitTm_Minute_Disp_Rq );
    _mHumanMachineIfc_AR.ClutchCoolDn_WaitTm_Second_Disp_Rq.phys = getValue( HMI_ClutchCoolDn_WaitTm_Second_Disp_Rq );
    _mHumanMachineIfc_AR.ClutchPdlPosn.phys = getValue( HMI_ClutchPdlPosn );
    _mHumanMachineIfc_AR.CPC_H2StopFill_V2.phys = getValue( HMI_CPC_H2StopFill_V2 );
    _mHumanMachineIfc_AR.DPC_DrvProg_EDrive_Avl.phys = getValue( HMI_DPC_DrvProg_EDrive_Avl );
    _mHumanMachineIfc_AR.EngRPMDisp_RedRngStart.phys = getValue( HMI_EngRPMDisp_RedRngStart );
    _mHumanMachineIfc_AR.Gr_MTX_Disp_Rq_ECM_V2.phys = getValue( HMI_Gr_MTX_Disp_Rq_ECM_V2 );
    _mHumanMachineIfc_AR.Gr_Target_Disp_Rq_ECM.phys = getValue( HMI_Gr_Target_Disp_Rq_ECM );
    _mHumanMachineIfc_AR.PNHV_LowPwr_Disp_Rq.phys = getValue( HMI_PNHV_LowPwr_Disp_Rq );
	  _mHumanMachineIfc_AR.PNHV_Max_Avl_ElecPerf_Disp_Rq.phys = getValue( HMI_PNHV_Max_Avl_ElecPerf_Disp_Rq );
    _mHumanMachineIfc_AR.PNHV_Perf_Total_Disp_Rq.phys = getValue( HMI_PNHV_Perf_Total_Disp_Rq );
    _mHumanMachineIfc_AR.TxShiftRcmmnd_Disp_Rq_ECM.phys = getValue( HMI_TxShiftRcmmnd_Disp_Rq_ECM );
    _mHumanMachineIfc_AR.DPC_DrvProg_EDrive_Msg_Disp_Rq.phys = getValue( HMI_DPC_DrvProg_EDrive_Msg_Disp_Rq );
}

HumanMachineIfc_AR_output(void)
{
    output( _mHumanMachineIfc_AR );
}

HumanMachineIfc_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: HumanMachineIfc_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_HumanMachineIfc_AR := %X\n", getValue( HMI__STMSG_HumanMachineIfc_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_HumanMachineIfc_AR := %X\n", getValue( HMI__STMSGT_HumanMachineIfc_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ClutchCoolDn_WaitTm_Minute_Disp_Rq := %X\n", getValue( HMI_ClutchCoolDn_WaitTm_Minute_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ClutchCoolDn_WaitTm_Second_Disp_Rq := %X\n", getValue( HMI_ClutchCoolDn_WaitTm_Second_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ClutchPdlPosn := %X\n", getValue( HMI_ClutchPdlPosn ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CPC_H2StopFill_V2 := %X\n", getValue( HMI_CPC_H2StopFill_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_DrvProg_EDrive_Avl := %X\n", getValue( HMI_DPC_DrvProg_EDrive_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngRPMDisp_RedRngStart := %X\n", getValue( HMI_EngRPMDisp_RedRngStart ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Gr_MTX_Disp_Rq_ECM_V2 := %X\n", getValue( HMI_Gr_MTX_Disp_Rq_ECM_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Gr_Target_Disp_Rq_ECM := %X\n", getValue( HMI_Gr_Target_Disp_Rq_ECM ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_LowPwr_Disp_Rq := %X\n", getValue( HMI_PNHV_LowPwr_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_Max_Avl_ElecPerf_Disp_Rq := %X\n", getValue( HMI_PNHV_Max_Avl_ElecPerf_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_Perf_Total_Disp_Rq := %X\n", getValue( HMI_PNHV_Perf_Total_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TxShiftRcmmnd_Disp_Rq_ECM := %X\n", getValue( HMI_TxShiftRcmmnd_Disp_Rq_ECM ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_DrvProg_EDrive_Msg_Disp_Rq := %X\n", getValue( HMI_DPC_DrvProg_EDrive_Msg_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tHumanMachineIfc_AR
{
    putValue( HMI__STMSG_HumanMachineIfc_AR, 0 );
}

on EnvVar HMI__STMSG_HumanMachineIfc_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_HumanMachineIfc_AR );
        if( tDelay > 0)    
            setTimer( _tHumanMachineIfc_AR, tDelay );
        else
            putValue( HMI__STMSG_HumanMachineIfc_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_HumanMachineIfc_AR
{
    if( getValue( this ) )
        openPanel("HumanMachineIfc_AR");
}

on EnvVar HMI_ClutchCoolDn_WaitTm_Minute_Disp_Rq
{
    _mHumanMachineIfc_AR.ClutchCoolDn_WaitTm_Minute_Disp_Rq.phys = getValue(this);
    _HumanMachineIfc_AR_SpontanFlag = 1;
}

on EnvVar HMI_ClutchCoolDn_WaitTm_Second_Disp_Rq
{
    _mHumanMachineIfc_AR.ClutchCoolDn_WaitTm_Second_Disp_Rq.phys = getValue(this);
    _HumanMachineIfc_AR_SpontanFlag = 1;
}

on EnvVar HMI_ClutchPdlPosn
{
    _mHumanMachineIfc_AR.ClutchPdlPosn.phys = getValue(this);
    _HumanMachineIfc_AR_SpontanFlag = 1;
}

on EnvVar HMI_CPC_H2StopFill_V2
{
    _mHumanMachineIfc_AR.CPC_H2StopFill_V2.phys = getValue(this);
    _HumanMachineIfc_AR_SpontanFlag = 1;
}


on EnvVar HMI_DPC_DrvProg_EDrive_Avl
{
    _mHumanMachineIfc_AR.DPC_DrvProg_EDrive_Avl.phys = getValue(this);
    _HumanMachineIfc_AR_SpontanFlag = 1;
}

on EnvVar HMI_EngRPMDisp_RedRngStart
{
    _mHumanMachineIfc_AR.EngRPMDisp_RedRngStart.phys = getValue(this);
    _HumanMachineIfc_AR_SpontanFlag = 1;
}

on EnvVar HMI_Gr_MTX_Disp_Rq_ECM_V2
{
    _mHumanMachineIfc_AR.Gr_MTX_Disp_Rq_ECM_V2.phys = getValue(this);
    _HumanMachineIfc_AR_SpontanFlag = 1;
}

on EnvVar HMI_Gr_Target_Disp_Rq_ECM
{
    _mHumanMachineIfc_AR.Gr_Target_Disp_Rq_ECM.phys = getValue(this);
    _HumanMachineIfc_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_LowPwr_Disp_Rq
{
    _mHumanMachineIfc_AR.PNHV_LowPwr_Disp_Rq.phys = getValue(this);
    _HumanMachineIfc_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_Max_Avl_ElecPerf_Disp_Rq
{
    _mHumanMachineIfc_AR.PNHV_Max_Avl_ElecPerf_Disp_Rq.phys = getValue(this);
    _HumanMachineIfc_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_Perf_Total_Disp_Rq
{
    _mHumanMachineIfc_AR.PNHV_Perf_Total_Disp_Rq.phys = getValue(this);
    _HumanMachineIfc_AR_SpontanFlag = 1;
}

on EnvVar HMI_TxShiftRcmmnd_Disp_Rq_ECM
{
    _mHumanMachineIfc_AR.TxShiftRcmmnd_Disp_Rq_ECM.phys = getValue(this);
    _HumanMachineIfc_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_DrvProg_EDrive_Msg_Disp_Rq
{
    _mHumanMachineIfc_AR.DPC_DrvProg_EDrive_Msg_Disp_Rq.phys = getValue(this);
    _HumanMachineIfc_AR_SpontanFlag = 1;
}

HumanMachineIfc_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_HumanMachineIfc_Rq_AR ) )
    {
    //  message   HumanMachineIfc_Rq_AR ID: 269 --- Sendeart 0 cyclicX --- 
        _HumanMachineIfc_Rq_AR_Cnt--;
        if( _HumanMachineIfc_Rq_AR_Cnt < 1 )
        {
            HumanMachineIfc_Rq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _HumanMachineIfc_Rq_AR_Cnt = _HumanMachineIfc_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

HumanMachineIfc_Rq_AR_init()
{   /* Botschaft HumanMachineIfc_Rq_AR ID: 269 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 269 0;
BA_ "NmAsrMessage" BO_ 269 0;
BA_ "GenMsgMinAcceptLength" BO_ 269 4;
BA_ "GenMsgILSupport" BO_ 269 1;
BA_ "DiagState" BO_ 269 0;
BA_ "DiagRequest" BO_ 269 0;
BA_ "DiagResponse" BO_ 269 0;
BA_ "GenMsgStartValue" BO_ 269 "0";
BA_ "GenMsgCycleTime" BO_ 269 20;
BA_ "GenMsgSendType" BO_ 269 0;
    */
    _HumanMachineIfc_Rq_AR_Timebase =           c_tDBKomTimer_20ms;
    _HumanMachineIfc_Rq_AR_CycleCount =         20 / _HumanMachineIfc_Rq_AR_Timebase;
    _HumanMachineIfc_Rq_AR_StartDelay =          0 / _HumanMachineIfc_Rq_AR_Timebase;
    _HumanMachineIfc_Rq_AR_Cnt = _HumanMachineIfc_Rq_AR_StartDelay;

    putValue( HMI__STMSGSD_HumanMachineIfc_Rq_AR, _HumanMachineIfc_Rq_AR_StartDelay * _HumanMachineIfc_Rq_AR_Timebase );

    _mHumanMachineIfc_Rq_AR.ECO_Score_CurrVal_Disp_Rq.phys = getValue( HMI_ECO_Score_CurrVal_Disp_Rq );
    _mHumanMachineIfc_Rq_AR.ECO_Score_IneffDrv_Disp_Rq.phys = getValue( HMI_ECO_Score_IneffDrv_Disp_Rq );
    _mHumanMachineIfc_Rq_AR.Displ_OffroadTurn_UI_MissPrerq_Gear_D.phys = getValue( HMI_Displ_OffroadTurn_UI_MissPrerq_Gear_D );
    _mHumanMachineIfc_Rq_AR.Displ_OffroadTurn_UI_MissPrerq_Tow.phys = getValue( HMI_Displ_OffroadTurn_UI_MissPrerq_Tow );
    _mHumanMachineIfc_Rq_AR.EngRPM_Dyn_Disp_Rq.phys = getValue( HMI_EngRPM_Dyn_Disp_Rq );
}

HumanMachineIfc_Rq_AR_output(void)
{
    output( _mHumanMachineIfc_Rq_AR );
}

HumanMachineIfc_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: HumanMachineIfc_Rq_AR\n", 35, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_HumanMachineIfc_Rq := %X\n", getValue( HMI__STMSG_HumanMachineIfc_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_HumanMachineIfc_Rq := %X\n", getValue( HMI__STMSGT_HumanMachineIfc_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ECO_Score_CurrVal_Disp_Rq := %X\n", getValue( HMI_ECO_Score_CurrVal_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ECO_Score_IneffDrv_Disp_Rq := %X\n", getValue( HMI_ECO_Score_IneffDrv_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Displ_OffroadTurn_UI_MissPrerq_Gear_D := %X\n", getValue( HMI_Displ_OffroadTurn_UI_MissPrerq_Gear_D ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Displ_OffroadTurn_UI_MissPrerq_Tow := %X\n", getValue( HMI_Displ_OffroadTurn_UI_MissPrerq_Tow ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngRPM_Dyn_Disp_Rq := %X\n", getValue( HMI_EngRPM_Dyn_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tHumanMachineIfc_Rq_AR
{
    putValue( HMI__STMSG_HumanMachineIfc_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_HumanMachineIfc_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_HumanMachineIfc_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tHumanMachineIfc_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_HumanMachineIfc_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_HumanMachineIfc_Rq_AR
{
    if( getValue( this ) )
        openPanel("HumanMachineIfc_Rq_AR");
}

on EnvVar HMI_ECO_Score_CurrVal_Disp_Rq
{
    _mHumanMachineIfc_Rq_AR.ECO_Score_CurrVal_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_ECO_Score_IneffDrv_Disp_Rq
{
    _mHumanMachineIfc_Rq_AR.ECO_Score_IneffDrv_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_Displ_OffroadTurn_UI_MissPrerq_Gear_D
{
    _mHumanMachineIfc_Rq_AR.Displ_OffroadTurn_UI_MissPrerq_Gear_D.phys = getValue(this);
}

on EnvVar HMI_Displ_OffroadTurn_UI_MissPrerq_Tow
{
    _mHumanMachineIfc_Rq_AR.Displ_OffroadTurn_UI_MissPrerq_Tow.phys = getValue(this);
}

on EnvVar HMI_EngRPM_Dyn_Disp_Rq
{
    _mHumanMachineIfc_Rq_AR.EngRPM_Dyn_Disp_Rq.phys = getValue(this);
}

HumanMachineIfc2_AR_check_output()
{
    if( !getValue( HMI__STMSG_HumanMachineIfc2_AR ) )
    {
    //  message   HumanMachineIfc2_AR ID: 1028 --- Sendeart 0 cyclicX --- 
        _HumanMachineIfc2_AR_Cnt--;
        if( _HumanMachineIfc2_AR_Cnt < 1 )
        {
            HumanMachineIfc2_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _HumanMachineIfc2_AR_Cnt = _HumanMachineIfc2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

HumanMachineIfc2_AR_init()
{   /* Botschaft HumanMachineIfc2_AR ID: 1028 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 1028 0;
BA_ "NmAsrMessage" BO_ 1028 0;
BA_ "GenMsgMinAcceptLength" BO_ 1028 8;
BA_ "GenMsgILSupport" BO_ 1028 1;
BA_ "DiagState" BO_ 1028 0;
BA_ "DiagRequest" BO_ 1028 0;
BA_ "DiagResponse" BO_ 1028 0;
BA_ "GenMsgStartValue" BO_ 1028 "0";
BA_ "GenMsgCycleTime" BO_ 1028 200;
BA_ "GenMsgSendType" BO_ 1028 0;
    */
    _HumanMachineIfc2_AR_Timebase =           c_tDBKomTimer_20ms;
    _HumanMachineIfc2_AR_CycleCount =         200 / _HumanMachineIfc2_AR_Timebase;
    _HumanMachineIfc2_AR_StartDelay =          0 / _HumanMachineIfc2_AR_Timebase;
    _HumanMachineIfc2_AR_Cnt = _HumanMachineIfc2_AR_StartDelay;

    putValue( HMI__STMSGSD_HumanMachineIfc2_AR, _HumanMachineIfc2_AR_StartDelay * _HumanMachineIfc2_AR_Timebase );

    _mHumanMachineIfc2_AR.PdlRcmmnd_Disp_Avl.phys = getValue( HMI_PdlRcmmnd_Disp_Avl );
    _mHumanMachineIfc2_AR.PdlRcmmnd_Disp_Rq.phys = getValue( HMI_PdlRcmmnd_Disp_Rq );
    _mHumanMachineIfc2_AR.PdlRcmmnd_Disp_Rsn_Rq.phys = getValue( HMI_PdlRcmmnd_Disp_Rsn_Rq );
    _mHumanMachineIfc2_AR.PdlRcmmnd_DispPrmnt_Rq.phys = getValue( HMI_PdlRcmmnd_DispPrmnt_Rq );
    _mHumanMachineIfc2_AR.PdlRcmmnd_FirstActvSeg.phys = getValue( HMI_PdlRcmmnd_FirstActvSeg );
    _mHumanMachineIfc2_AR.PdlRcmmnd_LastActvSeg.phys = getValue( HMI_PdlRcmmnd_LastActvSeg );
	_mHumanMachineIfc2_AR.PdlRcmmnd_Seg_Cnt.phys = getValue( HMI_PdlRcmmnd_Seg_Cnt );
    _mHumanMachineIfc2_AR.PdlRcmmnd_Stat.phys = getValue( HMI_PdlRcmmnd_Stat );
    _mHumanMachineIfc2_AR.EM02_RPM_EDR.phys = getValue( HMI_EM02_RPM_EDR );
	_mHumanMachineIfc2_AR.Creep_Md_Avl.phys = getValue( HMI_Creep_Md_Avl );
	_mHumanMachineIfc2_AR.Creep_Md_Stat.phys = getValue( HMI_Creep_Md_Stat );
	_mHumanMachineIfc2_AR.DriveWarnMsg.phys = getValue( HMI_DriveWarnMsg );
	_mHumanMachineIfc2_AR.EOS_Stat.phys = getValue ( HMI_EOS_Stat );
	_mHumanMachineIfc2_AR.PT4_PTCoor_BoostAvlDisp.phys = getValue( HMI_PT4_PTCoor_BoostAvlDisp );
	_mHumanMachineIfc2_AR.PT_Cap.phys = getValue( HMI_PT_Cap );
	_mHumanMachineIfc2_AR.PT4_PTCoor_RedPwr_IndLmp_On_Rq.phys = getValue( HMI_PT4_PTCoor_RedPwr_IndLmp_On_Rq );
	_mHumanMachineIfc2_AR.PT4_PTCoor_BoostMd_Stat.phys = getValue ( HMI_PT4_PTCoor_BoostMd_Stat );
	_mHumanMachineIfc2_AR.PTCoor_RecuLvl_Rs_AMG.phys = getValue ( HMI_PTCoor_RecuLvl_Rs_AMG );
	_mHumanMachineIfc2_AR.PT4_PTCoor_EmoStrtActv.phys = getValue ( HMI_PT4_PTCoor_EmoStrtActv );
}

HumanMachineIfc2_AR_output(void)
{
    output( _mHumanMachineIfc2_AR );
}

HumanMachineIfc2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: HumanMachineIfc2_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_HumanMachineIfc2_AR := %X\n", getValue( HMI__STMSG_HumanMachineIfc2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_HumanMachineIfc2_AR := %X\n", getValue( HMI__STMSGT_HumanMachineIfc2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PdlRcmmnd_Disp_Avl := %X\n", getValue( HMI_PdlRcmmnd_Disp_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PdlRcmmnd_Disp_Rq := %X\n", getValue( HMI_PdlRcmmnd_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PdlRcmmnd_Disp_Rsn_Rq := %X\n", getValue( HMI_PdlRcmmnd_Disp_Rsn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PdlRcmmnd_DispPrmnt_Rq := %X\n", getValue( HMI_PdlRcmmnd_DispPrmnt_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PdlRcmmnd_FirstActvSeg := %X\n", getValue( HMI_PdlRcmmnd_FirstActvSeg ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PdlRcmmnd_LastActvSeg := %X\n", getValue( HMI_PdlRcmmnd_LastActvSeg ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PdlRcmmnd_Seg_Cnt := %X\n", getValue( HMI_PdlRcmmnd_Seg_Cnt ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PdlRcmmnd_Stat := %X\n", getValue( HMI_PdlRcmmnd_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EM02_RPM_EDR := %X\n", getValue( HMI_EM02_RPM_EDR ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_EOS_Stat := %X\n", getValue( HMI_EOS_Stat ) );				   filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_DriveWarnMsg := %X\n", getValue( HMI_DriveWarnMsg ) );		filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Creep_Md_Avl := %X\n", getValue( HMI_Creep_Md_Avl ) );		filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Creep_Md_Stat := %X\n", getValue( HMI_Creep_Md_Stat ) );		filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT4_PTCoor_BoostAvlDisp := %X\n", getValue( HMI_PT4_PTCoor_BoostAvlDisp ) );				   filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT_Cap := %X\n", getValue( HMI_PT_Cap ) );				   filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT4_PTCoor_RedPwr_IndLmp_On_Rq := %X\n", getValue( HMI_PT4_PTCoor_RedPwr_IndLmp_On_Rq ) );				   filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT4_PTCoor_BoostMd_Stat := %X\n", getValue( HMI_PT4_PTCoor_BoostMd_Stat ) );		filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PTCoor_RecuLvl_Rs_AMG := %X\n", getValue( HMI_PTCoor_RecuLvl_Rs_AMG ) );		filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT4_PTCoor_EmoStrtActv := %X\n", getValue( HMI_PT4_PTCoor_EmoStrtActv ) );		filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tHumanMachineIfc2_AR
{
    putValue( HMI__STMSG_HumanMachineIfc2_AR, 0 );
}

on EnvVar HMI__STMSG_HumanMachineIfc2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_HumanMachineIfc2_AR );
        if( tDelay > 0)    
            setTimer( _tHumanMachineIfc2_AR, tDelay );
        else
            putValue( HMI__STMSG_HumanMachineIfc2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_HumanMachineIfc2_AR
{
    if( getValue( this ) )
        openPanel("HumanMachineIfc2_AR");
}

on EnvVar HMI_PdlRcmmnd_Disp_Avl
{
    _mHumanMachineIfc2_AR.PdlRcmmnd_Disp_Avl.phys = getValue(this);
    _HumanMachineIfc2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PdlRcmmnd_Disp_Rq
{
    _mHumanMachineIfc2_AR.PdlRcmmnd_Disp_Rq.phys = getValue(this);
    _HumanMachineIfc2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PdlRcmmnd_Disp_Rsn_Rq
{
    _mHumanMachineIfc2_AR.PdlRcmmnd_Disp_Rsn_Rq.phys = getValue(this);
    _HumanMachineIfc2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PdlRcmmnd_DispPrmnt_Rq
{
    _mHumanMachineIfc2_AR.PdlRcmmnd_DispPrmnt_Rq.phys = getValue(this);
    _HumanMachineIfc2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PdlRcmmnd_FirstActvSeg
{
    _mHumanMachineIfc2_AR.PdlRcmmnd_FirstActvSeg.phys = getValue(this);
    _HumanMachineIfc2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PdlRcmmnd_LastActvSeg
{
    _mHumanMachineIfc2_AR.PdlRcmmnd_LastActvSeg.phys = getValue(this);
    _HumanMachineIfc2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PdlRcmmnd_Seg_Cnt
{
    _mHumanMachineIfc2_AR.PdlRcmmnd_Seg_Cnt.phys = getValue(this);
    _HumanMachineIfc2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PdlRcmmnd_Stat
{
    _mHumanMachineIfc2_AR.PdlRcmmnd_Stat.phys = getValue(this);
    _HumanMachineIfc2_AR_SpontanFlag = 1;
}

on EnvVar HMI_EM02_RPM_EDR
{
        _mHumanMachineIfc2_AR.EM02_RPM_EDR.phys = getValue(this);
	 _HumanMachineIfc2_AR_SpontanFlag = 1;
}


on EnvVar HMI_DriveWarnMsg
{
	_mHumanMachineIfc2_AR.DriveWarnMsg.phys = getValue(this);
	_HumanMachineIfc2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Creep_Md_Avl
{
	_mHumanMachineIfc2_AR.Creep_Md_Avl.phys = getValue(this);
	_HumanMachineIfc2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Creep_Md_Stat
{
	_mHumanMachineIfc2_AR.Creep_Md_Stat.phys = getValue(this);
	_HumanMachineIfc2_AR_SpontanFlag = 1;
}

on EnvVar HMI_EOS_Stat
{
	_mHumanMachineIfc2_AR.EOS_Stat.phys = getValue(this);
	_HumanMachineIfc2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PT4_PTCoor_BoostAvlDisp
{
	_mHumanMachineIfc2_AR.PT4_PTCoor_BoostAvlDisp.phys = getValue(this);
	_HumanMachineIfc2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PT_Cap
{
	_mHumanMachineIfc2_AR.PT_Cap.phys = getValue(this);
	_HumanMachineIfc2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PT4_PTCoor_RedPwr_IndLmp_On_Rq
{
	_mHumanMachineIfc2_AR.PT4_PTCoor_RedPwr_IndLmp_On_Rq.phys = getValue(this);
	_HumanMachineIfc2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PT4_PTCoor_BoostMd_Stat
{
	_mHumanMachineIfc2_AR.PT4_PTCoor_BoostMd_Stat.phys = getValue(this);
	_HumanMachineIfc2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PTCoor_RecuLvl_Rs_AMG
{
	_mHumanMachineIfc2_AR.PTCoor_RecuLvl_Rs_AMG.phys = getValue(this);
	_HumanMachineIfc2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PT4_PTCoor_EmoStrtActv
{
	_mHumanMachineIfc2_AR.PT4_PTCoor_EmoStrtActv.phys = getValue(this);
	_HumanMachineIfc2_AR_SpontanFlag = 1;
}

HVAC_Disp_Stat1_AR_check_output()
{
    if( !getValue( HMI__STMSG_HVAC_Disp_Stat1_AR ) )
    {
    //  message   HVAC_Disp_Stat1_AR ID: 851 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _HVAC_Disp_Stat1_AR_Cnt--;
        if( _HVAC_Disp_Stat1_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            HVAC_Disp_Stat1_AR_output();
            _HVAC_Disp_Stat1_AR_Cnt = _HVAC_Disp_Stat1_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _HVAC_Disp_Stat1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _HVAC_Disp_Stat1_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            HVAC_Disp_Stat1_AR_output();
            _HVAC_Disp_Stat1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

HVAC_Disp_Stat1_AR_init()
{   /* Botschaft HVAC_Disp_Stat1_AR ID: 851 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 851 0;
BA_ "NmAsrMessage" BO_ 851 0;
BA_ "GenMsgMinAcceptLength" BO_ 851 8;
BA_ "GenMsgILSupport" BO_ 851 1;
BA_ "DiagState" BO_ 851 0;
BA_ "DiagRequest" BO_ 851 0;
BA_ "DiagResponse" BO_ 851 0;
BA_ "GenMsgStartValue" BO_ 851 "0";
BA_ "GenMsgDelayTime" BO_ 851 20;
BA_ "GenMsgNrOfRepetitions" BO_ 851 0;
BA_ "GenMsgCycleTime" BO_ 851 1000;
BA_ "GenMsgSendType" BO_ 851 5;
    */
    _HVAC_Disp_Stat1_AR_Timebase =           c_tDBKomTimer_20ms;
    _HVAC_Disp_Stat1_AR_CycleCount =       1000 / _HVAC_Disp_Stat1_AR_Timebase;
    _HVAC_Disp_Stat1_AR_StartDelay =          0 / _HVAC_Disp_Stat1_AR_Timebase;
    _HVAC_Disp_Stat1_AR_Cnt = _HVAC_Disp_Stat1_AR_StartDelay;
    _HVAC_Disp_Stat1_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_HVAC_Disp_Stat1_AR, _HVAC_Disp_Stat1_AR_StartDelay * _HVAC_Disp_Stat1_AR_Timebase );

    _mHVAC_Disp_Stat1_AR.HVAC_AC_Z1Z2_Actv.phys = getValue( HMI_HVAC_AC_Z1Z2_Actv );
    _mHVAC_Disp_Stat1_AR.HVAC_AirDist_Zone1_Stat.phys = getValue( HMI_HVAC_AirDist_Zone1_Stat );
    _mHVAC_Disp_Stat1_AR.HVAC_AirDist_Zone2_Stat.phys = getValue( HMI_HVAC_AirDist_Zone2_Stat );
    _mHVAC_Disp_Stat1_AR.HVAC_Airflow_Zone1_Stat.phys = getValue( HMI_HVAC_Airflow_Zone1_Stat );
    _mHVAC_Disp_Stat1_AR.HVAC_Airflow_Zone2_Stat.phys = getValue( HMI_HVAC_Airflow_Zone2_Stat );
    _mHVAC_Disp_Stat1_AR.HVAC_Auto_Zone1_Stat .phys = getValue( HMI_HVAC_Auto_Zone1_Stat  );
    _mHVAC_Disp_Stat1_AR.HVAC_Auto_Zone2_Stat .phys = getValue( HMI_HVAC_Auto_Zone2_Stat  );
    _mHVAC_Disp_Stat1_AR.HVAC_CO2_Sens_Flt.phys = getValue( HMI_HVAC_CO2_Sens_Flt );
    _mHVAC_Disp_Stat1_AR.HVAC_CO2_Warn_Rq.phys = getValue( HMI_HVAC_CO2_Warn_Rq );
    _mHVAC_Disp_Stat1_AR.HVAC_Dfrst_Z1Z2_Actv .phys = getValue( HMI_HVAC_Dfrst_Z1Z2_Actv  );
    _mHVAC_Disp_Stat1_AR.HVAC_eHeV_Disp_Rq.phys = getValue( HMI_HVAC_eHeV_Disp_Rq );
    _mHVAC_Disp_Stat1_AR.HVAC_eHeV_Stat.phys = getValue( HMI_HVAC_eHeV_Stat );
    _mHVAC_Disp_Stat1_AR.HVAC_Fan_Zone1_Stat.phys = getValue( HMI_HVAC_Fan_Zone1_Stat );
    _mHVAC_Disp_Stat1_AR.HVAC_Fan_Zone2_Stat.phys = getValue( HMI_HVAC_Fan_Zone2_Stat );
    _mHVAC_Disp_Stat1_AR.HVAC_FtwInc_Zone1_Stat.phys = getValue( HMI_HVAC_FtwInc_Zone1_Stat );
    _mHVAC_Disp_Stat1_AR.HVAC_FtwInc_Zone2_Stat.phys = getValue( HMI_HVAC_FtwInc_Zone2_Stat );
    _mHVAC_Disp_Stat1_AR.HVAC_ICH1_2_LED_On_Rq.phys = getValue( HMI_HVAC_ICH1_2_LED_On_Rq );
    _mHVAC_Disp_Stat1_AR.HVAC_Off_Z1Z2_Actv.phys = getValue( HMI_HVAC_Off_Z1Z2_Actv );
    _mHVAC_Disp_Stat1_AR.HVAC_Recirc_Stat.phys = getValue( HMI_HVAC_Recirc_Stat );
    _mHVAC_Disp_Stat1_AR.HVAC_RHU_Z1Z2_Actv.phys = getValue( HMI_HVAC_RHU_Z1Z2_Actv );
    _mHVAC_Disp_Stat1_AR.HVAC_Temp_Zone1_Stat.phys = getValue( HMI_HVAC_Temp_Zone1_Stat );
    _mHVAC_Disp_Stat1_AR.HVAC_Temp_Zone2_Stat.phys = getValue( HMI_HVAC_Temp_Zone2_Stat );
    _mHVAC_Disp_Stat1_AR.HVAC_Recirc_Max_Stat.phys = getValue( HMI_HVAC_Recirc_Max_Stat );
}

HVAC_Disp_Stat1_AR_output(void)
{
    output( _mHVAC_Disp_Stat1_AR );
}

HVAC_Disp_Stat1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: HVAC_Disp_Stat1_AR\n", 32, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_HVAC_Disp_Stat1_AR := %X\n", getValue( HMI__STMSG_HVAC_Disp_Stat1_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_HVAC_Disp_Stat1_AR := %X\n", getValue( HMI__STMSGT_HVAC_Disp_Stat1_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_AC_Z1Z2_Actv := %X\n", getValue( HMI_HVAC_AC_Z1Z2_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_AirDist_Zone1_Stat := %X\n", getValue( HMI_HVAC_AirDist_Zone1_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_AirDist_Zone2_Stat := %X\n", getValue( HMI_HVAC_AirDist_Zone2_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Airflow_Zone1_Stat := %X\n", getValue( HMI_HVAC_Airflow_Zone1_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Airflow_Zone2_Stat := %X\n", getValue( HMI_HVAC_Airflow_Zone2_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Auto_Zone1_Stat  := %X\n", getValue( HMI_HVAC_Auto_Zone1_Stat  ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Auto_Zone2_Stat  := %X\n", getValue( HMI_HVAC_Auto_Zone2_Stat  ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_CO2_Sens_Flt  := %X\n", getValue( HMI_HVAC_CO2_Sens_Flt  ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_CO2_Warn_Rq  := %X\n", getValue( HMI_HVAC_CO2_Warn_Rq  ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Dfrst_Z1Z2_Actv  := %X\n", getValue( HMI_HVAC_Dfrst_Z1Z2_Actv  ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_eHeV_Disp_Rq := %X\n", getValue( HMI_HVAC_eHeV_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_eHeV_Stat := %X\n", getValue( HMI_HVAC_eHeV_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Fan_Zone1_Stat := %X\n", getValue( HMI_HVAC_Fan_Zone1_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Fan_Zone2_Stat := %X\n", getValue( HMI_HVAC_Fan_Zone2_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_FtwInc_Zone1_Stat := %X\n", getValue( HMI_HVAC_FtwInc_Zone1_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_FtwInc_Zone2_Stat := %X\n", getValue( HMI_HVAC_FtwInc_Zone2_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_ICH1_2_LED_On_Rq := %X\n", getValue( HMI_HVAC_ICH1_2_LED_On_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Off_Z1Z2_Actv := %X\n", getValue( HMI_HVAC_Off_Z1Z2_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Recirc_Stat := %X\n", getValue( HMI_HVAC_Recirc_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_RHU_Z1Z2_Actv := %X\n", getValue( HMI_HVAC_RHU_Z1Z2_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Temp_Zone1_Stat := %X\n", getValue( HMI_HVAC_Temp_Zone1_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Temp_Zone2_Stat := %X\n", getValue( HMI_HVAC_Temp_Zone2_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Recirc_Max_Stat := %X\n", getValue( HMI_HVAC_Recirc_Max_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tHVAC_Disp_Stat1_AR
{
    putValue( HMI__STMSG_HVAC_Disp_Stat1_AR, 0 );
}

on EnvVar HMI__STMSG_HVAC_Disp_Stat1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_HVAC_Disp_Stat1_AR );
        if( tDelay > 0)    
            setTimer( _tHVAC_Disp_Stat1_AR, tDelay );
        else
            putValue( HMI__STMSG_HVAC_Disp_Stat1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_HVAC_Disp_Stat1_AR
{
    if( getValue( this ) )
        openPanel("HVAC_Disp_Stat1_AR");
}

on EnvVar HMI_HVAC_AC_Z1Z2_Actv
{
    _mHVAC_Disp_Stat1_AR.HVAC_AC_Z1Z2_Actv.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_AirDist_Zone1_Stat
{
    _mHVAC_Disp_Stat1_AR.HVAC_AirDist_Zone1_Stat.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_AirDist_Zone2_Stat
{
    _mHVAC_Disp_Stat1_AR.HVAC_AirDist_Zone2_Stat.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Airflow_Zone1_Stat
{
    _mHVAC_Disp_Stat1_AR.HVAC_Airflow_Zone1_Stat.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Airflow_Zone2_Stat
{
    _mHVAC_Disp_Stat1_AR.HVAC_Airflow_Zone2_Stat.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Auto_Zone1_Stat
{
    _mHVAC_Disp_Stat1_AR.HVAC_Auto_Zone1_Stat.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Auto_Zone2_Stat
{
    _mHVAC_Disp_Stat1_AR.HVAC_Auto_Zone2_Stat.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_CO2_Sens_Flt
{
    _mHVAC_Disp_Stat1_AR.HVAC_CO2_Sens_Flt.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_CO2_Warn_Rq
{
    _mHVAC_Disp_Stat1_AR.HVAC_CO2_Warn_Rq.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Dfrst_Z1Z2_Actv
{
    _mHVAC_Disp_Stat1_AR.HVAC_Dfrst_Z1Z2_Actv.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_eHeV_Disp_Rq
{
    _mHVAC_Disp_Stat1_AR.HVAC_eHeV_Disp_Rq.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_eHeV_Stat
{
    _mHVAC_Disp_Stat1_AR.HVAC_eHeV_Stat.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Fan_Zone1_Stat
{
    _mHVAC_Disp_Stat1_AR.HVAC_Fan_Zone1_Stat.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Fan_Zone2_Stat
{
    _mHVAC_Disp_Stat1_AR.HVAC_Fan_Zone2_Stat.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_FtwInc_Zone1_Stat
{
    _mHVAC_Disp_Stat1_AR.HVAC_FtwInc_Zone1_Stat.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_FtwInc_Zone2_Stat
{
    _mHVAC_Disp_Stat1_AR.HVAC_FtwInc_Zone2_Stat.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_ICH1_2_LED_On_Rq
{
    _mHVAC_Disp_Stat1_AR.HVAC_ICH1_2_LED_On_Rq.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Off_Z1Z2_Actv
{
    _mHVAC_Disp_Stat1_AR.HVAC_Off_Z1Z2_Actv.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Recirc_Stat
{
    _mHVAC_Disp_Stat1_AR.HVAC_Recirc_Stat.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_RHU_Z1Z2_Actv
{
    _mHVAC_Disp_Stat1_AR.HVAC_RHU_Z1Z2_Actv.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Temp_Zone1_Stat
{
    _mHVAC_Disp_Stat1_AR.HVAC_Temp_Zone1_Stat.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Temp_Zone2_Stat
{
    _mHVAC_Disp_Stat1_AR.HVAC_Temp_Zone2_Stat.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Recirc_Max_Stat
{
    _mHVAC_Disp_Stat1_AR.HVAC_Recirc_Max_Stat.phys = getValue(this);
    _HVAC_Disp_Stat1_AR_SpontanFlag = 1;
}

HVAC_Disp_Stat2_AR_check_output()
{
    if( !getValue( HMI__STMSG_HVAC_Disp_Stat2_AR ) )
    {
    //  message   HVAC_Disp_Stat2_AR ID: 853 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _HVAC_Disp_Stat2_AR_Cnt--;
        if( _HVAC_Disp_Stat2_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            HVAC_Disp_Stat2_AR_output();
            _HVAC_Disp_Stat2_AR_Cnt = _HVAC_Disp_Stat2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _HVAC_Disp_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _HVAC_Disp_Stat2_AR_SpontanFlag )
        {
            // Nachricht wg. spontaner �nderung ausgeben
            HVAC_Disp_Stat2_AR_output();
            _HVAC_Disp_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

HVAC_Disp_Stat2_AR_init()
{   /* Botschaft HVAC_Disp_Stat2_AR ID: 853 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 853 0;
BA_ "NmAsrMessage" BO_ 853 0;
BA_ "GenMsgMinAcceptLength" BO_ 853 8;
BA_ "GenMsgILSupport" BO_ 853 1;
BA_ "DiagState" BO_ 853 0;
BA_ "DiagRequest" BO_ 853 0;
BA_ "DiagResponse" BO_ 853 0;
BA_ "GenMsgStartValue" BO_ 853 "0";
BA_ "GenMsgDelayTime" BO_ 853 5;
BA_ "GenMsgNrOfRepetitions" BO_ 853 0;
BA_ "GenMsgCycleTime" BO_ 853 1000;
BA_ "GenMsgSendType" BO_ 853 5;
    */
    _HVAC_Disp_Stat2_AR_Timebase =           c_tDBKomTimer_20ms;
    _HVAC_Disp_Stat2_AR_CycleCount =      1000 / _HVAC_Disp_Stat2_AR_Timebase;
    _HVAC_Disp_Stat2_AR_StartDelay =         0 / _HVAC_Disp_Stat2_AR_Timebase;
    _HVAC_Disp_Stat2_AR_Cnt = _HVAC_Disp_Stat2_AR_StartDelay;
    _HVAC_Disp_Stat2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_HVAC_Disp_Stat2_AR, _HVAC_Disp_Stat2_AR_StartDelay * _HVAC_Disp_Stat2_AR_Timebase );

    _mHVAC_Disp_Stat2_AR.HVAC_AC_Z3Z4_Actv.phys = getValue( HMI_HVAC_AC_Z3Z4_Actv );
    _mHVAC_Disp_Stat2_AR.HVAC_AirDist_Zone3_Stat.phys = getValue( HMI_HVAC_AirDist_Zone3_Stat );
    _mHVAC_Disp_Stat2_AR.HVAC_AirDist_Zone4_Stat.phys = getValue( HMI_HVAC_AirDist_Zone4_Stat );
    _mHVAC_Disp_Stat2_AR.HVAC_Airflow_Zone3_Stat.phys = getValue( HMI_HVAC_Airflow_Zone3_Stat );
    _mHVAC_Disp_Stat2_AR.HVAC_Airflow_Zone4_Stat.phys = getValue( HMI_HVAC_Airflow_Zone4_Stat );
    _mHVAC_Disp_Stat2_AR.HVAC_Auto_Zone3_Stat.phys = getValue( HMI_HVAC_Auto_Zone3_Stat );
    _mHVAC_Disp_Stat2_AR.HVAC_Auto_Zone4_Stat.phys = getValue( HMI_HVAC_Auto_Zone4_Stat );
    _mHVAC_Disp_Stat2_AR.HVAC_Fan_Zone3_Stat.phys = getValue( HMI_HVAC_Fan_Zone3_Stat );
    _mHVAC_Disp_Stat2_AR.HVAC_Fan_Zone4_Stat.phys = getValue( HMI_HVAC_Fan_Zone4_Stat );
    _mHVAC_Disp_Stat2_AR.HVAC_Off_Z3Z4_Actv.phys = getValue( HMI_HVAC_Off_Z3Z4_Actv );
    _mHVAC_Disp_Stat2_AR.HVAC_RHU_Z3Z4_Actv.phys = getValue( HMI_HVAC_RHU_Z3Z4_Actv );
    _mHVAC_Disp_Stat2_AR.HVAC_Temp_Zone3_Stat.phys = getValue( HMI_HVAC_Temp_Zone3_Stat );
    _mHVAC_Disp_Stat2_AR.HVAC_Temp_Zone4_Stat.phys = getValue( HMI_HVAC_Temp_Zone4_Stat );
}

HVAC_Disp_Stat2_AR_output(void)
{
    output( _mHVAC_Disp_Stat2_AR );
}

HVAC_Disp_Stat2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: HVAC_Disp_Stat2_AR \n", 32, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_HVAC_Disp_Stat2_AR := %X\n", getValue( HMI__STMSG_HVAC_Disp_Stat2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_HVAC_Disp_Stat2_AR := %X\n", getValue( HMI__STMSGT_HVAC_Disp_Stat2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_AC_Z3Z4_Actv := %X\n", getValue( HMI_HVAC_AC_Z3Z4_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_AirDist_Zone3_Stat := %X\n", getValue( HMI_HVAC_AirDist_Zone3_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_AirDist_Zone4_Stat := %X\n", getValue( HMI_HVAC_AirDist_Zone4_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Airflow_Zone3_Stat := %X\n", getValue( HMI_HVAC_Airflow_Zone3_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Airflow_Zone4_Stat := %X\n", getValue( HMI_HVAC_Airflow_Zone4_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Auto_Zone3_Stat := %X\n", getValue( HMI_HVAC_Auto_Zone3_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Auto_Zone4_Stat := %X\n", getValue( HMI_HVAC_Auto_Zone4_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Fan_Zone3_Stat := %X\n", getValue( HMI_HVAC_Fan_Zone3_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Fan_Zone4_Stat := %X\n", getValue( HMI_HVAC_Fan_Zone4_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Off_Z3Z4_Actv := %X\n", getValue( HMI_HVAC_Off_Z3Z4_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_RHU_Z3Z4_Actv := %X\n", getValue( HMI_HVAC_RHU_Z3Z4_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Temp_Zone3_Stat := %X\n", getValue( HMI_HVAC_Temp_Zone3_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Temp_Zone4_Stat := %X\n", getValue( HMI_HVAC_Temp_Zone4_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );

}

on timer _tHVAC_Disp_Stat2_AR
{
    putValue( HMI__STMSG_HVAC_Disp_Stat2_AR, 0 );
}

on EnvVar HMI__STMSG_HVAC_Disp_Stat2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_HVAC_Disp_Stat2_AR );
        if( tDelay > 0)    
            setTimer( _tHVAC_Disp_Stat2_AR, tDelay );
        else
            putValue( HMI__STMSG_HVAC_Disp_Stat2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_HVAC_Disp_Stat2_AR
{
    if( getValue( this ) )
        openPanel("HVAC_Disp_Stat2_AR");
}

on EnvVar HMI_HVAC_AC_Z3Z4_Actv
{
    _mHVAC_Disp_Stat2_AR.HVAC_AC_Z3Z4_Actv.phys = getValue(this);
    _HVAC_Disp_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_AirDist_Zone3_Stat
{
    _mHVAC_Disp_Stat2_AR.HVAC_AirDist_Zone3_Stat.phys = getValue(this);
    _HVAC_Disp_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_AirDist_Zone4_Stat
{
    _mHVAC_Disp_Stat2_AR.HVAC_AirDist_Zone4_Stat.phys = getValue(this);
    _HVAC_Disp_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Airflow_Zone3_Stat
{
    _mHVAC_Disp_Stat2_AR.HVAC_Airflow_Zone3_Stat.phys = getValue(this);
    _HVAC_Disp_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Airflow_Zone4_Stat
{
    _mHVAC_Disp_Stat2_AR.HVAC_Airflow_Zone4_Stat.phys = getValue(this);
    _HVAC_Disp_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Auto_Zone3_Stat
{
    _mHVAC_Disp_Stat2_AR.HVAC_Auto_Zone3_Stat.phys = getValue(this);
    _HVAC_Disp_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Auto_Zone4_Stat
{
    _mHVAC_Disp_Stat2_AR.HVAC_Auto_Zone4_Stat.phys = getValue(this);
    _HVAC_Disp_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Fan_Zone3_Stat
{
    _mHVAC_Disp_Stat2_AR.HVAC_Fan_Zone3_Stat.phys = getValue(this);
    _HVAC_Disp_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Fan_Zone4_Stat
{
    _mHVAC_Disp_Stat2_AR.HVAC_Fan_Zone4_Stat.phys = getValue(this);
    _HVAC_Disp_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Off_Z3Z4_Actv
{
    _mHVAC_Disp_Stat2_AR.HVAC_Off_Z3Z4_Actv.phys = getValue(this);
    _HVAC_Disp_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_RHU_Z3Z4_Actv
{
    _mHVAC_Disp_Stat2_AR.HVAC_RHU_Z3Z4_Actv.phys = getValue(this);
    _HVAC_Disp_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Temp_Zone3_Stat
{
    _mHVAC_Disp_Stat2_AR.HVAC_Temp_Zone3_Stat.phys = getValue(this);
    _HVAC_Disp_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Temp_Zone4_Stat
{
    _mHVAC_Disp_Stat2_AR.HVAC_Temp_Zone4_Stat.phys = getValue(this);
    _HVAC_Disp_Stat2_AR_SpontanFlag = 1;
}

HVAC_Disp_Stat3_AR_check_output()
{
    if( !getValue( HMI__STMSG_HVAC_Disp_Stat3_AR ) )
    {
    //  message   HVAC_Disp_Stat3_AR ID: 855 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _HVAC_Disp_Stat3_AR_DelayCnt > 0) _HVAC_Disp_Stat3_AR_DelayCnt--; // Mindestsendeabstand
        _HVAC_Disp_Stat3_AR_Cnt--;
        if( _HVAC_Disp_Stat3_AR_Cnt < 1 )
        {
            if( _HVAC_Disp_Stat3_AR_DelayCnt < 1 )
            {
                HVAC_Disp_Stat3_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                _HVAC_Disp_Stat3_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _HVAC_Disp_Stat3_AR_DelayCnt = _HVAC_Disp_Stat3_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
            }
            _HVAC_Disp_Stat3_AR_Cnt = _HVAC_Disp_Stat3_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _HVAC_Disp_Stat3_AR_SpontanFlag )
        {
            if( _HVAC_Disp_Stat3_AR_DelayCnt < 1 )
            {
                HVAC_Disp_Stat3_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _HVAC_Disp_Stat3_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _HVAC_Disp_Stat3_AR_DelayCnt = _HVAC_Disp_Stat3_AR_MinDelay;
            }
        }
    }
}

HVAC_Disp_Stat3_AR_init()
{   /* Botschaft HVAC_Disp_Stat3_AR ID: 855 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 855 0;
BA_ "NmAsrMessage" BO_ 855 0;
BA_ "GenMsgMinAcceptLength" BO_ 855 8;
BA_ "GenMsgILSupport" BO_ 855 1;
BA_ "DiagState" BO_ 855 0;
BA_ "DiagRequest" BO_ 855 0;
BA_ "DiagResponse" BO_ 855 0;
BA_ "GenMsgStartValue" BO_ 855 "0";
BA_ "GenMsgDelayTime" BO_ 855 200;
BA_ "GenMsgNrOfRepetitions" BO_ 855 0;
BA_ "GenMsgCycleTime" BO_ 855 1000;
BA_ "GenMsgSendType" BO_ 855 5;
    */
    _HVAC_Disp_Stat3_AR_Timebase =           c_tDBKomTimer_20ms;
    _HVAC_Disp_Stat3_AR_CycleCount =       1000 / _HVAC_Disp_Stat3_AR_Timebase;
    _HVAC_Disp_Stat3_AR_StartDelay =          0 / _HVAC_Disp_Stat3_AR_Timebase;
    _HVAC_Disp_Stat3_AR_MinDelay =          200 / _HVAC_Disp_Stat3_AR_Timebase;
    _HVAC_Disp_Stat3_AR_Cnt = _HVAC_Disp_Stat3_AR_StartDelay;
    _HVAC_Disp_Stat3_AR_SpontanFlag = 0;
    _HVAC_Disp_Stat3_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_HVAC_Disp_Stat3_AR, _HVAC_Disp_Stat3_AR_StartDelay * _HVAC_Disp_Stat3_AR_Timebase );

    _mHVAC_Disp_Stat3_AR.AirTemp_Insd_Disp.phys = getValue( HMI_AirTemp_Insd_Disp );
    _mHVAC_Disp_Stat3_AR.HVAC_ActvComf_TempCtrl_Stat.phys = getValue( HMI_HVAC_ActvComf_TempCtrl_Stat );
    _mHVAC_Disp_Stat3_AR.HVAC_AirDist_FL_Psd_HVAC_F.phys = getValue( HMI_HVAC_AirDist_FL_Psd_HVAC_F );
    _mHVAC_Disp_Stat3_AR.HVAC_AirDist_FR_Psd_HVAC_F.phys = getValue( HMI_HVAC_AirDist_FR_Psd_HVAC_F );
    _mHVAC_Disp_Stat3_AR.HVAC_AirDist_RL_Psd_HVAC_R.phys = getValue( HMI_HVAC_AirDist_RL_Psd_HVAC_R );
    _mHVAC_Disp_Stat3_AR.HVAC_AirDist_RR_Psd_HVAC_R.phys = getValue( HMI_HVAC_AirDist_RR_Psd_HVAC_R );
    _mHVAC_Disp_Stat3_AR.HVAC_Fan_FL_Psd_HVAC_F.phys = getValue( HMI_HVAC_Fan_FL_Psd_HVAC_F );
    _mHVAC_Disp_Stat3_AR.HVAC_Fan_FR_Psd_HVAC_F.phys = getValue( HMI_HVAC_Fan_FR_Psd_HVAC_F );
    _mHVAC_Disp_Stat3_AR.HVAC_Fan_RL_Psd_HVAC_R.phys = getValue( HMI_HVAC_Fan_RL_Psd_HVAC_R );
    _mHVAC_Disp_Stat3_AR.HVAC_Fan_RR_Psd_HVAC_R.phys = getValue( HMI_HVAC_Fan_RR_Psd_HVAC_R );
	_mHVAC_Disp_Stat3_AR.HVAC_Fltr_Particle_Load.phys = getValue( HMI_HVAC_Fltr_Particle_Load );
    _mHVAC_Disp_Stat3_AR.HVAC_FondKey_Psd.phys = getValue( HMI_HVAC_FondKey_Psd );
    _mHVAC_Disp_Stat3_AR.HVAC_Ionzr_Actv.phys = getValue( HMI_HVAC_Ionzr_Actv );
    _mHVAC_Disp_Stat3_AR.HVAC_Ionzr_Md.phys = getValue( HMI_HVAC_Ionzr_Md );
    _mHVAC_Disp_Stat3_AR.HVAC_MenuKey_Psd.phys = getValue( HMI_HVAC_MenuKey_Psd );
    _mHVAC_Disp_Stat3_AR.HVAC_Mono_Actv.phys = getValue( HMI_HVAC_Mono_Actv );
    _mHVAC_Disp_Stat3_AR.HVAC_Pulsation_ActvComf_Stat.phys = getValue( HMI_HVAC_Pulsation_ActvComf_Stat );
    _mHVAC_Disp_Stat3_AR.HVAC_SGEN_Actv.phys = getValue( HMI_HVAC_SGEN_Actv );
    _mHVAC_Disp_Stat3_AR.HVAC_SGEN_Insty.phys = getValue( HMI_HVAC_SGEN_Insty );
//    _mHVAC_Disp_Stat3_AR.HVAC_SGEN_Lk_Stat.phys = getValue( HMI_HVAC_SGEN_Lk_Stat );
    _mHVAC_Disp_Stat3_AR.HVAC_Temp_FL_Psd_HVAC_F.phys = getValue( HMI_HVAC_Temp_FL_Psd_HVAC_F );
    _mHVAC_Disp_Stat3_AR.HVAC_Temp_FR_Psd_HVAC_F.phys = getValue( HMI_HVAC_Temp_FR_Psd_HVAC_F );
    _mHVAC_Disp_Stat3_AR.HVAC_Temp_RL_Psd_HVAC_R.phys = getValue( HMI_HVAC_Temp_RL_Psd_HVAC_R );
    _mHVAC_Disp_Stat3_AR.HVAC_Temp_RR_Psd_HVAC_R.phys = getValue( HMI_HVAC_Temp_RR_Psd_HVAC_R );
    _mHVAC_Disp_Stat3_AR.SGEN_Flacon_Flt.phys = getValue( HMI_SGEN_Flacon_Flt );
}

HVAC_Disp_Stat3_AR_output(void)
{
    output( _mHVAC_Disp_Stat3_AR );
}

HVAC_Disp_Stat3_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: HVAC_Disp_Stat3_AR\n", 32, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_HVAC_Disp_Stat3_AR := %X\n", getValue( HMI__STMSG_HVAC_Disp_Stat3_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_HVAC_Disp_Stat3_AR := %X\n", getValue( HMI__STMSGT_HVAC_Disp_Stat3_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AirTemp_Insd_Disp := %X\n", getValue( HMI_AirTemp_Insd_Disp ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_ActvComf_TempCtrl_Stat := %X\n", getValue( HMI_HVAC_ActvComf_TempCtrl_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_AirDist_FL_Psd_HVAC_F := %X\n", getValue( HMI_HVAC_AirDist_FL_Psd_HVAC_F ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_AirDist_FR_Psd_HVAC_F := %X\n", getValue( HMI_HVAC_AirDist_FR_Psd_HVAC_F ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_AirDist_RL_Psd_HVAC_R := %X\n", getValue( HMI_HVAC_AirDist_RL_Psd_HVAC_R ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_AirDist_RR_Psd_HVAC_R := %X\n", getValue( HMI_HVAC_AirDist_RR_Psd_HVAC_R ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Fan_FL_Psd_HVAC_F := %X\n", getValue( HMI_HVAC_Fan_FL_Psd_HVAC_F ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Fan_FR_Psd_HVAC_F := %X\n", getValue( HMI_HVAC_Fan_FR_Psd_HVAC_F ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Fan_RL_Psd_HVAC_R := %X\n", getValue( HMI_HVAC_Fan_RL_Psd_HVAC_R ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Fan_RR_Psd_HVAC_R := %X\n", getValue( HMI_HVAC_Fan_RR_Psd_HVAC_R ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Fltr_Particle_Load := %X\n", getValue( HMI_HVAC_Fltr_Particle_Load ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_FondKey_Psd := %X\n", getValue( HMI_HVAC_FondKey_Psd ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Ionzr_Actv := %X\n", getValue( HMI_HVAC_Ionzr_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Ionzr_Md := %X\n", getValue( HMI_HVAC_Ionzr_Md ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_MenuKey_Psd := %X\n", getValue( HMI_HVAC_MenuKey_Psd ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Mono_Actv := %X\n", getValue( HMI_HVAC_Mono_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Pulsation_ActvComf_Stat := %X\n", getValue( HMI_HVAC_Pulsation_ActvComf_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_SGEN_Actv := %X\n", getValue( HMI_HVAC_SGEN_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_SGEN_Insty := %X\n", getValue( HMI_HVAC_SGEN_Insty ) );    filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_SGEN_Lk_Stat := %X\n", getValue( HMI_HVAC_SGEN_Lk_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Temp_FL_Psd_HVAC_F := %X\n", getValue( HMI_HVAC_Temp_FL_Psd_HVAC_F ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Temp_FR_Psd_HVAC_F := %X\n", getValue( HMI_HVAC_Temp_FR_Psd_HVAC_F ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Temp_RL_Psd_HVAC_R := %X\n", getValue( HMI_HVAC_Temp_RL_Psd_HVAC_R ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Temp_RR_Psd_HVAC_R := %X\n", getValue( HMI_HVAC_Temp_RR_Psd_HVAC_R ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SGEN_Flacon_Flt := %X\n", getValue( HMI_SGEN_Flacon_Flt ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tHVAC_Disp_Stat3_AR
{
    putValue( HMI__STMSG_HVAC_Disp_Stat3_AR, 0 );
}

on EnvVar HMI__STMSG_HVAC_Disp_Stat3_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_HVAC_Disp_Stat3_AR );
        if( tDelay > 0)    
            setTimer( _tHVAC_Disp_Stat3_AR, tDelay );
        else
            putValue( HMI__STMSG_HVAC_Disp_Stat3_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_HVAC_Disp_Stat3_AR
{
    if( getValue( this ) )
        openPanel("HVAC_Disp_Stat3_AR");
}

on EnvVar HMI_AirTemp_Insd_Disp
{
    _mHVAC_Disp_Stat3_AR.AirTemp_Insd_Disp.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_ActvComf_TempCtrl_Stat
{
    _mHVAC_Disp_Stat3_AR.HVAC_ActvComf_TempCtrl_Stat.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_AirDist_FL_Psd_HVAC_F
{
    _mHVAC_Disp_Stat3_AR.HVAC_AirDist_FL_Psd_HVAC_F.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_AirDist_FR_Psd_HVAC_F
{
    _mHVAC_Disp_Stat3_AR.HVAC_AirDist_FR_Psd_HVAC_F.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_AirDist_RL_Psd_HVAC_R
{
    _mHVAC_Disp_Stat3_AR.HVAC_AirDist_RL_Psd_HVAC_R.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_AirDist_RR_Psd_HVAC_R
{
    _mHVAC_Disp_Stat3_AR.HVAC_AirDist_RR_Psd_HVAC_R.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Fan_FL_Psd_HVAC_F
{
    _mHVAC_Disp_Stat3_AR.HVAC_Fan_FL_Psd_HVAC_F.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Fan_FR_Psd_HVAC_F
{
    _mHVAC_Disp_Stat3_AR.HVAC_Fan_FR_Psd_HVAC_F.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Fan_RL_Psd_HVAC_R
{
    _mHVAC_Disp_Stat3_AR.HVAC_Fan_RL_Psd_HVAC_R.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Fan_RR_Psd_HVAC_R
{
    _mHVAC_Disp_Stat3_AR.HVAC_Fan_RR_Psd_HVAC_R.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Fltr_Particle_Load
{
    _mHVAC_Disp_Stat3_AR.HVAC_Fltr_Particle_Load.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_FondKey_Psd
{
    _mHVAC_Disp_Stat3_AR.HVAC_FondKey_Psd.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Ionzr_Actv
{
    _mHVAC_Disp_Stat3_AR.HVAC_Ionzr_Actv.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Ionzr_Md
{
    _mHVAC_Disp_Stat3_AR.HVAC_Ionzr_Md.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_MenuKey_Psd
{
    _mHVAC_Disp_Stat3_AR.HVAC_MenuKey_Psd.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Mono_Actv
{
    _mHVAC_Disp_Stat3_AR.HVAC_Mono_Actv.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Pulsation_ActvComf_Stat
{
    _mHVAC_Disp_Stat3_AR.HVAC_Pulsation_ActvComf_Stat.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_SGEN_Actv
{
    _mHVAC_Disp_Stat3_AR.HVAC_SGEN_Actv.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_SGEN_Insty
{
    _mHVAC_Disp_Stat3_AR.HVAC_SGEN_Insty.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

/*on EnvVar HMI_HVAC_SGEN_Lk_Stat
{
    _mHVAC_Disp_Stat3_AR.HVAC_SGEN_Lk_Stat.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}
*/
on EnvVar HMI_HVAC_Temp_FL_Psd_HVAC_F
{
    _mHVAC_Disp_Stat3_AR.HVAC_Temp_FL_Psd_HVAC_F.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Temp_FR_Psd_HVAC_F
{
    _mHVAC_Disp_Stat3_AR.HVAC_Temp_FR_Psd_HVAC_F.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Temp_RL_Psd_HVAC_R
{
    _mHVAC_Disp_Stat3_AR.HVAC_Temp_RL_Psd_HVAC_R.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Temp_RR_Psd_HVAC_R
{
    _mHVAC_Disp_Stat3_AR.HVAC_Temp_RR_Psd_HVAC_R.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_SGEN_Flacon_Flt
{
    _mHVAC_Disp_Stat3_AR.SGEN_Flacon_Flt.phys = getValue(this);
    _HVAC_Disp_Stat3_AR_SpontanFlag = 1;
}

HVAC_Disp_Stat4_AR_check_output()
{
    if( !getValue( HMI__STMSG_HVAC_Disp_Stat4_AR ) )
    {
    //  message   HVAC_Disp_Stat4_AR ID: 1120 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _HVAC_Disp_Stat4_AR_DelayCnt > 0) _HVAC_Disp_Stat4_AR_DelayCnt--; // Mindestsendeabstand
        _HVAC_Disp_Stat4_AR_Cnt--;
        if( _HVAC_Disp_Stat4_AR_Cnt < 1 )
        {
            if( _HVAC_Disp_Stat4_AR_DelayCnt < 1 )
            {
                HVAC_Disp_Stat4_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                 _HVAC_Disp_Stat4_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _HVAC_Disp_Stat4_AR_DelayCnt = _HVAC_Disp_Stat4_AR_MinDelay;
            }
            else
            {
                 _HVAC_Disp_Stat4_AR_SpontanFlag = 1; // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
            }
            _HVAC_Disp_Stat4_AR_Cnt = _HVAC_Disp_Stat4_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _HVAC_Disp_Stat4_AR_SpontanFlag)
        {
            if( _HVAC_Disp_Stat4_AR_DelayCnt < 1 )
            {
                HVAC_Disp_Stat4_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _HVAC_Disp_Stat4_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _HVAC_Disp_Stat4_AR_DelayCnt = _HVAC_Disp_Stat4_AR_MinDelay;
            }
        }
    }
}

HVAC_Disp_Stat4_AR_init()
{   /* Botschaft HVAC_Disp_Stat4_AR ID: 1120 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1120 0;
BA_ "NmAsrMessage" BO_ 1120 0;
BA_ "GenMsgMinAcceptLength" BO_ 1120 8;
BA_ "GenMsgILSupport" BO_ 1120 1;
BA_ "DiagState" BO_ 1120 0;
BA_ "DiagRequest" BO_ 1120 0;
BA_ "DiagResponse" BO_ 1120 0;
BA_ "GenMsgStartValue" BO_ 1120 "0";
BA_ "GenMsgDelayTime" BO_ 1120 200;
BA_ "GenMsgNrOfRepetition" BO_ 1120 0;
BA_ "GenMsgCycleTime" BO_ 1120 1000;
BA_ "GenMsgSendType" BO_ 1120 5;
    */
    _HVAC_Disp_Stat4_AR_Timebase =               c_tDBKomTimer_5ms;
    _HVAC_Disp_Stat4_AR_CycleCount =            1000 / _HVAC_Disp_Stat4_AR_Timebase;
    _HVAC_Disp_Stat4_AR_StartDelay =               0 / _HVAC_Disp_Stat4_AR_Timebase;
    _HVAC_Disp_Stat4_AR_MinDelay =                200 / _HVAC_Disp_Stat4_AR_Timebase;
    _HVAC_Disp_Stat4_AR_Cnt = _HVAC_Disp_Stat4_AR_StartDelay;
    _HVAC_Disp_Stat4_AR_SpontanFlag = 0;
    _HVAC_Disp_Stat4_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_HVAC_Disp_Stat4_AR, _HVAC_Disp_Stat4_AR_StartDelay * _HVAC_Disp_Stat4_AR_Timebase );

    _mHVAC_Disp_Stat4_AR.HVAC_AC_Z5_Actv.phys = getValue( HMI_HVAC_AC_Z5_Actv );
    _mHVAC_Disp_Stat4_AR.HVAC_AirDist_Zone5_Stat.phys = getValue( HMI_HVAC_AirDist_Zone5_Stat );
    _mHVAC_Disp_Stat4_AR.HVAC_Airflow_Zone5_Stat.phys = getValue( HMI_HVAC_Airflow_Zone5_Stat );
    _mHVAC_Disp_Stat4_AR.HVAC_Auto_Zone5_Stat.phys = getValue( HMI_HVAC_Auto_Zone5_Stat );
    _mHVAC_Disp_Stat4_AR.HVAC_Fan_Zone5_Stat.phys = getValue( HMI_HVAC_Fan_Zone5_Stat );
    _mHVAC_Disp_Stat4_AR.HVAC_FtwInc_Zone5_Stat.phys = getValue( HMI_HVAC_FtwInc_Zone5_Stat );
	  _mHVAC_Disp_Stat4_AR.HVAC_Off_Z5_Actv.phys = getValue( HMI_HVAC_Off_Z5_Actv );
	  _mHVAC_Disp_Stat4_AR.HVAC_Temp_Zone5_Stat.phys = getValue( HMI_HVAC_Temp_Zone5_Stat );
    _mHVAC_Disp_Stat4_AR.HVAC_AQS_PartclConc_Insd_Disp_Rq.phys = getValue( HMI_HVAC_AQS_PartclConc_Insd_Disp_Rq );
    _mHVAC_Disp_Stat4_AR.HVAC_AQS_PartclConc_Outsd_Disp_Rq.phys = getValue( HMI_HVAC_AQS_PartclConc_Outsd_Disp_Rq );
    _mHVAC_Disp_Stat4_AR.HVAC_AQS_Sens_Stat_Disp_Rq.phys = getValue( HMI_HVAC_AQS_Sens_Stat_Disp_Rq );
    _mHVAC_Disp_Stat4_AR.HVAC_AQS_Sens_Type_Disp_Rq.phys = getValue( HMI_HVAC_AQS_Sens_Type_Disp_Rq );
    _mHVAC_Disp_Stat4_AR.HVAC_AQS_WinRcmmnd_Disp_Rq.phys = getValue( HMI_HVAC_AQS_WinRcmmnd_Disp_Rq );
  
}

HVAC_Disp_Stat4_AR_output(void)
{
    output( _mHVAC_Disp_Stat4_AR );
}

HVAC_Disp_Stat4_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: HVAC_Disp_Stat4_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_HVAC_Disp_Stat4_AR := %X\n", getValue( HMI__STMSG_HVAC_Disp_Stat4_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_HVAC_Disp_Stat4_AR := %X\n", getValue( HMI__STMSGT_HVAC_Disp_Stat4_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_AC_Z5_Actv := %X\n", getValue( HMI_HVAC_AC_Z5_Actv ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_AirDist_Zone5_Stat := %X\n", getValue( HMI_HVAC_AirDist_Zone5_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Airflow_Zone5_Stat := %X\n", getValue( HMI_HVAC_Airflow_Zone5_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Auto_Zone5_Stat := %X\n", getValue( HMI_HVAC_Auto_Zone5_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Fan_Zone5_Stat := %X\n", getValue( HMI_HVAC_Fan_Zone5_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_FtwInc_Zone5_Stat := %X\n", getValue( HMI_HVAC_FtwInc_Zone5_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_HVAC_Off_Z5_Actv := %X\n", getValue( HMI_HVAC_Off_Z5_Actv ) );        filePutString( buffer, elcount( buffer ), hFile );
	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Temp_Zone5_Stat := %X\n", getValue( HMI_HVAC_Temp_Zone5_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount(buffer), "0.0000 HMI_HVAC_AQS_PartclConc_Insd_Disp_Rq:= %X\n", getValue( HMI_HVAC_AQS_PartclConc_Insd_Disp_Rq) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_HVAC_AQS_PartclConc_Outsd_Disp_Rq:= %X\n", getValue( HMI_HVAC_AQS_PartclConc_Outsd_Disp_Rq) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_HVAC_AQS_Sens_Stat_Disp_Rq:= %X\n", getValue( HMI_HVAC_AQS_Sens_Stat_Disp_Rq) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_HVAC_AQS_Sens_Type_Disp_Rq:= %X\n", getValue( HMI_HVAC_AQS_Sens_Type_Disp_Rq) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_HVAC_AQS_WinRcmmnd_Disp_Rq:= %X\n", getValue( HMI_HVAC_AQS_WinRcmmnd_Disp_Rq) );        filePutString( buffer, elcount(buffer), hFile);
}

on timer _tHVAC_Disp_Stat4_AR
{
    putValue( HMI__STMSG_HVAC_Disp_Stat4_AR, 0 );
}

on EnvVar HMI__STMSG_HVAC_Disp_Stat4_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_HVAC_Disp_Stat4_AR );
        if( tDelay > 0)    
            setTimer( _tHVAC_Disp_Stat4_AR, tDelay );
        else
            putValue( HMI__STMSG_HVAC_Disp_Stat4_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_HVAC_Disp_Stat4_AR
{
    if( getValue( this ) )
        openPanel("HVAC_Disp_Stat4_AR");
}

on EnvVar HMI_HVAC_AC_Z5_Actv
{
    _mHVAC_Disp_Stat4_AR.HVAC_AC_Z5_Actv.phys = getValue(this);
    _HVAC_Disp_Stat4_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_AirDist_Zone5_Stat
{
    _mHVAC_Disp_Stat4_AR.HVAC_AirDist_Zone5_Stat.phys = getValue(this);
    _HVAC_Disp_Stat4_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Airflow_Zone5_Stat
{
    _mHVAC_Disp_Stat4_AR.HVAC_Airflow_Zone5_Stat.phys = getValue(this);
    _HVAC_Disp_Stat4_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Auto_Zone5_Stat
{
    _mHVAC_Disp_Stat4_AR.HVAC_Auto_Zone5_Stat.phys = getValue(this);
    _HVAC_Disp_Stat4_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Fan_Zone5_Stat
{
    _mHVAC_Disp_Stat4_AR.HVAC_Fan_Zone5_Stat.phys = getValue(this);
    _HVAC_Disp_Stat4_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_FtwInc_Zone5_Stat
{
    _mHVAC_Disp_Stat4_AR.HVAC_FtwInc_Zone5_Stat.phys = getValue(this);
    _HVAC_Disp_Stat4_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Off_Z5_Actv
{
    _mHVAC_Disp_Stat4_AR.HVAC_Off_Z5_Actv.phys = getValue(this);
    _HVAC_Disp_Stat4_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Temp_Zone5_Stat
{
    _mHVAC_Disp_Stat4_AR.HVAC_Temp_Zone5_Stat.phys = getValue(this);
    _HVAC_Disp_Stat4_AR_SpontanFlag = 1;
}

on EnvVar HMI_ADASLR_ProfLong_AirTemp_WthrOffboard
{
	_mHVAC_Disp_Stat4_AR.HVAC_AQS_PartclConc_Insd_Disp_Rq.phys = getValue(this);
	_HVAC_Disp_Stat4_AR_SpontanFlag = 1;
}

on EnvVar HMI_ADASLR_ProfLong_CtrlPnt_WthrOffboard
{
	_mHVAC_Disp_Stat4_AR.HVAC_AQS_PartclConc_Outsd_Disp_Rq.phys = getValue(this);
	_HVAC_Disp_Stat4_AR_SpontanFlag = 1;
}

on EnvVar HMI_ADASLR_ProfLong_CycCnt_WthrOffboard
{
	_mHVAC_Disp_Stat4_AR.HVAC_AQS_Sens_Stat_Disp_Rq.phys = getValue(this);
	_HVAC_Disp_Stat4_AR_SpontanFlag = 1;
}

on EnvVar HMI_ADASLR_ProfLong_MsgTyp_WthrOffboard
{
	_mHVAC_Disp_Stat4_AR.HVAC_AQS_Sens_Type_Disp_Rq.phys = getValue(this);
	_HVAC_Disp_Stat4_AR_SpontanFlag = 1;
}

on EnvVar HMI_ADASLR_ProfLong_Offset_WthrOffboard
{
	_mHVAC_Disp_Stat4_AR.HVAC_AQS_WinRcmmnd_Disp_Rq.phys = getValue(this);
	_HVAC_Disp_Stat4_AR_SpontanFlag = 1;
}

HVAC_State1_AR_check_output()
{
    if( !getValue( HMI__STMSG_HVAC_State1_AR ) )
    {
    //  message   HVAC_State1_AR ID: 895 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _HVAC_State1_AR_Cnt--;
        if( _HVAC_State1_AR_Cnt < 1 )
        {
            HVAC_State1_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _HVAC_State1_AR_Cnt = _HVAC_State1_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _HVAC_State1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _HVAC_State1_AR_SpontanFlag)
        {
            HVAC_State1_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _HVAC_State1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

HVAC_State1_AR_init()
{   /* Botschaft HVAC_State1_AR ID: 895 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 895 0;
BA_ "NmAsrMessage" BO_ 895 0;
BA_ "GenMsgMinAcceptLength" BO_ 895 8;
BA_ "GenMsgILSupport" BO_ 895 1;
BA_ "DiagState" BO_ 895 0;
BA_ "DiagRequest" BO_ 895 0;
BA_ "DiagResponse" BO_ 895 0;
BA_ "GenMsgStartValue" BO_ 895 "0";
BA_ "GenMsgDelayTime" BO_ 895 5;
BA_ "GenMsgNrOfRepetitions" BO_ 895 0;
BA_ "GenMsgCycleTime" BO_ 895 500;
BA_ "GenMsgSendType" BO_ 895 5;
    */
    _HVAC_State1_AR_Timebase =           c_tDBKomTimer_20ms;
    _HVAC_State1_AR_CycleCount =        500 / _HVAC_State1_AR_Timebase;
    _HVAC_State1_AR_StartDelay =          0 / _HVAC_State1_AR_Timebase;
    _HVAC_State1_AR_Cnt = _HVAC_State1_AR_StartDelay;
    _HVAC_State1_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_HVAC_State1_AR, _HVAC_State1_AR_StartDelay * _HVAC_State1_AR_Timebase );

    _mHVAC_State1_AR.AirTemp_Insd_V2.phys = getValue( HMI_AirTemp_Insd_V2 );
    _mHVAC_State1_AR.AirTemp_InsdSens_OHCM_FanOnRq.phys = getValue( HMI_AirTemp_InsdSens_OHCM_FanOnRq );
    _mHVAC_State1_AR.DewTemp.phys = getValue( HMI_DewTemp );
    _mHVAC_State1_AR.DPC_Md_AC_Rs.phys = getValue( HMI_DPC_Md_AC_Rs );
    _mHVAC_State1_AR.DPC_Md_Ht_Rs.phys = getValue( HMI_DPC_Md_Ht_Rs );
    _mHVAC_State1_AR.EBL_Sw_Psd.phys = getValue( HMI_EBL_Sw_Psd );
    _mHVAC_State1_AR.HVAC_AC_Off.phys = getValue( HMI_HVAC_AC_Off );
    _mHVAC_State1_AR.HVAC_AuxHt_Enbl.phys = getValue( HMI_HVAC_AuxHt_Enbl );
    _mHVAC_State1_AR.HVAC_Dfrst_Actv.phys = getValue( HMI_HVAC_Dfrst_Actv );
    _mHVAC_State1_AR.HVAC_Fan_Actv_IgnOff.phys = getValue( HMI_HVAC_Fan_Actv_IgnOff );
    _mHVAC_State1_AR.HVAC_Fan_F.phys = getValue( HMI_HVAC_Fan_F );
    _mHVAC_State1_AR.HVAC_AC_Off.phys = getValue( HMI_HVAC_AC_Off );
    _mHVAC_State1_AR.HVAC_Off_Ft_Actv.phys = getValue( HMI_HVAC_Off_Ft_Actv );
    _mHVAC_State1_AR.HVAC_Pulsation_Stat.phys = getValue( HMI_HVAC_Pulsation_Stat );
    _mHVAC_State1_AR.HVAC_RecircAir_Actv.phys = getValue( HMI_HVAC_RecircAir_Actv );
    _mHVAC_State1_AR.HVAC_RecircAirSw_F_Psd_HVAC_F.phys = getValue( HMI_HVAC_RecircAirSw_F_Psd_HVAC_F );
    _mHVAC_State1_AR.HVAC_RHU_Ft_Actv.phys = getValue( HMI_HVAC_RHU_Ft_Actv );
    _mHVAC_State1_AR.HVAC_RHU_R_Actv.phys = getValue( HMI_HVAC_RHU_R_Actv );
    _mHVAC_State1_AR.HVAC_Vprzr_DryVn_Actv.phys = getValue( HMI_HVAC_Vprzr_DryVn_Actv );
    _mHVAC_State1_AR.HVAC_Vprzr_DryVnTmr_On_Rq.phys = getValue( HMI_HVAC_Vprzr_DryVnTmr_On_Rq );
    _mHVAC_State1_AR.ICH_Dur_Stat.phys = getValue( HMI_ICH_Dur_Stat );
    _mHVAC_State1_AR.ICH_HtVnSw_Psd.phys = getValue( HMI_ICH_HtVnSw_Psd );
    _mHVAC_State1_AR.ICH_LED_Rd_Flt.phys = getValue( HMI_ICH_LED_Rd_Flt );
    _mHVAC_State1_AR.ICH_LED_Ye_Flt.phys = getValue( HMI_ICH_LED_Ye_Flt );
    _mHVAC_State1_AR.ICH_Rq.phys = getValue( HMI_ICH_Rq );
    _mHVAC_State1_AR.ICH_WtrPmp_On_Rq_HVAC.phys = getValue( HMI_ICH_WtrPmp_On_Rq_HVAC );
    _mHVAC_State1_AR.PN14_GM1_Off_Rq_HVAC.phys = getValue( HMI_PN14_GM1_Off_Rq_HVAC );
}

HVAC_State1_AR_output(void)
{
    output( _mHVAC_State1_AR );
}

HVAC_State1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: HVAC_State1_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_HVAC_State1 := %X\n", getValue( HMI__STMSG_HVAC_State1_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_HVAC_State1 := %X\n", getValue( HMI__STMSGT_HVAC_State1_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AirTemp_Insd_V2 := %X\n", getValue( HMI_AirTemp_Insd_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AirTemp_InsdSens_OHCM_FanOnRq := %X\n", getValue( HMI_AirTemp_InsdSens_OHCM_FanOnRq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DewTemp := %X\n", getValue( HMI_DewTemp ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_AC_Rs := %X\n", getValue( HMI_DPC_Md_AC_Rs ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_Ht_Rs := %X\n", getValue( HMI_DPC_Md_Ht_Rs ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EBL_Sw_Psd := %X\n", getValue( HMI_EBL_Sw_Psd ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_AC_Off := %X\n", getValue( HMI_HVAC_AC_Off ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_AuxHt_Enbl := %X\n", getValue( HMI_HVAC_AuxHt_Enbl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Dfrst_Actv := %X\n", getValue( HMI_HVAC_Dfrst_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Fan_Actv_IgnOff := %X\n", getValue( HMI_HVAC_Fan_Actv_IgnOff ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Fan_F := %X\n", getValue( HMI_HVAC_Fan_F ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Off_Ft_Actv := %X\n", getValue( HMI_HVAC_Off_Ft_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Pulsation_Stat := %X\n", getValue( HMI_HVAC_Pulsation_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_RecircAir_Actv := %X\n", getValue( HMI_HVAC_RecircAir_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_RecircAirSw_F_Psd_HVAC_F := %X\n", getValue( HMI_HVAC_RecircAirSw_F_Psd_HVAC_F ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_RHU_Ft_Actv := %X\n", getValue( HMI_HVAC_RHU_Ft_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_RHU_R_Actv := %X\n", getValue( HMI_HVAC_RHU_R_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Vprzr_DryVn_Actv := %X\n", getValue( HMI_HVAC_Vprzr_DryVn_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Vprzr_DryVnTmr_On_Rq := %X\n", getValue( HMI_HVAC_Vprzr_DryVnTmr_On_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_Dur_Stat := %X\n", getValue( HMI_ICH_Dur_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_HtVnSw_Psd := %X\n", getValue( HMI_ICH_HtVnSw_Psd ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_LED_Rd_Flt := %X\n", getValue( HMI_ICH_LED_Rd_Flt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_LED_Ye_Flt := %X\n", getValue( HMI_ICH_LED_Ye_Flt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_Rq := %X\n", getValue( HMI_ICH_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_WtrPmp_On_Rq_HVAC := %X\n", getValue( HMI_ICH_WtrPmp_On_Rq_HVAC ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_GM1_Off_Rq_HVAC := %X\n", getValue( HMI_PN14_GM1_Off_Rq_HVAC ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tHVAC_State1_AR
{
    putValue( HMI__STMSG_HVAC_State1_AR, 0 );
}

on EnvVar HMI__STMSG_HVAC_State1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_HVAC_State1_AR );
        if( tDelay > 0)    
            setTimer( _tHVAC_State1_AR, tDelay );
        else
            putValue( HMI__STMSG_HVAC_State1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_HVAC_State1_AR
{
    if( getValue( this ) )
        openPanel("HVAC_State1_AR");
}

on EnvVar HMI_AirTemp_Insd_V2
{
    _mHVAC_State1_AR.AirTemp_Insd_V2.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_AirTemp_InsdSens_OHCM_FanOnRq
{
    _mHVAC_State1_AR.AirTemp_InsdSens_OHCM_FanOnRq.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DewTemp
{
    _mHVAC_State1_AR.DewTemp.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_AC_Rs
{
    _mHVAC_State1_AR.DPC_Md_AC_Rs.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_Ht_Rs
{
    _mHVAC_State1_AR.DPC_Md_Ht_Rs.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_EBL_Sw_Psd
{
    _mHVAC_State1_AR.EBL_Sw_Psd.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_AC_Off
{
    _mHVAC_State1_AR.HVAC_AC_Off.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_AuxHt_Enbl
{
    _mHVAC_State1_AR.HVAC_AuxHt_Enbl.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Dfrst_Actv
{
    _mHVAC_State1_AR.HVAC_Dfrst_Actv.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Fan_Actv_IgnOff
{
    _mHVAC_State1_AR.HVAC_Fan_Actv_IgnOff.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Fan_F
{
    _mHVAC_State1_AR.HVAC_Fan_F.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Off_Ft_Actv
{
    _mHVAC_State1_AR.HVAC_Off_Ft_Actv.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Pulsation_Stat
{
    _mHVAC_State1_AR.HVAC_Pulsation_Stat.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_RecircAir_Actv
{
    _mHVAC_State1_AR.HVAC_RecircAir_Actv.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_RecircAirSw_F_Psd_HVAC_F
{
    _mHVAC_State1_AR.HVAC_RecircAirSw_F_Psd_HVAC_F.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_RHU_Ft_Actv
{
    _mHVAC_State1_AR.HVAC_RHU_Ft_Actv.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_RHU_R_Actv
{
    _mHVAC_State1_AR.HVAC_RHU_R_Actv.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Vprzr_DryVn_Actv
{
    _mHVAC_State1_AR.HVAC_Vprzr_DryVn_Actv.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Vprzr_DryVnTmr_On_Rq
{
    _mHVAC_State1_AR.HVAC_Vprzr_DryVnTmr_On_Rq.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_Dur_Stat
{
    _mHVAC_State1_AR.ICH_Dur_Stat.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_HtVnSw_Psd
{
    _mHVAC_State1_AR.ICH_HtVnSw_Psd.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_LED_Rd_Flt
{
    _mHVAC_State1_AR.ICH_LED_Rd_Flt.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_LED_Ye_Flt
{
    _mHVAC_State1_AR.ICH_LED_Ye_Flt.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_Rq
{
    _mHVAC_State1_AR.ICH_Rq.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_WtrPmp_On_Rq_HVAC
{
    _mHVAC_State1_AR.ICH_WtrPmp_On_Rq_HVAC.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_GM1_Off_Rq_HVAC
{
    _mHVAC_State1_AR.PN14_GM1_Off_Rq_HVAC.phys = getValue(this);
    _HVAC_State1_AR_SpontanFlag = 1;
}

ICH_PreTime_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_ICH_PreTime_Stat_AR ) )
    {
    //  message   ICH_PreTime_Stat_AR ID: 889 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _ICH_PreTime_Stat_AR_Cnt--;
        if( _ICH_PreTime_Stat_AR_Cnt < 1 )
        {
            ICH_PreTime_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _ICH_PreTime_Stat_AR_Cnt = _ICH_PreTime_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _ICH_PreTime_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _ICH_PreTime_Stat_AR_SpontanFlag )
        {
            ICH_PreTime_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _ICH_PreTime_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

ICH_PreTime_Stat_AR_init()
{   /* Botschaft ICH_PreTime_Stat_AR ID: 889 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 889 0;
BA_ "NmAsrMessage" BO_ 889 0;
BA_ "GenMsgMinAcceptLength" BO_ 889 7;
BA_ "GenMsgILSupport" BO_ 889 1;
BA_ "DiagState" BO_ 889 0;
BA_ "DiagRequest" BO_ 889 0;
BA_ "DiagResponse" BO_ 889 0;
BA_ "GenMsgStartValue" BO_ 889 "0";
BA_ "GenMsgDelayTime" BO_ 889 5;
BA_ "GenMsgNrOfRepetitions" BO_ 889 0;
BA_ "GenMsgCycleTime" BO_ 889 1000;
BA_ "GenMsgSendType" BO_ 889 5;
    */
    _ICH_PreTime_Stat_AR_Timebase =           c_tDBKomTimer_20ms;
    _ICH_PreTime_Stat_AR_CycleCount =       1000 / _ICH_PreTime_Stat_AR_Timebase;
    _ICH_PreTime_Stat_AR_StartDelay =          0 / _ICH_PreTime_Stat_AR_Timebase;
    _ICH_PreTime_Stat_AR_Cnt = _ICH_PreTime_Stat_AR_StartDelay;
    _ICH_PreTime_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_ICH_PreTime_Stat_AR, _ICH_PreTime_Stat_AR_StartDelay * _ICH_PreTime_Stat_AR_Timebase );

    _mICH_PreTime_Stat_AR.ICH_PreTm_Stat.phys = getValue( HMI_ICH_PreTm_Stat );
    _mICH_PreTime_Stat_AR.ICH_PreTm1_Hour_Stat.phys = getValue( HMI_ICH_PreTm1_Hour_Stat );
    _mICH_PreTime_Stat_AR.ICH_PreTm1_Minute_Stat.phys = getValue( HMI_ICH_PreTm1_Minute_Stat );
    _mICH_PreTime_Stat_AR.ICH_PreTm2_Hour_Stat.phys = getValue( HMI_ICH_PreTm2_Hour_Stat );
    _mICH_PreTime_Stat_AR.ICH_PreTm2_Minute_Stat.phys = getValue( HMI_ICH_PreTm2_Minute_Stat );
    _mICH_PreTime_Stat_AR.ICH_PreTm3_Hour_Stat.phys = getValue( HMI_ICH_PreTm3_Hour_Stat );
    _mICH_PreTime_Stat_AR.ICH_PreTm3_Minute_Stat.phys = getValue( HMI_ICH_PreTm3_Minute_Stat );
}

ICH_PreTime_Stat_AR_output(void)
{
    output( _mICH_PreTime_Stat_AR );
}

ICH_PreTime_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: ICH_PreTime_Stat_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_ICH_PreTime_Stat := %X\n", getValue( HMI__STMSG_ICH_PreTime_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_ICH_PreTime_Stat := %X\n", getValue( HMI__STMSGT_ICH_PreTime_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_PreTm_Stat := %X\n", getValue( HMI_ICH_PreTm_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_PreTm1_Hour_Stat := %X\n", getValue( HMI_ICH_PreTm1_Hour_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_PreTm1_Minute_Stat := %X\n", getValue( HMI_ICH_PreTm1_Minute_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_PreTm2_Hour_Stat := %X\n", getValue( HMI_ICH_PreTm2_Hour_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_PreTm2_Minute_Stat := %X\n", getValue( HMI_ICH_PreTm2_Minute_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_PreTm3_Hour_Stat := %X\n", getValue( HMI_ICH_PreTm3_Hour_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_PreTm3_Minute_Stat := %X\n", getValue( HMI_ICH_PreTm3_Minute_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tICH_PreTime_Stat_AR
{
    putValue( HMI__STMSG_ICH_PreTime_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_ICH_PreTime_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_ICH_PreTime_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tICH_PreTime_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_ICH_PreTime_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_ICH_PreTime_Stat_AR
{
    if( getValue( this ) )
        openPanel("ICH_PreTime_Stat_AR");
}

on EnvVar HMI_ICH_PreTm_Stat
{
    _mICH_PreTime_Stat_AR.ICH_PreTm_Stat.phys = getValue(this);
    _ICH_PreTime_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_PreTm1_Hour_Stat
{
    _mICH_PreTime_Stat_AR.ICH_PreTm1_Hour_Stat.phys = getValue(this);
    _ICH_PreTime_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_PreTm1_Minute_Stat
{
    _mICH_PreTime_Stat_AR.ICH_PreTm1_Minute_Stat.phys = getValue(this);
    _ICH_PreTime_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_PreTm2_Hour_Stat
{
    _mICH_PreTime_Stat_AR.ICH_PreTm2_Hour_Stat.phys = getValue(this);
    _ICH_PreTime_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_PreTm2_Minute_Stat
{
    _mICH_PreTime_Stat_AR.ICH_PreTm2_Minute_Stat.phys = getValue(this);
    _ICH_PreTime_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_PreTm3_Hour_Stat
{
    _mICH_PreTime_Stat_AR.ICH_PreTm3_Hour_Stat.phys = getValue(this);
    _ICH_PreTime_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_PreTm3_Minute_Stat
{
    _mICH_PreTime_Stat_AR.ICH_PreTm3_Minute_Stat.phys = getValue(this);
    _ICH_PreTime_Stat_AR_SpontanFlag = 1;
}

ICH_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_ICH_Stat_AR ) )
    {
    //  message   ICH_Stat_AR ID: 887 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _ICH_Stat_AR_Cnt--;
        if( _ICH_Stat_AR_Cnt < 1 )
        {
            ICH_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _ICH_Stat_AR_Cnt = _ICH_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _ICH_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _ICH_Stat_AR_SpontanFlag)
        {
            ICH_Stat_AR_output();// Nachricht wg. spontaner �nderung ausgeben
            _ICH_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

ICH_Stat_AR_init()
{   /* Botschaft ICH_Stat_AR ID: 887 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 887 0;
BA_ "NmAsrMessage" BO_ 887 0;
BA_ "GenMsgMinAcceptLength" BO_ 887 8;
BA_ "GenMsgILSupport" BO_ 887 1;
BA_ "DiagState" BO_ 887 0;
BA_ "DiagRequest" BO_ 887 0;
BA_ "DiagResponse" BO_ 887 0;
BA_ "GenMsgStartValue" BO_ 887 "0";
BA_ "GenMsgStartDelayTime" BO_ 887 0;
BA_ "GenMsgDelayTime" BO_ 887 5;
BA_ "GenMsgNrOfRepetitions" BO_ 887 0;
BA_ "GenMsgCycleTime" BO_ 887 500;
BA_ "GenMsgSendType" BO_ 887 5;
    */
    _ICH_Stat_AR_Timebase =           c_tDBKomTimer_20ms;
    _ICH_Stat_AR_CycleCount =        500 / _ICH_Stat_AR_Timebase;
    _ICH_Stat_AR_StartDelay =          0 / _ICH_Stat_AR_Timebase;
    _ICH_Stat_AR_Cnt = _ICH_Stat_AR_StartDelay;
    _ICH_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_ICH_Stat_AR, _ICH_Stat_AR_StartDelay * _ICH_Stat_AR_Timebase );

    _mICH_Stat_AR.HU_Disp_On_Rq.phys = getValue( HMI_HU_Disp_On_Rq );
    _mICH_Stat_AR.HVAC_Fan_On_Rq.phys = getValue( HMI_HVAC_Fan_On_Rq );
    _mICH_Stat_AR.ICH_AuxHt_LED_On_Rq.phys = getValue( HMI_ICH_AuxHt_LED_On_Rq );
    _mICH_Stat_AR.ICH_Bdgt_Empty.phys = getValue( HMI_ICH_Bdgt_Empty );
    _mICH_Stat_AR.ICH_Bdgt_Empty_ErrDisp.phys = getValue( HMI_ICH_Bdgt_Empty_ErrDisp );
    _mICH_Stat_AR.ICH_Bdgt_Empty_Occ.phys = getValue( HMI_ICH_Bdgt_Empty_Occ );
    _mICH_Stat_AR.ICH_Bdgt_Empty_Stat.phys = getValue( HMI_ICH_Bdgt_Empty_Stat );
    _mICH_Stat_AR.ICH_Flt.phys = getValue( HMI_ICH_Flt );
    _mICH_Stat_AR.ICH_Flt_ErrDisp.phys = getValue( HMI_ICH_Flt_ErrDisp );
    _mICH_Stat_AR.ICH_Flt_Occ.phys = getValue( HMI_ICH_Flt_Occ );
    _mICH_Stat_AR.ICH_Flt_Stat.phys = getValue( HMI_ICH_Flt_Stat );
    _mICH_Stat_AR.ICH_Ht_Test.phys = getValue( HMI_ICH_Ht_Test );
    _mICH_Stat_AR.ICH_HtVn_Actv_V2.phys = getValue( HMI_ICH_HtVn_Actv_V2 );
    _mICH_Stat_AR.ICH_PreTm_Actv_V2.phys = getValue( HMI_ICH_PreTm_Actv_V2 );
    _mICH_Stat_AR.ICH_PreTm_Hour.phys = getValue( HMI_ICH_PreTm_Hour );
    _mICH_Stat_AR.ICH_PreTm_Minute.phys = getValue( HMI_ICH_PreTm_Minute );
    _mICH_Stat_AR.ICH_Pwr_Stat.phys = getValue( HMI_ICH_Pwr_Stat );
    _mICH_Stat_AR.ICH_ResRunTm.phys = getValue( HMI_ICH_ResRunTm );
    _mICH_Stat_AR.ICH_SupVolt_Lo.phys = getValue( HMI_ICH_SupVolt_Lo );
    _mICH_Stat_AR.ICH_SupVolt_Lo_ErrDisp.phys = getValue( HMI_ICH_SupVolt_Lo_ErrDisp );
    _mICH_Stat_AR.ICH_SupVolt_Lo_Occ.phys = getValue( HMI_ICH_SupVolt_Lo_Occ );
    _mICH_Stat_AR.ICH_SupVolt_Lo_Stat.phys = getValue( HMI_ICH_SupVolt_Lo_Stat );
    _mICH_Stat_AR.ICH_SwitchVlv_Stat.phys = getValue( HMI_ICH_SwitchVlv_Stat );
    _mICH_Stat_AR.ICH_TankLvl_Min.phys = getValue( HMI_ICH_TankLvl_Min );
    _mICH_Stat_AR.ICH_TankLvl_Min_ErrDisp.phys = getValue( HMI_ICH_TankLvl_Min_ErrDisp );
    _mICH_Stat_AR.ICH_TankLvl_Min_Occ.phys = getValue( HMI_ICH_TankLvl_Min_Occ );
    _mICH_Stat_AR.ICH_TankLvl_Min_Stat.phys = getValue( HMI_ICH_TankLvl_Min_Stat );
    _mICH_Stat_AR.ICH_WtrPmp_Stat.phys = getValue( HMI_ICH_WtrPmp_Stat );
    _mICH_Stat_AR.ICH_WtrTemp_V2.phys = getValue( HMI_ICH_WtrTemp_V2 );
    _mICH_Stat_AR.TxmtSync_Actv.phys = getValue( HMI_TxmtSync_Actv );
}

ICH_Stat_AR_output(void)
{
    output( _mICH_Stat_AR );
}

ICH_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: ICH_Stat_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_ICH_Stat_AR := %X\n", getValue( HMI__STMSG_ICH_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_ICH_Stat_AR := %X\n", getValue( HMI__STMSGT_ICH_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HU_Disp_On_Rq := %X\n", getValue( HMI_HU_Disp_On_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Fan_On_Rq := %X\n", getValue( HMI_HVAC_Fan_On_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_AuxHt_LED_On_Rq := %X\n", getValue( HMI_ICH_AuxHt_LED_On_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_Bdgt_Empty := %X\n", getValue( HMI_ICH_Bdgt_Empty ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_Bdgt_Empty_ErrDisp := %X\n", getValue( HMI_ICH_Bdgt_Empty_ErrDisp ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_Bdgt_Empty_Occ := %X\n", getValue( HMI_ICH_Bdgt_Empty_Occ ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_Bdgt_Empty_Stat := %X\n", getValue( HMI_ICH_Bdgt_Empty_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_Flt := %X\n", getValue( HMI_ICH_Flt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_Flt_ErrDisp := %X\n", getValue( HMI_ICH_Flt_ErrDisp ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_Flt_Occ := %X\n", getValue( HMI_ICH_Flt_Occ ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_Flt_Stat := %X\n", getValue( HMI_ICH_Flt_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_Ht_Test := %X\n", getValue( HMI_ICH_Ht_Test ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_HtVn_Actv_V2 := %X\n", getValue( HMI_ICH_HtVn_Actv_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_PreTm_Actv_V2 := %X\n", getValue( HMI_ICH_PreTm_Actv_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_PreTm_Hour := %X\n", getValue( HMI_ICH_PreTm_Hour ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_PreTm_Minute := %X\n", getValue( HMI_ICH_PreTm_Minute ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_Pwr_Stat := %X\n", getValue( HMI_ICH_Pwr_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_ResRunTm := %X\n", getValue( HMI_ICH_ResRunTm ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_SupVolt_Lo := %X\n", getValue( HMI_ICH_SupVolt_Lo ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_SupVolt_Lo_ErrDisp := %X\n", getValue( HMI_ICH_SupVolt_Lo_ErrDisp ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_SupVolt_Lo_Occ := %X\n", getValue( HMI_ICH_SupVolt_Lo_Occ ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_SupVolt_Lo_Stat := %X\n", getValue( HMI_ICH_SupVolt_Lo_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_SwitchVlv_Stat := %X\n", getValue( HMI_ICH_SwitchVlv_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_TankLvl_Min := %X\n", getValue( HMI_ICH_TankLvl_Min ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_TankLvl_Min_ErrDisp := %X\n", getValue( HMI_ICH_TankLvl_Min_ErrDisp ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_TankLvl_Min_Occ := %X\n", getValue( HMI_ICH_TankLvl_Min_Occ ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_TankLvl_Min_Stat := %X\n", getValue( HMI_ICH_TankLvl_Min_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_WtrPmp_Stat := %X\n", getValue( HMI_ICH_WtrPmp_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_WtrTemp_V2 := %X\n", getValue( HMI_ICH_WtrTemp_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TxmtSync_Actv := %X\n", getValue( HMI_TxmtSync_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tICH_Stat_AR
{
    putValue( HMI__STMSG_ICH_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_ICH_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_ICH_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tICH_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_ICH_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_ICH_Stat_AR
{
    if( getValue( this ) )
        openPanel("ICH_Stat_AR");
}

on EnvVar HMI_ICH_ResRunTm
{
    _mICH_Stat_AR.ICH_ResRunTm.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_Bdgt_Empty_ErrDisp
{
    _mICH_Stat_AR.ICH_Bdgt_Empty_ErrDisp.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_Flt_Stat
{
    _mICH_Stat_AR.ICH_Flt_Stat.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_SupVolt_Lo_ErrDisp
{
    _mICH_Stat_AR.ICH_SupVolt_Lo_ErrDisp.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}


on EnvVar HMI_ICH_TankLvl_Min_Stat
{
    _mICH_Stat_AR.ICH_TankLvl_Min_Stat.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_SupVolt_Lo_Stat
{
    _mICH_Stat_AR.ICH_SupVolt_Lo_Stat.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_TankLvl_Min_ErrDisp
{
    _mICH_Stat_AR.ICH_TankLvl_Min_ErrDisp.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_Flt_ErrDisp
{
    _mICH_Stat_AR.ICH_Flt_ErrDisp.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_Bdgt_Empty_Stat
{
    _mICH_Stat_AR.ICH_Bdgt_Empty_Stat.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_HU_Disp_On_Rq
{
    _mICH_Stat_AR.HU_Disp_On_Rq.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Fan_On_Rq
{
    _mICH_Stat_AR.HVAC_Fan_On_Rq.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_AuxHt_LED_On_Rq
{
    _mICH_Stat_AR.ICH_AuxHt_LED_On_Rq.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_Bdgt_Empty
{
    _mICH_Stat_AR.ICH_Bdgt_Empty.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_Bdgt_Empty_Occ
{
    _mICH_Stat_AR.ICH_Bdgt_Empty_Occ.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_Flt
{
    _mICH_Stat_AR.ICH_Flt.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_Flt_Occ
{
    _mICH_Stat_AR.ICH_Flt_Occ.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_Ht_Test
{
    _mICH_Stat_AR.ICH_Ht_Test.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_HtVn_Actv_V2
{
    _mICH_Stat_AR.ICH_HtVn_Actv_V2.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_PreTm_Actv_V2
{
    _mICH_Stat_AR.ICH_PreTm_Actv_V2.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_PreTm_Hour
{
    _mICH_Stat_AR.ICH_PreTm_Hour.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_PreTm_Minute
{
    _mICH_Stat_AR.ICH_PreTm_Minute.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_Pwr_Stat
{
    _mICH_Stat_AR.ICH_Pwr_Stat.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_SupVolt_Lo
{
    _mICH_Stat_AR.ICH_SupVolt_Lo.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_SupVolt_Lo_Occ
{
    _mICH_Stat_AR.ICH_SupVolt_Lo_Occ.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_SwitchVlv_Stat
{
    _mICH_Stat_AR.ICH_SwitchVlv_Stat.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_TankLvl_Min
{
    _mICH_Stat_AR.ICH_TankLvl_Min.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_TankLvl_Min_Occ
{
    _mICH_Stat_AR.ICH_TankLvl_Min_Occ.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_WtrPmp_Stat
{
    _mICH_Stat_AR.ICH_WtrPmp_Stat.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_WtrTemp_V2
{
    _mICH_Stat_AR.ICH_WtrTemp_V2.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_TxmtSync_Actv
{
    _mICH_Stat_AR.TxmtSync_Actv.phys = getValue(this);
    _ICH_Stat_AR_SpontanFlag = 1;
}

Ign_Veh_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_Ign_Veh_Stat_AR ) )
    {
    //  message   Ign_Veh_Stat_AR ID: 32 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _Ign_Veh_Stat_AR_Cnt--;
        if( _Ign_Veh_Stat_AR_Cnt < 1 )
        {
            Ign_Veh_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _Ign_Veh_Stat_AR_Cnt = _Ign_Veh_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _Ign_Veh_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _Ign_Veh_Stat_AR_SpontanFlag )
        {
            Ign_Veh_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _Ign_Veh_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

Ign_Veh_Stat_AR_init()
{   /* Botschaft Ign_Veh_Stat_AR ID: 32 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 32 0;
BA_ "NmAsrMessage" BO_ 32 0;
BA_ "GenMsgMinAcceptLength" BO_ 32 8;
BA_ "GenMsgILSupport" BO_ 32 1;
BA_ "DiagState" BO_ 32 0;
BA_ "DiagRequest" BO_ 32 0;
BA_ "DiagResponse" BO_ 32 0;
BA_ "GenMsgStartValue" BO_ 32 "0";
BA_ "GenMsgStartDelayTime" BO_ 32 0;
BA_ "GenMsgDelayTime" BO_ 32 5;
BA_ "GenMsgNrOfRepetitions" BO_ 32 0;
BA_ "GenMsgCycleTime" BO_ 32 100;
BA_ "GenMsgSendType" BO_ 32 5;
    */
    _Ign_Veh_Stat_AR_Timebase =           c_tDBKomTimer_20ms;
    _Ign_Veh_Stat_AR_CycleCount =        100 / _Ign_Veh_Stat_AR_Timebase;
    _Ign_Veh_Stat_AR_StartDelay =          0 / _Ign_Veh_Stat_AR_Timebase;
    _Ign_Veh_Stat_AR_Cnt = _Ign_Veh_Stat_AR_StartDelay;
    _Ign_Veh_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_Ign_Veh_Stat_AR, _Ign_Veh_Stat_AR_StartDelay * _Ign_Veh_Stat_AR_Timebase );

    _mIgn_Veh_Stat_AR.BusFlt_PrmntActv.phys = getValue( HMI_BusFlt_PrmntActv );
    _mIgn_Veh_Stat_AR.ContEngRun_Stat.phys = getValue( HMI_ContEngRun_Stat );
    _mIgn_Veh_Stat_AR.DidA_ExtTest_Pres.phys = getValue( HMI_DidA_ExtTest_Pres );
    _mIgn_Veh_Stat_AR.EngSt_Enbl_Rq_KG.phys = getValue( HMI_EngSt_Enbl_Rq_KG );
    _mIgn_Veh_Stat_AR.ESL_Lk_Rq.phys = getValue( HMI_ESL_Lk_Rq );
    _mIgn_Veh_Stat_AR.Ign_On_StartProc_Inact.phys = getValue( HMI_Ign_On_StartProc_Inact );
    _mIgn_Veh_Stat_AR.ISw_Stat.phys = getValue( HMI_ISw_Stat );
    _mIgn_Veh_Stat_AR.KG_IgnCtrl_Actv.phys = getValue( HMI_KG_IgnCtrl_Actv );
    _mIgn_Veh_Stat_AR.KG_StartSw_Psd.phys = getValue( HMI_KG_StartSw_Psd );
    _mIgn_Veh_Stat_AR.Mobile_Chrg_Rq_EIS.phys = getValue( HMI_Mobile_Chrg_Rq_EIS );
    _mIgn_Veh_Stat_AR.RemSt_IgnCtrl_Actv.phys = getValue( HMI_RemSt_IgnCtrl_Actv );
    _mIgn_Veh_Stat_AR.RemSt_IgnCtrl_Info.phys = getValue( HMI_RemSt_IgnCtrl_Info );
    _mIgn_Veh_Stat_AR.RevGr_Engg.phys = getValue( HMI_RevGr_Engg );
    _mIgn_Veh_Stat_AR.SPCR_AcustWarn_Rq_EIS.phys = getValue( HMI_SPCR_AcustWarn_Rq_EIS );
    _mIgn_Veh_Stat_AR.SPCR_Conf_EIS.phys = getValue( HMI_SPCR_Conf_EIS );
    _mIgn_Veh_Stat_AR.SPCR_Flt_EIS.phys = getValue( HMI_SPCR_Flt_EIS );
    _mIgn_Veh_Stat_AR.TxPkPosn_Emg_Rq.phys = getValue( HMI_TxPkPosn_Emg_Rq );
    _mIgn_Veh_Stat_AR.TxPkPosn_Rq.phys = getValue( HMI_TxPkPosn_Rq );
    _mIgn_Veh_Stat_AR.TxPkPosn_Rq_SPCR_Enbl.phys = getValue( HMI_TxPkPosn_Rq_SPCR_Enbl );
    _mIgn_Veh_Stat_AR.TxPkPosnAuto_Enbl.phys = getValue( HMI_TxPkPosnAuto_Enbl );
    _mIgn_Veh_Stat_AR.Carwash_Actv_Rq.phys = getValue( HMI_Carwash_Actv_Rq );
}

Ign_Veh_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_Ign_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_Ign_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _Ign_Veh_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _Ign_Veh_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_Ign_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _Ign_Veh_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _Ign_Veh_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _Ign_Veh_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _Ign_Veh_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _Ign_Veh_Stat_AR_SQC_RepeatedCnt ) &&
            ( _Ign_Veh_Stat_AR_E2E_Armed == 1  )    )
        {
            _Ign_Veh_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_Ign_Stat, SQC_help );
    }
    _mIgn_Veh_Stat_AR.SQC_Ign_Stat = SQC_help;

    if( getValue( HMI_CRC_Ign_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_Ign_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mIgn_Veh_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mIgn_Veh_Stat_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mIgn_Veh_Stat_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mIgn_Veh_Stat_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mIgn_Veh_Stat_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mIgn_Veh_Stat_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mIgn_Veh_Stat_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mIgn_Veh_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _Ign_Veh_Stat_AR_CRC_Offset[ _mIgn_Veh_Stat_AR.SQC_Ign_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _Ign_Veh_Stat_AR_CRC_ErrorCnt   && ( _Ign_Veh_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Ign_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _Ign_Veh_Stat_AR_CRC_ErrorCnt > 0 )
                    _Ign_Veh_Stat_AR_CRC_ErrorCnt--; 
            }
            _mIgn_Veh_Stat_AR.CRC_Ign_Stat = crc;
            putValue( HMI_CRC_Ign_Stat, crc );
        }
        else
            _mIgn_Veh_Stat_AR.CRC_Ign_Stat = getValue( HMI_CRC_Ign_Stat );
    }
    else
    {
        if( !getValue( HMI_CRC_Ign_Stat_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mIgn_Veh_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mIgn_Veh_Stat_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mIgn_Veh_Stat_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mIgn_Veh_Stat_AR.byte( 3 ) ];
//            crc = crctable[ crc ^ _mIgn_Veh_Stat_AR.byte( 4 ) ];
//            crc = crctable[ crc ^ _mIgn_Veh_Stat_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mIgn_Veh_Stat_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mIgn_Veh_Stat_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _Ign_Veh_Stat_AR_CRC_ErrorCnt   && ( _Ign_Veh_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Ign_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _Ign_Veh_Stat_AR_CRC_ErrorCnt > 0 )
                    _Ign_Veh_Stat_AR_CRC_ErrorCnt--; 
            }
            _mIgn_Veh_Stat_AR.CRC_Ign_Stat = crc;
            putValue( HMI_CRC_Ign_Stat, crc );
        }
        else
            _mIgn_Veh_Stat_AR.CRC_Ign_Stat = getValue( HMI_CRC_Ign_Stat );
    }
    if( ( _Ign_Veh_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _Ign_Veh_Stat_AR_E2E_Armed == 1  )    )
    {
        _Ign_Veh_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mIgn_Veh_Stat_AR );
        
    if( _Ign_Veh_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _Ign_Veh_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _Ign_Veh_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _Ign_Veh_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _Ign_Veh_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _Ign_Veh_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_Ign_Stat_State, 0 );
        }
    }
}

Ign_Veh_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Ign_Veh_Stat_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Ign_Veh_Stat_AR := %X\n", getValue( HMI__STMSG_Ign_Veh_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Ign_Veh_Stat_AR := %X\n", getValue( HMI__STMSGT_Ign_Veh_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BusFlt_PrmntActv := %X\n", getValue( HMI_BusFlt_PrmntActv ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ContEngRun_Stat := %X\n", getValue( HMI_ContEngRun_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Ign_Stat := %X\n", getValue( HMI_CRC_Ign_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Ign_Stat_Auto := %X\n", getValue( HMI_CRC_Ign_Stat_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DidA_ExtTest_Pres := %X\n", getValue( HMI_DidA_ExtTest_Pres ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngSt_Enbl_Rq_KG := %X\n", getValue( HMI_EngSt_Enbl_Rq_KG ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ESL_Lk_Rq := %X\n", getValue( HMI_ESL_Lk_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Ign_On_StartProc_Inact := %X\n", getValue( HMI_Ign_On_StartProc_Inact ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ISw_Stat := %X\n", getValue( HMI_ISw_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KG_IgnCtrl_Actv := %X\n", getValue( HMI_KG_IgnCtrl_Actv ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KG_StartSw_Psd := %X\n", getValue( HMI_KG_StartSw_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mobile_Chrg_Rq_EIS := %X\n", getValue( HMI_Mobile_Chrg_Rq_EIS ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RemSt_IgnCtrl_Actv := %X\n", getValue( HMI_RemSt_IgnCtrl_Actv ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RemSt_IgnCtrl_Info := %X\n", getValue( HMI_RemSt_IgnCtrl_Info ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RevGr_Engg := %X\n", getValue( HMI_RevGr_Engg ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPCR_AcustWarn_Rq_EIS := %X\n", getValue( HMI_SPCR_AcustWarn_Rq_EIS ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPCR_Conf_EIS := %X\n", getValue( HMI_SPCR_Conf_EIS ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPCR_Flt_EIS := %X\n", getValue( HMI_SPCR_Flt_EIS ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Ign_Stat := %X\n", getValue( HMI_SQC_Ign_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Ign_Stat_Auto := %X\n", getValue( HMI_SQC_Ign_Stat_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TxPkPosn_Emg_Rq := %X\n", getValue( HMI_TxPkPosn_Emg_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TxPkPosn_Rq := %X\n", getValue( HMI_TxPkPosn_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TxPkPosn_Rq_SPCR_Enbl := %X\n", getValue( HMI_TxPkPosn_Rq_SPCR_Enbl ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TxPkPosnAuto_Enbl := %X\n", getValue( HMI_TxPkPosnAuto_Enbl ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Carwash_Actv_Rq := %X\n", getValue( HMI_Carwash_Actv_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tIgn_Veh_Stat_AR
{
    putValue( HMI__STMSG_Ign_Veh_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_Ign_Veh_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Ign_Veh_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tIgn_Veh_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_Ign_Veh_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Ign_Veh_Stat_AR
{
    if( getValue( this ) )
        openPanel("Ign_Veh_Stat_AR");
}

on envVar HMI_E2E_Ign_Stat_Inject
{
    if( getValue( this ) )
    {
        _Ign_Veh_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_Ign_Stat_ErrorCount );
        _Ign_Veh_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_Ign_Stat_TriggerPosition );
        _Ign_Veh_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_Ign_Stat_WrongSeq );
        _Ign_Veh_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_Ign_Stat_Repeated );
        _Ign_Veh_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_Ign_Stat_MSG_DropCnt );
        putValue( HMI_E2E_Ign_Stat_State, 2 );
        _Ign_Veh_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_BusFlt_PrmntActv
{
    _mIgn_Veh_Stat_AR.BusFlt_PrmntActv.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ContEngRun_Stat
{
    _mIgn_Veh_Stat_AR.ContEngRun_Stat.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DidA_ExtTest_Pres
{
    _mIgn_Veh_Stat_AR.DidA_ExtTest_Pres.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_EngSt_Enbl_Rq_KG
{
    _mIgn_Veh_Stat_AR.EngSt_Enbl_Rq_KG.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ESL_Lk_Rq
{
    _mIgn_Veh_Stat_AR.ESL_Lk_Rq.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Ign_On_StartProc_Inact
{
    _mIgn_Veh_Stat_AR.Ign_On_StartProc_Inact.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ISw_Stat
{
    byte temp;   //actual ISw_stat
    temp = getValue( this );
    if( temp == 0)
    {
        if( getValue( HMI__NM_EIS_AutomaticModeActive ) == 1 )
        {
        cancelTimer( t_KeyInLockNMCancelTimer );
        _SetCommRequest( cIgnitionNMRequest );
        setTimer( t_KeyInLockNMCancelTimer, c_NMCancelTimer_05sec );
        //write("HJH:_tKeyInLockNMCancelTimer : armed, ISw_Stat = %d", temp );
        }
    }
    if( temp == 1 )
    {
        if( getValue( HMI__NM_EIS_AutomaticModeActive ) == 1 )
        {
        cancelTimer( t_KeyInLockNMCancelTimer );
        _SetCommRequest( cIgnitionNMRequest );
        setTimer( t_KeyInLockNMCancelTimer, c_NMCancelTimer_05sec );
        //write("HJH:_tKeyInLockNMCancelTimer : armed, ISw_Stat = %d", temp );
        }
    }
    if( temp == 2)
    {
        if( getValue( HMI__NM_EIS_AutomaticModeActive ) == 1 )
        {
        cancelTimer( t_KeyInLockNMCancelTimer );
        //write("HJH:_tKeyInLockNMCancelTimer : canceled, ISw_Stat = %d", temp );
        _SetCommRequest( cIgnitionNMRequest );
        }
    }
    if( temp == 4 )
    {
        if( getValue( HMI__NM_EIS_AutomaticModeActive ) == 1 )
        {
        cancelTimer( t_KeyInLockNMCancelTimer );
        //write("HJH:_tKeyInLockNMCancelTimer : canceled, ISw_Stat = %d", temp );
        _SetCommRequest( cIgnitionNMRequest );
        }
    }
    if( temp == 5 )
    {
        if( getValue( HMI__NM_EIS_AutomaticModeActive ) == 1 )
        {
        cancelTimer( t_KeyInLockNMCancelTimer );
        //write("HJH:_tKeyInLockNMCancelTimer : canceled, ISw_Stat = %d", temp );
        _SetCommRequest( cIgnitionNMRequest );
        }
    }
    if( temp == 3)
    {
        _ReleaseCommRequest( cIgnitionNMRequest );
    }
    if( temp == 6)
    {
        _ReleaseCommRequest( cIgnitionNMRequest );
    }
    if( temp == 7)
    {
        _ReleaseCommRequest( cIgnitionNMRequest );
    }
    _mIgn_Veh_Stat_AR.ISw_Stat.phys = temp;
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_KG_IgnCtrl_Actv
{
    _mIgn_Veh_Stat_AR.KG_IgnCtrl_Actv.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_KG_StartSw_Psd
{
    _mIgn_Veh_Stat_AR.KG_StartSw_Psd.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Mobile_Chrg_Rq_EIS
{
    _mIgn_Veh_Stat_AR.Mobile_Chrg_Rq_EIS.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_RemSt_IgnCtrl_Actv
{
    _mIgn_Veh_Stat_AR.RemSt_IgnCtrl_Actv.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_RemSt_IgnCtrl_Info
{
    _mIgn_Veh_Stat_AR.RemSt_IgnCtrl_Info.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_RevGr_Engg
{
    _mIgn_Veh_Stat_AR.RevGr_Engg.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPCR_AcustWarn_Rq_EIS
{
    _mIgn_Veh_Stat_AR.SPCR_AcustWarn_Rq_EIS.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPCR_Conf_EIS
{
    _mIgn_Veh_Stat_AR.SPCR_Conf_EIS.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPCR_Flt_EIS
{
    _mIgn_Veh_Stat_AR.SPCR_Flt_EIS.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_TxPkPosn_Emg_Rq
{
    _mIgn_Veh_Stat_AR.TxPkPosn_Emg_Rq.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_TxPkPosn_Rq
{
    _mIgn_Veh_Stat_AR.TxPkPosn_Rq.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_TxPkPosn_Rq_SPCR_Enbl
{
    _mIgn_Veh_Stat_AR.TxPkPosn_Rq_SPCR_Enbl.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_TxPkPosnAuto_Enbl
{
    _mIgn_Veh_Stat_AR.TxPkPosnAuto_Enbl.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Carwash_Actv_Rq
{
    _mIgn_Veh_Stat_AR.Carwash_Actv_Rq.phys = getValue(this);
    _Ign_Veh_Stat_AR_SpontanFlag = 1;
}

IHC_Lgt_Stat_MPC_AR_check_output()
{
    if( !getValue( HMI__STMSG_IHC_Lgt_Stat_MPC_AR ) )
    {
    //  message   IHC_Lgt_Stat_MPC_AR ID: 551 --- Sendeart 0 cyclicX --- 
        _IHC_Lgt_Stat_MPC_AR_Cnt--;
        if( _IHC_Lgt_Stat_MPC_AR_Cnt < 1 )
        {
            IHC_Lgt_Stat_MPC_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _IHC_Lgt_Stat_MPC_AR_Cnt = _IHC_Lgt_Stat_MPC_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

IHC_Lgt_Stat_MPC_AR_init()
{   /* Botschaft IHC_Lgt_Stat_MPC_AR ID: 551 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 551 0;
BA_ "NmAsrMessage" BO_ 551 0;
BA_ "GenMsgMinAcceptLength" BO_ 551 8;
BA_ "GenMsgILSupport" BO_ 551 1;
BA_ "DiagState" BO_ 551 0;
BA_ "DiagRequest" BO_ 551 0;
BA_ "DiagResponse" BO_ 551 0;
BA_ "GenMsgStartValue" BO_ 551 "0";
BA_ "GenMsgCycleTime" BO_ 551 40;
BA_ "GenMsgSendType" BO_ 551 0;
    */
    _IHC_Lgt_Stat_MPC_AR_Timebase =           c_tDBKomTimer_20ms;
    _IHC_Lgt_Stat_MPC_AR_CycleCount =        40 / _IHC_Lgt_Stat_MPC_AR_Timebase;
    _IHC_Lgt_Stat_MPC_AR_StartDelay =         0 / _IHC_Lgt_Stat_MPC_AR_Timebase;
    _IHC_Lgt_Stat_MPC_AR_Cnt = _IHC_Lgt_Stat_MPC_AR_StartDelay;

    putValue( HMI__STMSGSD_IHC_Lgt_Stat_MPC_AR, _IHC_Lgt_Stat_MPC_AR_StartDelay * _IHC_Lgt_Stat_MPC_AR_Timebase );
    
    _mIHC_Lgt_Stat_MPC_AR.IHC_Block_Disp_Rq.phys = getValue( HMI_IHC_Block_Disp_Rq__IHC_Lgt_Stat );
    _mIHC_Lgt_Stat_MPC_AR.IHC_Brt_Outsd.phys = getValue( HMI_IHC_Brt_Outsd );
    _mIHC_Lgt_Stat_MPC_AR.IHC_ChgovrLvl_V2.phys = getValue( HMI_IHC_ChgovrLvl_V2 );
    _mIHC_Lgt_Stat_MPC_AR.IHC_City_Dtct.phys = getValue( HMI_IHC_City_Dtct );
    _mIHC_Lgt_Stat_MPC_AR.IHC_DrvDir.phys = getValue( HMI_IHC_DrvDir );
    _mIHC_Lgt_Stat_MPC_AR.IHC_HiBm_Stat.phys = getValue( HMI_IHC_HiBm_Stat );
    _mIHC_Lgt_Stat_MPC_AR.IHC_LgtDist_Rq.phys = getValue( HMI_IHC_LgtDist_Rq );
    _mIHC_Lgt_Stat_MPC_AR.IHC_MotorWay_Dtct.phys = getValue( HMI_IHC_MotorWay_Dtct );
    _mIHC_Lgt_Stat_MPC_AR.IHC_ObjAngl.phys = getValue( HMI_IHC_ObjAngl );
    _mIHC_Lgt_Stat_MPC_AR.IHC_OptHdLgtLvl_Stat.phys = getValue( HMI_IHC_OptHdLgtLvl_Stat );
    _mIHC_Lgt_Stat_MPC_AR.IHC_Plus_HL_Lt_LgtOut_V2.phys = getValue( HMI_IHC_Plus_HL_Lt_LgtOut_V2 );
    _mIHC_Lgt_Stat_MPC_AR.IHC_Plus_HL_Rt_LgtOut_V2.phys = getValue( HMI_IHC_Plus_HL_Rt_LgtOut_V2 );
    _mIHC_Lgt_Stat_MPC_AR.IHC_Stat_MPC.phys = getValue( HMI_IHC_Stat_MPC );
    _mIHC_Lgt_Stat_MPC_AR.IHC_TrffcStyle.phys = getValue( HMI_IHC_TrffcStyle );
    _mIHC_Lgt_Stat_MPC_AR.IHC_Tunnel.phys = getValue( HMI_IHC_Tunnel );
    _mIHC_Lgt_Stat_MPC_AR.IHC_WShHt_Rq_Stat.phys = getValue( HMI_IHC_WShHt_Rq_Stat );
    _mIHC_Lgt_Stat_MPC_AR.IHC_Wthr_Dtct.phys = getValue( HMI_IHC_Wthr_Dtct );
}

IHC_Lgt_Stat_MPC_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_IHC_Lgt_Stat_MPC ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_IHC_Lgt_Stat_MPC_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _IHC_Lgt_Stat_MPC_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _IHC_Lgt_Stat_MPC_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_IHC_Lgt_Stat_MPC_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _IHC_Lgt_Stat_MPC_AR_SQC_WrongSeqJump != 0 ) &&
            ( _IHC_Lgt_Stat_MPC_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _IHC_Lgt_Stat_MPC_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _IHC_Lgt_Stat_MPC_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _IHC_Lgt_Stat_MPC_AR_SQC_RepeatedCnt ) &&
            ( _IHC_Lgt_Stat_MPC_AR_E2E_Armed == 1  )    )
        {
            _IHC_Lgt_Stat_MPC_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_IHC_Lgt_Stat_MPC, SQC_help );
    }
    _mIHC_Lgt_Stat_MPC_AR.SQC_IHC_Lgt_Stat_MPC = SQC_help;

    if( getValue( HMI_CRC_IHC_Lgt_Stat_MPC_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_IHC_Lgt_Stat_MPC_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mIHC_Lgt_Stat_MPC_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mIHC_Lgt_Stat_MPC_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mIHC_Lgt_Stat_MPC_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mIHC_Lgt_Stat_MPC_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mIHC_Lgt_Stat_MPC_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mIHC_Lgt_Stat_MPC_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mIHC_Lgt_Stat_MPC_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mIHC_Lgt_Stat_MPC_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _IHC_Lgt_Stat_MPC_AR_CRC_Offset[ _mIHC_Lgt_Stat_MPC_AR.SQC_IHC_Lgt_Stat_MPC ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _IHC_Lgt_Stat_MPC_AR_CRC_ErrorCnt   && ( _IHC_Lgt_Stat_MPC_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_IHC_Lgt_Stat_MPC_Invalid )                                         )    )
            {
                crc++;
                if( _IHC_Lgt_Stat_MPC_AR_CRC_ErrorCnt > 0 )
                    _IHC_Lgt_Stat_MPC_AR_CRC_ErrorCnt--; 
            }
            _mIHC_Lgt_Stat_MPC_AR.CRC_IHC_Lgt_Stat_MPC = crc;
            putValue( HMI_CRC_IHC_Lgt_Stat_MPC, crc );
        }
        else
            _mIHC_Lgt_Stat_MPC_AR.CRC_IHC_Lgt_Stat_MPC = getValue( HMI_CRC_IHC_Lgt_Stat_MPC );
    }
    else
    {
        if( !getValue( HMI_CRC_IHC_Lgt_Stat_MPC_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mIHC_Lgt_Stat_MPC_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mIHC_Lgt_Stat_MPC_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mIHC_Lgt_Stat_MPC_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mIHC_Lgt_Stat_MPC_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mIHC_Lgt_Stat_MPC_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mIHC_Lgt_Stat_MPC_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mIHC_Lgt_Stat_MPC_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mIHC_Lgt_Stat_MPC_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _IHC_Lgt_Stat_MPC_AR_CRC_ErrorCnt   && ( _IHC_Lgt_Stat_MPC_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_IHC_Lgt_Stat_MPC_Invalid )                                         )    )
            {
                crc++;
                if( _IHC_Lgt_Stat_MPC_AR_CRC_ErrorCnt > 0 )
                    _IHC_Lgt_Stat_MPC_AR_CRC_ErrorCnt--; 
            }
            _mIHC_Lgt_Stat_MPC_AR.CRC_IHC_Lgt_Stat_MPC = crc;
            putValue( HMI_CRC_IHC_Lgt_Stat_MPC, crc );
        }
        else
            _mIHC_Lgt_Stat_MPC_AR.CRC_IHC_Lgt_Stat_MPC = getValue( HMI_CRC_IHC_Lgt_Stat_MPC );
    }
    if( ( _IHC_Lgt_Stat_MPC_AR_MSG_DropCnt > 0 ) &&
        ( _IHC_Lgt_Stat_MPC_AR_E2E_Armed == 1  )    )
    {
        _IHC_Lgt_Stat_MPC_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mIHC_Lgt_Stat_MPC_AR );
        
    if( _IHC_Lgt_Stat_MPC_AR_E2E_Armed == 1 )
    {
        if ( ( _IHC_Lgt_Stat_MPC_AR_MSG_DropCnt == 0      ) &&
             ( _IHC_Lgt_Stat_MPC_AR_CRC_ErrorCnt == 0     ) &&
             ( _IHC_Lgt_Stat_MPC_AR_SQC_RepeatedCnt == 0  ) &&
             ( _IHC_Lgt_Stat_MPC_AR_SQC_WrongSeqJump == 0 )    )
        {
            _IHC_Lgt_Stat_MPC_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_IHC_Lgt_Stat_MPC_State, 0 );
        }
    }
}

IHC_Lgt_Stat_MPC_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: IHC_Lgt_Stat_MPC_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_IHC_Lgt_Stat_MPC := %X\n", getValue( HMI__STMSG_IHC_Lgt_Stat_MPC_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_IHC_Lgt_Stat_MPC := %X\n", getValue( HMI__STMSGT_IHC_Lgt_Stat_MPC_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_IHC_Lgt_Stat_MPC := %X\n", getValue( HMI_CRC_IHC_Lgt_Stat_MPC ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_IHC_Lgt_Stat_MPC_Auto := %X\n", getValue( HMI_CRC_IHC_Lgt_Stat_MPC_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_Block_Disp_Rq__IHC_Lgt_Stat := %X\n", getValue( HMI_IHC_Block_Disp_Rq__IHC_Lgt_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_Brt_Outsd := %X\n", getValue( HMI_IHC_Brt_Outsd ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_ChgovrLvl_V2 := %X\n", getValue( HMI_IHC_ChgovrLvl_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_City_Dtct := %X\n", getValue( HMI_IHC_City_Dtct ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_DrvDir := %X\n", getValue( HMI_IHC_DrvDir ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_HiBm_Stat := %X\n", getValue( HMI_IHC_HiBm_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_LgtDist_Rq := %X\n", getValue( HMI_IHC_LgtDist_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_MotorWay_Dtct := %X\n", getValue( HMI_IHC_MotorWay_Dtct ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_ObjAngl := %X\n", getValue( HMI_IHC_ObjAngl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_OptHdLgtLvl_Stat := %X\n", getValue( HMI_IHC_OptHdLgtLvl_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_Plus_HL_Lt_LgtOut_V2 := %X\n", getValue( HMI_IHC_Plus_HL_Lt_LgtOut_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_Plus_HL_Rt_LgtOut_V2 := %X\n", getValue( HMI_IHC_Plus_HL_Rt_LgtOut_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_Stat_MPC := %X\n", getValue( HMI_IHC_Stat_MPC ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_TrffcStyle := %X\n", getValue( HMI_IHC_TrffcStyle ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_Tunnel := %X\n", getValue( HMI_IHC_Tunnel ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_WShHt_Rq_Stat := %X\n", getValue( HMI_IHC_WShHt_Rq_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_Wthr_Dtct := %X\n", getValue( HMI_IHC_Wthr_Dtct ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_IHC_Lgt_Stat_MPC := %X\n", getValue( HMI_SQC_IHC_Lgt_Stat_MPC ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_IHC_Lgt_Stat_MPC_Auto := %X\n", getValue( HMI_SQC_IHC_Lgt_Stat_MPC_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tIHC_Lgt_Stat_MPC_AR
{
    putValue( HMI__STMSG_IHC_Lgt_Stat_MPC_AR, 0 );
}

on EnvVar HMI__STMSG_IHC_Lgt_Stat_MPC_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_IHC_Lgt_Stat_MPC_AR );
        if( tDelay > 0)    
            setTimer( _tIHC_Lgt_Stat_MPC_AR, tDelay );
        else
            putValue( HMI__STMSG_IHC_Lgt_Stat_MPC_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_IHC_Lgt_Stat_MPC_AR
{
    if( getValue( this ) )
        openPanel("IHC_Lgt_Stat_MPC_AR");
}

on envVar HMI_E2E_IHC_Lgt_Stat_MPC_Inject
{
    if( getValue( this ) )
    {
        _IHC_Lgt_Stat_MPC_AR_CRC_ErrorCnt = getValue( HMI_CRC_IHC_Lgt_Stat_MPC_ErrorCount );
        _IHC_Lgt_Stat_MPC_AR_SQC_TriggPos = getValue( HMI_SQC_IHC_Lgt_Stat_MPC_TriggerPosition );
        _IHC_Lgt_Stat_MPC_AR_SQC_WrongSeqJump = getValue( HMI_SQC_IHC_Lgt_Stat_MPC_WrongSeq );
        _IHC_Lgt_Stat_MPC_AR_SQC_RepeatedCnt = getValue( HMI_SQC_IHC_Lgt_Stat_MPC_Repeated );
        _IHC_Lgt_Stat_MPC_AR_MSG_DropCnt = getValue( HMI_SQC_IHC_Lgt_Stat_MPC_MSG_DropCnt );
        putValue( HMI_E2E_IHC_Lgt_Stat_MPC_State, 2 );
        _IHC_Lgt_Stat_MPC_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_IHC_Block_Disp_Rq__IHC_Lgt_Stat
{
    _mIHC_Lgt_Stat_MPC_AR.IHC_Block_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_IHC_Brt_Outsd
{
    _mIHC_Lgt_Stat_MPC_AR.IHC_Brt_Outsd.phys = getValue(this);
}

on EnvVar HMI_IHC_ChgovrLvl_V2
{
    _mIHC_Lgt_Stat_MPC_AR.IHC_ChgovrLvl_V2.phys = getValue(this);
}

on EnvVar HMI_IHC_City_Dtct
{
    _mIHC_Lgt_Stat_MPC_AR.IHC_City_Dtct.phys = getValue(this);
}

on EnvVar HMI_IHC_DrvDir
{
    _mIHC_Lgt_Stat_MPC_AR.IHC_DrvDir.phys = getValue(this);
}

on EnvVar HMI_IHC_HiBm_Stat
{
    _mIHC_Lgt_Stat_MPC_AR.IHC_HiBm_Stat.phys = getValue(this);
}

on EnvVar HMI_IHC_LgtDist_Rq
{
    _mIHC_Lgt_Stat_MPC_AR.IHC_LgtDist_Rq.phys = getValue(this);
}

on EnvVar HMI_IHC_MotorWay_Dtct
{
    _mIHC_Lgt_Stat_MPC_AR.IHC_MotorWay_Dtct.phys = getValue(this);
}

on EnvVar HMI_IHC_ObjAngl
{
    _mIHC_Lgt_Stat_MPC_AR.IHC_ObjAngl.phys = getValue(this);
}

on EnvVar HMI_IHC_OptHdLgtLvl_Stat
{
    _mIHC_Lgt_Stat_MPC_AR.IHC_OptHdLgtLvl_Stat.phys = getValue(this);
}

on EnvVar HMI_IHC_Plus_HL_Lt_LgtOut_V2
{
    _mIHC_Lgt_Stat_MPC_AR.IHC_Plus_HL_Lt_LgtOut_V2.phys = getValue(this);
}

on EnvVar HMI_IHC_Plus_HL_Rt_LgtOut_V2
{
    _mIHC_Lgt_Stat_MPC_AR.IHC_Plus_HL_Rt_LgtOut_V2.phys = getValue(this);
}

on EnvVar HMI_IHC_Stat_MPC
{
    _mIHC_Lgt_Stat_MPC_AR.IHC_Stat_MPC.phys = getValue(this);
}

on EnvVar HMI_IHC_TrffcStyle
{
    _mIHC_Lgt_Stat_MPC_AR.IHC_TrffcStyle.phys = getValue(this);
}

on EnvVar HMI_IHC_Tunnel
{
    _mIHC_Lgt_Stat_MPC_AR.IHC_Tunnel.phys = getValue(this);
}

on EnvVar HMI_IHC_WShHt_Rq_Stat
{
    _mIHC_Lgt_Stat_MPC_AR.IHC_WShHt_Rq_Stat.phys = getValue(this);
}

on EnvVar HMI_IHC_Wthr_Dtct
{
    _mIHC_Lgt_Stat_MPC_AR.IHC_Wthr_Dtct.phys = getValue(this);
}

IL_AmbLgt_Disp_AR_check_output()
{
    if( !getValue( HMI__STMSG_IL_AmbLgt_Disp_AR ) )
    {
    //  message   IL_AmbLgt_Disp_AR ID: 1067 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _IL_AmbLgt_Disp_AR_Cnt--;
        if( _IL_AmbLgt_Disp_AR_Cnt < 1 )
        {
            IL_AmbLgt_Disp_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _IL_AmbLgt_Disp_AR_Cnt = _IL_AmbLgt_Disp_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _IL_AmbLgt_Disp_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _IL_AmbLgt_Disp_AR_SpontanFlag)
        {
            IL_AmbLgt_Disp_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _IL_AmbLgt_Disp_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

IL_AmbLgt_Disp_AR_init()
{   /* Botschaft IL_AmbLgt_Disp_AR ID: 1067 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1067 0;
BA_ "NmAsrMessage" BO_ 1067 0;
BA_ "GenMsgMinAcceptLength" BO_ 1067 8;
BA_ "GenMsgILSupport" BO_ 1067 1;
BA_ "DiagState" BO_ 1067 0;
BA_ "DiagRequest" BO_ 1067 0;
BA_ "DiagResponse" BO_ 1067 0;
BA_ "GenMsgStartValue" BO_ 1067 "0";
BA_ "GenMsgStartDelayTime" BO_ 1067 0;
BA_ "GenMsgDelayTime" BO_ 1067 5;
BA_ "GenMsgNrOfRepetitions" BO_ 1067 0;
BA_ "GenMsgCycleTime" BO_ 1067 1000;
BA_ "GenMsgSendType" BO_ 1067 5;
    */
    _IL_AmbLgt_Disp_AR_Timebase =           c_tDBKomTimer_20ms;
    _IL_AmbLgt_Disp_AR_CycleCount =      1000 / _IL_AmbLgt_Disp_AR_Timebase;
    _IL_AmbLgt_Disp_AR_StartDelay =         0 / _IL_AmbLgt_Disp_AR_Timebase;
    _IL_AmbLgt_Disp_AR_Cnt = _IL_AmbLgt_Disp_AR_StartDelay;
    _IL_AmbLgt_Disp_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_IL_AmbLgt_Disp_AR, _IL_AmbLgt_Disp_AR_StartDelay * _IL_AmbLgt_Disp_AR_Timebase );

    _mIL_AmbLgt_Disp_AR.AmbBrt_Disp1.phys = getValue( HMI_AmbBrt_Disp1 );
    _mIL_AmbLgt_Disp_AR.AmbBrt_Disp2.phys = getValue( HMI_AmbBrt_Disp2 );
    _mIL_AmbLgt_Disp_AR.AmbBrt_Disp3.phys = getValue( HMI_AmbBrt_Disp3 );
    _mIL_AmbLgt_Disp_AR.DrHdl_Brt_F.phys = getValue( HMI_DrHdl_Brt_F );
    _mIL_AmbLgt_Disp_AR.DrHdl_Brt_R.phys = getValue( HMI_DrHdl_Brt_R );
}

IL_AmbLgt_Disp_AR_output(void)
{
    output( _mIL_AmbLgt_Disp_AR );
}

IL_AmbLgt_Disp_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: IL_AmbLgt_Disp_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_IL_AmbLgt_Disp_AR := %X\n", getValue( HMI__STMSG_IL_AmbLgt_Disp_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_IL_AmbLgt_Disp_AR := %X\n", getValue( HMI__STMSGT_IL_AmbLgt_Disp_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AmbBrt_Disp1 := %f\n", getValue( HMI_AmbBrt_Disp1 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AmbBrt_Disp2 := %f\n", getValue( HMI_AmbBrt_Disp2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AmbBrt_Disp3 := %f\n", getValue( HMI_AmbBrt_Disp3 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrHdl_Brt_F := %f\n", getValue( HMI_DrHdl_Brt_F ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrHdl_Brt_R := %f\n", getValue( HMI_DrHdl_Brt_R ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tIL_AmbLgt_Disp_AR
{
    putValue( HMI__STMSG_IL_AmbLgt_Disp_AR, 0 );
}

on EnvVar HMI__STMSG_IL_AmbLgt_Disp_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_IL_AmbLgt_Disp_AR );
        if( tDelay > 0)    
            setTimer( _tIL_AmbLgt_Disp_AR, tDelay );
        else
            putValue( HMI__STMSG_IL_AmbLgt_Disp_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_IL_AmbLgt_Disp_AR
{
    if( getValue( this ) )
        openPanel("IL_AmbLgt_Disp_AR");
}

on EnvVar HMI_AmbBrt_Disp1
{
    _mIL_AmbLgt_Disp_AR.AmbBrt_Disp1.phys = getValue(this);
    _IL_AmbLgt_Disp_AR_SpontanFlag = 1;
}

on EnvVar HMI_AmbBrt_Disp2
{
    _mIL_AmbLgt_Disp_AR.AmbBrt_Disp2.phys = getValue(this);
    _IL_AmbLgt_Disp_AR_SpontanFlag = 1;
}

on EnvVar HMI_AmbBrt_Disp3
{
    _mIL_AmbLgt_Disp_AR.AmbBrt_Disp3.phys = getValue(this);
    _IL_AmbLgt_Disp_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrHdl_Brt_F
{
    _mIL_AmbLgt_Disp_AR.DrHdl_Brt_F.phys = getValue(this);
    _IL_AmbLgt_Disp_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrHdl_Brt_R
{
    _mIL_AmbLgt_Disp_AR.DrHdl_Brt_R.phys = getValue(this);
    _IL_AmbLgt_Disp_AR_SpontanFlag = 1;
}

IL_AmbLgtCfg_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_IL_AmbLgtCfg_Stat_AR ) )
    {
    //  message   IL_AmbLgtCfg_Stat_AR ID: 842 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _IL_AmbLgtCfg_Stat_AR_Cnt--;
        if( _IL_AmbLgtCfg_Stat_AR_Cnt < 1 )
        {
            IL_AmbLgtCfg_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _IL_AmbLgtCfg_Stat_AR_Cnt = _IL_AmbLgtCfg_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _IL_AmbLgtCfg_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _IL_AmbLgtCfg_Stat_AR_SpontanFlag )
        {
            IL_AmbLgtCfg_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _IL_AmbLgtCfg_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

IL_AmbLgtCfg_Stat_AR_init()
{   /* Botschaft IL_AmbLgtCfg_Stat_AR ID: 842 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 842 0;
BA_ "NmAsrMessage" BO_ 842 0;
BA_ "GenMsgMinAcceptLength" BO_ 842 8;
BA_ "GenMsgILSupport" BO_ 842 1;
BA_ "DiagState" BO_ 842 0;
BA_ "DiagRequest" BO_ 842 0;
BA_ "DiagResponse" BO_ 842 0;
BA_ "GenMsgStartValue" BO_ 842 "0";
BA_ "GenMsgDelayTime" BO_ 842 5;
BA_ "GenMsgNrOfRepetitions" BO_ 842 0;
BA_ "GenMsgCycleTime" BO_ 842 1000;
BA_ "GenMsgSendType" BO_ 842 5;
    */
    _IL_AmbLgtCfg_Stat_AR_Timebase =           c_tDBKomTimer_20ms;
    _IL_AmbLgtCfg_Stat_AR_CycleCount =      1000 / _IL_AmbLgtCfg_Stat_AR_Timebase;
    _IL_AmbLgtCfg_Stat_AR_StartDelay =         0 / _IL_AmbLgtCfg_Stat_AR_Timebase;
    _IL_AmbLgtCfg_Stat_AR_Cnt = _IL_AmbLgtCfg_Stat_AR_StartDelay;
    _IL_AmbLgtCfg_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_IL_AmbLgtCfg_Stat_AR, _IL_AmbLgtCfg_Stat_AR_StartDelay * _IL_AmbLgtCfg_Stat_AR_Timebase );

    _mIL_AmbLgtCfg_Stat_AR.AmbLgtCfg_01_Stat.phys = getValue( HMI_AmbLgtCfg_01_Stat );
    _mIL_AmbLgtCfg_Stat_AR.AmbLgtCfg_02_Stat.phys = getValue( HMI_AmbLgtCfg_02_Stat );
    _mIL_AmbLgtCfg_Stat_AR.AmbLgtColor_Stat_V2.phys = getValue( HMI_AmbLgtColor_Stat_V2 );
    _mIL_AmbLgtCfg_Stat_AR.AmbLgtColProg_Stat.phys = getValue( HMI_AmbLgtColProg_Stat );  
    _mIL_AmbLgtCfg_Stat_AR.AmbLgtColorDesign_Rq.phys = getValue( HMI_AmbLgtColorDesign_Rq );
    _mIL_AmbLgtCfg_Stat_AR.AmbLgtColTmToChg_Rq.phys = getValue( HMI_AmbLgtColTmToChg_Rq );
}

IL_AmbLgtCfg_Stat_AR_output(void)
{
    output( _mIL_AmbLgtCfg_Stat_AR );
}

IL_AmbLgtCfg_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: IL_AmbLgtCfg_Stat_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_IL_AmbLgtCfg_Stat_AR := %X\n", getValue( HMI__STMSG_IL_AmbLgtCfg_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_IL_AmbLgtCfg_Stat_AR := %X\n", getValue( HMI__STMSGT_IL_AmbLgtCfg_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AmbLgtCfg_01_Stat := %X\n", getValue( HMI_AmbLgtCfg_01_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AmbLgtCfg_02_Stat := %X\n", getValue( HMI_AmbLgtCfg_02_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AmbLgtColor_Stat_V2 := %X\n", getValue( HMI_AmbLgtColor_Stat_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AmbLgtColorDesign_Rq := %X\n", getValue( HMI_AmbLgtColorDesign_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AmbLgtColTmToChg_Rq := %X\n", getValue( HMI_AmbLgtColTmToChg_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AmbLgtColProg_Stat := %X\n", getValue( HMI_AmbLgtColProg_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tIL_AmbLgtCfg_Stat_AR
{
    putValue( HMI__STMSG_IL_AmbLgtCfg_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_IL_AmbLgtCfg_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_IL_AmbLgtCfg_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tIL_AmbLgtCfg_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_IL_AmbLgtCfg_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_IL_AmbLgtCfg_Stat_AR
{
    if( getValue( this ) )
        openPanel("IL_AmbLgtCfg_Stat_AR");
}

on EnvVar HMI_AmbLgtCfg_01_Stat
{
    _mIL_AmbLgtCfg_Stat_AR.AmbLgtCfg_01_Stat.phys = getValue(this);
    _IL_AmbLgtCfg_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_AmbLgtCfg_02_Stat
{
    _mIL_AmbLgtCfg_Stat_AR.AmbLgtCfg_02_Stat.phys = getValue(this);
    _IL_AmbLgtCfg_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_AmbLgtColor_Stat_V2
{
    _mIL_AmbLgtCfg_Stat_AR.AmbLgtColor_Stat_V2.phys = getValue(this);
    _IL_AmbLgtCfg_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_AmbLgtColProg_Stat
{
    _mIL_AmbLgtCfg_Stat_AR.AmbLgtColProg_Stat.phys = getValue(this);
    _IL_AmbLgtCfg_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_AmbLgtColorDesign_Rq
{
    _mIL_AmbLgtCfg_Stat_AR.AmbLgtColorDesign_Rq.phys = getValue(this);
    _IL_AmbLgtCfg_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_AmbLgtColTmToChg_Rq
{
    _mIL_AmbLgtCfg_Stat_AR.AmbLgtColTmToChg_Rq.phys = getValue(this);
    _IL_AmbLgtCfg_Stat_AR_SpontanFlag = 1;
}

IL_AmbLgtCfg_Stat2_AR_check_output()
{
    if( !getValue( HMI__STMSG_IL_AmbLgtCfg_Stat2_AR ) )
    {
    //  message   IL_AmbLgtCfg_Stat2_AR ID: 846 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _IL_AmbLgtCfg_Stat2_AR_Cnt--;
        if( _IL_AmbLgtCfg_Stat2_AR_Cnt < 1 )
        {
            IL_AmbLgtCfg_Stat2_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _IL_AmbLgtCfg_Stat2_AR_Cnt = _IL_AmbLgtCfg_Stat2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _IL_AmbLgtCfg_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _IL_AmbLgtCfg_Stat2_AR_SpontanFlag )
        {
            IL_AmbLgtCfg_Stat2_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _IL_AmbLgtCfg_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

IL_AmbLgtCfg_Stat2_AR_init()
{   /* Botschaft IL_AmbLgtCfg_Stat2_AR ID: 846 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 846 0;
BA_ "NmAsrMessage" BO_ 846 0;
BA_ "GenMsgMinAcceptLength" BO_ 846 8;
BA_ "GenMsgILSupport" BO_ 846 1;
BA_ "DiagState" BO_ 846 0;
BA_ "DiagRequest" BO_ 846 0;
BA_ "DiagResponse" BO_ 846 0;
BA_ "GenMsgStartValue" BO_ 846 "0";
BA_ "GenMsgDelayTime" BO_ 846 5;
BA_ "GenMsgNrOfRepetitions" BO_ 846 0;
BA_ "GenMsgCycleTime" BO_ 846 1000;
BA_ "GenMsgSendType" BO_ 846 5;
    */
    _IL_AmbLgtCfg_Stat2_AR_Timebase =           c_tDBKomTimer_20ms;
    _IL_AmbLgtCfg_Stat2_AR_CycleCount =      1000 / _IL_AmbLgtCfg_Stat2_AR_Timebase;
    _IL_AmbLgtCfg_Stat2_AR_StartDelay =         0 / _IL_AmbLgtCfg_Stat2_AR_Timebase;
    _IL_AmbLgtCfg_Stat2_AR_Cnt = _IL_AmbLgtCfg_Stat2_AR_StartDelay;
    _IL_AmbLgtCfg_Stat2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_IL_AmbLgtCfg_Stat2_AR, _IL_AmbLgtCfg_Stat2_AR_StartDelay * _IL_AmbLgtCfg_Stat2_AR_Timebase );

    _mIL_AmbLgtCfg_Stat2_AR.AmbBrt_Z01_Stat.phys = getValue( HMI_AmbBrt_Z01_Stat );
    _mIL_AmbLgtCfg_Stat2_AR.AmbBrt_Z02_Stat.phys = getValue( HMI_AmbBrt_Z02_Stat );
    _mIL_AmbLgtCfg_Stat2_AR.AmbBrt_Z03_Stat.phys = getValue( HMI_AmbBrt_Z03_Stat );
    _mIL_AmbLgtCfg_Stat2_AR.AmbBrt_Z04_Stat.phys = getValue( HMI_AmbBrt_Z04_Stat );
    _mIL_AmbLgtCfg_Stat2_AR.AmbBrt_Z05_Stat.phys = getValue( HMI_AmbBrt_Z05_Stat );
    _mIL_AmbLgtCfg_Stat2_AR.AmbBrt_Z06_Stat.phys = getValue( HMI_AmbBrt_Z06_Stat );
    _mIL_AmbLgtCfg_Stat2_AR.AmbBrt_Z07_Stat.phys = getValue( HMI_AmbBrt_Z07_Stat );
}

IL_AmbLgtCfg_Stat2_AR_output(void)
{
    output( _mIL_AmbLgtCfg_Stat2_AR );
}

IL_AmbLgtCfg_Stat2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: IL_AmbLgtCfg_Stat2_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_IL_AmbLgtCfg_Stat2_AR := %X\n", getValue( HMI__STMSG_IL_AmbLgtCfg_Stat2_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_IL_AmbLgtCfg_Stat2_AR := %X\n", getValue( HMI__STMSGT_IL_AmbLgtCfg_Stat2_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AmbBrt_Z01_Stat := %X\n", getValue( HMI_AmbBrt_Z01_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AmbBrt_Z02_Stat := %X\n", getValue( HMI_AmbBrt_Z02_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AmbBrt_Z03_Stat := %X\n", getValue( HMI_AmbBrt_Z03_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AmbBrt_Z04_Stat := %X\n", getValue( HMI_AmbBrt_Z04_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AmbBrt_Z05_Stat := %X\n", getValue( HMI_AmbBrt_Z05_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AmbBrt_Z06_Stat := %X\n", getValue( HMI_AmbBrt_Z06_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AmbBrt_Z07_Stat := %X\n", getValue( HMI_AmbBrt_Z07_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tIL_AmbLgtCfg_Stat2_AR
{
    putValue( HMI__STMSG_IL_AmbLgtCfg_Stat2_AR, 0 );
}

on EnvVar HMI__STMSG_IL_AmbLgtCfg_Stat2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_IL_AmbLgtCfg_Stat2_AR );
        if( tDelay > 0)    
            setTimer( _tIL_AmbLgtCfg_Stat2_AR, tDelay );
        else
            putValue( HMI__STMSG_IL_AmbLgtCfg_Stat2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_IL_AmbLgtCfg_Stat2_AR
{
    if( getValue( this ) )
        openPanel("IL_AmbLgtCfg_Stat2_AR");
}

on EnvVar HMI_AmbBrt_Z01_Stat
{
    _mIL_AmbLgtCfg_Stat2_AR.AmbBrt_Z01_Stat.phys = getValue(this);
    _IL_AmbLgtCfg_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_AmbBrt_Z02_Stat
{
    _mIL_AmbLgtCfg_Stat2_AR.AmbBrt_Z02_Stat.phys = getValue(this);
    _IL_AmbLgtCfg_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_AmbBrt_Z03_Stat
{
    _mIL_AmbLgtCfg_Stat2_AR.AmbBrt_Z03_Stat.phys = getValue(this);
    _IL_AmbLgtCfg_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_AmbBrt_Z04_Stat
{
    _mIL_AmbLgtCfg_Stat2_AR.AmbBrt_Z04_Stat.phys = getValue(this);
    _IL_AmbLgtCfg_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_AmbBrt_Z05_Stat
{
    _mIL_AmbLgtCfg_Stat2_AR.AmbBrt_Z05_Stat.phys = getValue(this);
    _IL_AmbLgtCfg_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_AmbBrt_Z06_Stat
{
    _mIL_AmbLgtCfg_Stat2_AR.AmbBrt_Z06_Stat.phys = getValue(this);
    _IL_AmbLgtCfg_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_AmbBrt_Z07_Stat
{
    _mIL_AmbLgtCfg_Stat2_AR.AmbBrt_Z07_Stat.phys = getValue(this);
    _IL_AmbLgtCfg_Stat2_AR_SpontanFlag = 1;
}

IL_Stat2_AR_check_output()
{
    if( !getValue( HMI__STMSG_IL_Stat2_AR ) )
    {
    //  message   IL_Stat2_AR ID: 830 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _IL_Stat2_AR_Cnt--;
        if( _IL_Stat2_AR_Cnt < 1 )
        {
            IL_Stat2_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _IL_Stat2_AR_Cnt = _IL_Stat2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _IL_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _IL_Stat2_AR_SpontanFlag )
        {
            IL_Stat2_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _IL_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

IL_Stat2_AR_init()
{   /* Botschaft IL_Stat2_AR ID: 830 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 830 0;
BA_ "NmAsrMessage" BO_ 830 0;
BA_ "GenMsgMinAcceptLength" BO_ 830 8;
BA_ "GenMsgILSupport" BO_ 830 1;
BA_ "DiagState" BO_ 830 0;
BA_ "DiagRequest" BO_ 830 0;
BA_ "DiagResponse" BO_ 830 0;
BA_ "GenMsgStartValue" BO_ 830 "0";
BA_ "GenMsgDelayTime" BO_ 830 5;
BA_ "GenMsgNrOfRepetition" BO_ 830 0;
BA_ "GenMsgCycleTime" BO_ 830 500;
BA_ "GenMsgSendType" BO_ 830 5;
    */
    _IL_Stat2_AR_Timebase =           c_tDBKomTimer_20ms;
    _IL_Stat2_AR_CycleCount =      1000 / _IL_Stat2_AR_Timebase;
    _IL_Stat2_AR_StartDelay =       110 / _IL_Stat2_AR_Timebase;
    _IL_Stat2_AR_Cnt = _IL_Stat2_AR_StartDelay;
    _IL_Stat2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_IL_Stat2_AR, _IL_Stat2_AR_StartDelay * _IL_Stat2_AR_Timebase );

	_mIL_Stat2_AR.Cmprtmnt_SillLmp_Brt_Rq.phys = getValue( HMI_Cmprtmnt_SillLmp_Brt_Rq );
	_mIL_Stat2_AR.Cmprtmnt_SillLmp_Dim_Rq.phys = getValue( HMI_Cmprtmnt_SillLmp_Dim_Rq );
    _mIL_Stat2_AR.FtwLmp_R_Dim_Rq.phys = getValue( HMI_FtwLmp_R_Dim_Rq );
    _mIL_Stat2_AR.FtwLmp_R_Rq.phys = getValue( HMI_FtwLmp_R_Rq );
    _mIL_Stat2_AR.IL_ILCtrl_Stat.phys = getValue( HMI_IL_ILCtrl_Stat );
    _mIL_Stat2_AR.IL_R_Md_Stat.phys = getValue( HMI_IL_R_Md_Stat );
    _mIL_Stat2_AR.IL_RdLgt_FL_Md_Stat.phys = getValue( HMI_IL_RdLgt_FL_Md_Stat );
    _mIL_Stat2_AR.IL_RdLgt_FR_Md_Stat.phys = getValue( HMI_IL_RdLgt_FR_Md_Stat );
    _mIL_Stat2_AR.ISwLgtBrt.phys = getValue( HMI_ISwLgtBrt );
    _mIL_Stat2_AR.TGC_IL_RdLgt_FL_Md_Stat.phys = getValue( HMI_TGC_IL_RdLgt_FL_Md_Stat );
    _mIL_Stat2_AR.TGC_IL_RdLgt_FR_Md_Stat.phys = getValue( HMI_TGC_IL_RdLgt_FR_Md_Stat );
}

IL_Stat2_AR_output(void)
{
    output( _mIL_Stat2_AR );
}

IL_Stat2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: IL_Stat2_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_IL_Stat2_AR := %X\n", getValue( HMI__STMSG_IL_Stat2_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_IL_Stat2_AR := %X\n", getValue( HMI__STMSGT_IL_Stat2_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Cmprtmnt_SillLmp_Dim_Rq := %X\n", getValue( HMI_Cmprtmnt_SillLmp_Dim_Rq ) );	filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Cmprtmnt_SillLmp_Brt_Rq := %X\n", getValue( HMI_Cmprtmnt_SillLmp_Brt_Rq ) );	filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FtwLmp_R_Dim_Rq := %X\n", getValue( HMI_FtwLmp_R_Dim_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FtwLmp_R_Rq := %X\n", getValue( HMI_FtwLmp_R_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IL_ILCtrl_Stat := %X\n", getValue( HMI_IL_ILCtrl_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IL_R_Md_Stat := %X\n", getValue( HMI_IL_R_Md_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IL_RdLgt_FL_Md_Stat := %X\n", getValue( HMI_IL_RdLgt_FL_Md_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IL_RdLgt_FR_Md_Stat := %X\n", getValue( HMI_IL_RdLgt_FR_Md_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ISwLgtBrt := %X\n", getValue( HMI_ISwLgtBrt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount(buffer), "0.0000 HMI_TGC_IL_RdLgt_FL_Md_Stat := %X\n", getValue( HMI_TGC_IL_RdLgt_FL_Md_Stat ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_TGC_IL_RdLgt_FR_Md_Stat := %X\n", getValue( HMI_TGC_IL_RdLgt_FR_Md_Stat ) );        filePutString( buffer, elcount(buffer), hFile);
}

on timer _tIL_Stat2_AR
{
    putValue( HMI__STMSG_IL_Stat2_AR, 0 );
}

on EnvVar HMI__STMSG_IL_Stat2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_IL_Stat2_AR );
        if( tDelay > 0)    
            setTimer( _tIL_Stat2_AR, tDelay );
        else
            putValue( HMI__STMSG_IL_Stat2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_IL_Stat2_AR
{
    if( getValue( this ) )
        openPanel("IL_Stat2_AR");
}

on EnvVar HMI_Cmprtmnt_SillLmp_Brt_Rq
{
	_mIL_Stat2_AR.Cmprtmnt_SillLmp_Brt_Rq.phys = getValue(this);
	_IL_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Cmprtmnt_SillLmp_Dim_Rq
{
	_mIL_Stat2_AR.Cmprtmnt_SillLmp_Dim_Rq.phys = getValue(this);
	_IL_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_FtwLmp_R_Dim_Rq
{
    _mIL_Stat2_AR.FtwLmp_R_Dim_Rq.phys = getValue(this);
    _IL_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_FtwLmp_R_Rq
{
    _mIL_Stat2_AR.FtwLmp_R_Rq.phys = getValue(this);
    _IL_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_IL_ILCtrl_Stat
{
    _mIL_Stat2_AR.IL_ILCtrl_Stat.phys = getValue(this);
    _IL_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_IL_R_Md_Stat
{
    _mIL_Stat2_AR.IL_R_Md_Stat.phys = getValue(this);
    _IL_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_IL_RdLgt_FL_Md_Stat
{
    _mIL_Stat2_AR.IL_RdLgt_FL_Md_Stat.phys = getValue(this);
    _IL_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_IL_RdLgt_FR_Md_Stat
{
    _mIL_Stat2_AR.IL_RdLgt_FR_Md_Stat.phys = getValue(this);
    _IL_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_ISwLgtBrt
{
    _mIL_Stat2_AR.ISwLgtBrt.phys = getValue(this);
    _IL_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_TGC_IL_RdLgt_FL_Md_Stat
{
    _mIL_Stat2_AR.TGC_IL_RdLgt_FL_Md_Stat.phys = getValue(this);
    _IL_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_TGC_IL_RdLgt_FR_Md_Stat
{
    _mIL_Stat2_AR.TGC_IL_RdLgt_FR_Md_Stat.phys = getValue(this);
    _IL_Stat2_AR_SpontanFlag = 1;
}

Immobilizer_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_Immobilizer_Disp_Rq_AR ) )
    {
    //  message   Immobilizer_Disp_Rq_AR ID: 1037 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _Immobilizer_Disp_Rq_AR_Cnt--;
        if( _Immobilizer_Disp_Rq_AR_Cnt < 1 )
        {
            Immobilizer_Disp_Rq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _Immobilizer_Disp_Rq_AR_Cnt = _Immobilizer_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _Immobilizer_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _Immobilizer_Disp_Rq_AR_SpontanFlag )
        {
            Immobilizer_Disp_Rq_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _Immobilizer_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

Immobilizer_Disp_Rq_AR_init()
{   /* Botschaft Immobilizer_Disp_Rq_AR ID: 1037 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1037 0;
BA_ "NmAsrMessage" BO_ 1037 0;
BA_ "GenMsgMinAcceptLength" BO_ 1037 4;
BA_ "GenMsgILSupport" BO_ 1037 1;
BA_ "DiagState" BO_ 1037 0;
BA_ "DiagRequest" BO_ 1037 0;
BA_ "DiagResponse" BO_ 1037 0;
BA_ "GenMsgStartValue" BO_ 1037 "0";
BA_ "GenMsgStartDelayTime" BO_ 1037 110;
BA_ "GenMsgDelayTime" BO_ 1037 20;
BA_ "GenMsgNrOfRepetitions" BO_ 1037 0;
BA_ "GenMsgCycleTime" BO_ 1037 1000;
BA_ "GenMsgSendType" BO_ 1037 5;
    */
    _Immobilizer_Disp_Rq_AR_Timebase =           c_tDBKomTimer_20ms;
    _Immobilizer_Disp_Rq_AR_CycleCount =      1000 / _Immobilizer_Disp_Rq_AR_Timebase;
    _Immobilizer_Disp_Rq_AR_StartDelay =       110 / _Immobilizer_Disp_Rq_AR_Timebase;
    _Immobilizer_Disp_Rq_AR_Cnt = _Immobilizer_Disp_Rq_AR_StartDelay;
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_Immobilizer_Disp_Rq_AR, _Immobilizer_Disp_Rq_AR_StartDelay * _Immobilizer_Disp_Rq_AR_Timebase );

    _mImmobilizer_Disp_Rq_AR.EIS_Msg0.phys = getValue( HMI_EIS_Msg0 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg1.phys = getValue( HMI_EIS_Msg1 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg3.phys = getValue( HMI_EIS_Msg3 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg4.phys = getValue( HMI_EIS_Msg4 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg5.phys = getValue( HMI_EIS_Msg5 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg6.phys = getValue( HMI_EIS_Msg6 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg7.phys = getValue( HMI_EIS_Msg7 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg8.phys = getValue( HMI_EIS_Msg8 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg9.phys = getValue( HMI_EIS_Msg9 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg10.phys = getValue( HMI_EIS_Msg10 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg11.phys = getValue( HMI_EIS_Msg11 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg12.phys = getValue( HMI_EIS_Msg12 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg13.phys = getValue( HMI_EIS_Msg13 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg14.phys = getValue( HMI_EIS_Msg14 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg15.phys = getValue( HMI_EIS_Msg15 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg16.phys = getValue( HMI_EIS_Msg16 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg17.phys = getValue( HMI_EIS_Msg17 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg18.phys = getValue( HMI_EIS_Msg18 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg19.phys = getValue( HMI_EIS_Msg19 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg20.phys = getValue( HMI_EIS_Msg20 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg21.phys = getValue( HMI_EIS_Msg21 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg22.phys = getValue( HMI_EIS_Msg22 );
    _mImmobilizer_Disp_Rq_AR.EIS_Msg24.phys = getValue( HMI_EIS_Msg24 );
}

Immobilizer_Disp_Rq_AR_output(void)
{
    output( _mImmobilizer_Disp_Rq_AR );
}

Immobilizer_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Immobilizer_Disp_Rq_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Immobilizer_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_Immobilizer_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Immobilizer_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_Immobilizer_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg0 := %X\n", getValue( HMI_EIS_Msg0 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg1 := %X\n", getValue( HMI_EIS_Msg1 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg3 := %X\n", getValue( HMI_EIS_Msg3 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg4 := %X\n", getValue( HMI_EIS_Msg4 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg5 := %X\n", getValue( HMI_EIS_Msg5 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg6 := %X\n", getValue( HMI_EIS_Msg6 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg7 := %X\n", getValue( HMI_EIS_Msg7 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg8 := %X\n", getValue( HMI_EIS_Msg8 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg9 := %X\n", getValue( HMI_EIS_Msg9 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg10 := %X\n", getValue( HMI_EIS_Msg10 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg11 := %X\n", getValue( HMI_EIS_Msg11 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg12 := %X\n", getValue( HMI_EIS_Msg12 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg13 := %X\n", getValue( HMI_EIS_Msg13 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg14 := %X\n", getValue( HMI_EIS_Msg14 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg15 := %X\n", getValue( HMI_EIS_Msg15 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg16 := %X\n", getValue( HMI_EIS_Msg16 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg17 := %X\n", getValue( HMI_EIS_Msg17 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg18 := %X\n", getValue( HMI_EIS_Msg18 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg19 := %X\n", getValue( HMI_EIS_Msg19 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg20 := %X\n", getValue( HMI_EIS_Msg20 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg21 := %X\n", getValue( HMI_EIS_Msg21 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg22 := %X\n", getValue( HMI_EIS_Msg22 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EIS_Msg24 := %X\n", getValue( HMI_EIS_Msg24 ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tImmobilizer_Disp_Rq_AR
{
    putValue( HMI__STMSG_Immobilizer_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_Immobilizer_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Immobilizer_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tImmobilizer_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_Immobilizer_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Immobilizer_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("Immobilizer_Disp_Rq_AR");
}

on EnvVar HMI_EIS_Msg0
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg0.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg1
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg1.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg3
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg3.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg4
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg4.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg5
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg5.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg6
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg6.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg7
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg7.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg8
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg8.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg9
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg9.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg10
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg10.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg11
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg11.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg12
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg12.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg13
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg13.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg14
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg14.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg15
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg15.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg16
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg16.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg17
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg17.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg18
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg18.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg19
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg19.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg20
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg20.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg21
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg21.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg22
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg22.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EIS_Msg24
{
    _mImmobilizer_Disp_Rq_AR.EIS_Msg24.phys = getValue(this);
    _Immobilizer_Disp_Rq_AR_SpontanFlag = 1;
}

Immobilizer_IC_AR_check_output()
{
    if( !getValue( HMI__STMSG_Immobilizer_IC_AR ) )
    {
    //  message   Immobilizer_IC_AR ID: 1039 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _Immobilizer_IC_AR_Cnt--;
        if( _Immobilizer_IC_AR_Cnt < 1 )
        {
            Immobilizer_IC_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _Immobilizer_IC_AR_Cnt = _Immobilizer_IC_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

Immobilizer_IC_AR_init()
{   /* Botschaft Immobilizer_IC_AR ID: 1039 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 1039 0;
BA_ "NmAsrMessage" BO_ 1039 0;
BA_ "GenMsgMinAcceptLength" BO_ 1039 8;
BA_ "GenMsgILSupport" BO_ 1039 1;
BA_ "DiagState" BO_ 1039 0;
BA_ "DiagRequest" BO_ 1039 0;
BA_ "DiagResponse" BO_ 1039 0;
BA_ "GenMsgStartValue" BO_ 1039 "0";
BA_ "GenMsgStartDelayTime" BO_ 1039 240;
BA_ "GenMsgCycleTime" BO_ 1039 1000;
BA_ "GenMsgSendType" BO_ 1039 0;
    */
    dword KeyIdByte1;              // F�r Ident.Schl�ssel
    dword KeyIdByte2;              // F�r Ident.Schl�ssel
    dword KeyIdByte3;              // F�r Ident.Schl�ssel
    dword KeyIdByte4;              // F�r Ident.Schl�ssel

    _Immobilizer_IC_AR_Timebase =           c_tDBKomTimer_20ms;
    _Immobilizer_IC_AR_CycleCount =      1000 / _Immobilizer_IC_AR_Timebase;
    _Immobilizer_IC_AR_StartDelay =       240 / _Immobilizer_IC_AR_Timebase;
    _Immobilizer_IC_AR_Cnt = _Immobilizer_IC_AR_StartDelay;

    putValue( HMI__STMSGSD_Immobilizer_IC_AR, _Immobilizer_IC_AR_StartDelay * _Immobilizer_IC_AR_Timebase );

    putValue( HMI_KeyId_EIS_V2, 0xfffffffe );
    _mImmobilizer_IC_AR.Odo_EIS.phys = getValue( HMI_Odo_EIS);
    KeyIdByte1 = getvalue( Env_KeyId_EIS_V2_Byte1 );
    KeyIdByte2 = getvalue( Env_KeyId_EIS_V2_Byte2 ) * 0x100;
    KeyIdByte3 = getvalue( Env_KeyId_EIS_V2_Byte3 ) * 0x10000;
    KeyIdByte4 = getvalue( Env_KeyId_EIS_V2_Byte4 ) * 0x1000000;
  
    putValue( HMI_KeyId_EIS_V2, ( KeyIdByte4 + KeyIdByte3 + KeyIdByte2 + KeyIdByte1 ) );
    _mImmobilizer_IC_AR.KeyId_EIS_V2.phys = getValue( HMI_KeyId_EIS_V2);
}

Immobilizer_IC_AR_output(void)
{
    output( _mImmobilizer_IC_AR );
}

Immobilizer_IC_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Immobilizer_IC_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Immobilizer_IC := %X\n", getValue( HMI__STMSG_Immobilizer_IC_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Immobilizer_IC := %X\n", getValue( HMI__STMSGT_Immobilizer_IC_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Odo_EIS := %f\n", getValue( HMI_Odo_EIS ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KeyId_EIS_V2 := %X\n", getValue( HMI_KeyId_EIS_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 Env_KeyId_EIS_V2_Byte4 := %X\n", getValue( Env_KeyId_EIS_V2_Byte4 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 Env_KeyId_EIS_V2_Byte3 := %X\n", getValue( Env_KeyId_EIS_V2_Byte3 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 Env_KeyId_EIS_V2_Byte2 := %X\n", getValue( Env_KeyId_EIS_V2_Byte2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 Env_KeyId_EIS_V2_Byte1 := %X\n", getValue( Env_KeyId_EIS_V2_Byte1 ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tImmobilizer_IC_AR
{
    putValue( HMI__STMSG_Immobilizer_IC_AR, 0 );
}

on EnvVar HMI__STMSG_Immobilizer_IC_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Immobilizer_IC_AR );
        if( tDelay > 0)    
            setTimer( _tImmobilizer_IC_AR, tDelay );
        else
            putValue( HMI__STMSG_Immobilizer_IC_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Immobilizer_IC_AR
{
    if( getValue( this ) )
        openPanel("Immobilizer_IC_AR");
}

on EnvVar HMI_Odo_EIS
{
    _mImmobilizer_IC_AR.Odo_EIS.phys = getValue(this);
}

Immobilizer_KeyID_AR_check_output()
{   // Botschaft Immobilizer_KeyID_AR --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    if( !getValue( HMI__STMSG_Immobilizer_KeyID_AR ) ) 
    {
    //  message   Immobilizer_KeyID_AR ID: 1038 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _Immobilizer_KeyID_AR_DelayCnt > 0) _Immobilizer_KeyID_AR_DelayCnt--; // Mindestsendeabstand
        _Immobilizer_KeyID_AR_Cnt--;
        if( _Immobilizer_KeyID_AR_Cnt < 1 )
        {
            if( _Immobilizer_KeyID_AR_DelayCnt < 1 )
            {
                Immobilizer_KeyID_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                _Immobilizer_KeyID_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Immobilizer_KeyID_AR_DelayCnt = _Immobilizer_KeyID_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _Immobilizer_KeyID_AR_SpontanFlag = 1;
            }
            _Immobilizer_KeyID_AR_Cnt = _Immobilizer_KeyID_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _Immobilizer_KeyID_AR_SpontanFlag )
        {
            if( _Immobilizer_KeyID_AR_DelayCnt < 1 )
            {
                Immobilizer_KeyID_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _Immobilizer_KeyID_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Immobilizer_KeyID_AR_DelayCnt = _Immobilizer_KeyID_AR_MinDelay;
            }
        }
    }
}

Immobilizer_KeyID_AR_init()
{   /* Botschaft Immobilizer_KeyID_AR ID: 1038 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1038 0;
BA_ "NmAsrMessage" BO_ 1038 0;
BA_ "GenMsgMinAcceptLength" BO_ 1038 6;
BA_ "GenMsgILSupport" BO_ 1038 1;
BA_ "DiagState" BO_ 1038 0;
BA_ "DiagRequest" BO_ 1038 0;
BA_ "DiagResponse" BO_ 1038 0;
BA_ "GenMsgStartValue" BO_ 1038 "0";
BA_ "GenMsgStartDelayTime" BO_ 1038 205;
BA_ "GenMsgDelayTime" BO_ 1038 200;
BA_ "GenMsgNrOfRepetitions" BO_ 1038 0;
BA_ "GenMsgCycleTime" BO_ 1038 1000;
BA_ "GenMsgSendType" BO_ 1038 5;
    */
    dword KeyIdByte1;              // F�r Ident.Schl�ssel
    dword KeyIdByte2;              // F�r Ident.Schl�ssel
    dword KeyIdByte3;              // F�r Ident.Schl�ssel
    dword KeyIdByte4;              // F�r Ident.Schl�ssel
    
    _Immobilizer_KeyID_AR_Timebase =           c_tDBKomTimer_20ms;
    _Immobilizer_KeyID_AR_CycleCount =       1000 / _Immobilizer_KeyID_AR_Timebase;
    _Immobilizer_KeyID_AR_StartDelay =        205 / _Immobilizer_KeyID_AR_Timebase;
    _Immobilizer_KeyID_AR_MinDelay =          200 / _Immobilizer_KeyID_AR_Timebase;
    _Immobilizer_KeyID_AR_Cnt = _Immobilizer_KeyID_AR_StartDelay;
    _Immobilizer_KeyID_AR_SpontanFlag = 0;
    _Immobilizer_KeyID_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_Immobilizer_KeyID_AR, _Immobilizer_KeyID_AR_StartDelay * _Immobilizer_KeyID_AR_Timebase );

    putValue( HMI_KeyId_EIS_V2, 0xfffffffe );
    _mImmobilizer_KeyID_AR.Rsrv1_Immobilizer_KeyID = getValue( HMI_Rsrv1_Immobilizer_KeyID );
    _mImmobilizer_KeyID_AR.KeyId_EIS_V2.phys = getValue( HMI_KeyId_EIS_V2 );
    KeyIdByte1 = getvalue( Env_KeyId_EIS_V2_Byte1 );
    KeyIdByte2 = getvalue( Env_KeyId_EIS_V2_Byte2 ) * 0x100;
    KeyIdByte3 = getvalue( Env_KeyId_EIS_V2_Byte3 ) * 0x10000;
    KeyIdByte4 = getvalue( Env_KeyId_EIS_V2_Byte4 ) * 0x1000000;
  
    putValue( HMI_KeyId_EIS_V2, ( KeyIdByte4 + KeyIdByte3 + KeyIdByte2 + KeyIdByte1 ) );
    _mImmobilizer_KeyID_AR.KeyId_EIS_V2.phys = getValue( HMI_KeyId_EIS_V2);
}

Immobilizer_KeyID_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_Immobilizer_KeyID ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_Immobilizer_KeyID_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _Immobilizer_KeyID_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _Immobilizer_KeyID_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_Immobilizer_KeyID_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _Immobilizer_KeyID_AR_SQC_WrongSeqJump != 0 ) &&
            ( _Immobilizer_KeyID_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _Immobilizer_KeyID_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _Immobilizer_KeyID_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _Immobilizer_KeyID_AR_SQC_RepeatedCnt ) &&
            ( _Immobilizer_KeyID_AR_E2E_Armed == 1  )    )
        {
            _Immobilizer_KeyID_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_Immobilizer_KeyID, SQC_help );
    }
    _mImmobilizer_KeyID_AR.SQC_Immobilizer_KeyID = SQC_help;

    if( getValue( HMI_CRC_Immobilizer_KeyID_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_Immobilizer_KeyID_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mImmobilizer_KeyID_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mImmobilizer_KeyID_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mImmobilizer_KeyID_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mImmobilizer_KeyID_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mImmobilizer_KeyID_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mImmobilizer_KeyID_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mImmobilizer_KeyID_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mImmobilizer_KeyID_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _Immobilizer_KeyID_AR_CRC_Offset[ _mImmobilizer_KeyID_AR.SQC_Immobilizer_KeyID ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _Immobilizer_KeyID_AR_CRC_ErrorCnt   && ( _Immobilizer_KeyID_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Immobilizer_KeyID_Invalid )                                         )    )
            {
                crc++;
                if( _Immobilizer_KeyID_AR_CRC_ErrorCnt > 0 )
                    _Immobilizer_KeyID_AR_CRC_ErrorCnt--; 
            }
            _mImmobilizer_KeyID_AR.CRC_Immobilizer_KeyID = crc;
            putValue( HMI_CRC_Immobilizer_KeyID, crc );
        }
        else
            _mImmobilizer_KeyID_AR.CRC_Immobilizer_KeyID = getValue( HMI_CRC_Immobilizer_KeyID );
    }
    else
    {
        if( !getValue( HMI_CRC_Immobilizer_KeyID_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mImmobilizer_KeyID_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mImmobilizer_KeyID_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mImmobilizer_KeyID_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mImmobilizer_KeyID_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mImmobilizer_KeyID_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mImmobilizer_KeyID_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mImmobilizer_KeyID_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mImmobilizer_KeyID_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _Immobilizer_KeyID_AR_CRC_ErrorCnt   && ( _Immobilizer_KeyID_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Immobilizer_KeyID_Invalid )                                         )    )
            {
                crc++;
                if( _Immobilizer_KeyID_AR_CRC_ErrorCnt > 0 )
                    _Immobilizer_KeyID_AR_CRC_ErrorCnt--; 
            }
            _mImmobilizer_KeyID_AR.CRC_Immobilizer_KeyID = crc;
            putValue( HMI_CRC_Immobilizer_KeyID, crc );
        }
        else
            _mImmobilizer_KeyID_AR.CRC_Immobilizer_KeyID = getValue( HMI_CRC_Immobilizer_KeyID );
    }
    if( ( _Immobilizer_KeyID_AR_MSG_DropCnt > 0 ) &&
        ( _Immobilizer_KeyID_AR_E2E_Armed == 1  )    )
    {
        _Immobilizer_KeyID_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mImmobilizer_KeyID_AR );
        
    if( _Immobilizer_KeyID_AR_E2E_Armed == 1 )
    {
        if ( ( _Immobilizer_KeyID_AR_MSG_DropCnt == 0      ) &&
             ( _Immobilizer_KeyID_AR_CRC_ErrorCnt == 0     ) &&
             ( _Immobilizer_KeyID_AR_SQC_RepeatedCnt == 0  ) &&
             ( _Immobilizer_KeyID_AR_SQC_WrongSeqJump == 0 )    )
        {
            _Immobilizer_KeyID_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_Immobilizer_KeyID_State, 0 );
        }
    }
}

Immobilizer_KeyID_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Immobilizer_KeyID_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Immobilizer_KeyID := %X\n", getValue( HMI__STMSG_Immobilizer_KeyID_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Immobilizer_KeyID := %X\n", getValue( HMI__STMSGT_Immobilizer_KeyID_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 Rsrv1_Immobilizer_KeyID := %f\n", getValue( HMI_Rsrv1_Immobilizer_KeyID ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KeyId_EIS_V2 := %X\n", getValue( HMI_KeyId_EIS_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 Env_KeyId_EIS_V2_Byte4 := %X\n", getValue( Env_KeyId_EIS_V2_Byte4 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 Env_KeyId_EIS_V2_Byte3 := %X\n", getValue( Env_KeyId_EIS_V2_Byte3 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 Env_KeyId_EIS_V2_Byte2 := %X\n", getValue( Env_KeyId_EIS_V2_Byte2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 Env_KeyId_EIS_V2_Byte1 := %X\n", getValue( Env_KeyId_EIS_V2_Byte1 ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tImmobilizer_KeyID_AR
{
    putValue( HMI__STMSG_Immobilizer_KeyID_AR, 0 );
}

on EnvVar HMI__STMSG_Immobilizer_KeyID_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Immobilizer_KeyID_AR );
        if( tDelay > 0)    
            setTimer( _tImmobilizer_KeyID_AR, tDelay );
        else
            putValue( HMI__STMSG_Immobilizer_KeyID_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Immobilizer_KeyID_AR
{
    if( getValue( this ) )
        openPanel("Immobilizer_KeyID_AR");
}

on envVar HMI_E2E_Immobilizer_KeyID_Inject
{
    if( getValue( this ) )
    {
        _Immobilizer_KeyID_AR_CRC_ErrorCnt = getValue( HMI_CRC_Immobilizer_KeyID_ErrorCount );
        _Immobilizer_KeyID_AR_SQC_TriggPos = getValue( HMI_SQC_Immobilizer_KeyID_TriggerPosition );
        _Immobilizer_KeyID_AR_SQC_WrongSeqJump = getValue( HMI_SQC_Immobilizer_KeyID_WrongSeq );
        _Immobilizer_KeyID_AR_SQC_RepeatedCnt = getValue( HMI_SQC_Immobilizer_KeyID_Repeated );
        _Immobilizer_KeyID_AR_MSG_DropCnt = getValue( HMI_SQC_Immobilizer_KeyID_MSG_DropCnt );
        putValue( HMI_E2E_Immobilizer_KeyID_State, 2 );
        _Immobilizer_KeyID_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_KeyId_EIS_V2
{
    _mImmobilizer_KeyID_AR.KeyId_EIS_V2.phys = getValue(this);
    _Immobilizer_KeyID_AR_SpontanFlag = 1;

    _mImmobilizer_IC_AR.KeyId_EIS_V2.phys = getValue(this);
}

on EnvVar HMI_Rsrv1_Immobilizer_KeyID
{
    _mImmobilizer_KeyID_AR.Rsrv1_Immobilizer_KeyID.phys = getValue(this);
    _Immobilizer_KeyID_AR_SpontanFlag = 1;
}


KEP_MODE_DISP_RQ_check_output()
{
    if( !getValue( HMI__STMSG_KEP_MODE_DISP_RQ ) )
    {
    //  message   KEP_MODE_DISP_RQ ID: 1115 --- Sendeart 0 cyclic --- 
        _KEP_MODE_DISP_RQ_Cnt--;
        if( _KEP_MODE_DISP_RQ_Cnt < 1 )
        {
            KEP_MODE_DISP_RQ_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _KEP_MODE_DISP_RQ_Cnt = _KEP_MODE_DISP_RQ_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

KEP_MODE_DISP_RQ_init()
{   /* Botschaft KEP_MODE_DISP_RQ ID: 1115 --- Sendeart 0 cyclicX --- 

    */
    dword KeyIdByte1;              // F�r Ident.Schl�ssel
    dword KeyIdByte2;              // F�r Ident.Schl�ssel
    dword KeyIdByte3;              // F�r Ident.Schl�ssel
    dword KeyIdByte4;              // F�r Ident.Schl�ssel

    _KEP_MODE_DISP_RQ_Timebase =           c_tDBKomTimer_20ms;
    _KEP_MODE_DISP_RQ_CycleCount =      200 / _KEP_MODE_DISP_RQ_Timebase;
    _KEP_MODE_DISP_RQ_StartDelay =      0 / _KEP_MODE_DISP_RQ_Timebase;
    _KEP_MODE_DISP_RQ_Cnt = _KEP_MODE_DISP_RQ_StartDelay;

    putValue( HMI__STMSGSD_KEP_MODE_DISP_RQ, _KEP_MODE_DISP_RQ_StartDelay * _KEP_MODE_DISP_RQ_Timebase );

  
    _mKEP_MODE_DISP_RQ.DrvProg_C_NotAvl.phys = getValue( HMI_DrvProg_C_NotAvl);
    _mKEP_MODE_DISP_RQ.EngyMd_Actv.phys = getValue( HMI_EngyMd_Actv);
    _mKEP_MODE_DISP_RQ.DrvProgSelect_Sw_Psd_CPC.phys = getValue( HMI_DrvProgSelect_Sw_Psd_CPC);
    _mKEP_MODE_DISP_RQ.TM_HVAC_AcPrg_Rq.phys = getValue( HMI_TM_HVAC_AcPrg_Rq);
    _mKEP_MODE_DISP_RQ.TM_HVAC_EngySave_Rq.phys = getValue( HMI_TM_HVAC_EngySave_Rq);
    _mKEP_MODE_DISP_RQ.TM_HVAC_FanLim_Rq.phys = getValue( HMI_TM_HVAC_FanLim_Rq);
    _mKEP_MODE_DISP_RQ.TM_HVAC_HvPwrLim_Rq.phys = getValue( HMI_TM_HVAC_HvPwrLim_Rq);
    _mKEP_MODE_DISP_RQ.TM_HVAC_LvPtcLim_Rq.phys = getValue( HMI_TM_HVAC_LvPtcLim_Rq);
}

KEP_MODE_DISP_RQ_output(void)
{
    output( _mKEP_MODE_DISP_RQ );
}

KEP_MODE_DISP_RQ_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: KEP_MODE_DISP_RQ\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_KEP_MODE_DISP_RQ := %X\n", getValue( HMI__STMSG_KEP_MODE_DISP_RQ ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_KEP_MODE_DISP_RQ := %X\n", getValue( HMI__STMSGT_KEP_MODE_DISP_RQ ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrvProg_C_NotAvl := %f\n", getValue( HMI_DrvProg_C_NotAvl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngyMd_Actv := %X\n", getValue( HMI_EngyMd_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrvProgSelect_Sw_Psd_CPC := %X\n", getValue( HMI_DrvProgSelect_Sw_Psd_CPC ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TM_HVAC_AcPrg_Rq := %X\n", getValue( HMI_TM_HVAC_AcPrg_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TM_HVAC_EngySave_Rq := %X\n", getValue( HMI_TM_HVAC_EngySave_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TM_HVAC_FanLim_Rq := %X\n", getValue( HMI_TM_HVAC_FanLim_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TM_HVAC_HvPwrLim_Rq := %X\n", getValue( HMI_TM_HVAC_HvPwrLim_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TM_HVAC_LvPtcLim_Rq := %X\n", getValue( HMI_TM_HVAC_LvPtcLim_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
   
}

on timer _tKEP_MODE_DISP_RQ
{
    putValue( HMI__STMSG_KEP_MODE_DISP_RQ, 0 );
}

on EnvVar HMI__STMSG_KEP_MODE_DISP_RQ
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_KEP_MODE_DISP_RQ );
        if( tDelay > 0)    
            setTimer( _tKEP_MODE_DISP_RQ, tDelay );
        else
            putValue( HMI__STMSG_KEP_MODE_DISP_RQ, 0 );
    }
}

on envVar HMI__STMSG_PO_KEP_MODE_DISP_RQ
{
    if( getValue( this ) )
        openPanel("KEP_MODE_DISP_RQ");
}

on EnvVar HMI_DrvProg_C_NotAvl
{
    _mKEP_MODE_DISP_RQ.DrvProg_C_NotAvl.phys = getValue(this);
}

on EnvVar HMI_EngyMd_Actv
{
    _mKEP_MODE_DISP_RQ.EngyMd_Actv.phys = getValue(this);
}

on EnvVar HMI_DrvProgSelect_Sw_Psd_CPC
{
    _mKEP_MODE_DISP_RQ.DrvProgSelect_Sw_Psd_CPC.phys = getValue(this);
}

on EnvVar HMI_TM_HVAC_AcPrg_Rq
{
    _mKEP_MODE_DISP_RQ.TM_HVAC_AcPrg_Rq.phys = getValue(this);
}

on EnvVar HMI_TM_HVAC_EngySave_Rq
{
    _mKEP_MODE_DISP_RQ.TM_HVAC_EngySave_Rq.phys = getValue(this);
}

on EnvVar HMI_TM_HVAC_FanLim_Rq
{
    _mKEP_MODE_DISP_RQ.TM_HVAC_FanLim_Rq.phys = getValue(this);
}

on EnvVar HMI_TM_HVAC_HvPwrLim_Rq
{
    _mKEP_MODE_DISP_RQ.TM_HVAC_HvPwrLim_Rq.phys = getValue(this);
}

on EnvVar HMI_TM_HVAC_LvPtcLim_Rq
{
    _mKEP_MODE_DISP_RQ.TM_HVAC_LvPtcLim_Rq.phys = getValue(this);
}

KG_Msg_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_KG_Msg_Disp_Rq_AR ) )
    {
    //  message   KG_Msg_Disp_Rq_AR ID: 857 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _KG_Msg_Disp_Rq_AR_Cnt--;
        if( _KG_Msg_Disp_Rq_AR_Cnt < 1 )
        {
            KG_Msg_Disp_Rq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _KG_Msg_Disp_Rq_AR_Cnt = _KG_Msg_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _KG_Msg_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _KG_Msg_Disp_Rq_AR_SpontanFlag )
        {
            KG_Msg_Disp_Rq_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _KG_Msg_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

KG_Msg_Disp_Rq_AR_init()
{   /* Botschaft KG_Msg_Disp_Rq_AR ID: 857 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 857 0;
BA_ "NmAsrMessage" BO_ 857 0;
BA_ "GenMsgMinAcceptLength" BO_ 857 2;
BA_ "GenMsgILSupport" BO_ 857 1;
BA_ "DiagState" BO_ 857 0;
BA_ "DiagRequest" BO_ 857 0;
BA_ "DiagResponse" BO_ 857 0;
BA_ "GenMsgStartValue" BO_ 857 "0";
BA_ "GenMsgStartDelayTime" BO_ 857 270;
BA_ "GenMsgDelayTime" BO_ 857 5;
BA_ "GenMsgNrOfRepetitions" BO_ 857 0;
BA_ "GenMsgCycleTime" BO_ 857 1000;
BA_ "GenMsgSendType" BO_ 857 5;
    */
    _KG_Msg_Disp_Rq_AR_Timebase =           c_tDBKomTimer_20ms;
    _KG_Msg_Disp_Rq_AR_CycleCount =       1000 / _KG_Msg_Disp_Rq_AR_Timebase;
    _KG_Msg_Disp_Rq_AR_StartDelay =        270 / _KG_Msg_Disp_Rq_AR_Timebase;
    _KG_Msg_Disp_Rq_AR_Cnt = _KG_Msg_Disp_Rq_AR_StartDelay;
    _KG_Msg_Disp_Rq_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_KG_Msg_Disp_Rq_AR, _KG_Msg_Disp_Rq_AR_StartDelay * _KG_Msg_Disp_Rq_AR_Timebase );

    _mKG_Msg_Disp_Rq_AR.KG_Msg0.phys = getValue( HMI_KG_Msg0 );
    _mKG_Msg_Disp_Rq_AR.KG_Msg1.phys = getValue( HMI_KG_Msg1 );
    _mKG_Msg_Disp_Rq_AR.KG_Msg2.phys = getValue( HMI_KG_Msg2 );
    _mKG_Msg_Disp_Rq_AR.KG_Msg3.phys = getValue( HMI_KG_Msg3 );
    _mKG_Msg_Disp_Rq_AR.KG_Msg4.phys = getValue( HMI_KG_Msg4 );
    _mKG_Msg_Disp_Rq_AR.KG_Msg5.phys = getValue( HMI_KG_Msg5 );
    _mKG_Msg_Disp_Rq_AR.KG_Msg8.phys = getValue( HMI_KG_Msg8 );
    _mKG_Msg_Disp_Rq_AR.KG_Msg12.phys = getValue( HMI_KG_Msg12 );
}

KG_Msg_Disp_Rq_AR_output(void)
{
    output( _mKG_Msg_Disp_Rq_AR );
}

KG_Msg_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: KG_Msg_Disp_Rq_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_KG_Msg_Disp_Rq := %X\n", getValue( HMI__STMSG_KG_Msg_Disp_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_KG_Msg_Disp_Rq := %X\n", getValue( HMI__STMSGT_KG_Msg_Disp_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KG_Msg0 := %X\n", getValue( HMI_KG_Msg0 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KG_Msg1 := %X\n", getValue( HMI_KG_Msg1 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KG_Msg2 := %X\n", getValue( HMI_KG_Msg2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KG_Msg3 := %X\n", getValue( HMI_KG_Msg3 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KG_Msg4 := %X\n", getValue( HMI_KG_Msg4 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KG_Msg5 := %X\n", getValue( HMI_KG_Msg5 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KG_Msg8 := %X\n", getValue( HMI_KG_Msg8 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KG_Msg12 := %X\n", getValue( HMI_KG_Msg12 ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tKG_Msg_Disp_Rq_AR
{
    putValue( HMI__STMSG_KG_Msg_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_KG_Msg_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_KG_Msg_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tKG_Msg_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_KG_Msg_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_KG_Msg_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("KG_Msg_Disp_Rq_AR");
}

on EnvVar HMI_KG_Msg0
{
    _mKG_Msg_Disp_Rq_AR.KG_Msg0.phys = getValue(this);
    _KG_Msg_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_KG_Msg1
{
    _mKG_Msg_Disp_Rq_AR.KG_Msg1.phys = getValue(this);
    _KG_Msg_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_KG_Msg2
{
    _mKG_Msg_Disp_Rq_AR.KG_Msg2.phys = getValue(this);
    _KG_Msg_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_KG_Msg3
{
    _mKG_Msg_Disp_Rq_AR.KG_Msg3.phys = getValue(this);
    _KG_Msg_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_KG_Msg4
{
    _mKG_Msg_Disp_Rq_AR.KG_Msg4.phys = getValue(this);
    _KG_Msg_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_KG_Msg5
{
    _mKG_Msg_Disp_Rq_AR.KG_Msg5.phys = getValue(this);
    _KG_Msg_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_KG_Msg8
{
    _mKG_Msg_Disp_Rq_AR.KG_Msg8.phys = getValue(this);
    _KG_Msg_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_KG_Msg12
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cWakeWarningNMRequest );
        setTimer( t_WakeWarningNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mKG_Msg_Disp_Rq_AR.KG_Msg12.phys = getValue(this);
    _KG_Msg_Disp_Rq_AR_SpontanFlag = 1;
}

KG_State_AR_check_output()
{
    if( !getValue( HMI__STMSG_KG_State_AR ) )
    {
    //  Botschaft KG_State_AR ID: 859 --- Sendeart 0 cyclicX --- 
        _KG_State_AR_Cnt--;
        if( _KG_State_AR_Cnt < 1 )
        {
            KG_State_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _KG_State_AR_Cnt = _KG_State_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

KG_State_AR_init()
{   /* Botschaft KG_State_AR ID: 859 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 859 0;
BA_ "NmAsrMessage" BO_ 859 0;
BA_ "GenMsgMinAcceptLength" BO_ 859 8;
BA_ "GenMsgILSupport" BO_ 859 1;
BA_ "DiagState" BO_ 859 0;
BA_ "DiagRequest" BO_ 859 0;
BA_ "DiagResponse" BO_ 859 0;
BA_ "GenMsgStartValue" BO_ 859 "0";
BA_ "GenMsgStartDelayTime" BO_ 859 60;
BA_ "GenMsgCycleTime" BO_ 859 400;
BA_ "GenMsgSendType" BO_ 859 0;
    */
    _KG_State_AR_Timebase =           c_tDBKomTimer_20ms;
    _KG_State_AR_CycleCount =       400 / _KG_State_AR_Timebase;
    _KG_State_AR_StartDelay =         6 / _KG_State_AR_Timebase;
    _KG_State_AR_Cnt = _KG_State_AR_StartDelay;

    putValue( HMI__STMSGSD_KG_State_AR, _KG_State_AR_StartDelay * _KG_State_AR_Timebase );

    _mKG_State_AR.HFA_DL_Rq_KG.phys = getValue( HMI_HFA_DL_Rq_KG );
    _mKG_State_AR.KG_Dr_FL_Dr_Hndl_pulled.phys = getValue( HMI_KG_Dr_FL_Dr_Hndl_pulled );
    _mKG_State_AR.KG_Dr_FR_Dr_Hndl_pulled.phys = getValue( HMI_KG_Dr_FR_Dr_Hndl_pulled );
    _mKG_State_AR.KG_Dr_RL_Dr_Hndl_pulled.phys = getValue( HMI_KG_Dr_RL_Dr_Hndl_pulled );
    _mKG_State_AR.KG_Dr_RR_Dr_Hndl_pulled.phys = getValue( HMI_KG_Dr_RR_Dr_Hndl_pulled );
    _mKG_State_AR.KG_Key_Rs.phys = getValue( HMI_KG_Key_Rs );
    _mKG_State_AR.KG_KeySrch_Actv.phys = getValue( HMI_KG_KeySrch_Actv );
    _mKG_State_AR.KG_TrSrch_Actv.phys = getValue( HMI_KG_TrSrch_Actv );
    _mKG_State_AR.LockImposbl_InvPreCond .phys = getValue( HMI_LockImposbl_InvPreCond  );
    _mKG_State_AR.RemPark_Cancel_Stat.phys = getValue( HMI_RemPark_Cancel_Stat );
    _mKG_State_AR.RemPark_Stat_KG.phys = getValue( HMI_RemPark_Stat_KG );
    _mKG_State_AR.RemPark_Stat_KG_UB.phys = getValue( HMI_RemPark_Stat_KG_UB );
    _mKG_State_AR.Rsrv1_RemPark_Stat_KG.phys = getValue( HMI_Rsrv1_RemPark_Stat_KG );
    _mKG_State_AR.PNHV_KeySrch_Rs.phys = getValue( HMI_PNHV_KeySrch_Rs );
}

KG_State_AR_output(void)
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_RemPark_Stat_KG ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_RemPark_Stat_KG_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _KG_State_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _KG_State_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_RemPark_Stat_KG_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _KG_State_AR_SQC_WrongSeqJump != 0 ) &&
            ( _KG_State_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _KG_State_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _KG_State_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _KG_State_AR_SQC_RepeatedCnt ) &&
            ( _KG_State_AR_E2E_Armed == 1  )    )
        {
            _KG_State_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_RemPark_Stat_KG, SQC_help );
    }
    _mKG_State_AR.SQC_RemPark_Stat_KG = SQC_help;

    if( getValue( HMI_CRC_RemPark_Stat_KG_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_RemPark_Stat_KG_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mKG_State_AR.byte( 0 ) ];  not secured data
//          crc = crctable_profile02[ crc ^ _mKG_State_AR.byte( 1 ) ];  not secured data
//          crc = crctable_profile02[ crc ^ _mKG_State_AR.byte( 2 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mKG_State_AR.byte( 3 ) ]; // SQC + data
            crc = crctable_profile02[ crc ^ _mKG_State_AR.byte( 4 ) ]; // data
//          crc = crctable_profile02[ crc ^ _mKG_State_AR.byte( 5 ) ];
//          crc = crctable_profile02[ crc ^ _mKG_State_AR.byte( 6 ) ];
//          crc = crctable_profile02[ crc ^ _mKG_State_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _KG_State_AR_CRC_Offset[ _mKG_State_AR.SQC_RemPark_Stat_KG ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _KG_State_AR_CRC_ErrorCnt   && ( _KG_State_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_RemPark_Stat_KG_Invalid )                                         )    )
            {
                crc++;
                if( _KG_State_AR_CRC_ErrorCnt > 0 )
                    _KG_State_AR_CRC_ErrorCnt--; 
            }
            _mKG_State_AR.CRC_RemPark_Stat_KG = crc;
            putValue( HMI_CRC_RemPark_Stat_KG, crc );
        }
        else
            _mKG_State_AR.CRC_RemPark_Stat_KG = getValue( HMI_CRC_RemPark_Stat_KG );
    }
    if( ( _KG_State_AR_MSG_DropCnt > 0 ) &&
        ( _KG_State_AR_E2E_Armed == 1  )    )
    {
        _KG_State_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mKG_State_AR );
        
    if( _KG_State_AR_E2E_Armed == 1 )
    {
        if ( ( _KG_State_AR_MSG_DropCnt == 0      ) &&
             ( _KG_State_AR_CRC_ErrorCnt == 0     ) &&
             ( _KG_State_AR_SQC_RepeatedCnt == 0  ) &&
             ( _KG_State_AR_SQC_WrongSeqJump == 0 )    )
        {
            _KG_State_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_RemPark_Stat_KG_State, 0 );
        }
    }
}

KG_State_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: KG_State_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Immobilizer_IC := %X\n", getValue( HMI__STMSG_KG_State_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Immobilizer_IC := %X\n", getValue( HMI__STMSGT_KG_State_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_RemPark_Stat_KG := %f\n", getValue( HMI_CRC_RemPark_Stat_KG ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_RemPark_Stat_KG_Auto := %X\n", getValue( HMI_CRC_RemPark_Stat_KG_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HFA_DL_Rq_KG := %f\n", getValue( HMI_HFA_DL_Rq_KG ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KG_Dr_FL_Dr_Hndl_pulled := %X\n", getValue( HMI_KG_Dr_FL_Dr_Hndl_pulled ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KG_Dr_FR_Dr_Hndl_pulled := %f\n", getValue( HMI_KG_Dr_FR_Dr_Hndl_pulled ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KG_Dr_RL_Dr_Hndl_pulled := %X\n", getValue( HMI_KG_Dr_RL_Dr_Hndl_pulled ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KG_Dr_RR_Dr_Hndl_pulled := %f\n", getValue( HMI_KG_Dr_RR_Dr_Hndl_pulled ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KG_Key_Rs := %X\n", getValue( HMI_KG_Key_Rs ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KG_KeySrch_Actv := %f\n", getValue( HMI_KG_KeySrch_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_KG_TrSrch_Actv := %X\n", getValue( HMI_KG_TrSrch_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LockImposbl_InvPreCond  := %f\n", getValue( HMI_LockImposbl_InvPreCond  ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RemPark_Cancel_Stat := %X\n", getValue( HMI_RemPark_Cancel_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RemPark_Stat_KG := %f\n", getValue( HMI_RemPark_Stat_KG ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RemPark_Stat_KG_UB := %X\n", getValue( HMI_RemPark_Stat_KG_UB ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_RemPark_Stat_KG := %f\n", getValue( HMI_Rsrv1_RemPark_Stat_KG ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_RemPark_Stat_KG := %X\n", getValue( HMI_SQC_RemPark_Stat_KG ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_RemPark_Stat_KG_Auto := %f\n", getValue( HMI_SQC_RemPark_Stat_KG_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_KeySrch_Rs := %f\n", getValue( HMI_PNHV_KeySrch_Rs ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tKG_State_AR
{
    putValue( HMI__STMSG_KG_State_AR, 0 );
}

on EnvVar HMI__STMSG_KG_State_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_KG_State_AR );
        if( tDelay > 0)    
            setTimer( _tKG_State_AR, tDelay );
        else
            putValue( HMI__STMSG_KG_State_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_KG_State_AR
{
    if( getValue( this ) )
        openPanel("KG_State_AR");
}

on envVar HMI_E2E_RemPark_Stat_KG_Inject
{
    if( getValue( this ) )
    {
        _KG_State_AR_CRC_ErrorCnt = getValue( HMI_CRC_RemPark_Stat_KG_ErrorCount );
        _KG_State_AR_SQC_TriggPos = getValue( HMI_SQC_RemPark_Stat_KG_TriggerPosition );
        _KG_State_AR_SQC_WrongSeqJump = getValue( HMI_SQC_RemPark_Stat_KG_WrongSeq );
        _KG_State_AR_SQC_RepeatedCnt = getValue( HMI_SQC_RemPark_Stat_KG_Repeated );
        _KG_State_AR_MSG_DropCnt = getValue( HMI_SQC_RemPark_Stat_KG_MSG_DropCnt );
        putValue( HMI_E2E_RemPark_Stat_KG_State, 2 );
        _KG_State_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_HFA_DL_Rq_KG
{
    _mKG_State_AR.HFA_DL_Rq_KG.phys = getValue(this);
}

on EnvVar HMI_KG_Dr_FL_Dr_Hndl_pulled
{
    _mKG_State_AR.KG_Dr_FL_Dr_Hndl_pulled.phys = getValue(this);
}

on EnvVar HMI_KG_Dr_FR_Dr_Hndl_pulled
{
    _mKG_State_AR.KG_Dr_FR_Dr_Hndl_pulled.phys = getValue(this);
}

on EnvVar HMI_KG_Dr_RL_Dr_Hndl_pulled
{
    _mKG_State_AR.KG_Dr_RL_Dr_Hndl_pulled.phys = getValue(this);
}

on EnvVar HMI_KG_Dr_RR_Dr_Hndl_pulled
{
    _mKG_State_AR.KG_Dr_RR_Dr_Hndl_pulled.phys = getValue(this);
}

on EnvVar HMI_KG_Key_Rs
{
    _mKG_State_AR.KG_Key_Rs.phys = getValue(this);
}

on EnvVar HMI_KG_KeySrch_Actv
{
    _mKG_State_AR.KG_KeySrch_Actv.phys = getValue(this);
}

on EnvVar HMI_KG_TrSrch_Actv
{
    _mKG_State_AR.KG_TrSrch_Actv.phys = getValue(this);
}

on EnvVar HMI_LockImposbl_InvPreCond
{
    _mKG_State_AR.LockImposbl_InvPreCond.phys = getValue(this);
}

on EnvVar HMI_RemPark_Cancel_Stat
{
    _mKG_State_AR.RemPark_Cancel_Stat.phys = getValue(this);
}

on EnvVar HMI_RemPark_Stat_KG
{
    _mKG_State_AR.RemPark_Stat_KG.phys = getValue(this);
}

on EnvVar HMI_RemPark_Stat_KG_UB
{
    _mKG_State_AR.RemPark_Stat_KG_UB.phys = getValue(this);
}

on EnvVar HMI_Rsrv1_RemPark_Stat_KG
{
    _mKG_State_AR.Rsrv1_RemPark_Stat_KG.phys = getValue(this);
}

on EnvVar HMI_PNHV_KeySrch_Rs
{
    _mKG_State_AR.PNHV_KeySrch_Rs.phys = getValue(this);
}

LDC_Disp_Rq_ESP_AR_check_output()
{
    if( !getValue( HMI__STMSG_LDC_Disp_Rq_ESP_AR ) )
    {
    //  message   LDC_Disp_Rq_ESP_AR ID: 1047 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _LDC_Disp_Rq_ESP_AR_Cnt--;
        if( _LDC_Disp_Rq_ESP_AR_Cnt < 1 )
        {
            LDC_Disp_Rq_ESP_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _LDC_Disp_Rq_ESP_AR_Cnt = _LDC_Disp_Rq_ESP_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _LDC_Disp_Rq_ESP_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _LDC_Disp_Rq_ESP_AR_SpontanFlag)
        {
            LDC_Disp_Rq_ESP_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _LDC_Disp_Rq_ESP_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

LDC_Disp_Rq_ESP_AR_init()
{   /* Botschaft LDC_Disp_Rq_ESP_AR ID: 1047 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1047 0;
BA_ "NmAsrMessage" BO_ 1047 0;
BA_ "GenMsgMinAcceptLength" BO_ 1047 8;
BA_ "GenMsgILSupport" BO_ 1047 1;
BA_ "DiagState" BO_ 1047 0;
BA_ "DiagRequest" BO_ 1047 0;
BA_ "DiagResponse" BO_ 1047 0;
BA_ "GenMsgStartValue" BO_ 1047 "0";
BA_ "GenMsgStartDelayTime" BO_ 1047 0;
BA_ "GenMsgDelayTime" BO_ 1047 5;
BA_ "GenMsgNrOfRepetitions" BO_ 1047 0;
BA_ "GenMsgCycleTime" BO_ 1047 200;
BA_ "GenMsgSendType" BO_ 1047 5;
    */
    _LDC_Disp_Rq_ESP_AR_Timebase =           c_tDBKomTimer_20ms;
    _LDC_Disp_Rq_ESP_AR_CycleCount =        200 / _LDC_Disp_Rq_ESP_AR_Timebase;
    _LDC_Disp_Rq_ESP_AR_StartDelay =          0 / _LDC_Disp_Rq_ESP_AR_Timebase;
    _LDC_Disp_Rq_ESP_AR_Cnt = _LDC_Disp_Rq_ESP_AR_StartDelay;
    _LDC_Disp_Rq_ESP_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_LDC_Disp_Rq_ESP_AR, _LDC_Disp_Rq_ESP_AR_StartDelay * _LDC_Disp_Rq_ESP_AR_Timebase );

    _mLDC_Disp_Rq_ESP_AR.LDC_AcustWarn_Rq.phys = getValue( HMI_LDC_AcustWarn_Rq );
    _mLDC_Disp_Rq_ESP_AR.LDC_DTR_MM_Ctrl_Actv.phys = getValue( HMI_LDC_DTR_MM_Ctrl_Actv );
    _mLDC_Disp_Rq_ESP_AR.LDC_DTR_MsgDisp_Rq.phys = getValue( HMI_LDC_DTR_MsgDisp_Rq );
    _mLDC_Disp_Rq_ESP_AR.LDC_DTR_Stat.phys = getValue( HMI_LDC_DTR_Stat );
    _mLDC_Disp_Rq_ESP_AR.LDC_IconDisp_Rq_ESP.phys = getValue( HMI_LDC_IconDisp_Rq_ESP );
    _mLDC_Disp_Rq_ESP_AR.LDC_Master.phys = getValue( HMI_LDC_Master );
    _mLDC_Disp_Rq_ESP_AR.LDC_MsgDisp_Rq.phys = getValue( HMI_LDC_MsgDisp_Rq );
    _mLDC_Disp_Rq_ESP_AR.LDC_MsgDisp_TrgrRq.phys = getValue( HMI_LDC_MsgDisp_TrgrRq );
    _mLDC_Disp_Rq_ESP_AR.LDC_Spd_Add.phys = getValue( HMI_LDC_Spd_Add );
    _mLDC_Disp_Rq_ESP_AR.LDC_Spd_Dsr.phys = getValue( HMI_LDC_Spd_Dsr );
    _mLDC_Disp_Rq_ESP_AR.LDC_SpdUnit_Rs.phys = getValue( HMI_LDC_SpdUnit_Rs );
    _mLDC_Disp_Rq_ESP_AR.LDC_SPEEDO_SegRing_Disp_Rq.phys = getValue( HMI_LDC_SPEEDO_SegRing_Disp_Rq );
    _mLDC_Disp_Rq_ESP_AR.LDC_VSL_On.phys = getValue( HMI_LDC_VSL_On );
    _mLDC_Disp_Rq_ESP_AR.LDC_WTSL_Flt.phys = getValue( HMI_LDC_WTSL_Flt );
    _mLDC_Disp_Rq_ESP_AR.LDC_WTSL_MsgDisp_Rq.phys = getValue( HMI_LDC_WTSL_MsgDisp_Rq );
    _mLDC_Disp_Rq_ESP_AR.LDC_WTSL_Spd_Max_Disp_TrgrRq.phys = getValue( HMI_LDC_WTSL_Spd_Max_Disp_TrgrRq );
    _mLDC_Disp_Rq_ESP_AR.LDC_WTSL_Spd_Max_Stat.phys = getValue( HMI_LDC_WTSL_Spd_Max_Stat );
}

LDC_Disp_Rq_ESP_AR_output(void)
{
    output( _mLDC_Disp_Rq_ESP_AR );
}

LDC_Disp_Rq_ESP_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: LDC_Disp_Rq_ESP_AR\n", 32, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_LDC_Disp_Rq_ESP := %X\n", getValue( HMI__STMSG_LDC_Disp_Rq_ESP_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_LDC_Disp_Rq_ESP := %X\n", getValue( HMI__STMSGT_LDC_Disp_Rq_ESP_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_AcustWarn_Rq := %X\n", getValue( HMI_LDC_AcustWarn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_DTR_MM_Ctrl_Actv := %X\n", getValue( HMI_LDC_DTR_MM_Ctrl_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_DTR_MsgDisp_Rq := %X\n", getValue( HMI_LDC_DTR_MsgDisp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_DTR_Stat := %X\n", getValue( HMI_LDC_DTR_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_IconDisp_Rq_ESP := %X\n", getValue( HMI_LDC_IconDisp_Rq_ESP ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_Master := %X\n", getValue( HMI_LDC_Master ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_MsgDisp_Rq := %X\n", getValue( HMI_LDC_MsgDisp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_MsgDisp_TrgrRq := %X\n", getValue( HMI_LDC_MsgDisp_TrgrRq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_Spd_Add := %X\n", getValue( HMI_LDC_Spd_Add ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_Spd_Dsr := %X\n", getValue( HMI_LDC_Spd_Dsr ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_SpdUnit_Rs := %X\n", getValue( HMI_LDC_SpdUnit_Rs ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_SPEEDO_SegRing_Disp_Rq := %X\n", getValue( HMI_LDC_SPEEDO_SegRing_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_VSL_On := %X\n", getValue( HMI_LDC_VSL_On ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_WTSL_Flt := %X\n", getValue( HMI_LDC_WTSL_Flt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_WTSL_MsgDisp_Rq := %X\n", getValue( HMI_LDC_WTSL_MsgDisp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_WTSL_Spd_Max_Disp_TrgrRq := %X\n", getValue( HMI_LDC_WTSL_Spd_Max_Disp_TrgrRq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_WTSL_Spd_Max_Stat := %X\n", getValue( HMI_LDC_WTSL_Spd_Max_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tLDC_Disp_Rq_ESP_AR
{
    putValue( HMI__STMSG_LDC_Disp_Rq_ESP_AR, 0 );
}

on EnvVar HMI__STMSG_LDC_Disp_Rq_ESP_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_LDC_Disp_Rq_ESP_AR );
        if( tDelay > 0)    
            setTimer( _tLDC_Disp_Rq_ESP_AR, tDelay );
        else
            putValue( HMI__STMSG_LDC_Disp_Rq_ESP_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_LDC_Disp_Rq_ESP_AR
{
    if( getValue( this ) )
        openPanel("LDC_Disp_Rq_ESP_AR");
}

on EnvVar HMI_LDC_AcustWarn_Rq
{
    _mLDC_Disp_Rq_ESP_AR.LDC_AcustWarn_Rq.phys = getValue(this);
    _LDC_Disp_Rq_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_DTR_MM_Ctrl_Actv
{
    _mLDC_Disp_Rq_ESP_AR.LDC_DTR_MM_Ctrl_Actv.phys = getValue(this);
    _LDC_Disp_Rq_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_DTR_MsgDisp_Rq
{
    _mLDC_Disp_Rq_ESP_AR.LDC_DTR_MsgDisp_Rq.phys = getValue(this);
    _LDC_Disp_Rq_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_DTR_Stat
{
    _mLDC_Disp_Rq_ESP_AR.LDC_DTR_Stat.phys = getValue(this);
    _LDC_Disp_Rq_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_IconDisp_Rq_ESP
{
    _mLDC_Disp_Rq_ESP_AR.LDC_IconDisp_Rq_ESP.phys = getValue(this);
    _LDC_Disp_Rq_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_Master
{
    _mLDC_Disp_Rq_ESP_AR.LDC_Master.phys = getValue(this);
    _LDC_Disp_Rq_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_MsgDisp_Rq
{
    _mLDC_Disp_Rq_ESP_AR.LDC_MsgDisp_Rq.phys = getValue(this);
    _LDC_Disp_Rq_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_MsgDisp_TrgrRq
{
    _mLDC_Disp_Rq_ESP_AR.LDC_MsgDisp_TrgrRq.phys = getValue(this);
    _LDC_Disp_Rq_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_Spd_Add
{
    _mLDC_Disp_Rq_ESP_AR.LDC_Spd_Add.phys = getValue(this);
    _LDC_Disp_Rq_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_Spd_Dsr
{
    _mLDC_Disp_Rq_ESP_AR.LDC_Spd_Dsr.phys = getValue(this);
    _LDC_Disp_Rq_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_SpdUnit_Rs
{
    _mLDC_Disp_Rq_ESP_AR.LDC_SpdUnit_Rs.phys = getValue(this);
    _LDC_Disp_Rq_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_SPEEDO_SegRing_Disp_Rq
{
    _mLDC_Disp_Rq_ESP_AR.LDC_SPEEDO_SegRing_Disp_Rq.phys = getValue(this);
    _LDC_Disp_Rq_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_VSL_On
{
    _mLDC_Disp_Rq_ESP_AR.LDC_VSL_On.phys = getValue(this);
    _LDC_Disp_Rq_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_WTSL_Flt
{
    _mLDC_Disp_Rq_ESP_AR.LDC_WTSL_Flt.phys = getValue(this);
    _LDC_Disp_Rq_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_WTSL_MsgDisp_Rq
{
    _mLDC_Disp_Rq_ESP_AR.LDC_WTSL_MsgDisp_Rq.phys = getValue(this);
    _LDC_Disp_Rq_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_WTSL_Spd_Max_Disp_TrgrRq
{
    _mLDC_Disp_Rq_ESP_AR.LDC_WTSL_Spd_Max_Disp_TrgrRq.phys = getValue(this);
    _LDC_Disp_Rq_ESP_AR_SpontanFlag = 1;
}

