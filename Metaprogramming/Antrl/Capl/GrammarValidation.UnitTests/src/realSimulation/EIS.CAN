    _mPSL_L_Stat_AR.PSD_L_Sound_Disp_Rq.phys = getValue( HMI_PSD_L_Sound_Disp_Rq );
    _mPSL_L_Stat_AR.PSD_L_SwLED_Rq.phys = getValue( HMI_PSD_L_SwLED_Rq );
    _mPSL_L_Stat_AR.PSD_L_Open_Width_V2.phys = getValue( HMI_PSD_L_Open_Width_V2 );
    _mPSL_L_Stat_AR.Rsrv1_PSD_L_Stat.phys = getValue( HMI_Rsrv1_PSD_L_Stat );
}

PSL_L_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_PSD_L_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_PSD_L_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _PSL_L_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _PSL_L_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_PSD_L_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _PSL_L_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _PSL_L_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _PSL_L_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _PSL_L_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _PSL_L_Stat_AR_SQC_RepeatedCnt ) &&
            ( _PSL_L_Stat_AR_E2E_Armed == 1  )    )
        {
            _PSL_L_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_PSD_L_Stat, SQC_help );
    }
    _mPSL_L_Stat_AR.SQC_PSD_L_Stat = SQC_help;

    if( getValue( HMI_CRC_PSD_L_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_PSD_L_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mPSL_L_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mPSL_L_Stat_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mPSL_L_Stat_AR.byte( 2 ) ];
//            crc = crctable_profile02[ crc ^ _mPSL_L_Stat_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mPSL_L_Stat_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mPSL_L_Stat_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mPSL_L_Stat_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mPSL_L_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _PSL_L_Stat_AR_CRC_Offset[ _mPSL_L_Stat_AR.SQC_PSD_L_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _PSL_L_Stat_AR_CRC_ErrorCnt   && ( _PSL_L_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_PSD_L_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _PSL_L_Stat_AR_CRC_ErrorCnt > 0 )
                    _PSL_L_Stat_AR_CRC_ErrorCnt--; 
            }
            _mPSL_L_Stat_AR.CRC_PSD_L_Stat = crc;
            putValue( HMI_CRC_PSD_L_Stat, crc );
        }
        else
            _mPSL_L_Stat_AR.CRC_PSD_L_Stat = getValue( HMI_CRC_PSD_L_Stat );
    }
    if( ( _PSL_L_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _PSL_L_Stat_AR_E2E_Armed == 1  )    )
    {
        _PSL_L_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mPSL_L_Stat_AR );
        
    if( _PSL_L_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _PSL_L_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _PSL_L_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _PSL_L_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _PSL_L_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _PSL_L_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_PSD_L_Stat_State, 0 );
        }
    }
}

PSL_L_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PSL_L_Stat_AR\n", 40, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PSL_L_Stat_AR := %X\n", getValue( HMI__STMSG_PSL_L_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PSL_L_Stat_AR := %X\n", getValue( HMI__STMSGT_PSL_L_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_PSD_L_Stat := %X\n", getValue( HMI_CRC_PSD_L_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_PSD_L_Stat_Auto := %X\n", getValue( HMI_CRC_PSD_L_Stat_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrRLtch_PSD_L_Stat := %X\n", getValue( HMI_DrRLtch_PSD_L_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PSD_L_A_FFB := %X\n", getValue( HMI_PSD_L_A_FFB ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_RecircAir_On_Rq_PSL_L := %X\n", getValue( HMI_HVAC_RecircAir_On_Rq_PSL_L ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PSD_L_FFB := %X\n", getValue( HMI_PSD_L_FFB ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PSD_L_PwrCls_Stat := %X\n", getValue( HMI_PSD_L_PwrCls_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PSD_L_Sound_Disp_Rq := %X\n", getValue( HMI_PSD_L_Sound_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PSD_L_SwLED_Rq := %X\n", getValue( HMI_PSD_L_SwLED_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PSD_L_Open_Width_V2 := %X\n", getValue( HMI_PSD_L_Open_Width_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_PSD_L_Stat := %X\n", getValue( HMI_Rsrv1_PSD_L_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_PSD_L_Stat := %X\n", getValue( HMI_SQC_PSD_L_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_PSD_L_Stat_Auto := %X\n", getValue( HMI_SQC_PSD_L_Stat_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPSL_L_Stat_AR
{
    putValue( HMI__STMSG_PSL_L_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_PSL_L_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PSL_L_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tPSL_L_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_PSL_L_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PSL_L_Stat_AR
{
    if( getValue( this ) )
        openPanel("PSL_L_Stat_AR");
}

on envVar HMI_E2E_PSD_L_Stat_Inject
{
    if( getValue( this ) )
    {
        _PSL_L_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_PSD_L_Stat_ErrorCount );
        _PSL_L_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_PSD_L_Stat_TriggerPosition );
        _PSL_L_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_PSD_L_Stat_WrongSeq );
        _PSL_L_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_PSD_L_Stat_Repeated );
        _PSL_L_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_PSD_L_Stat_MSG_DropCnt );
        putValue( HMI_E2E_PSD_L_Stat_State, 2 );
        _PSL_L_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_DrRLtch_PSD_L_Stat
{
    _mPSL_L_Stat_AR.DrRLtch_PSD_L_Stat.phys = getValue(this);
    _PSL_L_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PSD_L_A_FFB
{
    _mPSL_L_Stat_AR.PSD_L_A_FFB.phys = getValue(this);
    _PSL_L_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_RecircAir_On_Rq_PSL_L
{
    _mPSL_L_Stat_AR.HVAC_RecircAir_On_Rq_PSL_L.phys = getValue(this);
    _PSL_L_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PSD_L_FFB
{
    _mPSL_L_Stat_AR.PSD_L_FFB.phys = getValue(this);
    _PSL_L_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PSD_L_PwrCls_Stat
{
    _mPSL_L_Stat_AR.PSD_L_PwrCls_Stat.phys = getValue(this);
    _PSL_L_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PSD_L_Sound_Disp_Rq
{
    _mPSL_L_Stat_AR.PSD_L_Sound_Disp_Rq.phys = getValue(this);
    _PSL_L_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PSD_L_SwLED_Rq
{
    _mPSL_L_Stat_AR.PSD_L_SwLED_Rq.phys = getValue(this);
    _PSL_L_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PSD_L_Open_Width_V2
{
    _mPSL_L_Stat_AR.PSD_L_Open_Width_V2.phys = getValue(this);
    _PSL_L_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_PSD_L_Stat
{
    _mPSL_L_Stat_AR.Rsrv1_PSD_L_Stat.phys = getValue(this);
    _PSL_L_Stat_AR_SpontanFlag = 1;
}

PSL_R_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_PSL_R_Stat_AR ) )
    {
    //  Botschaft PSL_R_Stat_AR ID: 936 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _PSL_R_Stat_AR_Cnt--;
        if( _PSL_R_Stat_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            PSL_R_Stat_AR_output();
            _PSL_R_Stat_AR_Cnt = _PSL_R_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _PSL_R_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _PSL_R_Stat_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            PSL_R_Stat_AR_output();
            _PSL_R_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

PSL_R_Stat_AR_init()
{   /* Botschaft PSL_R_Stat_AR ID: 936 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 936 0;
BA_ "NmAsrMessage" BO_ 936 0;
BA_ "GenMsgMinAcceptLength" BO_ 936 8;
BA_ "GenMsgILSupport" BO_ 936 1;
BA_ "DiagState" BO_ 936 0;
BA_ "DiagRequest" BO_ 936 0;
BA_ "DiagResponse" BO_ 936 0;
BA_ "GenMsgStartValue" BO_ 936 "0";
BA_ "GenMsgDelayTime" BO_ 936 5;
BA_ "GenMsgNrOfRepetition" BO_ 936 0;
BA_ "GenMsgCycleTime" BO_ 936 500;
BA_ "GenMsgSendType" BO_ 936 5;
    */
    _PSL_R_Stat_AR_Timebase =         c_tDBKomTimer_20ms;
    _PSL_R_Stat_AR_CycleCount =     500 / _PSL_R_Stat_AR_Timebase;
    _PSL_R_Stat_AR_StartDelay =       0 / _PSL_R_Stat_AR_Timebase;
    _PSL_R_Stat_AR_Cnt = _PSL_R_Stat_AR_StartDelay;
    _PSL_R_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_PSL_R_Stat_AR, _PSL_R_Stat_AR_StartDelay * _PSL_R_Stat_AR_Timebase );

    _mPSL_R_Stat_AR.DrRLtch_PSD_R_Stat.phys = getValue( HMI_DrRLtch_PSD_R_Stat );
    _mPSL_R_Stat_AR.PSD_R_A_FFB.phys = getValue( HMI_PSD_R_A_FFB );
    _mPSL_R_Stat_AR.HVAC_RecircAir_On_Rq_PSL_R.phys = getValue( HMI_HVAC_RecircAir_On_Rq_PSL_R );
    _mPSL_R_Stat_AR.PSD_R_FFB.phys = getValue( HMI_PSD_R_FFB );
    _mPSL_R_Stat_AR.PSD_R_Open_Width_V2.phys = getValue( HMI_PSD_R_Open_Width_V2 );
    _mPSL_R_Stat_AR.PSD_R_PwrCls_Stat.phys = getValue( HMI_PSD_R_PwrCls_Stat );
    _mPSL_R_Stat_AR.PSD_R_Sound_Disp_Rq.phys = getValue( HMI_PSD_R_Sound_Disp_Rq );
    _mPSL_R_Stat_AR.DL_Sw_Psd_VAN.phys = getValue( HMI_DL_Sw_Psd_VAN );
    _mPSL_R_Stat_AR.DL_RLtch_Stat_VAN.phys = getValue( HMI_DL_RLtch_Stat_VAN );
    _mPSL_R_Stat_AR.PSD_R_SwLED_Rq.phys = getValue( HMI_PSD_R_SwLED_Rq );
    _mPSL_R_Stat_AR.Rsrv1_PSD_R_Stat.phys = getValue( HMI_Rsrv1_PSD_R_Stat );
}

PSL_R_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_PSD_R_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_PSD_R_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _PSL_R_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _PSL_R_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_PSD_R_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _PSL_R_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _PSL_R_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _PSL_R_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _PSL_R_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _PSL_R_Stat_AR_SQC_RepeatedCnt ) &&
            ( _PSL_R_Stat_AR_E2E_Armed == 1  )    )
        {
            _PSL_R_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_PSD_R_Stat, SQC_help );
    }
    _mPSL_R_Stat_AR.SQC_PSD_R_Stat = SQC_help;

    if( getValue( HMI_CRC_PSD_R_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_PSD_R_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mPSL_R_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mPSL_R_Stat_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mPSL_R_Stat_AR.byte( 2 ) ];
//            crc = crctable_profile02[ crc ^ _mPSL_R_Stat_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mPSL_R_Stat_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mPSL_R_Stat_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mPSL_R_Stat_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mPSL_R_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _PSL_R_Stat_AR_CRC_Offset[ _mPSL_R_Stat_AR.SQC_PSD_R_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _PSL_R_Stat_AR_CRC_ErrorCnt   && ( _PSL_R_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_PSD_R_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _PSL_R_Stat_AR_CRC_ErrorCnt > 0 )
                    _PSL_R_Stat_AR_CRC_ErrorCnt--; 
            }
            _mPSL_R_Stat_AR.CRC_PSD_R_Stat = crc;
            putValue( HMI_CRC_PSD_R_Stat, crc );
        }
        else
            _mPSL_R_Stat_AR.CRC_PSD_R_Stat = getValue( HMI_CRC_PSD_R_Stat );
    }
    if( ( _PSL_R_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _PSL_R_Stat_AR_E2E_Armed == 1  )    )
    {
        _PSL_R_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mPSL_R_Stat_AR );
        
    if( _PSL_R_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _PSL_R_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _PSL_R_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _PSL_R_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _PSL_R_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _PSL_R_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_PSD_R_Stat_State, 0 );
        }
    }
}

PSL_R_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PSL_R_Stat_AR\n", 40, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PSL_R_Stat_AR := %X\n", getValue( HMI__STMSG_PSL_R_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PSL_R_Stat_AR := %X\n", getValue( HMI__STMSGT_PSL_R_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_PSD_R_Stat := %X\n", getValue( HMI_CRC_PSD_R_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_PSD_R_Stat_Auto := %X\n", getValue( HMI_CRC_PSD_R_Stat_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrRLtch_PSD_R_Stat := %X\n", getValue( HMI_DrRLtch_PSD_R_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PSD_R_A_FFB := %X\n", getValue( HMI_PSD_R_A_FFB ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_RecircAir_On_Rq_PSL_R := %X\n", getValue( HMI_HVAC_RecircAir_On_Rq_PSL_R ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PSD_R_FFB := %X\n", getValue( HMI_PSD_R_FFB ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PSD_R_Open_Width_V2 := %X\n", getValue( HMI_PSD_R_Open_Width_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PSD_R_PwrCls_Stat := %X\n", getValue( HMI_PSD_R_PwrCls_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PSD_R_Sound_Disp_Rq := %X\n", getValue( HMI_PSD_R_Sound_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DL_Sw_Psd_VAN := %X\n", getValue( HMI_DL_Sw_Psd_VAN ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DL_RLtch_Stat_VAN := %X\n", getValue( HMI_DL_RLtch_Stat_VAN ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PSD_R_SwLED_Rq := %X\n", getValue( HMI_PSD_R_SwLED_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_PSD_R_Stat := %X\n", getValue( HMI_Rsrv1_PSD_R_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_PSD_R_Stat := %X\n", getValue( HMI_SQC_PSD_R_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_PSD_R_Stat_Auto := %X\n", getValue( HMI_SQC_PSD_R_Stat_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPSL_R_Stat_AR
{
    putValue( HMI__STMSG_PSL_R_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_PSL_R_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PSL_R_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tPSL_R_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_PSL_R_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PSL_R_Stat_AR
{
    if( getValue( this ) )
        openPanel("PSL_R_Stat_AR");
}

on envVar HMI_E2E_PSD_R_Stat_Inject
{
    if( getValue( this ) )
    {
        _PSL_R_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_PSD_R_Stat_ErrorCount );
        _PSL_R_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_PSD_R_Stat_TriggerPosition );
        _PSL_R_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_PSD_R_Stat_WrongSeq );
        _PSL_R_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_PSD_R_Stat_Repeated );
        _PSL_R_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_PSD_R_Stat_MSG_DropCnt );
        putValue( HMI_E2E_PSD_R_Stat_State, 2 );
        _PSL_R_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_DrRLtch_PSD_R_Stat
{
    _mPSL_R_Stat_AR.DrRLtch_PSD_R_Stat.phys = getValue(this);
    _PSL_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PSD_R_A_FFB
{
    _mPSL_R_Stat_AR.PSD_R_A_FFB.phys = getValue(this);
    _PSL_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_RecircAir_On_Rq_PSL_R
{
    _mPSL_R_Stat_AR.HVAC_RecircAir_On_Rq_PSL_R.phys = getValue(this);
    _PSL_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PSD_R_FFB
{
    _mPSL_R_Stat_AR.PSD_R_FFB.phys = getValue(this);
    _PSL_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PSD_R_Open_Width_V2
{
    _mPSL_R_Stat_AR.PSD_R_Open_Width_V2.phys = getValue(this);
    _PSL_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PSD_R_PwrCls_Stat
{
    _mPSL_R_Stat_AR.PSD_R_PwrCls_Stat.phys = getValue(this);
    _PSL_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PSD_R_Sound_Disp_Rq
{
    _mPSL_R_Stat_AR.PSD_R_Sound_Disp_Rq.phys = getValue(this);
    _PSL_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DL_RLtch_Stat_VAN
{
    _mPSL_R_Stat_AR.DL_RLtch_Stat_VAN.phys = getValue(this);
    _PSL_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DL_Sw_Psd_VAN
{
    _mPSL_R_Stat_AR.DL_Sw_Psd_VAN.phys = getValue(this);
    _PSL_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PSD_R_SwLED_Rq
{
    _mPSL_R_Stat_AR.PSD_R_SwLED_Rq.phys = getValue(this);
    _PSL_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_PSD_R_Stat
{
    _mPSL_R_Stat_AR.Rsrv1_PSD_R_Stat.phys = getValue(this);
    _PSL_R_Stat_AR_SpontanFlag = 1;
}

PT_Data_VAN_AR_check_output()
{
    if( !getValue( HMI__STMSG_PT_Data_VAN_AR ) )
    {
    //  message   PT_Data_VAN_AR ID: 736 --- Sendeart 0 cyclicX --- 
        _PT_Data_VAN_AR_Cnt--;
        if( _PT_Data_VAN_AR_Cnt < 1 )
        {
            PT_Data_VAN_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _PT_Data_VAN_AR_Cnt = _PT_Data_VAN_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

PT_Data_VAN_AR_init()
{   /* Botschaft PT_Data_VAN_AR ID: 736 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 736 0;
BA_ "NmAsrMessage" BO_ 736 0;
BA_ "GenMsgMinAcceptLength" BO_ 736 8;
BA_ "GenMsgILSupport" BO_ 736 1;
BA_ "DiagState" BO_ 736 0;
BA_ "DiagRequest" BO_ 736 0;
BA_ "DiagResponse" BO_ 736 0;
BA_ "GenMsgStartValue" BO_ 736 "0";
BA_ "GenMsgCycleTime" BO_ 736 100;
BA_ "GenMsgSendType" BO_ 736 0;
    */
    _PT_Data_VAN_AR_Timebase =           c_tDBKomTimer_20ms;
    _PT_Data_VAN_AR_CycleCount =        100 / _PT_Data_VAN_AR_Timebase;
    _PT_Data_VAN_AR_StartDelay =          0 / _PT_Data_VAN_AR_Timebase;
    _PT_Data_VAN_AR_Cnt = _PT_Data_VAN_AR_StartDelay;

    putValue( HMI__STMSGSD_PT_Data_VAN_AR, _PT_Data_VAN_AR_StartDelay * _PT_Data_VAN_AR_Timebase );

    _mPT_Data_VAN_AR.OpRPM_MPM_Flt.phys = getValue( HMI_OpRPM_MPM_Flt );
    _mPT_Data_VAN_AR.OpRPM_MPM_LED_Rq.phys = getValue( HMI_OpRPM_MPM_LED_Rq );
    _mPT_Data_VAN_AR.Rsrv1_PT_Data_VAN.phys = getValue( HMI_Rsrv1_PT_Data_VAN );
    _mPT_Data_VAN_AR.Rsrv2_PT_Data_VAN.phys = getValue( HMI_Rsrv2_PT_Data_VAN );
    _mPT_Data_VAN_AR.Rsrv3_PT_Data_VAN.phys = getValue( HMI_Rsrv3_PT_Data_VAN );
}

PT_Data_VAN_AR_output(void)
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_PT_Data_VAN ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_PT_Data_VAN_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _PT_Data_VAN_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _PT_Data_VAN_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_PT_Data_VAN_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _PT_Data_VAN_AR_SQC_WrongSeqJump != 0 ) &&
            ( _PT_Data_VAN_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _PT_Data_VAN_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _PT_Data_VAN_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _PT_Data_VAN_AR_SQC_RepeatedCnt ) &&
            ( _PT_Data_VAN_AR_E2E_Armed == 1  )    )
        {
            _PT_Data_VAN_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_PT_Data_VAN, SQC_help );
    }
    _mPT_Data_VAN_AR.SQC_PT_Data_VAN = SQC_help;

    if( getValue( HMI_CRC_PT_Data_VAN_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_PT_Data_VAN_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mPT_Data_VAN_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mPT_Data_VAN_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mPT_Data_VAN_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mPT_Data_VAN_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mPT_Data_VAN_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mPT_Data_VAN_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mPT_Data_VAN_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mPT_Data_VAN_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _PT_Data_VAN_AR_CRC_Offset[ _mPT_Data_VAN_AR.SQC_PT_Data_VAN ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _PT_Data_VAN_AR_CRC_ErrorCnt   && ( _PT_Data_VAN_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_PT_Data_VAN_Invalid )                                         )    )
            {
                crc++;
                if( _PT_Data_VAN_AR_CRC_ErrorCnt > 0 )
                    _PT_Data_VAN_AR_CRC_ErrorCnt--; 
            }
            _mPT_Data_VAN_AR.CRC_PT_Data_VAN = crc;
            putValue( HMI_CRC_PT_Data_VAN, crc );
        }
        else
            _mPT_Data_VAN_AR.CRC_PT_Data_VAN = getValue( HMI_CRC_PT_Data_VAN );
    }
    if( ( _PT_Data_VAN_AR_MSG_DropCnt > 0 ) &&
        ( _PT_Data_VAN_AR_E2E_Armed == 1  )    )
    {
        _PT_Data_VAN_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mPT_Data_VAN_AR );
        
    if( _PT_Data_VAN_AR_E2E_Armed == 1 )
    {
        if ( ( _PT_Data_VAN_AR_MSG_DropCnt == 0      ) &&
             ( _PT_Data_VAN_AR_CRC_ErrorCnt == 0     ) &&
             ( _PT_Data_VAN_AR_SQC_RepeatedCnt == 0  ) &&
             ( _PT_Data_VAN_AR_SQC_WrongSeqJump == 0 )    )
        {
            _PT_Data_VAN_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_PT_Data_VAN_State, 0 );
        }
    }
}

PT_Data_VAN_AR_saveEnvVars(dword hFile )
{
    filePutString("\n// Knoten EIS: PT_Data_VAN_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PT_Data_VAN_AR := %X\n", getValue( HMI__STMSG_PT_Data_VAN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PT_Data_VAN_AR := %X\n", getValue( HMI__STMSGT_PT_Data_VAN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_PT_Data_VAN := %X\n", getValue( HMI_CRC_PT_Data_VAN ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_PT_Data_VAN_Auto := %X\n", getValue( HMI_CRC_PT_Data_VAN_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_OpRPM_MPM_Flt := %X\n", getValue( HMI_OpRPM_MPM_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_OpRPM_MPM_LED_Rq := %X\n", getValue( HMI_OpRPM_MPM_LED_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_PT_Data_VAN := %X\n", getValue( HMI_Rsrv1_PT_Data_VAN ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_PT_Data_VAN := %X\n", getValue( HMI_Rsrv2_PT_Data_VAN ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv3_PT_Data_VAN := %X\n", getValue( HMI_Rsrv3_PT_Data_VAN ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_PT_Data_VAN := %X\n", getValue( HMI_SQC_PT_Data_VAN ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_PT_Data_VAN_Auto := %X\n", getValue( HMI_SQC_PT_Data_VAN_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPT_Data_VAN_AR
{
    putValue( HMI__STMSG_PT_Data_VAN_AR, 0 );
}

on EnvVar HMI__STMSG_PT_Data_VAN_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PT_Data_VAN_AR );
        if( tDelay > 0)    
            setTimer( _tPT_Data_VAN_AR, tDelay );
        else
            putValue( HMI__STMSG_PT_Data_VAN_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PT_Data_VAN_AR
{
    if( getValue( this ) )
        openPanel("PT_Data_VAN_AR");
}

on envVar HMI_E2E_PT_Data_VAN_Inject
{
    if( getValue( this ) )
    {
        _PT_Data_VAN_AR_CRC_ErrorCnt = getValue( HMI_CRC_PT_Data_VAN_ErrorCount );
        _PT_Data_VAN_AR_SQC_TriggPos = getValue( HMI_SQC_PT_Data_VAN_TriggerPosition );
        _PT_Data_VAN_AR_SQC_WrongSeqJump = getValue( HMI_SQC_PT_Data_VAN_WrongSeq );
        _PT_Data_VAN_AR_SQC_RepeatedCnt = getValue( HMI_SQC_PT_Data_VAN_Repeated );
        _PT_Data_VAN_AR_MSG_DropCnt = getValue( HMI_SQC_PT_Data_VAN_MSG_DropCnt );
        putValue( HMI_E2E_PT_Data_VAN_State, 2 );
        _PT_Data_VAN_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_OpRPM_MPM_Flt
{
    _mPT_Data_VAN_AR.OpRPM_MPM_Flt.phys = getValue(this);
}

on EnvVar HMI_OpRPM_MPM_LED_Rq
{
    _mPT_Data_VAN_AR.OpRPM_MPM_LED_Rq.phys = getValue(this);
}

on EnvVar HMI_Rsrv1_PT_Data_VAN
{
    _mPT_Data_VAN_AR.Rsrv1_PT_Data_VAN.phys = getValue(this);
}

on EnvVar HMI_Rsrv2_PT_Data_VAN
{
    _mPT_Data_VAN_AR.Rsrv2_PT_Data_VAN.phys = getValue(this);
}

on EnvVar HMI_Rsrv3_PT_Data_VAN
{
    _mPT_Data_VAN_AR.Rsrv3_PT_Data_VAN.phys = getValue(this);
}

PT_DataContain_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_PT_DataContain_Rq_AR ) )
    {
    //  message   PT_DataContain_Rq_AR ID: 1178 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _PT_DataContain_Rq_AR_DelayCnt > 0) _PT_DataContain_Rq_AR_DelayCnt--; // Mindestsendeabstand
        _PT_DataContain_Rq_AR_Cnt--;
        if( _PT_DataContain_Rq_AR_Cnt < 1 )
        {
            if( _PT_DataContain_Rq_AR_DelayCnt < 1 )
            {
                PT_DataContain_Rq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                _PT_DataContain_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _PT_DataContain_Rq_AR_DelayCnt = _PT_DataContain_Rq_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _PT_DataContain_Rq_AR_SpontanFlag = 1;
            }
            _PT_DataContain_Rq_AR_Cnt = _PT_DataContain_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _PT_DataContain_Rq_AR_SpontanFlag)
        {
            if( _PT_DataContain_Rq_AR_DelayCnt < 1 )
            {
                PT_DataContain_Rq_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _PT_DataContain_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _PT_DataContain_Rq_AR_DelayCnt = _PT_DataContain_Rq_AR_MinDelay;
            }
        }
    }
}

PT_DataContain_Rq_AR_init()
{   /* Botschaft PT_DataContain_Rq_AR ID: 1178 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1178 0;
BA_ "NmAsrMessage" BO_ 1178 0;
BA_ "GenMsgMinAcceptLength" BO_ 1178 8;
BA_ "GenMsgILSupport" BO_ 1178 1;
BA_ "DiagState" BO_ 1178 0;
BA_ "DiagRequest" BO_ 1178 0;
BA_ "DiagResponse" BO_ 1178 0;
BA_ "GenMsgStartValue" BO_ 1178 "0";
BA_ "GenMsgDelayTime" BO_ 1178 200;
BA_ "GenMsgNrOfRepetition" BO_ 1178 0;
BA_ "GenMsgCycleTime" BO_ 1178 1000;
BA_ "GenMsgSendType" BO_ 1178 5;
    */
    _PT_DataContain_Rq_AR_Timebase =           c_tDBKomTimer_20ms;
    _PT_DataContain_Rq_AR_CycleCount =       1000 / _PT_DataContain_Rq_AR_Timebase;
    _PT_DataContain_Rq_AR_StartDelay =          0 / _PT_DataContain_Rq_AR_Timebase;
    _PT_DataContain_Rq_AR_MinDelay =          200 / _PT_DataContain_Rq_AR_Timebase;
    _PT_DataContain_Rq_AR_Cnt = _PT_DataContain_Rq_AR_StartDelay;
    _PT_DataContain_Rq_AR_SpontanFlag = 0;
    _PT_DataContain_Rq_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_PT_DataContain_Rq_AR, _PT_DataContain_Rq_AR_StartDelay * _PT_DataContain_Rq_AR_Timebase );

    _mPT_DataContain_Rq_AR.CmbstEngMaintMd_Disp_Rq.phys = getValue( HMI_CmbstEngMaintMd_Disp_Rq );
	_mPT_DataContain_Rq_AR.CmbstEngMaintMd_RemDlys.phys = getValue( HMI_CmbstEngMaintMd_RemDlys );
	_mPT_DataContain_Rq_AR.CmbstEngMaintMd_Rsn.phys = getValue( HMI_CmbstEngMaintMd_Rsn );
    _mPT_DataContain_Rq_AR.HDC_AttribNum.phys = getValue( HMI_HDC_AttribNum );
    _mPT_DataContain_Rq_AR.HDC_PosnMark.phys = getValue( HMI_HDC_PosnMark );
    _mPT_DataContain_Rq_AR.HDC_RouteNum.phys = getValue( HMI_HDC_RouteNum );
    _mPT_DataContain_Rq_AR.HDC_SvContain_Rq.phys = getValue( HMI_HDC_SvContain_Rq );
    _mPT_DataContain_Rq_AR.PT4_PTCoor_ZEZ_ID_Msg.phys = getValue( HMI_PT4_PTCoor_ZEZ_ID_Msg );
    _mPT_DataContain_Rq_AR.PT4_PTCoor_ZEZ_MsgNr.phys = getValue( HMI_PT4_PTCoor_ZEZ_MsgNr );
}

PT_DataContain_Rq_AR_output()
{
    output( _mPT_DataContain_Rq_AR );
}

PT_DataContain_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PT_DataContain_Rq_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PT_DataContain_Rq_AR := %X\n", getValue( HMI__STMSG_PT_DataContain_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PT_DataContain_Rq_AR := %X\n", getValue( HMI__STMSGT_PT_DataContain_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CmbstEngMaintMd_Disp_Rq := %X\n", getValue( HMI_CmbstEngMaintMd_Disp_Rq ) );	filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CmbstEngMaintMd_RemDlys := %X\n", getValue( HMI_CmbstEngMaintMd_RemDlys ) );	filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CmbstEngMaintMd_Rsn := %X\n", getValue( HMI_CmbstEngMaintMd_Rsn ) );			filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HDC_AttribNum := %X\n", getValue( HMI_HDC_AttribNum ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HDC_PosnMark := %X\n", getValue( HMI_HDC_PosnMark ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HDC_RouteNum := %X\n", getValue( HMI_HDC_RouteNum ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HDC_SvContain_Rq := %X\n", getValue( HMI_HDC_SvContain_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT4_PTCoor_ZEZ_ID_Msg := %X\n", getValue( HMI_PT4_PTCoor_ZEZ_ID_Msg ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT4_PTCoor_ZEZ_MsgNr := %X\n", getValue( HMI_PT4_PTCoor_ZEZ_MsgNr ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPT_DataContain_Rq_AR
{
    putValue( HMI__STMSG_PT_DataContain_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_PT_DataContain_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PT_DataContain_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tPT_DataContain_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_PT_DataContain_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PT_DataContain_Rq_AR
{
    if( getValue( this ) )
        openPanel("PT_DataContain_Rq_AR");
}

on EnvVar HMI_CmbstEngMaintMd_Disp_Rq 
{
	_mPT_DataContain_Rq_AR.CmbstEngMaintMd_Disp_Rq.phys = getValue(this);
	_PT_DataContain_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CmbstEngMaintMd_RemDlys 
{
	_mPT_DataContain_Rq_AR.CmbstEngMaintMd_RemDlys.phys = getValue(this);
	_PT_DataContain_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CmbstEngMaintMd_Rsn 
{
	_mPT_DataContain_Rq_AR.CmbstEngMaintMd_Rsn.phys = getValue(this);
	_PT_DataContain_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_HDC_AttribNum
{
    _mPT_DataContain_Rq_AR.HDC_AttribNum.phys = getValue(this);
    _PT_DataContain_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_HDC_PosnMark
{
    _mPT_DataContain_Rq_AR.HDC_PosnMark.phys = getValue(this);
    _PT_DataContain_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_HDC_RouteNum
{
    _mPT_DataContain_Rq_AR.HDC_RouteNum.phys = getValue(this);
    _PT_DataContain_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_HDC_SvContain_Rq
{
    _mPT_DataContain_Rq_AR.HDC_SvContain_Rq.phys = getValue(this);
    _PT_DataContain_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PT4_PTCoor_ZEZ_ID_Msg
{
    _mPT_DataContain_Rq_AR.PT4_PTCoor_ZEZ_ID_Msg.phys = getValue(this);
    _PT_DataContain_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PT4_PTCoor_ZEZ_MsgNr
{
    _mPT_DataContain_Rq_AR.PT4_PTCoor_ZEZ_MsgNr.phys = getValue(this);
    _PT_DataContain_Rq_AR_SpontanFlag = 1;
}

PT_Disp_Rq2_AR_check_output()
{
    if( !getValue( HMI__STMSG_PT_Disp_Rq2_AR ) )
    {
    //  message   PT_Disp_Rq2_AR ID: 656 --- Sendeart 0 cyclicX --- 
        _PT_Disp_Rq2_AR_Cnt--;
        if( _PT_Disp_Rq2_AR_Cnt < 1 )
        {
            PT_Disp_Rq2_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _PT_Disp_Rq2_AR_Cnt = _PT_Disp_Rq2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

PT_Disp_Rq2_AR_init()
{   /* Botschaft PT_Disp_Rq2_AR ID: 656 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 656 0;
BA_ "NmAsrMessage" BO_ 656 0;
BA_ "GenMsgMinAcceptLength" BO_ 656 8;
BA_ "GenMsgILSupport" BO_ 656 1;
BA_ "DiagState" BO_ 656 0;
BA_ "DiagRequest" BO_ 656 0;
BA_ "DiagResponse" BO_ 656 0;
BA_ "GenMsgStartValue" BO_ 656 "0";
BA_ "GenMsgCycleTime" BO_ 656 100;
BA_ "GenMsgSendType" BO_ 656 0;
    */
    _PT_Disp_Rq2_AR_Timebase =           c_tDBKomTimer_20ms;
    _PT_Disp_Rq2_AR_CycleCount =        100 / _PT_Disp_Rq2_AR_Timebase;
    _PT_Disp_Rq2_AR_StartDelay =          0 / _PT_Disp_Rq2_AR_Timebase;
    _PT_Disp_Rq2_AR_Cnt = _PT_Disp_Rq2_AR_StartDelay;

    putValue( HMI__STMSGSD_PT_Disp_Rq2_AR, _PT_Disp_Rq2_AR_StartDelay * _PT_Disp_Rq2_AR_Timebase );

	  _mPT_Disp_Rq2_AR.AccelPdlPosn_EDR.phys = getValue( HMI_AccelPdlPosn_EDR );
	  _mPT_Disp_Rq2_AR.AccelPdlPosn_EDR_Avl.phys = getValue( HMI_AccelPdlPosn_EDR_Avl );
	  _mPT_Disp_Rq2_AR.Eng_BoostPress_Disp_Rq.phys = getValue( HMI_Eng_BoostPress_Disp_Rq );
	  _mPT_Disp_Rq2_AR.Eng_BoostPress_Max_Disp_Rq.phys = getValue( HMI_Eng_BoostPress_Max_Disp_Rq );
    _mPT_Disp_Rq2_AR.EngPwrDisp.phys = getValue( HMI_EngPwrDisp );
    _mPT_Disp_Rq2_AR.EngPwrDisp_Max.phys = getValue( HMI_EngPwrDisp_Max );
    _mPT_Disp_Rq2_AR.EngTrqDisp.phys = getValue( HMI_EngTrqDisp );
    _mPT_Disp_Rq2_AR.EngTrqDisp_Max.phys = getValue( HMI_EngTrqDisp_Max );
    _mPT_Disp_Rq2_AR.PT_DispLrnMax.phys = getValue( HMI_PT_DispLrnMax );
    _mPT_Disp_Rq2_AR.PwrTrqDispMd_Rq.phys = getValue( HMI_PwrTrqDispMd_Rq );
    _mPT_Disp_Rq2_AR.FAIA_Warn_Fail_Disp_Rq.phys = getValue( HMI_FAIA_Warn_Fail_Disp_Rq );
}

PT_Disp_Rq2_AR_output(void)
{
    output( _mPT_Disp_Rq2_AR );
}

PT_Disp_Rq2_AR_saveEnvVars(dword hFile )
{
    filePutString("\n// Knoten EIS: PT_Disp_Rq2_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PT_Disp_Rq2_AR := %X\n", getValue( HMI__STMSG_PT_Disp_Rq2_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PT_Disp_Rq2_AR := %X\n", getValue( HMI__STMSGT_PT_Disp_Rq2_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_AccelPdlPosn_EDR := %X\n", getValue( HMI_AccelPdlPosn_EDR ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_AccelPdlPosn_EDR_Avl := %X\n", getValue( HMI_AccelPdlPosn_EDR_Avl ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Eng_BoostPress_Disp_Rq := %X\n", getValue( HMI_Eng_BoostPress_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Eng_BoostPress_Max_Disp_Rq := %X\n", getValue( HMI_Eng_BoostPress_Max_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngPwrDisp := %X\n", getValue( HMI_EngPwrDisp ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngPwrDisp_Max := %X\n", getValue( HMI_EngPwrDisp_Max ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngTrqDisp := %X\n", getValue( HMI_EngTrqDisp ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngTrqDisp_Max := %X\n", getValue( HMI_EngTrqDisp_Max ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT_DispLrnMax := %X\n", getValue( HMI_PT_DispLrnMax ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PwrTrqDispMd_Rq := %X\n", getValue( HMI_PwrTrqDispMd_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount(buffer), "0.0000 HMI_FAIA_Warn_Fail_Disp_Rq := %X\n", getValue( HMI_FAIA_Warn_Fail_Disp_Rq ) );        filePutString( buffer, elcount(buffer), hFile);
}

on timer _tPT_Disp_Rq2_AR
{
    putValue( HMI__STMSG_PT_Disp_Rq2_AR, 0 );
}

on EnvVar HMI__STMSG_PT_Disp_Rq2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PT_Disp_Rq2_AR );
        if( tDelay > 0)    
            setTimer( _tPT_Disp_Rq2_AR, tDelay );
        else
            putValue( HMI__STMSG_PT_Disp_Rq2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PT_Disp_Rq2_AR
{
    if( getValue( this ) )
        openPanel("PT_Disp_Rq2_AR");
}

on EnvVar HMI_AccelPdlPosn_EDR
{
    _mPT_Disp_Rq2_AR.AccelPdlPosn_EDR.phys = getValue(this);
}

on EnvVar HMI_AccelPdlPosn_EDR_Avl
{
    _mPT_Disp_Rq2_AR.AccelPdlPosn_EDR_Avl.phys = getValue(this);
}

on EnvVar HMI_Eng_BoostPress_Disp_Rq
{
    _mPT_Disp_Rq2_AR.Eng_BoostPress_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_Eng_BoostPress_Max_Disp_Rq
{
    _mPT_Disp_Rq2_AR.Eng_BoostPress_Max_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_EngPwrDisp
{
    _mPT_Disp_Rq2_AR.EngPwrDisp.phys = getValue(this);
}

on EnvVar HMI_EngPwrDisp_Max
{
    _mPT_Disp_Rq2_AR.EngPwrDisp_Max.phys = getValue(this);
}

on EnvVar HMI_EngTrqDisp
{
    _mPT_Disp_Rq2_AR.EngTrqDisp.phys = getValue(this);
}

on EnvVar HMI_EngTrqDisp_Max
{
    _mPT_Disp_Rq2_AR.EngTrqDisp_Max.phys = getValue(this);
}

on EnvVar HMI_PT_DispLrnMax
{
    _mPT_Disp_Rq2_AR.PT_DispLrnMax.phys = getValue(this);
}

on EnvVar HMI_PwrTrqDispMd_Rq
{
    _mPT_Disp_Rq2_AR.PwrTrqDispMd_Rq.phys = getValue(this);
}

on EnvVar HMI_FAIA_Warn_Fail_Disp_Rq
{
    _mPT_Disp_Rq2_AR.FAIA_Warn_Fail_Disp_Rq.phys = getValue(this);
//	_mDRVU_DrvDyn_Disp_Rq_AR.FAIA_Warn_Fail_Disp_Rq.phys = getValue(this);
}
//////


PNHV_Stat_VAN_AR_check_output()
{
    if( !getValue( HMI__STMSG_PNHV_Stat_VAN_AR ) )
    {
    //  message   PT_Disp_Rq2_AR ID: 656 --- Sendeart 0 cyclicX --- 
        _PNHV_Stat_VAN_AR_Cnt--;
        if( _PNHV_Stat_VAN_AR_Cnt < 1 )
        {
            PNHV_Stat_VAN_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _PNHV_Stat_VAN_AR_Cnt = _PNHV_Stat_VAN_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

PNHV_Stat_VAN_AR_init()
{   /* Botschaft PNHV_Stat_VAN_AR ID: 2359033856 --- Sendeart 0 cyclicX --- 
    */
  
    _PNHV_Stat_VAN_AR_Timebase =           c_tDBKomTimer_20ms;
    _PNHV_Stat_VAN_AR_CycleCount =        100 / _PNHV_Stat_VAN_AR_Timebase;
    _PNHV_Stat_VAN_AR_StartDelay =          0 / _PNHV_Stat_VAN_AR_Timebase;
    _PNHV_Stat_VAN_AR_Cnt = _PNHV_Stat_VAN_AR_StartDelay;

    putValue( HMI__STMSGSD_PNHV_Stat_VAN_AR, _PNHV_Stat_VAN_AR_StartDelay * _PNHV_Stat_VAN_AR_Timebase );

	  _mPNHV_Stat_VAN_AR.PNHV_CellStrings_Stat.phys = getValue( HMI_PNHV_CellStrings_Stat );

}

PNHV_Stat_VAN_AR_output(void)
{
    output( _mPNHV_Stat_VAN_AR );
}

PNHV_Stat_VAN_AR_saveEnvVars(dword hFile )
{
    filePutString("\n// Knoten EIS: PNHV_Stat_VAN_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PNHV_Stat_VAN_AR := %X\n", getValue( HMI__STMSG_PNHV_Stat_VAN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PNHV_Stat_VAN_AR := %X\n", getValue( HMI__STMSGT_PNHV_Stat_VAN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
  	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_CellStrings_Stat := %X\n", getValue( HMI_PNHV_CellStrings_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
      filePutString( buffer, elcount(buffer), hFile);
}

on timer _tPNHV_Stat_VAN_AR
{
    putValue( HMI__STMSG_PNHV_Stat_VAN_AR, 0 );
}

on EnvVar HMI__STMSG_PNHV_Stat_VAN_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PNHV_Stat_VAN_AR );
        if( tDelay > 0)    
            setTimer( _tPNHV_Stat_VAN_AR, tDelay );
        else
            putValue( HMI__STMSG_PNHV_Stat_VAN_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PNHV_Stat_VAN_AR
{
    if( getValue( this ) )
        openPanel("PNHV_Stat_VAN_AR");
}

on EnvVar HMI_PNHV_CellStrings_Stat
{
    _mPNHV_Stat_VAN_AR.PNHV_CellStrings_Stat.phys = getValue(this);
}

OBWlight_Message_VAN_AR_check_output()
{
    if( !getValue( HMI__STMSG_OBWlight_Message_VAN_AR ) )
    {
    //  message   PT_Disp_Rq2_AR ID: 656 --- Sendeart 0 cyclicX --- 
        _OBWlight_Message_VAN_AR_Cnt--;
        if( _OBWlight_Message_VAN_AR_Cnt < 1 )
        {
            OBWlight_Message_VAN_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _OBWlight_Message_VAN_AR_Cnt = _OBWlight_Message_VAN_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

OBWlight_Message_VAN_AR_init()
{   /* Botschaft OBWlight_Message_VAN_AR ID: 2359033856 --- Sendeart 0 cyclicX --- 
    */
  
    _OBWlight_Message_VAN_AR_Timebase =           c_tDBKomTimer_20ms;
    _OBWlight_Message_VAN_AR_CycleCount =        1000 / _OBWlight_Message_VAN_AR_Timebase;
    _OBWlight_Message_VAN_AR_StartDelay =          0 / _OBWlight_Message_VAN_AR_Timebase;
    _OBWlight_Message_VAN_AR_Cnt = _OBWlight_Message_VAN_AR_StartDelay;

    putValue( HMI__STMSGSD_OBWlight_Message_VAN_AR, _OBWlight_Message_VAN_AR_StartDelay * _OBWlight_Message_VAN_AR_Timebase );

	  _mOBWlight_Message_VAN_AR.OWS1.phys = getValue( HMI_OWS1 );
	  _mOBWlight_Message_VAN_AR.OWS2.phys = getValue( HMI_OWS2 );
	  _mOBWlight_Message_VAN_AR.Rsrv0_OBWlight_Message_VAN.phys = getValue( HMI_Rsrv0_OBWlight_Message_VAN );

}

OBWlight_Message_VAN_AR_output(void)
{
    output( _mOBWlight_Message_VAN_AR );
}

OBWlight_Message_VAN_AR_saveEnvVars(dword hFile )
{
    filePutString("\n// Knoten EIS: OBWlight_Message_VAN_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_OBWlight_Message_VAN_AR := %X\n", getValue( HMI__STMSG_OBWlight_Message_VAN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_OBWlight_Message_VAN_AR := %X\n", getValue( HMI__STMSGT_OBWlight_Message_VAN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
  	snprintf( buffer, elcount( buffer ), "0.0000 HMI_OWS1 := %X\n", getValue( HMI_OWS1 ) );        filePutString( buffer, elcount( buffer ), hFile );
  	snprintf( buffer, elcount( buffer ), "0.0000 HMI_OWS2 := %X\n", getValue( HMI_OWS2 ) );        filePutString( buffer, elcount( buffer ), hFile );
  	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv0_OBWlight_Message_VAN := %X\n", getValue( HMI_Rsrv0_OBWlight_Message_VAN ) );        filePutString( buffer, elcount( buffer ), hFile );
      filePutString( buffer, elcount(buffer), hFile);
}

on timer _tOBWlight_Message_VAN_AR
{
    putValue( HMI__STMSG_OBWlight_Message_VAN_AR, 0 );
}

on EnvVar HMI__STMSG_OBWlight_Message_VAN_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_OBWlight_Message_VAN_AR );
        if( tDelay > 0)    
            setTimer( _tOBWlight_Message_VAN_AR, tDelay );
        else
            putValue( HMI__STMSG_OBWlight_Message_VAN_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_OBWlight_Message_VAN_AR
{
    if( getValue( this ) )
        openPanel("OBWlight_Message_VAN_AR");
}

on EnvVar HMI_OWS1
{
    _mOBWlight_Message_VAN_AR.OWS1.phys = getValue(this);
}

on EnvVar HMI_OWS2
{
    _mOBWlight_Message_VAN_AR.OWS2.phys = getValue(this);
}

on EnvVar HMI_Rsrv0_OBWlight_Message_VAN
{
    _mOBWlight_Message_VAN_AR.Rsrv0_OBWlight_Message_VAN.phys = getValue(this);
}

Tire_temp_VAN_AR_check_output()
{
    if( !getValue( HMI__STMSG_Tire_temp_VAN_AR ) )
    {
    //  message   PT_Disp_Rq2_AR ID: 656 --- Sendeart 0 cyclicX --- 
        _Tire_temp_VAN_AR_Cnt--;
        if( _Tire_temp_VAN_AR_Cnt < 1 )
        {
            Tire_temp_VAN_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _Tire_temp_VAN_AR_Cnt = _Tire_temp_VAN_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

Tire_temp_VAN_AR_init()
{   /* Botschaft Tire_temp_VAN_AR ID: 2359033856 --- Sendeart 0 cyclicX --- 
    */
  
    _Tire_temp_VAN_AR_Timebase =           c_tDBKomTimer_20ms;
    _Tire_temp_VAN_AR_CycleCount =        1000 / _Tire_temp_VAN_AR_Timebase;
    _Tire_temp_VAN_AR_StartDelay =          0 / _Tire_temp_VAN_AR_Timebase;
    _Tire_temp_VAN_AR_Cnt = _Tire_temp_VAN_AR_StartDelay;

    putValue( HMI__STMSGSD_Tire_temp_VAN_AR, _Tire_temp_VAN_AR_StartDelay * _Tire_temp_VAN_AR_Timebase );

	  _mTire_temp_VAN_AR.Tire_Temp_Stat_RLi.phys = getValue( HMI_Tire_Temp_Stat_RLi );
	  _mTire_temp_VAN_AR.Tire_Temp_Stat_RRi.phys = getValue( HMI_Tire_Temp_Stat_RRi );
	  _mTire_temp_VAN_AR.TirePress_RLi.phys = getValue( HMI_TirePress_RLi );
	  _mTire_temp_VAN_AR.TirePress_RRi.phys = getValue( HMI_TirePress_RRi );
	  _mTire_temp_VAN_AR.TireStat_RLi.phys = getValue( HMI_TireStat_RLi );
	  _mTire_temp_VAN_AR.TireStat_RRi.phys = getValue( HMI_TireStat_RRi );
	  _mTire_temp_VAN_AR.TireTemp_RLi.phys = getValue( HMI_TireTemp_RLi );
	  _mTire_temp_VAN_AR.TireTemp_RRi.phys = getValue( HMI_TireTemp_RRi );

}

Tire_temp_VAN_AR_output(void)
{
    output( _mTire_temp_VAN_AR );
}

Tire_temp_VAN_AR_saveEnvVars(dword hFile )
{
    filePutString("\n// Knoten EIS: Tire_temp_VAN_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Tire_temp_VAN_AR := %X\n", getValue( HMI__STMSG_Tire_temp_VAN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Tire_temp_VAN_AR := %X\n", getValue( HMI__STMSGT_Tire_temp_VAN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
  	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Tire_Temp_Stat_RLi := %X\n", getValue( HMI_Tire_Temp_Stat_RLi ) );        filePutString( buffer, elcount( buffer ), hFile );
  	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Tire_Temp_Stat_RRi := %X\n", getValue( HMI_Tire_Temp_Stat_RRi ) );        filePutString( buffer, elcount( buffer ), hFile );
  	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TirePress_RLi := %X\n", getValue( HMI_TirePress_RLi ) );        filePutString( buffer, elcount( buffer ), hFile );
  	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TirePress_RRi := %X\n", getValue( HMI_TirePress_RRi ) );        filePutString( buffer, elcount( buffer ), hFile );
  	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TireStat_RLi := %X\n", getValue( HMI_TireStat_RLi ) );        filePutString( buffer, elcount( buffer ), hFile );
  	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TireStat_RRi := %X\n", getValue( HMI_TireStat_RRi ) );        filePutString( buffer, elcount( buffer ), hFile );
  	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TireTemp_RLi := %X\n", getValue( HMI_TireTemp_RLi ) );        filePutString( buffer, elcount( buffer ), hFile );
  	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TireTemp_RRi := %X\n", getValue( HMI_TireTemp_RRi ) );        filePutString( buffer, elcount( buffer ), hFile );
      filePutString( buffer, elcount(buffer), hFile);
}

on timer _tTire_temp_VAN_AR
{
    putValue( HMI__STMSG_Tire_temp_VAN_AR, 0 );
}

on EnvVar HMI__STMSG_Tire_temp_VAN_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Tire_temp_VAN_AR );
        if( tDelay > 0)    
            setTimer( _tTire_temp_VAN_AR, tDelay );
        else
            putValue( HMI__STMSG_Tire_temp_VAN_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Tire_temp_VAN_AR
{
    if( getValue( this ) )
        openPanel("Tire_temp_VAN_AR");
}

on EnvVar HMI_Tire_Temp_Stat_RLi
{
    _mTire_temp_VAN_AR.Tire_Temp_Stat_RLi.phys = getValue(this);
}

on EnvVar HMI_Tire_Temp_Stat_RRi
{
    _mTire_temp_VAN_AR.Tire_Temp_Stat_RRi.phys = getValue(this);
}

on EnvVar HMI_TirePress_RLi
{
    _mTire_temp_VAN_AR.TirePress_RLi.phys = getValue(this);
}

on EnvVar HMI_TirePress_RRi
{
    _mTire_temp_VAN_AR.TirePress_RRi.phys = getValue(this);
}

on EnvVar HMI_TireStat_RLi
{
    _mTire_temp_VAN_AR.TireStat_RLi.phys = getValue(this);
}

on EnvVar HMI_TireStat_RRi
{
    _mTire_temp_VAN_AR.TireStat_RRi.phys = getValue(this);
}

on EnvVar HMI_TireTemp_RLi
{
    _mTire_temp_VAN_AR.TireTemp_RLi.phys = getValue(this);
}

on EnvVar HMI_TireTemp_RRi
{
    _mTire_temp_VAN_AR.TireTemp_RRi.phys = getValue(this);
}



//////

PtHyb_Mngmnt_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_PtHyb_Mngmnt_Rq_AR ) )
    {
    //  message   PtHyb_Mngmnt_Rq_AR ID: 1279 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _PtHyb_Mngmnt_Rq_AR_DelayCnt > 0) _PtHyb_Mngmnt_Rq_AR_DelayCnt--; // Mindestsendeabstand
        _PtHyb_Mngmnt_Rq_AR_Cnt--;
        if( _PtHyb_Mngmnt_Rq_AR_Cnt < 1 )
        {
            if( _PtHyb_Mngmnt_Rq_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                PtHyb_Mngmnt_Rq_AR_output();
                _PtHyb_Mngmnt_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _PtHyb_Mngmnt_Rq_AR_DelayCnt = _PtHyb_Mngmnt_Rq_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _PtHyb_Mngmnt_Rq_AR_SpontanFlag = 1;
            }
            _PtHyb_Mngmnt_Rq_AR_Cnt = _PtHyb_Mngmnt_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _PtHyb_Mngmnt_Rq_AR_SpontanFlag)
        {
            if( _PtHyb_Mngmnt_Rq_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                PtHyb_Mngmnt_Rq_AR_output();
                _PtHyb_Mngmnt_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _PtHyb_Mngmnt_Rq_AR_DelayCnt = _PtHyb_Mngmnt_Rq_AR_MinDelay;
            }
        }
    }
}

PtHyb_Mngmnt_Rq_AR_init()
{   /* Botschaft PtHyb_Mngmnt_Rq_AR ID: 1279 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1279 0;
BA_ "NmAsrMessage" BO_ 1279 0;
BA_ "GenMsgMinAcceptLength" BO_ 1279 2;
BA_ "GenMsgILSupport" BO_ 1279 1;
BA_ "DiagState" BO_ 1279 0;
BA_ "DiagRequest" BO_ 1279 0;
BA_ "DiagResponse" BO_ 1279 0;
BA_ "GenMsgStartValue" BO_ 1279 "0";
BA_ "GenMsgDelayTime" BO_ 1279 100;
BA_ "GenMsgNrOfRepetition" BO_ 1279 0;
BA_ "GenMsgCycleTime" BO_ 1279 5000;
BA_ "GenMsgSendType" BO_ 1279 5;
    */
    _PtHyb_Mngmnt_Rq_AR_Timebase =                  c_tDBKomTimer_20ms;
    _PtHyb_Mngmnt_Rq_AR_CycleCount =             5000 / _PtHyb_Mngmnt_Rq_AR_Timebase;
    _PtHyb_Mngmnt_Rq_AR_StartDelay =                0 / _PtHyb_Mngmnt_Rq_AR_Timebase;
    _PtHyb_Mngmnt_Rq_AR_MinDelay =                100 / _PtHyb_Mngmnt_Rq_AR_Timebase;
    _PtHyb_Mngmnt_Rq_AR_Cnt = _PtHyb_Mngmnt_Rq_AR_StartDelay;
    _PtHyb_Mngmnt_Rq_AR_SpontanFlag = 0;
    _PtHyb_Mngmnt_Rq_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_PtHyb_Mngmnt_Rq_AR, _PtHyb_Mngmnt_Rq_AR_StartDelay * _PtHyb_Mngmnt_Rq_AR_Timebase );

    _mPtHyb_Mngmnt_Rq_AR.RemTank_SwLED_Rq.phys = getValue( HMI_RemTank_SwLED_Rq );
    _mPtHyb_Mngmnt_Rq_AR.RemTank_Unlk_Rq.phys = getValue( HMI_RemTank_Unlk_Rq );
}

PtHyb_Mngmnt_Rq_AR_output(void)
{
    output( _mPtHyb_Mngmnt_Rq_AR );
}

PtHyb_Mngmnt_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PtHyb_Mngmnt_Rq_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PtHyb_Mngmnt_Rq_AR := %X\n", getValue( HMI__STMSG_PtHyb_Mngmnt_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PtHyb_Mngmnt_Rq_AR := %X\n", getValue( HMI__STMSGT_PtHyb_Mngmnt_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RemTank_SwLED_Rq := %X\n", getValue( HMI_RemTank_SwLED_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RemTank_Unlk_Rq := %X\n", getValue( HMI_RemTank_Unlk_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPtHyb_Mngmnt_Rq_AR
{
    putValue( HMI__STMSG_PtHyb_Mngmnt_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_PtHyb_Mngmnt_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PtHyb_Mngmnt_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tPtHyb_Mngmnt_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_PtHyb_Mngmnt_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PtHyb_Mngmnt_Rq_AR
{
    if( getValue( this ) )
        openPanel("PtHyb_Mngmnt_Rq_AR");
}

on EnvVar HMI_RemTank_SwLED_Rq
{
    _mPtHyb_Mngmnt_Rq_AR.RemTank_SwLED_Rq.phys = getValue(this);
}

on EnvVar HMI_RemTank_Unlk_Rq
{
    _mPtHyb_Mngmnt_Rq_AR.RemTank_Unlk_Rq.phys = getValue(this);
}

PtMngmnt_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_PtMngmnt_Disp_Rq_AR ) )
    {
    //  message   PtMngmnt_Disp_Rq_AR ID: 321 --- Sendeart 0 cyclicX --- 
        _PtMngmnt_Disp_Rq_AR_Cnt--;
        if( _PtMngmnt_Disp_Rq_AR_Cnt < 1 )
        {
            PtMngmnt_Disp_Rq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _PtMngmnt_Disp_Rq_AR_Cnt = _PtMngmnt_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

PtMngmnt_Disp_Rq_AR_init()
{   /* Botschaft PtMngmnt_Disp_Rq_AR ID: 321 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 321 0;
BA_ "NmAsrMessage" BO_ 321 0;
BA_ "GenMsgMinAcceptLength" BO_ 321 8;
BA_ "GenMsgILSupport" BO_ 321 1;
BA_ "DiagState" BO_ 321 0;
BA_ "DiagRequest" BO_ 321 0;
BA_ "DiagResponse" BO_ 321 0;
BA_ "GenMsgStartValue" BO_ 321 "0";
BA_ "GenMsgStartDelayTime" BO_ 321 0;
BA_ "GenMsgCycleTime" BO_ 321 100;
BA_ "GenMsgSendType" BO_ 321 0;
    */
    _PtMngmnt_Disp_Rq_AR_Timebase =         c_tDBKomTimer_20ms;
    _PtMngmnt_Disp_Rq_AR_CycleCount =      100 / _PtMngmnt_Disp_Rq_AR_Timebase;
    _PtMngmnt_Disp_Rq_AR_StartDelay =        0 / _PtMngmnt_Disp_Rq_AR_Timebase;
    _PtMngmnt_Disp_Rq_AR_Cnt = _PtMngmnt_Disp_Rq_AR_StartDelay;

    putValue( HMI__STMSGSD_PtMngmnt_Disp_Rq_AR, _PtMngmnt_Disp_Rq_AR_StartDelay * _PtMngmnt_Disp_Rq_AR_Timebase );

    _mPtMngmnt_Disp_Rq_AR.ClutchOverTemp_Disp_Rq.phys = getValue( HMI_ClutchOverTemp_Disp_Rq );
    _mPtMngmnt_Disp_Rq_AR.EngOilPress_Warn_Rq.phys = getValue( HMI_EngOilPress_Warn_Rq );
    _mPtMngmnt_Disp_Rq_AR.Hyb_Energy_WarnDisp_Rq.phys = getValue( HMI_Hyb_Energy_WarnDisp_Rq );
    _mPtMngmnt_Disp_Rq_AR.Hyb_EnergyFlow_Disp_Rq_V2.phys = getValue( HMI_Hyb_EnergyFlow_Disp_Rq_V2 );
    _mPtMngmnt_Disp_Rq_AR.Hyb_WarnDisp_Rq.phys = getValue( HMI_Hyb_WarnDisp_Rq );
    _mPtMngmnt_Disp_Rq_AR.HybPwr_Disp_Rq.phys = getValue( HMI_HybPwr_Disp_Rq );
    _mPtMngmnt_Disp_Rq_AR.IndLmpChk_Off_Rq.phys = getValue( HMI_IndLmpChk_Off_Rq );
    _mPtMngmnt_Disp_Rq_AR.PlugInHyb_OprtnMd_V2.phys = getValue( HMI_PlugInHyb_OprtnMd_V2 );
    _mPtMngmnt_Disp_Rq_AR.PlugInHyb_OprtnMdMsg_V2.phys = getValue( HMI_PlugInHyb_OprtnMdMsg_V2 );
    _mPtMngmnt_Disp_Rq_AR.RDOS_Md_Stat.phys = getValue( HMI_RDOS_Md_Stat );
    _mPtMngmnt_Disp_Rq_AR.RDOS_Md_Avl.phys = getValue( HMI_RDOS_Md_Avl );
    _mPtMngmnt_Disp_Rq_AR.PNHV_Bat_SOC_Disp_Rq.phys = getValue( HMI_PNHV_Bat_SOC_Disp_Rq );
    _mPtMngmnt_Disp_Rq_AR.PressClutchPdl_MsgDisp_Rq.phys = getValue( HMI_PressClutchPdl_MsgDisp_Rq );
    _mPtMngmnt_Disp_Rq_AR.PT_Rdy_IndLmp_Rq.phys = getValue( HMI_PT_Rdy_IndLmp_Rq );
    _mPtMngmnt_Disp_Rq_AR.SSA_ECO_Md_Actv_Disp_Rq.phys = getValue( HMI_SSA_ECO_Md_Actv_Disp_Rq );
    _mPtMngmnt_Disp_Rq_AR.SSA_ECO_Md_DispCol_Rq.phys = getValue( HMI_SSA_ECO_Md_DispCol_Rq );
    _mPtMngmnt_Disp_Rq_AR.SSA_ECO_Sw_LED_On_Rq.phys = getValue( HMI_SSA_ECO_Sw_LED_On_Rq );
	  _mPtMngmnt_Disp_Rq_AR.SSA_Icon_Disp_Rq.phys = getValue( HMI_SSA_Icon_Disp_Rq );  
    _mPtMngmnt_Disp_Rq_AR.SSA_Md_Disp_Rq.phys = getValue( HMI_SSA_Md_Disp_Rq );
    _mPtMngmnt_Disp_Rq_AR.SSA_MdChg_Msg_Disp_Rq.phys = getValue( HMI_SSA_MdChg_Msg_Disp_Rq );  
    _mPtMngmnt_Disp_Rq_AR.SSA_Msg_Disp_Rq.phys = getValue( HMI_SSA_Msg_Disp_Rq );
}

PtMngmnt_Disp_Rq_AR_output(void)
{
    output( _mPtMngmnt_Disp_Rq_AR );
}

PtMngmnt_Disp_Rq_AR_saveEnvVars(dword hFile )
{
    filePutString("\n// Knoten EIS: PtMngmnt_Disp_Rq_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PtMngmnt_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_PtMngmnt_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PtMngmnt_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_PtMngmnt_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ClutchOverTemp_Disp_Rq := %X\n", getValue( HMI_ClutchOverTemp_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngOilPress_Warn_Rq := %X\n", getValue( HMI_EngOilPress_Warn_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Hyb_Energy_WarnDisp_Rq := %X\n", getValue( HMI_Hyb_Energy_WarnDisp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Hyb_EnergyFlow_Disp_Rq_V2 := %X\n", getValue( HMI_Hyb_EnergyFlow_Disp_Rq_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Hyb_WarnDisp_Rq := %X\n", getValue( HMI_Hyb_WarnDisp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HybPwr_Disp_Rq := %X\n", getValue( HMI_HybPwr_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IndLmpChk_Off_Rq := %X\n", getValue( HMI_IndLmpChk_Off_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PlugInHyb_OprtnMd_V2 := %X\n", getValue( HMI_PlugInHyb_OprtnMd_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PlugInHyb_OprtnMdMsg_V2 := %X\n", getValue( HMI_PlugInHyb_OprtnMdMsg_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RDOS_Md_Stat := %X\n", getValue( HMI_RDOS_Md_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RDOS_Md_Avl := %X\n", getValue( HMI_RDOS_Md_Avl ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_Bat_SOC_Disp_Rq := %X\n", getValue( HMI_PNHV_Bat_SOC_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PressClutchPdl_MsgDisp_Rq := %X\n", getValue( HMI_PressClutchPdl_MsgDisp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT_Rdy_IndLmp_Rq := %X\n", getValue( HMI_PT_Rdy_IndLmp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SSA_ECO_Md_Actv_Disp_Rq := %X\n", getValue( HMI_SSA_ECO_Md_Actv_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SSA_ECO_Md_DispCol_Rq := %X\n", getValue( HMI_SSA_ECO_Md_DispCol_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SSA_ECO_Sw_LED_On_Rq := %X\n", getValue( HMI_SSA_ECO_Sw_LED_On_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SSA_MdChg_Msg_Disp_Rq := %X\n", getValue( HMI_SSA_MdChg_Msg_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );  
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SSA_Md_Disp_Rq := %X\n", getValue( HMI_SSA_Md_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_SSA_Icon_Disp_Rq := %X\n", getValue( HMI_SSA_Icon_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );  
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SSA_Msg_Disp_Rq := %X\n", getValue( HMI_SSA_Msg_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPtMngmnt_Disp_Rq_AR
{
    putValue( HMI__STMSG_PtMngmnt_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_PtMngmnt_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PtMngmnt_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tPtMngmnt_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_PtMngmnt_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PtMngmnt_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("PtMngmnt_Disp_Rq_AR");
}

on EnvVar HMI_ClutchOverTemp_Disp_Rq
{
    _mPtMngmnt_Disp_Rq_AR.ClutchOverTemp_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_EngOilPress_Warn_Rq
{
    _mPtMngmnt_Disp_Rq_AR.EngOilPress_Warn_Rq.phys = getValue(this);
}

on EnvVar HMI_Hyb_Energy_WarnDisp_Rq
{
    _mPtMngmnt_Disp_Rq_AR.Hyb_Energy_WarnDisp_Rq.phys = getValue(this);
}

on EnvVar HMI_Hyb_EnergyFlow_Disp_Rq_V2
{
    _mPtMngmnt_Disp_Rq_AR.Hyb_EnergyFlow_Disp_Rq_V2.phys = getValue(this);
}

on EnvVar HMI_Hyb_WarnDisp_Rq
{
    _mPtMngmnt_Disp_Rq_AR.Hyb_WarnDisp_Rq.phys = getValue(this);
}

on EnvVar HMI_HybPwr_Disp_Rq
{
    _mPtMngmnt_Disp_Rq_AR.HybPwr_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_IndLmpChk_Off_Rq
{
    _mPtMngmnt_Disp_Rq_AR.IndLmpChk_Off_Rq.phys = getValue(this);
}

on EnvVar HMI_PlugInHyb_OprtnMd_V2
{
    _mPtMngmnt_Disp_Rq_AR.PlugInHyb_OprtnMd_V2.phys = getValue(this);
}

on EnvVar HMI_PlugInHyb_OprtnMdMsg_V2
{
    _mPtMngmnt_Disp_Rq_AR.PlugInHyb_OprtnMdMsg_V2.phys = getValue(this);
}

on EnvVar HMI_RDOS_Md_Stat
{
    _mPtMngmnt_Disp_Rq_AR.RDOS_Md_Stat.phys = getValue(this);
}

on EnvVar HMI_RDOS_Md_Avl
{
    _mPtMngmnt_Disp_Rq_AR.RDOS_Md_Avl.phys = getValue(this);
}

on EnvVar HMI_PNHV_Bat_SOC_Disp_Rq
{
    _mPtMngmnt_Disp_Rq_AR.PNHV_Bat_SOC_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_PressClutchPdl_MsgDisp_Rq
{
    _mPtMngmnt_Disp_Rq_AR.PressClutchPdl_MsgDisp_Rq.phys = getValue(this);
}

on EnvVar HMI_PT_Rdy_IndLmp_Rq
{
    _mPtMngmnt_Disp_Rq_AR.PT_Rdy_IndLmp_Rq.phys = getValue(this);
}

on EnvVar HMI_SSA_ECO_Md_Actv_Disp_Rq
{
    _mPtMngmnt_Disp_Rq_AR.SSA_ECO_Md_Actv_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_SSA_ECO_Md_DispCol_Rq
{
    _mPtMngmnt_Disp_Rq_AR.SSA_ECO_Md_DispCol_Rq.phys = getValue(this);
}

on EnvVar HMI_SSA_ECO_Sw_LED_On_Rq
{
    _mPtMngmnt_Disp_Rq_AR.SSA_ECO_Sw_LED_On_Rq.phys = getValue(this);
}

on EnvVar HMI_SSA_Icon_Disp_Rq
{
    _mPtMngmnt_Disp_Rq_AR.SSA_Icon_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_SSA_Md_Disp_Rq
{
    _mPtMngmnt_Disp_Rq_AR.SSA_Md_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_SSA_MdChg_Msg_Disp_Rq
{
    _mPtMngmnt_Disp_Rq_AR.SSA_MdChg_Msg_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_SSA_Msg_Disp_Rq
{
    _mPtMngmnt_Disp_Rq_AR.SSA_Msg_Disp_Rq.phys = getValue(this);
}

	Radar_EGO1_Obj_Attr1_AR_check_output()
{
    if( !getValue( HMI__STMSG_Radar_EGO1_Obj_Attr1_AR ) )
    {
    //  message   Radar_EGO1_Obj_Attr1_AR ID: 2226913280 --- Sendeart 0 cyclicX --- 
        _Radar_EGO1_Obj_Attr1_AR_Cnt--;
        if( _Radar_EGO1_Obj_Attr1_AR_Cnt < 1 )
        {
            Radar_EGO1_Obj_Attr1_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _Radar_EGO1_Obj_Attr1_AR_Cnt = _Radar_EGO1_Obj_Attr1_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

Radar_EGO1_Obj_Attr1_AR_init()
{   /* Botschaft Radar_EGO1_Obj_Attr1_AR ID: 2226913280 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 2226913280 0;
BA_ "NmAsrMessage" BO_ 2226913280 0;
BA_ "GenMsgMinAcceptLength" BO_ 2226913280 8;
BA_ "GenMsgILSupport" BO_ 2226913280 1;
BA_ "DiagState" BO_ 2226913280 0;
BA_ "DiagRequest" BO_ 2226913280 0;
BA_ "DiagResponse" BO_ 2226913280 0;
BA_ "GenMsgStartValue" BO_ 2226913280 "0";
BA_ "GenMsgStartDelayTime" BO_ 2226913280 0;
BA_ "GenMsgDelayTime" BO_ 2226913280 5;
BA_ "GenMsgNrOfRepetitions" BO_ 2226913280 0;
BA_ "GenMsgCycleTime" BO_ 2226913280 40;
BA_ "GenMsgSendType" BO_ 2226913280 5;
    */
    _Radar_EGO1_Obj_Attr1_AR_Timebase =           c_tDBKomTimer_20ms;
    _Radar_EGO1_Obj_Attr1_AR_CycleCount =       40 / _Radar_EGO1_Obj_Attr1_AR_Timebase;
    _Radar_EGO1_Obj_Attr1_AR_StartDelay =         0 / _Radar_EGO1_Obj_Attr1_AR_Timebase;
    _Radar_EGO1_Obj_Attr1_AR_MinDelay =           5 / _Radar_EGO1_Obj_Attr1_AR_Timebase;
    _Radar_EGO1_Obj_Attr1_AR_Cnt = _Radar_EGO1_Obj_Attr1_AR_StartDelay;
    _Radar_EGO1_Obj_Attr1_AR_SpontanFlag = 0;
    _Radar_EGO1_Obj_Attr1_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_Radar_EGO1_Obj_Attr1_AR, _Radar_EGO1_Obj_Attr1_AR_StartDelay * _Radar_EGO1_Obj_Attr1_AR_Timebase );

    _mRadar_EGO1_Obj_Attr1_AR.CRC_Radar_EGO1_Obj_Attr1.phys = getValue( HMI_CRC_Radar_EGO1_Obj_Attr1 );
    _mRadar_EGO1_Obj_Attr1_AR.Radar_EGO1_Obj_Class.phys = getValue( HMI_Radar_EGO1_Obj_Class );
    _mRadar_EGO1_Obj_Attr1_AR.Radar_EGO1_Obj_CutInLvl.phys = getValue( HMI_Radar_EGO1_Obj_CutInLvl );
    _mRadar_EGO1_Obj_Attr1_AR.Radar_EGO1_Obj_Dist_X.phys = getValue( HMI_Radar_EGO1_Obj_Dist_X );
    _mRadar_EGO1_Obj_Attr1_AR.Radar_EGO1_Obj_MoveType.phys = getValue( HMI_Radar_EGO1_Obj_MoveType );
    _mRadar_EGO1_Obj_Attr1_AR.Radar_EGO1_Obj_RelAccel_X.phys = getValue( HMI_Radar_EGO1_Obj_RelAccel_X );
    _mRadar_EGO1_Obj_Attr1_AR.Radar_EGO1_Obj_RelSpd_X.phys = getValue( HMI_Radar_EGO1_Obj_RelSpd_X );
    _mRadar_EGO1_Obj_Attr1_AR.Rsrv1_Radar_EGO1_Obj_Attr1.phys = getValue( HMI_Rsrv1_Radar_EGO1_Obj_Attr1 );
    _mRadar_EGO1_Obj_Attr1_AR.Rsrv2_Radar_EGO1_Obj_Attr1.phys = getValue( HMI_Rsrv2_Radar_EGO1_Obj_Attr1 );
    _mRadar_EGO1_Obj_Attr1_AR.Rsrv3_Radar_EGO1_Obj_Attr1.phys = getValue( HMI_Rsrv3_Radar_EGO1_Obj_Attr1 );
    
}

Radar_EGO1_Obj_Attr1_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_Radar_EGO1_Obj_Attr1 ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_Radar_EGO1_Obj_Attr1_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _Radar_EGO1_Obj_Attr1_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _Radar_EGO1_Obj_Attr1_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_Radar_EGO1_Obj_Attr1_AR_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _Radar_EGO1_Obj_Attr1_AR_SQC_WrongSeqJump != 0 ) &&
            ( _Radar_EGO1_Obj_Attr1_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _Radar_EGO1_Obj_Attr1_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _Radar_EGO1_Obj_Attr1_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _Radar_EGO1_Obj_Attr1_AR_SQC_RepeatedCnt ) &&
            ( _Radar_EGO1_Obj_Attr1_AR_E2E_Armed == 1  )    )
        {
            _Radar_EGO1_Obj_Attr1_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_Radar_EGO1_Obj_Attr1, SQC_help );
    }
    _mRadar_EGO1_Obj_Attr1_AR.SQC_Radar_EGO1_Obj_Attr1 = SQC_help;

    if( getValue( HMI_CRC_Radar_EGO1_Obj_Attr1_AR_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_Radar_EGO1_Obj_Attr1_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable_profile02[ crc ^ _mRadar_EGO1_Obj_Attr1_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mRadar_EGO1_Obj_Attr1_AR.byte( 1 ) ];
//            crc = crctable_profile02[ crc ^ _mRadar_EGO1_Obj_Attr1_AR.byte( 2 ) ];
//            crc = crctable_profile02[ crc ^ _mRadar_EGO1_Obj_Attr1_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mRadar_EGO1_Obj_Attr1_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mRadar_EGO1_Obj_Attr1_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mRadar_EGO1_Obj_Attr1_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mRadar_EGO1_Obj_Attr1_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _Radar_EGO1_Obj_Attr1_AR_CRC_Offset[ _mRadar_EGO1_Obj_Attr1_AR.SQC_Radar_EGO1_Obj_Attr1 ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _Radar_EGO1_Obj_Attr1_AR_CRC_ErrorCnt   && ( _Radar_EGO1_Obj_Attr1_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Radar_EGO1_Obj_Attr1_AR_Invalid )                                         )    )
            {
                crc++;
                if( _Radar_EGO1_Obj_Attr1_AR_CRC_ErrorCnt > 0 )
                    _Radar_EGO1_Obj_Attr1_AR_CRC_ErrorCnt--; 
            }
            _mRadar_EGO1_Obj_Attr1_AR.CRC_Radar_EGO1_Obj_Attr1 = crc;
            putValue( HMI_CRC_Radar_EGO1_Obj_Attr1, crc );
        }
        else
            _mRadar_EGO1_Obj_Attr1_AR.CRC_Radar_EGO1_Obj_Attr1 = getValue( HMI_CRC_Radar_EGO1_Obj_Attr1 );
    }
    else
    {
        if( !getValue( HMI_CRC_Radar_EGO1_Obj_Attr1_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mRadar_EGO1_Obj_Attr1_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mRadar_EGO1_Obj_Attr1_AR.byte( 1 ) ];
//            crc = crctable[ crc ^ _mRadar_EGO1_Obj_Attr1_AR.byte( 2 ) ];
//            crc = crctable[ crc ^ _mRadar_EGO1_Obj_Attr1_AR.byte( 3 ) ];
//            crc = crctable[ crc ^ _mRadar_EGO1_Obj_Attr1_AR.byte( 4 ) ];
//            crc = crctable[ crc ^ _mRadar_EGO1_Obj_Attr1_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mRadar_EGO1_Obj_Attr1_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mRadar_EGO1_Obj_Attr1_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _Radar_EGO1_Obj_Attr1_AR_CRC_ErrorCnt   && ( _Radar_EGO1_Obj_Attr1_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Radar_EGO1_Obj_Attr1_AR_Invalid )                                         )    )
            {
                crc++;
                if( _Radar_EGO1_Obj_Attr1_AR_CRC_ErrorCnt > 0 )
                    _Radar_EGO1_Obj_Attr1_AR_CRC_ErrorCnt--; 
            }
            _mRadar_EGO1_Obj_Attr1_AR.CRC_Radar_EGO1_Obj_Attr1 = crc;
            putValue( HMI_CRC_Radar_EGO1_Obj_Attr1, crc );
        }
        else
            _mRadar_EGO1_Obj_Attr1_AR.CRC_Radar_EGO1_Obj_Attr1 = getValue( HMI_CRC_Radar_EGO1_Obj_Attr1 );
    }
    if( ( _Radar_EGO1_Obj_Attr1_AR_MSG_DropCnt > 0 ) &&
        ( _Radar_EGO1_Obj_Attr1_AR_E2E_Armed == 1  )    )
    {
        _Radar_EGO1_Obj_Attr1_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mRadar_EGO1_Obj_Attr1_AR );
        
    if( _Radar_EGO1_Obj_Attr1_AR_E2E_Armed == 1 )
    {
        if ( ( _Radar_EGO1_Obj_Attr1_AR_MSG_DropCnt == 0      ) &&
             ( _Radar_EGO1_Obj_Attr1_AR_CRC_ErrorCnt == 0     ) &&
             ( _Radar_EGO1_Obj_Attr1_AR_SQC_RepeatedCnt == 0  ) &&
             ( _Radar_EGO1_Obj_Attr1_AR_SQC_WrongSeqJump == 0 )    )
        {
            _Radar_EGO1_Obj_Attr1_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_Radar_EGO1_Obj_Attr1_AR_State, 0 );
        }
    }
}

Radar_EGO1_Obj_Attr1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Radar_EGO1_Obj_Attr1_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Radar_EGO1_Obj_Attr1_AR := %X\n", getValue( HMI__STMSG_Radar_EGO1_Obj_Attr1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Radar_EGO1_Obj_Attr1_AR := %X\n", getValue( HMI__STMSGT_Radar_EGO1_Obj_Attr1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Radar_EGO1_Obj_Attr1 := %X\n", getValue( HMI_CRC_Radar_EGO1_Obj_Attr1 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_EGO1_Obj_Class := %X\n", getValue( HMI_Radar_EGO1_Obj_Class ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_EGO1_Obj_CutInLvl := %X\n", getValue( HMI_Radar_EGO1_Obj_CutInLvl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_EGO1_Obj_Dist_X := %X\n", getValue( HMI_Radar_EGO1_Obj_Dist_X ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Radar_EGO1_Obj_Attr1_Auto := %X\n", getValue( HMI_CRC_Radar_EGO1_Obj_Attr1_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_EGO1_Obj_MoveType := %X\n", getValue( HMI_Radar_EGO1_Obj_MoveType ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_EGO1_Obj_RelAccel_X := %X\n", getValue( HMI_Radar_EGO1_Obj_RelAccel_X ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radar_EGO1_Obj_RelSpd_X := %X\n", getValue( HMI_Radar_EGO1_Obj_RelSpd_X ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_Radar_EGO1_Obj_Attr1 := %X\n", getValue( HMI_Rsrv1_Radar_EGO1_Obj_Attr1 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_Radar_EGO1_Obj_Attr1 := %X\n", getValue( HMI_Rsrv2_Radar_EGO1_Obj_Attr1 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv3_Radar_EGO1_Obj_Attr1 := %X\n", getValue( HMI_Rsrv3_Radar_EGO1_Obj_Attr1 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Radar_EGO1_Obj_Attr1 := %X\n", getValue( HMI_SQC_Radar_EGO1_Obj_Attr1 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Radar_EGO1_Obj_Attr1_Auto := %X\n", getValue( HMI_SQC_Radar_EGO1_Obj_Attr1_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tRadar_EGO1_Obj_Attr1_AR
{
    putValue( HMI__STMSG_Radar_EGO1_Obj_Attr1_AR, 0 );
}

on EnvVar HMI__STMSG_Radar_EGO1_Obj_Attr1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Radar_EGO1_Obj_Attr1_AR );
        if( tDelay > 0)    
            setTimer( _tRadar_EGO1_Obj_Attr1_AR, tDelay );
        else
            putValue( HMI__STMSG_Radar_EGO1_Obj_Attr1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Radar_EGO1_Obj_Attr1_AR
{
    if( getValue( this ) )
        openPanel("Radar_EGO1_Obj_Attr1_AR");
}

on envVar HMI_E2E_Radar_EGO1_Obj_Attr1_AR_Inject
{
    if( getValue( this ) )
    {
        _Radar_EGO1_Obj_Attr1_AR_CRC_ErrorCnt = getValue( HMI_CRC_Radar_EGO1_Obj_Attr1_AR_ErrorCount );
        _Radar_EGO1_Obj_Attr1_AR_SQC_TriggPos = getValue( HMI_SQC_Radar_EGO1_Obj_Attr1_TriggerPosition );
        _Radar_EGO1_Obj_Attr1_AR_SQC_WrongSeqJump = getValue( HMI_SQC_Radar_EGO1_Obj_Attr1_WrongSeq );
        _Radar_EGO1_Obj_Attr1_AR_SQC_RepeatedCnt = getValue( HMI_SQC_Radar_EGO1_Obj_Attr1_Repeated );
        _Radar_EGO1_Obj_Attr1_AR_MSG_DropCnt = getValue( HMI_SQC_Radar_EGO1_Obj_Attr1_MSG_DropCnt );
        putValue( HMI_E2E_Radar_EGO1_Obj_Attr1_AR_State, 2 );
        _Radar_EGO1_Obj_Attr1_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_CRC_Radar_EGO1_Obj_Attr1
{
    _mRadar_EGO1_Obj_Attr1_AR.CRC_Radar_EGO1_Obj_Attr1.phys = getValue(this);
    _Radar_EGO1_Obj_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Radar_EGO1_Obj_Class
{
    _mRadar_EGO1_Obj_Attr1_AR.Radar_EGO1_Obj_Class.phys = getValue(this);
    _Radar_EGO1_Obj_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Radar_EGO1_Obj_CutInLvl
{
    _mRadar_EGO1_Obj_Attr1_AR.Radar_EGO1_Obj_CutInLvl.phys = getValue(this);
    _Radar_EGO1_Obj_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Radar_EGO1_Obj_Dist_X
{
    _mRadar_EGO1_Obj_Attr1_AR.Radar_EGO1_Obj_Dist_X.phys = getValue(this);
    _Radar_EGO1_Obj_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Radar_EGO1_Obj_MoveType
{
    _mRadar_EGO1_Obj_Attr1_AR.Radar_EGO1_Obj_MoveType.phys = getValue(this);
    _Radar_EGO1_Obj_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Radar_EGO1_Obj_RelAccel_X
{
    _mRadar_EGO1_Obj_Attr1_AR.Radar_EGO1_Obj_RelAccel_X.phys = getValue(this);
    _Radar_EGO1_Obj_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Radar_EGO1_Obj_RelSpd_X
{
    _mRadar_EGO1_Obj_Attr1_AR.Radar_EGO1_Obj_RelSpd_X.phys = getValue(this);
    _Radar_EGO1_Obj_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_Radar_EGO1_Obj_Attr1
{
    _mRadar_EGO1_Obj_Attr1_AR.Rsrv1_Radar_EGO1_Obj_Attr1.phys = getValue(this);
    _Radar_EGO1_Obj_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv2_Radar_EGO1_Obj_Attr1
{
    _mRadar_EGO1_Obj_Attr1_AR.Rsrv2_Radar_EGO1_Obj_Attr1.phys = getValue(this);
    _Radar_EGO1_Obj_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv3_Radar_EGO1_Obj_Attr1
{
    _mRadar_EGO1_Obj_Attr1_AR.Rsrv3_Radar_EGO1_Obj_Attr1.phys = getValue(this);
    _Radar_EGO1_Obj_Attr1_AR_SpontanFlag = 1;
}

on EnvVar HMI_SQC_Radar_EGO1_Obj_Attr1
{
    _mRadar_EGO1_Obj_Attr1_AR.SQC_Radar_EGO1_Obj_Attr1.phys = getValue(this);
    _Radar_EGO1_Obj_Attr1_AR_SpontanFlag = 1;
}

RDS_Data_HU_AR_check_output()
{
    if( !getValue( HMI__STMSG_RDS_Data_HU_AR ) )
    {
    //  message   RDS_Data_HU_AR ID: 2429288448 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _RDS_Data_HU_AR_DelayCnt > 0) _RDS_Data_HU_AR_DelayCnt--; // Mindestsendeabstand
        _RDS_Data_HU_AR_Cnt--;
        if( _RDS_Data_HU_AR_Cnt < 1 )
        {
            if( _RDS_Data_HU_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                 RDS_Data_HU_AR_output();
                _RDS_Data_HU_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _RDS_Data_HU_AR_DelayCnt = _RDS_Data_HU_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _RDS_Data_HU_AR_SpontanFlag = 1;
            }
            _RDS_Data_HU_AR_Cnt = _RDS_Data_HU_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _RDS_Data_HU_AR_SpontanFlag)
        {
            if( _RDS_Data_HU_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                RDS_Data_HU_AR_output();
                _RDS_Data_HU_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _RDS_Data_HU_AR_DelayCnt = _RDS_Data_HU_AR_MinDelay;
            }
        }
    }
}

RDS_Data_HU_AR_init()
{   /* Botschaft DS_Data_HU_AR ID: 2457600000   --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 2457600000 0;
BA_ "NmAsrMessage" BO_ 2457600000 0;
BA_ "GenMsgMinAcceptLength" BO_ 2457600000 8;
BA_ "GenMsgILSupport" BO_ 2457600000 1;
BA_ "DiagState" BO_ 2457600000 0;
BA_ "DiagRequest" BO_ 2457600000 0;
BA_ "DiagResponse" BO_ 2457600000 0;
BA_ "GenMsgStartValue" BO_ 2457600000 "0";
BA_ "GenMsgDelayTime" BO_ 2457600000 100;
BA_ "GenMsgNrOfRepetitions" BO_ 2457600000 0;
BA_ "GenMsgCycleTime" BO_ 2457600000 500;
BA_ "GenMsgSendType" BO_ 2457600000 5;
    */
    _RDS_Data_HU_AR_Timebase =                c_tDBKomTimer_20ms;
    _RDS_Data_HU_AR_CycleCount =             500 / _RDS_Data_HU_AR_Timebase;
    _RDS_Data_HU_AR_StartDelay =               0 / _RDS_Data_HU_AR_Timebase;
    _RDS_Data_HU_AR_MinDelay =               100 / _RDS_Data_HU_AR_Timebase;
    _RDS_Data_HU_AR_Cnt =_RDS_Data_HU_AR_StartDelay;
    _RDS_Data_HU_AR_SpontanFlag = 0;
    _RDS_Data_HU_AR_DelayCnt = 0;
	
	putValue( HMI__STMSGSD_RDS_Data_HU_AR, _RDS_Data_HU_AR_StartDelay * _RDS_Data_HU_AR_Timebase );

    _mRDS_Data_HU_AR.RDS_DataAge.phys = getValue( HMI_RDS_DataAge );
    _mRDS_Data_HU_AR.RDS_PartclConc_2_5_Insd.phys = getValue( HMI_RDS_PartclConc_2_5_Insd );
    _mRDS_Data_HU_AR.RDS_PartclConc_2_5_Outsd.phys = getValue( HMI_RDS_PartclConc_2_5_Outsd );
    _mRDS_Data_HU_AR.RDS_PartclConc_10_Insd.phys = getValue( HMI_RDS_PartclConc_10_Insd );
    _mRDS_Data_HU_AR.RDS_PartclConc_10_Outsd.phys = getValue( HMI_RDS_PartclConc_10_Outsd );
    
 
}

RDS_Data_HU_AR_output(void)
{
    output( _mRDS_Data_HU_AR );
}

RDS_Data_HU_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: RDS_Data_HU_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_RDS_Data_HU_AR := %X\n", getValue( HMI__STMSG_RDS_Data_HU_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_RDS_Data_HU_AR := %X\n", getValue( HMI__STMSGT_RDS_Data_HU_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RDS_DataAge := %X\n", getValue( HMI_RDS_DataAge ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RDS_PartclConc_2_5_Insd := %X\n", getValue( HMI_RDS_PartclConc_2_5_Insd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RDS_PartclConc_2_5_Outsd := %X\n", getValue( HMI_RDS_PartclConc_2_5_Outsd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RDS_PartclConc_10_Insd := %X\n", getValue( HMI_RDS_PartclConc_10_Insd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RDS_PartclConc_10_Outsd := %X\n", getValue( HMI_RDS_PartclConc_10_Outsd ) );        filePutString( buffer, elcount( buffer ), hFile );
    
   
}

on timer _tRDS_Data_HU_AR
{
    putValue( HMI__STMSG_RDS_Data_HU_AR, 0 );
}

on EnvVar HMI__STMSG_RDS_Data_HU_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_RDS_Data_HU_AR );
        if( tDelay > 0)    
            setTimer( _tRDS_Data_HU_AR, tDelay );
        else
            putValue( HMI__STMSG_RDS_Data_HU_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_RDS_Data_HU_AR
{
    if( getValue( this ) )
        openPanel("RDS_Data_HU_AR");
}

on EnvVar HMI_RDS_DataAge
{
    _mRDS_Data_HU_AR.RDS_DataAge.phys = getValue(this);
    _RDS_Data_HU_AR_SpontanFlag = 1;
}

on EnvVar HMI_RDS_PartclConc_2_5_Insd
{
    _mRDS_Data_HU_AR.RDS_PartclConc_2_5_Insd.phys = getValue(this);
    _RDS_Data_HU_AR_SpontanFlag = 1;
}

on EnvVar HMI_RDS_PartclConc_2_5_Outsd
{
    _mRDS_Data_HU_AR.RDS_PartclConc_2_5_Outsd.phys = getValue(this);
    _RDS_Data_HU_AR_SpontanFlag = 1;
}

on EnvVar HMI_RDS_PartclConc_10_Insd
{
    _mRDS_Data_HU_AR.RDS_PartclConc_10_Insd.phys = getValue(this);
    _RDS_Data_HU_AR_SpontanFlag = 1;
}

on EnvVar HMI_RDS_PartclConc_10_Outsd
{
    _mRDS_Data_HU_AR.RDS_PartclConc_10_Outsd.phys = getValue(this);
    _RDS_Data_HU_AR_SpontanFlag = 1;
}


RDU_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_RDU_Disp_Rq_AR ) )
    {
    //  message   RDU_Disp_Rq_AR --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _RDU_Disp_Rq_AR_DelayCnt > 0) _RDU_Disp_Rq_AR_DelayCnt--; // Mindestsendeabstand
        _RDU_Disp_Rq_AR_Cnt--;
        if( _RDU_Disp_Rq_AR_Cnt < 1 )
        {
            if( _RDU_Disp_Rq_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                RDU_Disp_Rq_AR_output();
                _RDU_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _RDU_Disp_Rq_AR_DelayCnt = _RDU_Disp_Rq_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _RDU_Disp_Rq_AR_SpontanFlag = 1;
            }
            _RDU_Disp_Rq_AR_Cnt = _RDU_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _RDU_Disp_Rq_AR_SpontanFlag)
        {
            if( _RDU_Disp_Rq_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                RDU_Disp_Rq_AR_output();
                _RDU_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _RDU_Disp_Rq_AR_DelayCnt = _RDU_Disp_Rq_AR_MinDelay;
            }
        }
    }
}

RDU_Disp_Rq_AR_init()
{   /* Botschaft RDU_Disp_Rq_AR ID: 1185 --- Sendeart cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 812 0;
BA_ "NmAsrMessage" BO_ 812 0;
BA_ "GenMsgMinAcceptLength" BO_ 812 8;
BA_ "GenMsgILSupport" BO_ 812 1;
BA_ "DiagState" BO_ 812 0;
BA_ "DiagRequest" BO_ 812 0;
BA_ "DiagResponse" BO_ 812 0;
BA_ "GenMsgStartValue" BO_ 812 "0";
BA_ "GenMsgStartDelayTime" BO_ 812 235;
BA_ "GenMsgDelayTime" BO_ 812 50;
BA_ "GenMsgNrOfRepetitions" BO_ 812 0;
BA_ "GenMsgCycleTime" BO_ 812 500;
BA_ "GenMsgSendType" BO_ 812 5;
    */
    _RDU_Disp_Rq_AR_Timebase =                  c_tDBKomTimer_5ms;
    _RDU_Disp_Rq_AR_CycleCount =              500 / _RDU_Disp_Rq_AR_Timebase;
    _RDU_Disp_Rq_AR_StartDelay =              235 / _RDU_Disp_Rq_AR_Timebase;
    _RDU_Disp_Rq_AR_MinDelay =                 50 / _RDU_Disp_Rq_AR_Timebase;
    _RDU_Disp_Rq_AR_Cnt = _RDU_Disp_Rq_AR_StartDelay;
    _RDU_Disp_Rq_AR_SpontanFlag = 0;
    _RDU_Disp_Rq_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_RDU_Disp_Rq_AR, _RDU_Disp_Rq_AR_StartDelay * _RDU_Disp_Rq_AR_Timebase );

    _mRDU_Disp_Rq_AR.CamSensSoil_CMS_IconDisp_Rq_RDU.phys = getValue( HMI_CamSensSoil_CMS_IconDisp_Rq_RDU );
    _mRDU_Disp_Rq_AR.CamSensSoil_DTQ_IconDisp_Rq_RDU.phys = getValue( HMI_CamSensSoil_DTQ_IconDisp_Rq_RDU );
    _mRDU_Disp_Rq_AR.CamSensSoil_LDP_IconDisp_Rq_RDU.phys = getValue( HMI_CamSensSoil_LDP_IconDisp_Rq_RDU );
    _mRDU_Disp_Rq_AR.CamSensSoil_MsgDisp_Rq_RDU.phys = getValue( HMI_CamSensSoil_MsgDisp_Rq_RDU );
    _mRDU_Disp_Rq_AR.DTR_Curve_Md_Stat.phys = getValue( HMI_DTR_Curve_Md_Stat );
    _mRDU_Disp_Rq_AR.LDC_CMS_Md_Stat.phys = getValue( HMI_LDC_CMS_Md_Stat );
    _mRDU_Disp_Rq_AR.LDC_CMS_PreWarn_Md_Stat.phys = getValue( HMI_LDC_CMS_PreWarn_Md_Stat );
    _mRDU_Disp_Rq_AR.LDC_Dist_Dsr_MsgDisp_Rq_RDU.phys = getValue( HMI_LDC_Dist_Dsr_MsgDisp_Rq_RDU );
    _mRDU_Disp_Rq_AR.LDC_DTR_TkOvrWarn_Rq.phys = getValue( HMI_LDC_DTR_TkOvrWarn_Rq );
    _mRDU_Disp_Rq_AR.LDC_DynDistWarn_Rq.phys = getValue( HMI_LDC_DynDistWarn_Rq );
    _mRDU_Disp_Rq_AR.LDC_SLA_SpdLmtTkOvr_Avl_Stat.phys = getValue( HMI_LDC_SLA_SpdLmtTkOvr_Avl_Stat );
    _mRDU_Disp_Rq_AR.LDC_SLA_SpdLmtTkOvr_Stat.phys = getValue( HMI_LDC_SLA_SpdLmtTkOvr_Stat );
    _mRDU_Disp_Rq_AR.LDC_StaticDistWarn_Rq.phys = getValue( HMI_LDC_StaticDistWarn_Rq );
    _mRDU_Disp_Rq_AR.PN14_ElecPwr_Rq_AS.phys = getValue( HMI_PN14_ElecPwr_Rq_AS );
    _mRDU_Disp_Rq_AR.RadarSensSoil_BSM_IconDisp_Rq_RDU.phys = getValue( HMI_RadarSensSoil_BSM_IconDisp_Rq_RDU );
    _mRDU_Disp_Rq_AR.RadarSensSoil_CMS_IconDisp_Rq_RDU.phys = getValue( HMI_RadarSensSoil_CMS_IconDisp_Rq_RDU );
    _mRDU_Disp_Rq_AR.RadarSensSoil_DTR_IconDisp_Rq_RDU.phys = getValue( HMI_RadarSensSoil_DTR_IconDisp_Rq_RDU );
    _mRDU_Disp_Rq_AR.RadarSensSoil_LDP_IconDisp_Rq_RDU.phys = getValue( HMI_RadarSensSoil_LDP_IconDisp_Rq_RDU );
    _mRDU_Disp_Rq_AR.RadarSensSoil_MsgDisp_Rq_RDU.phys = getValue( HMI_RadarSensSoil_MsgDisp_Rq_RDU );
	_mRDU_Disp_Rq_AR.CamSensSoil_FDC_IconDisp_Rq_RDU.phys = getValue( HMI_CamSensSoil_FDC_IconDisp_Rq_RDU );
    _mRDU_Disp_Rq_AR.RadarSensSoil_FDC_IconDisp_Rq_RDU.phys = getValue( HMI_RadarSensSoil_FDC_IconDisp_Rq_RDU );
    _mRDU_Disp_Rq_AR.DTR_DrvCf_Md_Stat.phys = getValue( HMI_DTR_DrvCf_Md_Stat );
}

RDU_Disp_Rq_AR_output(void)
{
    output( _mRDU_Disp_Rq_AR );
}

RDU_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: RDU_Disp_Rq_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_RDU_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_RDU_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_RDU_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_RDU_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamSensSoil_CMS_IconDisp_Rq_RDU := %X\n", getValue( HMI_CamSensSoil_CMS_IconDisp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamSensSoil_DTQ_IconDisp_Rq_RDU := %X\n", getValue( HMI_CamSensSoil_DTQ_IconDisp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamSensSoil_LDP_IconDisp_Rq_RDU := %X\n", getValue( HMI_CamSensSoil_LDP_IconDisp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamSensSoil_MsgDisp_Rq_RDU := %X\n", getValue( HMI_CamSensSoil_MsgDisp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_Curve_Md_Stat := %X\n", getValue( HMI_DTR_Curve_Md_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_CMS_Md_Stat := %X\n", getValue( HMI_LDC_CMS_Md_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_CMS_PreWarn_Md_Stat := %X\n", getValue( HMI_LDC_CMS_PreWarn_Md_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_Dist_Dsr_MsgDisp_Rq_RDU := %X\n", getValue( HMI_LDC_Dist_Dsr_MsgDisp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_DTR_TkOvrWarn_Rq := %X\n", getValue( HMI_LDC_DTR_TkOvrWarn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_DynDistWarn_Rq := %X\n", getValue( HMI_LDC_DynDistWarn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_SLA_SpdLmtTkOvr_Avl_Stat := %X\n", getValue( HMI_LDC_SLA_SpdLmtTkOvr_Avl_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_SLA_SpdLmtTkOvr_Stat := %X\n", getValue( HMI_LDC_SLA_SpdLmtTkOvr_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_StaticDistWarn_Rq := %X\n", getValue( HMI_LDC_StaticDistWarn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_ElecPwr_Rq_AS := %X\n", getValue( HMI_PN14_ElecPwr_Rq_AS ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RadarSensSoil_BSM_IconDisp_Rq_RDU := %X\n", getValue( HMI_RadarSensSoil_BSM_IconDisp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RadarSensSoil_CMS_IconDisp_Rq_RDU := %X\n", getValue( HMI_RadarSensSoil_CMS_IconDisp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RadarSensSoil_DTR_IconDisp_Rq_RDU := %X\n", getValue( HMI_RadarSensSoil_DTR_IconDisp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RadarSensSoil_LDP_IconDisp_Rq_RDU := %X\n", getValue( HMI_RadarSensSoil_LDP_IconDisp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RadarSensSoil_MsgDisp_Rq_RDU := %X\n", getValue( HMI_RadarSensSoil_MsgDisp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CamSensSoil_FDC_IconDisp_Rq_RDU := %X\n", getValue( HMI_CamSensSoil_FDC_IconDisp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RadarSensSoil_FDC_IconDisp_Rq_RDU := %X\n", getValue( HMI_RadarSensSoil_FDC_IconDisp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000  HMI_DTR_DrvCf_Md_Stat := %X\n", getValue( HMI_DTR_DrvCf_Md_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
	
}

on timer _tRDU_Disp_Rq_AR
{
    putValue( HMI__STMSG_RDU_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_RDU_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_RDU_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tRDU_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_RDU_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_RDU_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("RDU_Disp_Rq_AR");
}

on EnvVar HMI_CamSensSoil_CMS_IconDisp_Rq_RDU
{
    _mRDU_Disp_Rq_AR.CamSensSoil_CMS_IconDisp_Rq_RDU.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CamSensSoil_DTQ_IconDisp_Rq_RDU
{
    _mRDU_Disp_Rq_AR.CamSensSoil_DTQ_IconDisp_Rq_RDU.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CamSensSoil_LDP_IconDisp_Rq_RDU
{
    _mRDU_Disp_Rq_AR.CamSensSoil_LDP_IconDisp_Rq_RDU.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CamSensSoil_MsgDisp_Rq_RDU
{
    _mRDU_Disp_Rq_AR.CamSensSoil_MsgDisp_Rq_RDU.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTR_Curve_Md_Stat
{
    _mRDU_Disp_Rq_AR.DTR_Curve_Md_Stat.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_CMS_Md_Stat
{
    _mRDU_Disp_Rq_AR.LDC_CMS_Md_Stat.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_CMS_PreWarn_Md_Stat
{
    _mRDU_Disp_Rq_AR.LDC_CMS_PreWarn_Md_Stat.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_Dist_Dsr_MsgDisp_Rq_RDU
{
    _mRDU_Disp_Rq_AR.LDC_Dist_Dsr_MsgDisp_Rq_RDU.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_DTR_TkOvrWarn_Rq
{
    _mRDU_Disp_Rq_AR.LDC_DTR_TkOvrWarn_Rq.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_DynDistWarn_Rq
{
    _mRDU_Disp_Rq_AR.LDC_DynDistWarn_Rq.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_SLA_SpdLmtTkOvr_Avl_Stat
{
    _mRDU_Disp_Rq_AR.LDC_SLA_SpdLmtTkOvr_Avl_Stat.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_SLA_SpdLmtTkOvr_Stat
{
    _mRDU_Disp_Rq_AR.LDC_SLA_SpdLmtTkOvr_Stat.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_StaticDistWarn_Rq
{
    _mRDU_Disp_Rq_AR.LDC_StaticDistWarn_Rq.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_ElecPwr_Rq_AS
{
    _mRDU_Disp_Rq_AR.PN14_ElecPwr_Rq_AS.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
    _mFCW_Disp_Rq_AR.PN14_ElecPwr_Rq_AS.phys = getValue(this);
    _FCW_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_RadarSensSoil_BSM_IconDisp_Rq_RDU
{
    _mRDU_Disp_Rq_AR.RadarSensSoil_BSM_IconDisp_Rq_RDU.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_RadarSensSoil_CMS_IconDisp_Rq_RDU
{
    _mRDU_Disp_Rq_AR.RadarSensSoil_CMS_IconDisp_Rq_RDU.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_RadarSensSoil_DTR_IconDisp_Rq_RDU
{
    _mRDU_Disp_Rq_AR.RadarSensSoil_DTR_IconDisp_Rq_RDU.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_RadarSensSoil_LDP_IconDisp_Rq_RDU
{
    _mRDU_Disp_Rq_AR.RadarSensSoil_LDP_IconDisp_Rq_RDU.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_RadarSensSoil_MsgDisp_Rq_RDU
{
    _mRDU_Disp_Rq_AR.RadarSensSoil_MsgDisp_Rq_RDU.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_RadarSensSoil_FDC_IconDisp_Rq_RDU
{
    _mRDU_Disp_Rq_AR.RadarSensSoil_FDC_IconDisp_Rq_RDU.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CamSensSoil_FDC_IconDisp_Rq_RDU
{
    _mRDU_Disp_Rq_AR.CamSensSoil_FDC_IconDisp_Rq_RDU.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTR_DrvCf_Md_Stat
{
    _mRDU_Disp_Rq_AR.DTR_DrvCf_Md_Stat.phys = getValue(this);
    _RDU_Disp_Rq_AR_SpontanFlag = 1;
}

RTC_Date_Time_AR_check_output()
{
    if( !getValue( HMI__STMSG_RTC_Date_Time_AR ) )
    {
    //  Botschaft RTC_Date_Time_AR ID: 779  --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _RTC_Date_Time_AR_DelayCnt > 0) _RTC_Date_Time_AR_DelayCnt--; // Mindestsendeabstand
        _RTC_Date_Time_AR_Cnt--;
        if( _RTC_Date_Time_AR_Cnt < 1 )
        {
            if( _RTC_Date_Time_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                RTC_Date_Time_AR_output();
                _RTC_Date_Time_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _RTC_Date_Time_AR_DelayCnt = _RTC_Date_Time_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _RTC_Date_Time_AR_SpontanFlag = 1;
            }
            _RTC_Date_Time_AR_Cnt = _RTC_Date_Time_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _RTC_Date_Time_AR_SpontanFlag)
        {
            if( _RTC_Date_Time_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                RTC_Date_Time_AR_output();
                _RTC_Date_Time_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _RTC_Date_Time_AR_DelayCnt = _RTC_Date_Time_AR_MinDelay;
            }
        }
    }
}

RTC_Date_Time_AR_init()
{   /* Botschaft RTC_Date_Time_AR ID: 779 --- Sendeart cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 779 0;
BA_ "NmAsrMessage" BO_ 779 0;
BA_ "GenMsgMinAcceptLength" BO_ 779 8;
BA_ "GenMsgILSupport" BO_ 779 1;
BA_ "DiagState" BO_ 779 0;
BA_ "DiagRequest" BO_ 779 0;
BA_ "DiagResponse" BO_ 779 0;
BA_ "GenMsgStartValue" BO_ 779 "0";
BA_ "GenMsgStartDelayTime" BO_ 779 250;
BA_ "GenMsgDelayTime" BO_ 779 40;
BA_ "GenMsgNrOfRepetition" BO_ 779 0;
BA_ "GenMsgCycleTime" BO_ 779 1000;
BA_ "GenMsgSendType" BO_ 779 5;
    */
    _RTC_Date_Time_AR_Timebase =                  c_tDBKomTimer_5ms;
    _RTC_Date_Time_AR_CycleCount =             1000 / _RTC_Date_Time_AR_Timebase;
    _RTC_Date_Time_AR_StartDelay =              250 / _RTC_Date_Time_AR_Timebase;
    _RTC_Date_Time_AR_MinDelay =                 40 / _RTC_Date_Time_AR_Timebase;
    _RTC_Date_Time_AR_Cnt = _RTC_Date_Time_AR_StartDelay;
    _RTC_Date_Time_AR_SpontanFlag = 0;
    _RTC_Date_Time_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_RTC_Date_Time_AR, _RTC_Date_Time_AR_StartDelay * _RTC_Date_Time_AR_Timebase );

    _mRTC_Date_Time_AR.DateTmDay.phys = getValue( HMI_DateTmDay );
    _mRTC_Date_Time_AR.DateTmHour.phys = getValue( HMI_DateTmHour );
    _mRTC_Date_Time_AR.DateTmMinute.phys = getValue( HMI_DateTmMinute );
    _mRTC_Date_Time_AR.DateTmMonth.phys = getValue( HMI_DateTmMonth );
    _mRTC_Date_Time_AR.DateTmSecond.phys = getValue( HMI_DateTmSecond );
    _mRTC_Date_Time_AR.DateTmStat.phys = getValue( HMI_DateTmStat );
    _mRTC_Date_Time_AR.DateTmWeekday.phys = getValue( HMI_DateTmWeekday );
    _mRTC_Date_Time_AR.DateTmYear.phys = getValue( HMI_DateTmYear );
    _mRTC_Date_Time_AR.ICH_Dur_Rq.phys = getValue( HMI_ICH_Dur_Rq );
    _mRTC_Date_Time_AR.ICH_HtVn_Rq_IC.phys = getValue( HMI_ICH_HtVn_Rq_IC );
}

RTC_Date_Time_AR_output(void)
{
    output( _mRTC_Date_Time_AR );
}

RTC_Date_Time_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: RTC_Date_Time_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_RTC_Date_Time_AR := %X\n", getValue( HMI__STMSG_RTC_Date_Time_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_RTC_Date_Time_AR := %X\n", getValue( HMI__STMSGT_RTC_Date_Time_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DateTmDay := %X\n", getValue( HMI_DateTmDay ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DateTmHour := %X\n", getValue( HMI_DateTmHour ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DateTmMinute := %X\n", getValue( HMI_DateTmMinute ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DateTmMonth := %X\n", getValue( HMI_DateTmMonth ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DateTmSecond := %X\n", getValue( HMI_DateTmSecond ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DateTmStat := %X\n", getValue( HMI_DateTmStat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DateTmWeekday := %X\n", getValue( HMI_DateTmWeekday ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DateTmYear := %X\n", getValue( HMI_DateTmYear ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_Dur_Rq := %X\n", getValue( HMI_ICH_Dur_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ICH_HtVn_Rq_IC := %X\n", getValue( HMI_ICH_HtVn_Rq_IC ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tRTC_Date_Time_AR
{
    putValue( HMI__STMSG_RTC_Date_Time_AR, 0 );
}

on EnvVar HMI__STMSG_RTC_Date_Time_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_RTC_Date_Time_AR );
        if( tDelay > 0)    
            setTimer( _tRTC_Date_Time_AR, tDelay );
        else
            putValue( HMI__STMSG_RTC_Date_Time_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_RTC_Date_Time_AR
{
    if( getValue( this ) )
        openPanel("RTC_Date_Time_AR");
}

on EnvVar HMI_DateTmDay
{
    _mRTC_Date_Time_AR.DateTmDay.phys = getValue(this);
    _RTC_Date_Time_AR_SpontanFlag = 1;
}

on EnvVar HMI_DateTmHour
{
    _mRTC_Date_Time_AR.DateTmHour.phys = getValue(this);
    _RTC_Date_Time_AR_SpontanFlag = 1;
}

on EnvVar HMI_DateTmMinute
{
    _mRTC_Date_Time_AR.DateTmMinute.phys = getValue(this);
    _RTC_Date_Time_AR_SpontanFlag = 1;
}

on EnvVar HMI_DateTmMonth
{
    _mRTC_Date_Time_AR.DateTmMonth.phys = getValue(this);
    _RTC_Date_Time_AR_SpontanFlag = 1;
}

on EnvVar HMI_DateTmSecond
{
    _mRTC_Date_Time_AR.DateTmSecond.phys = getValue(this);
    _RTC_Date_Time_AR_SpontanFlag = 1;
}

on EnvVar HMI_DateTmStat
{
    _mRTC_Date_Time_AR.DateTmStat.phys = getValue(this);
    _RTC_Date_Time_AR_SpontanFlag = 1;
}

on EnvVar HMI_DateTmWeekday
{
    _mRTC_Date_Time_AR.DateTmWeekday.phys = getValue(this);
    _RTC_Date_Time_AR_SpontanFlag = 1;
}

on EnvVar HMI_DateTmYear
{
    _mRTC_Date_Time_AR.DateTmYear.phys = getValue(this);
    _RTC_Date_Time_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_Dur_Rq
{
    _mRTC_Date_Time_AR.ICH_Dur_Rq.phys = getValue(this);
    _RTC_Date_Time_AR_SpontanFlag = 1;
}

on EnvVar HMI_ICH_HtVn_Rq_IC
{
    _mRTC_Date_Time_AR.ICH_HtVn_Rq_IC.phys = getValue(this);
    _RTC_Date_Time_AR_SpontanFlag = 1;
}

RTC_Stat1_AR_check_output()
{
    if( !getValue( HMI__STMSG_RTC_Stat1_AR ) )
    {
    //  Botschaft RTC_Stat1_AR ID: 1216  --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _RTC_Stat1_AR_DelayCnt > 0) _RTC_Stat1_AR_DelayCnt--; // Mindestsendeabstand
        _RTC_Stat1_AR_Cnt--;
        if( _RTC_Stat1_AR_Cnt < 1 )
        {
            if( _RTC_Stat1_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                RTC_Stat1_AR_output();
                _RTC_Stat1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _RTC_Stat1_AR_DelayCnt = _RTC_Stat1_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _RTC_Stat1_AR_SpontanFlag = 1;
            }
            _RTC_Stat1_AR_Cnt = _RTC_Stat1_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _RTC_Stat1_AR_SpontanFlag)
        {
            if( _RTC_Stat1_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                RTC_Stat1_AR_output();
                _RTC_Stat1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _RTC_Stat1_AR_DelayCnt = _RTC_Stat1_AR_MinDelay;
            }
        }
    }
}

RTC_Stat1_AR_init()
{   /* Botschaft RTC_Stat1_AR ID: 1216 --- Sendeart cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1216 0;
BA_ "NmAsrMessage" BO_ 1216 0;
BA_ "GenMsgMinAcceptLength" BO_ 1216 8;
BA_ "GenMsgILSupport" BO_ 1216 1;
BA_ "DiagState" BO_ 1216 0;
BA_ "DiagRequest" BO_ 1216 0;
BA_ "DiagResponse" BO_ 1216 0;
BA_ "GenMsgStartValue" BO_ 1216 "0";
BA_ "GenMsgStartDelayTime" BO_ 1216 260;
BA_ "GenMsgDelayTime" BO_ 1216 100;
BA_ "GenMsgNrOfRepetition" BO_ 1216 0;
BA_ "GenMsgCycleTime" BO_ 1216 1000;
BA_ "GenMsgSendType" BO_ 1216 5;
    */
    _RTC_Stat1_AR_Timebase =                  c_tDBKomTimer_5ms;
    _RTC_Stat1_AR_CycleCount =             1000 / _RTC_Stat1_AR_Timebase;
    _RTC_Stat1_AR_StartDelay =              260 / _RTC_Stat1_AR_Timebase;
    _RTC_Stat1_AR_MinDelay =                100 / _RTC_Stat1_AR_Timebase;
    _RTC_Stat1_AR_Cnt = _RTC_Stat1_AR_StartDelay;
    _RTC_Stat1_AR_SpontanFlag = 0;
    _RTC_Stat1_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_RTC_Stat1_AR, _RTC_Stat1_AR_StartDelay * _RTC_Stat1_AR_Timebase );

    _mRTC_Stat1_AR.DayCnt.phys = getValue( HMI_DayCnt );
    _mRTC_Stat1_AR.EngShutOffTm.phys = getValue( HMI_EngShutOffTm );
    _mRTC_Stat1_AR.EngShutOffTm_FastUpdt_Tgl.phys = getValue( HMI_EngShutOffTm_FastUpdt_Tgl );
    _mRTC_Stat1_AR.HVAC_Vprzr_DryVnTmr_Stat.phys = getValue( HMI_HVAC_Vprzr_DryVnTmr_Stat );
    _mRTC_Stat1_AR.PT_ShutOffTm.phys = getValue( HMI_PT_ShutOffTm );
    _mRTC_Stat1_AR.Carwash_Actv_Stat.phys = getValue( HMI_Carwash_Actv_Stat );
    _mRTC_Stat1_AR.Carwash_Avl_Stat.phys = getValue( HMI_Carwash_Avl_Stat );
}

RTC_Stat1_AR_output(void)
{
    output( _mRTC_Stat1_AR );
}

RTC_Stat1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: RTC_Stat1_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_RTC_Stat1_AR := %X\n", getValue( HMI__STMSG_RTC_Stat1_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_RTC_Stat1_AR := %X\n", getValue( HMI__STMSGT_RTC_Stat1_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DayCnt := %X\n", getValue( HMI_DayCnt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngShutOffTm := %X\n", getValue( HMI_EngShutOffTm ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngShutOffTm_FastUpdt_Tgl := %X\n", getValue( HMI_EngShutOffTm_FastUpdt_Tgl ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_Vprzr_DryVnTmr_Stat := %X\n", getValue( HMI_HVAC_Vprzr_DryVnTmr_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT_ShutOffTm := %X\n", getValue( HMI_PT_ShutOffTm ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Carwash_Actv_Stat := %X\n", getValue( HMI_Carwash_Actv_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Carwash_Avl_Stat := %X\n", getValue( HMI_Carwash_Avl_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tRTC_Stat1_AR
{
    putValue( HMI__STMSG_RTC_Stat1_AR, 0 );
}

on EnvVar HMI__STMSG_RTC_Stat1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_RTC_Stat1_AR );
        if( tDelay > 0)    
            setTimer( _tRTC_Stat1_AR, tDelay );
        else
            putValue( HMI__STMSG_RTC_Stat1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_RTC_Stat1_AR
{
    if( getValue( this ) )
        openPanel("RTC_Stat1_AR");
}

on EnvVar HMI_DayCnt
{
    _mRTC_Stat1_AR.DayCnt.phys = getValue(this);
    _RTC_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_EngShutOffTm
{
    _mRTC_Stat1_AR.EngShutOffTm.phys = getValue(this);
    _RTC_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_EngShutOffTm_FastUpdt_Tgl
{
    _mRTC_Stat1_AR.EngShutOffTm_FastUpdt_Tgl.phys = getValue(this);
    _RTC_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_Vprzr_DryVnTmr_Stat
{
    _mRTC_Stat1_AR.HVAC_Vprzr_DryVnTmr_Stat.phys = getValue(this);
    _RTC_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PT_ShutOffTm
{
    _mRTC_Stat1_AR.PT_ShutOffTm.phys = getValue(this);
    _RTC_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Carwash_Actv_Stat
{
    _mRTC_Stat1_AR.Carwash_Actv_Stat.phys = getValue(this);
    _RTC_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Carwash_Avl_Stat
{
    _mRTC_Stat1_AR.Carwash_Avl_Stat.phys = getValue(this);
    _RTC_Stat1_AR_SpontanFlag = 1;
}

RTC_Stat2_AR_check_output()
{
    if( !getValue( HMI__STMSG_RTC_Stat2_AR ) )
    {
    //  Botschaft RTC_Stat2_AR ID: 1152 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _RTC_Stat2_AR_DelayCnt > 0) _RTC_Stat2_AR_DelayCnt--; // Mindestsendeabstand
        _RTC_Stat2_AR_Cnt--;
        if( _RTC_Stat2_AR_Cnt < 1 )
        {
            if( _RTC_Stat2_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                RTC_Stat2_AR_output();
                _RTC_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _RTC_Stat2_AR_DelayCnt = _RTC_Stat2_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _RTC_Stat2_AR_SpontanFlag = 1;
            }
            _RTC_Stat2_AR_Cnt = _RTC_Stat2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _RTC_Stat2_AR_SpontanFlag)
        {
            if( _RTC_Stat2_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                RTC_Stat2_AR_output();
                _RTC_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _RTC_Stat2_AR_DelayCnt = _RTC_Stat2_AR_MinDelay;
            }
        }
    }
}

RTC_Stat2_AR_init()
{   /* Botschaft RTC_Stat2_AR ID: 1152 --- Sendeart cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1152 0;
BA_ "NmAsrMessage" BO_ 1152 0;
BA_ "GenMsgMinAcceptLength" BO_ 1152 8;
BA_ "GenMsgILSupport" BO_ 1152 1;
BA_ "DiagState" BO_ 1152 0;
BA_ "DiagRequest" BO_ 1152 0;
BA_ "DiagResponse" BO_ 1152 0;
BA_ "GenMsgStartValue" BO_ 1152 "0";
BA_ "GenMsgStartDelayTime" BO_ 1152 5;
BA_ "GenMsgDelayTime" BO_ 1152 100;
BA_ "GenMsgNrOfRepetition" BO_ 1152 0;
BA_ "GenMsgCycleTime" BO_ 1152 1000;
BA_ "GenMsgSendType" BO_ 1152 5;
    */
    _RTC_Stat2_AR_Timebase =                  c_tDBKomTimer_5ms;
    _RTC_Stat2_AR_CycleCount =             1000 / _RTC_Stat2_AR_Timebase;
    _RTC_Stat2_AR_StartDelay =                5 / _RTC_Stat2_AR_Timebase;
    _RTC_Stat2_AR_MinDelay =                100 / _RTC_Stat2_AR_Timebase;
    _RTC_Stat2_AR_Cnt = _RTC_Stat2_AR_StartDelay;
    _RTC_Stat2_AR_SpontanFlag = 0;
    _RTC_Stat2_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_RTC_Stat2_AR, _RTC_Stat2_AR_StartDelay * _RTC_Stat2_AR_Timebase );

    _mRTC_Stat2_AR.Airtemp_Outsd_EngWarmCnt.phys = getValue( HMI_Airtemp_Outsd_EngWarmCnt );
    _mRTC_Stat2_AR.TC_AutoReset_Start.phys = getValue( HMI_TC_AutoReset_Start );
    _mRTC_Stat2_AR.Carwash_Msg_Disp_Rq.phys = getValue( HMI_Carwash_Msg_Disp_Rq );
}

RTC_Stat2_AR_output(void)
{
    output( _mRTC_Stat2_AR );
}

RTC_Stat2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: RTC_Stat2_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_RTC_Stat2_AR := %X\n", getValue( HMI__STMSG_RTC_Stat2_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_RTC_Stat2_AR := %X\n", getValue( HMI__STMSGT_RTC_Stat2_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Airtemp_Outsd_EngWarmCnt := %X\n", getValue( HMI_Airtemp_Outsd_EngWarmCnt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_AutoReset_Start := %X\n", getValue( HMI_TC_AutoReset_Start ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Carwash_Msg_Disp_Rq := %X\n", getValue( HMI_Carwash_Msg_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tRTC_Stat2_AR
{
    putValue( HMI__STMSG_RTC_Stat2_AR, 0 );
}

on EnvVar HMI__STMSG_RTC_Stat2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_RTC_Stat2_AR );
        if( tDelay > 0)    
            setTimer( _tRTC_Stat2_AR, tDelay );
        else
            putValue( HMI__STMSG_RTC_Stat2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_RTC_Stat2_AR
{
    if( getValue( this ) )
        openPanel("RTC_Stat2_AR");
}

on EnvVar HMI_Airtemp_Outsd_EngWarmCnt
{
    _mRTC_Stat2_AR.Airtemp_Outsd_EngWarmCnt.phys = getValue(this);
    _RTC_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_TC_AutoReset_Start
{
    _mRTC_Stat2_AR.TC_AutoReset_Start.phys = getValue(this);
    _RTC_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Carwash_Msg_Disp_Rq
{
    _mRTC_Stat2_AR.Carwash_Msg_Disp_Rq.phys = getValue(this);
    _RTC_Stat2_AR_SpontanFlag = 1;
}

RVC_SVS_Park_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_RVC_SVS_Park_Stat_AR ) )
    {
    //  message   RVC_SVS_Park_Stat_AR ID: 1125  --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _RVC_SVS_Park_Stat_AR_DelayCnt > 0) _RVC_SVS_Park_Stat_AR_DelayCnt--; // Mindestsendeabstand
        _RVC_SVS_Park_Stat_AR_Cnt--;
        if( _RVC_SVS_Park_Stat_AR_Cnt < 1 )
        {
            if( _RVC_SVS_Park_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                RVC_SVS_Park_Stat_AR_output();
                _RVC_SVS_Park_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _RVC_SVS_Park_Stat_AR_DelayCnt = _RVC_SVS_Park_Stat_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
            }
            _RVC_SVS_Park_Stat_AR_Cnt = _RVC_SVS_Park_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _RVC_SVS_Park_Stat_AR_SpontanFlag)
        {
            if( _RVC_SVS_Park_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                RVC_SVS_Park_Stat_AR_output();
                _RVC_SVS_Park_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _RVC_SVS_Park_Stat_AR_DelayCnt = _RVC_SVS_Park_Stat_AR_MinDelay;
            }
        }
    }
}

RVC_SVS_Park_Stat_AR_init()
{   /* Botschaft RVC_SVS_Park_Stat_AR ID: 1125 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1125 0;
BA_ "NmAsrMessage" BO_ 1125 0;
BA_ "GenMsgMinAcceptLength" BO_ 1125 8;
BA_ "GenMsgILSupport" BO_ 1125 1;
BA_ "DiagState" BO_ 1125 0;
BA_ "DiagRequest" BO_ 1125 0;
BA_ "DiagResponse" BO_ 1125 0;
BA_ "GenMsgStartValue" BO_ 1125 "0";
BA_ "GenMsgStartDelayTime" BO_ 1125 165;
BA_ "GenMsgDelayTime" BO_ 1125 80;
BA_ "GenMsgNrOfRepetition" BO_ 1125 0;
BA_ "GenMsgCycleTime" BO_ 1125 1000;
BA_ "GenMsgSendType" BO_ 1125 5;
    */
    _RVC_SVS_Park_Stat_AR_Timebase =      c_tDBKomTimer_20ms;
    _RVC_SVS_Park_Stat_AR_CycleCount =   1000 / _RVC_SVS_Park_Stat_AR_Timebase;
    _RVC_SVS_Park_Stat_AR_StartDelay =    165 / _RVC_SVS_Park_Stat_AR_Timebase;
    _RVC_SVS_Park_Stat_AR_MinDelay =       80 / _RVC_SVS_Park_Stat_AR_Timebase;
    _RVC_SVS_Park_Stat_AR_Cnt = _RVC_SVS_Park_Stat_AR_StartDelay;
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 0;
    _RVC_SVS_Park_Stat_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_RVC_SVS_Park_Stat_AR, _RVC_SVS_Park_Stat_AR_StartDelay * _RVC_SVS_Park_Stat_AR_Timebase );

    _mRVC_SVS_Park_Stat_AR.DRVM_PkMd_Stat_V3.phys = getValue( HMI_DRVM_PkMd_Stat_V3 );
    _mRVC_SVS_Park_Stat_AR.DRVM_SysMd_Stat_V2.phys = getValue( HMI_DRVM_SysMd_Stat_V2 );
    _mRVC_SVS_Park_Stat_AR.DRVM_Warn_Rq.phys = getValue( HMI_DRVM_Warn_Rq );
    _mRVC_SVS_Park_Stat_AR.PARK_Detents_Rq.phys = getValue( HMI_PARK_Detents_Rq );
    _mRVC_SVS_Park_Stat_AR.PARK_Detents2_Rq.phys = getValue( HMI_PARK_Detents2_Rq );
    _mRVC_SVS_Park_Stat_AR.PARK_Detents3_Rq.phys = getValue( HMI_PARK_Detents3_Rq );
    _mRVC_SVS_Park_Stat_AR.Park_ExplorMd_Avl.phys = getValue( HMI_Park_ExplorMd_Avl );
    _mRVC_SVS_Park_Stat_AR.Park_Row1_MsgDisp_Rq.phys = getValue( HMI_Park_Row1_MsgDisp_Rq );
    _mRVC_SVS_Park_Stat_AR.Park_Row2_MsgDisp_Rq.phys = getValue( HMI_Park_Row2_MsgDisp_Rq );
    _mRVC_SVS_Park_Stat_AR.PARK_SelMenu_Rq.phys = getValue( HMI_PARK_SelMenu_Rq );
    _mRVC_SVS_Park_Stat_AR.PARK_SlotStartPosn_Rq.phys = getValue( HMI_PARK_SlotStartPosn_Rq );
    _mRVC_SVS_Park_Stat_AR.PARK_SlotStartPosn2_Rq.phys = getValue( HMI_PARK_SlotStartPosn2_Rq );
    _mRVC_SVS_Park_Stat_AR.PARK_SlotStartPosn3_Rq.phys = getValue( HMI_PARK_SlotStartPosn3_Rq );
    _mRVC_SVS_Park_Stat_AR.PARK_StartList_Rq.phys = getValue( HMI_PARK_StartList_Rq );
    _mRVC_SVS_Park_Stat_AR.PARK_SysMd_Rq_Cam.phys = getValue( HMI_PARK_SysMd_Rq_Cam );
    _mRVC_SVS_Park_Stat_AR.RVC_CPF_R_Rq.phys = getValue( HMI_RVC_CPF_R_Rq );
    _mRVC_SVS_Park_Stat_AR.SVS_CPF_Ft_Rq.phys = getValue( HMI_SVS_CPF_Ft_Rq );
    _mRVC_SVS_Park_Stat_AR.SVS_CPF_R_Rq.phys = getValue( HMI_SVS_CPF_R_Rq );
    _mRVC_SVS_Park_Stat_AR.SVS_ExtLmp_Rq.phys = getValue( HMI_SVS_ExtLmp_Rq );
}

RVC_SVS_Park_Stat_AR_output(void)
{
    output( _mRVC_SVS_Park_Stat_AR );
}

RVC_SVS_Park_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: RVC_SVS_Park_Stat_AR\n", 40, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMST_RVC_SVS_Park_Stat_AR := %X\n", getValue( HMI__STMSG_RVC_SVS_Park_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_RVC_SVS_Park_Stat_AR := %X\n", getValue( HMI__STMSGT_RVC_SVS_Park_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DRVM_PkMd_Stat_V3 := %X\n", getValue( HMI_DRVM_PkMd_Stat_V3 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DRVM_SysMd_Stat_V2 := %X\n", getValue( HMI_DRVM_SysMd_Stat_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DRVM_Warn_Rq := %X\n", getValue( HMI_DRVM_Warn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Detents_Rq := %X\n", getValue( HMI_PARK_Detents_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Detents2_Rq := %X\n", getValue( HMI_PARK_Detents2_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Detents3_Rq := %X\n", getValue( HMI_PARK_Detents3_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_ExplorMd_Avl := %X\n", getValue( HMI_Park_ExplorMd_Avl ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_Row1_MsgDisp_Rq := %X\n", getValue( HMI_Park_Row1_MsgDisp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_Row2_MsgDisp_Rq := %X\n", getValue( HMI_Park_Row2_MsgDisp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_SelMenu_Rq := %X\n", getValue( HMI_PARK_SelMenu_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_SlotStartPosn_Rq := %X\n", getValue( HMI_PARK_SlotStartPosn_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_SlotStartPosn2_Rq := %X\n", getValue( HMI_PARK_SlotStartPosn2_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_SlotStartPosn3_Rq := %X\n", getValue( HMI_PARK_SlotStartPosn3_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_StartList_Rq := %X\n", getValue( HMI_PARK_StartList_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_SysMd_Rq_Cam := %X\n", getValue( HMI_PARK_SysMd_Rq_Cam ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RVC_CPF_R_Rq := %X\n", getValue( HMI_RVC_CPF_R_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SVS_CPF_Ft_Rq := %X\n", getValue( HMI_SVS_CPF_Ft_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SVS_CPF_R_Rq := %X\n", getValue( HMI_SVS_CPF_R_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SVS_ExtLmp_Rq := %X\n", getValue( HMI_SVS_ExtLmp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tRVC_SVS_Park_Stat_AR
{
    putValue( HMI__STMSG_RVC_SVS_Park_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_RVC_SVS_Park_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_RVC_SVS_Park_Stat_AR );
        if( tDelay > 0 )
            setTimer( _tRVC_SVS_Park_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_RVC_SVS_Park_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_RVC_SVS_Park_Stat_AR
{
    if( getValue( this ) )
        openPanel("RVC_SVS_Park_Stat_AR");
}

on EnvVar HMI_DRVM_PkMd_Stat_V3
{
    _mRVC_SVS_Park_Stat_AR.DRVM_PkMd_Stat_V3.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DRVM_SysMd_Stat_V2
{
    _mRVC_SVS_Park_Stat_AR.DRVM_SysMd_Stat_V2.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DRVM_Warn_Rq
{
    _mRVC_SVS_Park_Stat_AR.DRVM_Warn_Rq.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PARK_Detents_Rq
{
    _mRVC_SVS_Park_Stat_AR.PARK_Detents_Rq.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PARK_Detents2_Rq
{
    _mRVC_SVS_Park_Stat_AR.PARK_Detents2_Rq.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PARK_Detents3_Rq
{
    _mRVC_SVS_Park_Stat_AR.PARK_Detents3_Rq.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Park_ExplorMd_Avl
{
    _mRVC_SVS_Park_Stat_AR.Park_ExplorMd_Avl.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Park_Row1_MsgDisp_Rq
{
    _mRVC_SVS_Park_Stat_AR.Park_Row1_MsgDisp_Rq.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Park_Row2_MsgDisp_Rq
{
    _mRVC_SVS_Park_Stat_AR.Park_Row2_MsgDisp_Rq.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PARK_SelMenu_Rq
{
    _mRVC_SVS_Park_Stat_AR.PARK_SelMenu_Rq.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PARK_SlotStartPosn_Rq
{
    _mRVC_SVS_Park_Stat_AR.PARK_SlotStartPosn_Rq.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PARK_SlotStartPosn2_Rq
{
    _mRVC_SVS_Park_Stat_AR.PARK_SlotStartPosn2_Rq.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PARK_SlotStartPosn3_Rq
{
    _mRVC_SVS_Park_Stat_AR.PARK_SlotStartPosn3_Rq.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PARK_StartList_Rq
{
    _mRVC_SVS_Park_Stat_AR.PARK_StartList_Rq.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PARK_SysMd_Rq_Cam
{
    _mRVC_SVS_Park_Stat_AR.PARK_SysMd_Rq_Cam.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_RVC_CPF_R_Rq
{
    _mRVC_SVS_Park_Stat_AR.RVC_CPF_R_Rq.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SVS_CPF_Ft_Rq
{
    _mRVC_SVS_Park_Stat_AR.SVS_CPF_Ft_Rq.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SVS_CPF_R_Rq
{
    _mRVC_SVS_Park_Stat_AR.SVS_CPF_R_Rq.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SVS_ExtLmp_Rq
{
    _mRVC_SVS_Park_Stat_AR.SVS_ExtLmp_Rq.phys = getValue(this);
    _RVC_SVS_Park_Stat_AR_SpontanFlag = 1;
}

SBW_DrvPosn_Disp_Rq_ISM_AR_check_output()
{
    if( !getValue( HMI__STMSG_SBW_DrvPosn_Disp_Rq_ISM_AR ) )
    {
    //  message   SBW_DrvPosn_Disp_Rq_ISM_AR ID: 323 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _SBW_DrvPosn_Disp_Rq_ISM_AR_Cnt--;
        if( _SBW_DrvPosn_Disp_Rq_ISM_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            SBW_DrvPosn_Disp_Rq_ISM_AR_output();
            _SBW_DrvPosn_Disp_Rq_ISM_AR_Cnt = _SBW_DrvPosn_Disp_Rq_ISM_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _SBW_DrvPosn_Disp_Rq_ISM_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _SBW_DrvPosn_Disp_Rq_ISM_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            SBW_DrvPosn_Disp_Rq_ISM_AR_output();
            _SBW_DrvPosn_Disp_Rq_ISM_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

SBW_DrvPosn_Disp_Rq_ISM_AR_init()
{   /* Botschaft SBW_DrvPosn_Disp_Rq_ISM_AR ID: 323 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 323 0;
BA_ "NmAsrMessage" BO_ 323 0;
BA_ "GenMsgMinAcceptLength" BO_ 323 8;
BA_ "GenMsgILSupport" BO_ 323 1;
BA_ "DiagState" BO_ 323 0;
BA_ "DiagRequest" BO_ 323 0;
BA_ "DiagResponse" BO_ 323 0;
BA_ "GenMsgStartValue" BO_ 323 "0";
BA_ "GenMsgDelayTime" BO_ 323 20;
BA_ "GenMsgNrOfRepetitions" BO_ 323 0;
BA_ "GenMsgCycleTime" BO_ 323 200;
BA_ "GenMsgSendType" BO_ 323 5;
    */
    _SBW_DrvPosn_Disp_Rq_ISM_AR_Timebase =         c_tDBKomTimer_20ms;
    _SBW_DrvPosn_Disp_Rq_ISM_AR_CycleCount =     200 / _SBW_DrvPosn_Disp_Rq_ISM_AR_Timebase;
    _SBW_DrvPosn_Disp_Rq_ISM_AR_StartDelay =       0 / _SBW_DrvPosn_Disp_Rq_ISM_AR_Timebase;
    _SBW_DrvPosn_Disp_Rq_ISM_AR_Cnt = _SBW_DrvPosn_Disp_Rq_ISM_AR_StartDelay;
    _SBW_DrvPosn_Disp_Rq_ISM_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_SBW_DrvPosn_Disp_Rq_ISM_AR, _SBW_DrvPosn_Disp_Rq_ISM_AR_StartDelay * _SBW_DrvPosn_Disp_Rq_ISM_AR_Timebase );

//    _mSBW_DrvPosn_Disp_Rq_ISM_AR.Rsrv1_ISM_TxDrvPosn_Disp_Rq.phys = getValue( HMI_Rsrv1_ISM_TxDrvPosn_Disp_Rq );
//    _mSBW_DrvPosn_Disp_Rq_ISM_AR.Rsrv2_ISM_TxDrvPosn_Disp_Rq.phys = getValue( HMI_Rsrv2_ISM_TxDrvPosn_Disp_Rq );
    _mSBW_DrvPosn_Disp_Rq_ISM_AR.Rsrv3_ISM_TxDrvPosn_Disp_Rq.phys = getValue( HMI_Rsrv3_ISM_TxDrvPosn_Disp_Rq );
    _mSBW_DrvPosn_Disp_Rq_ISM_AR.SBW_Msg_Disp_Rq_ISM.phys = getValue( HMI_SBW_Msg_Disp_Rq_ISM);
    _mSBW_DrvPosn_Disp_Rq_ISM_AR.SBW_ShiftLk_Msg_RevGr_ISM.phys = getValue( HMI_SBW_ShiftLk_Msg_RevGr_ISM );
    _mSBW_DrvPosn_Disp_Rq_ISM_AR.TSL_MtnLk1_Disp_Rq_ISM_V2.phys = getValue( HMI_TSL_MtnLk1_Disp_Rq_ISM_V2 );
    _mSBW_DrvPosn_Disp_Rq_ISM_AR.TSL_MtnLk2_Disp_Rq_ISM_V2.phys = getValue( HMI_TSL_MtnLk2_Disp_Rq_ISM_V2 );
    _mSBW_DrvPosn_Disp_Rq_ISM_AR.TSL_MtnLk3_Disp_Rq_ISM_V2.phys = getValue( HMI_TSL_MtnLk3_Disp_Rq_ISM_V2 );
    _mSBW_DrvPosn_Disp_Rq_ISM_AR.TxDrvPosn_Disp_Rq_ISM.phys = getValue( HMI_TxDrvPosn_Disp_Rq_ISM);
    _mSBW_DrvPosn_Disp_Rq_ISM_AR.EOSys_Stat.phys = getValue( HMI_EOSys_Stat);
}

SBW_DrvPosn_Disp_Rq_ISM_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_ISM_TxDrvPosn_Disp_Rq ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_ISM_TxDrvPosn_Disp_Rq_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _SBW_DrvPosn_Disp_Rq_ISM_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _SBW_DrvPosn_Disp_Rq_ISM_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_ISM_TxDrvPosn_Disp_Rq_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _SBW_DrvPosn_Disp_Rq_ISM_AR_SQC_WrongSeqJump != 0 ) &&
            ( _SBW_DrvPosn_Disp_Rq_ISM_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _SBW_DrvPosn_Disp_Rq_ISM_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _SBW_DrvPosn_Disp_Rq_ISM_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _SBW_DrvPosn_Disp_Rq_ISM_AR_SQC_RepeatedCnt ) &&
            ( _SBW_DrvPosn_Disp_Rq_ISM_AR_E2E_Armed == 1  )    )
        {
            _SBW_DrvPosn_Disp_Rq_ISM_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_ISM_TxDrvPosn_Disp_Rq, SQC_help );
    }
    _mSBW_DrvPosn_Disp_Rq_ISM_AR.SQC_ISM_TxDrvPosn_Disp_Rq = SQC_help;

    if( getValue( HMI_CRC_ISM_TxDrvPosn_Disp_Rq_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_ISM_TxDrvPosn_Disp_Rq_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mSBW_DrvPosn_Disp_Rq_ISM_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mSBW_DrvPosn_Disp_Rq_ISM_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mSBW_DrvPosn_Disp_Rq_ISM_AR.byte( 2 ) ];
//            crc = crctable_profile02[ crc ^ _mSBW_DrvPosn_Disp_Rq_ISM_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mSBW_DrvPosn_Disp_Rq_ISM_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mSBW_DrvPosn_Disp_Rq_ISM_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mSBW_DrvPosn_Disp_Rq_ISM_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mSBW_DrvPosn_Disp_Rq_ISM_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _SBW_DrvPosn_Disp_Rq_ISM_AR_CRC_Offset[ _mSBW_DrvPosn_Disp_Rq_ISM_AR.SQC_ISM_TxDrvPosn_Disp_Rq ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _SBW_DrvPosn_Disp_Rq_ISM_AR_CRC_ErrorCnt   && ( _SBW_DrvPosn_Disp_Rq_ISM_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_ISM_TxDrvPosn_Disp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _SBW_DrvPosn_Disp_Rq_ISM_AR_CRC_ErrorCnt > 0 )
                    _SBW_DrvPosn_Disp_Rq_ISM_AR_CRC_ErrorCnt--; 
            }
            _mSBW_DrvPosn_Disp_Rq_ISM_AR.CRC_ISM_TxDrvPosn_Disp_Rq = crc;
            putValue( HMI_CRC_ISM_TxDrvPosn_Disp_Rq, crc );
        }
        else
            _mSBW_DrvPosn_Disp_Rq_ISM_AR.CRC_ISM_TxDrvPosn_Disp_Rq = getValue( HMI_CRC_ISM_TxDrvPosn_Disp_Rq );
    }
    else
    {
        if( !getValue( HMI_CRC_ISM_TxDrvPosn_Disp_Rq_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mSBW_DrvPosn_Disp_Rq_ISM_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mSBW_DrvPosn_Disp_Rq_ISM_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mSBW_DrvPosn_Disp_Rq_ISM_AR.byte( 2 ) ];
//            crc = crctable[ crc ^ _mSBW_DrvPosn_Disp_Rq_ISM_AR.byte( 3 ) ];
//            crc = crctable[ crc ^ _mSBW_DrvPosn_Disp_Rq_ISM_AR.byte( 4 ) ];
//            crc = crctable[ crc ^ _mSBW_DrvPosn_Disp_Rq_ISM_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mSBW_DrvPosn_Disp_Rq_ISM_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mSBW_DrvPosn_Disp_Rq_ISM_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _SBW_DrvPosn_Disp_Rq_ISM_AR_CRC_ErrorCnt   && ( _SBW_DrvPosn_Disp_Rq_ISM_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_ISM_TxDrvPosn_Disp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _SBW_DrvPosn_Disp_Rq_ISM_AR_CRC_ErrorCnt > 0 )
                    _SBW_DrvPosn_Disp_Rq_ISM_AR_CRC_ErrorCnt--; 
            }
            _mSBW_DrvPosn_Disp_Rq_ISM_AR.CRC_ISM_TxDrvPosn_Disp_Rq = crc;
            putValue( HMI_CRC_ISM_TxDrvPosn_Disp_Rq, crc );
        }
        else
            _mSBW_DrvPosn_Disp_Rq_ISM_AR.CRC_ISM_TxDrvPosn_Disp_Rq = getValue( HMI_CRC_ISM_TxDrvPosn_Disp_Rq );
    }
    if( ( _SBW_DrvPosn_Disp_Rq_ISM_AR_MSG_DropCnt > 0 ) &&
        ( _SBW_DrvPosn_Disp_Rq_ISM_AR_E2E_Armed == 1  )    )
    {
        _SBW_DrvPosn_Disp_Rq_ISM_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mSBW_DrvPosn_Disp_Rq_ISM_AR );
        
    if( _SBW_DrvPosn_Disp_Rq_ISM_AR_E2E_Armed == 1 )
    {
        if ( ( _SBW_DrvPosn_Disp_Rq_ISM_AR_MSG_DropCnt == 0      ) &&
             ( _SBW_DrvPosn_Disp_Rq_ISM_AR_CRC_ErrorCnt == 0     ) &&
             ( _SBW_DrvPosn_Disp_Rq_ISM_AR_SQC_RepeatedCnt == 0  ) &&
             ( _SBW_DrvPosn_Disp_Rq_ISM_AR_SQC_WrongSeqJump == 0 )    )
        {
            _SBW_DrvPosn_Disp_Rq_ISM_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_ISM_TxDrvPosn_Disp_Rq_State, 0 );
        }
    }
}

SBW_DrvPosn_Disp_Rq_ISM_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SBW_DrvPosn_Disp_Rq_ISM_AR\n", 40, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSSBW_DrvPosn_Disp_Rq_ISM := %X\n", getValue( HMI__STMSG_SBW_DrvPosn_Disp_Rq_ISM_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSSBW_DrvPosn_Disp_Rq__02 := %X\n", getValue( HMI__STMSGT_SBW_DrvPosn_Disp_Rq_ISM_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ISM_TxDrvPosn_Disp_Rq := %X\n", getValue( HMI_CRC_ISM_TxDrvPosn_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ISM_TxDrvPosn_Disp_Rq_Auto := %X\n", getValue( HMI_CRC_ISM_TxDrvPosn_Disp_Rq_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv3_ISM_TxDrvPosn_Disp_Rq := %X\n", getValue( HMI_Rsrv3_ISM_TxDrvPosn_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SBW_Msg_Disp_Rq_ISM := %X\n", getValue( HMI_SBW_Msg_Disp_Rq_ISM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SBW_ShiftLk_Msg_RevGr_ISM := %X\n", getValue( HMI_SBW_ShiftLk_Msg_RevGr_ISM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_ISM_TxDrvPosn_Disp_Rq := %X\n", getValue( HMI_SQC_ISM_TxDrvPosn_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_ISM_TxDrvPosn_Disp_Rq_Auto := %X\n", getValue( HMI_SQC_ISM_TxDrvPosn_Disp_Rq_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSL_MtnLk1_Disp_Rq_ISM_V2 := %X\n", getValue( HMI_TSL_MtnLk1_Disp_Rq_ISM_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSL_MtnLk2_Disp_Rq_ISM_V2 := %X\n", getValue( HMI_TSL_MtnLk2_Disp_Rq_ISM_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSL_MtnLk3_Disp_Rq_ISM_V2 := %X\n", getValue( HMI_TSL_MtnLk3_Disp_Rq_ISM_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TxDrvPosn_Disp_Rq_ISM := %X\n", getValue( HMI_TxDrvPosn_Disp_Rq_ISM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EOSys_Stat := %X\n", getValue( HMI_EOSys_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tSBW_DrvPosn_Disp_Rq_ISM_AR
{
    putValue( HMI__STMSG_SBW_DrvPosn_Disp_Rq_ISM_AR, 0 );
}

on EnvVar HMI__STMSG_SBW_DrvPosn_Disp_Rq_ISM_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SBW_DrvPosn_Disp_Rq_ISM_AR );
        if( tDelay > 0)    
            setTimer( _tSBW_DrvPosn_Disp_Rq_ISM_AR, tDelay );
        else
            putValue( HMI__STMSG_SBW_DrvPosn_Disp_Rq_ISM_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_SBW_DrvPosn_Disp_Rq_ISM_AR
{
    if( getValue( this ) )
        openPanel("SBW_DrvPosn_Disp_Rq_ISM_AR");
}

on envVar HMI_E2E_ISM_TxDrvPosn_Disp_Rq_Inject
{
    if( getValue( this ) )
    {
        _SBW_DrvPosn_Disp_Rq_ISM_AR_CRC_ErrorCnt = getValue( HMI_CRC_ISM_TxDrvPosn_Disp_Rq_ErrorCount );
        _SBW_DrvPosn_Disp_Rq_ISM_AR_SQC_TriggPos = getValue( HMI_SQC_ISM_TxDrvPosn_Disp_Rq_TriggerPosition );
        _SBW_DrvPosn_Disp_Rq_ISM_AR_SQC_WrongSeqJump = getValue( HMI_SQC_ISM_TxDrvPosn_Disp_Rq_WrongSeq );
        _SBW_DrvPosn_Disp_Rq_ISM_AR_SQC_RepeatedCnt = getValue( HMI_SQC_ISM_TxDrvPosn_Disp_Rq_Repeated );
        _SBW_DrvPosn_Disp_Rq_ISM_AR_MSG_DropCnt = getValue( HMI_SQC_ISM_TxDrvPosn_Disp_Rq_MSG_DropCnt );
        putValue( HMI_E2E_ISM_TxDrvPosn_Disp_Rq_State, 2 );
        _SBW_DrvPosn_Disp_Rq_ISM_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_Rsrv3_ISM_TxDrvPosn_Disp_Rq
{
    _mSBW_DrvPosn_Disp_Rq_ISM_AR.Rsrv3_ISM_TxDrvPosn_Disp_Rq.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_ISM_AR_SpontanFlag = 1;
}

on EnvVar HMI_SBW_Msg_Disp_Rq_ISM
{
    _mSBW_DrvPosn_Disp_Rq_ISM_AR.SBW_Msg_Disp_Rq_ISM.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_ISM_AR_SpontanFlag = 1;
}

on EnvVar HMI_SBW_ShiftLk_Msg_RevGr_ISM
{
    _mSBW_DrvPosn_Disp_Rq_ISM_AR.SBW_ShiftLk_Msg_RevGr_ISM.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_ISM_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSL_MtnLk1_Disp_Rq_ISM_V2
{
    _mSBW_DrvPosn_Disp_Rq_ISM_AR.TSL_MtnLk1_Disp_Rq_ISM_V2.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_ISM_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSL_MtnLk2_Disp_Rq_ISM_V2
{
    _mSBW_DrvPosn_Disp_Rq_ISM_AR.TSL_MtnLk2_Disp_Rq_ISM_V2.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_ISM_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSL_MtnLk3_Disp_Rq_ISM_V2
{
    _mSBW_DrvPosn_Disp_Rq_ISM_AR.TSL_MtnLk3_Disp_Rq_ISM_V2.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_ISM_AR_SpontanFlag = 1;
}

on EnvVar HMI_EOSys_Stat
{
    _mSBW_DrvPosn_Disp_Rq_ISM_AR.EOSys_Stat.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_ISM_AR_SpontanFlag = 1;
}

on EnvVar HMI_TxDrvPosn_Disp_Rq_ISM
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cGearIndNMRequest );
        setTimer( t_GearIndNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mSBW_DrvPosn_Disp_Rq_ISM_AR.TxDrvPosn_Disp_Rq_ISM.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_ISM_AR_SpontanFlag = 1;
}

SBW_DrvPosn_Disp_Rq_TCM_AR_check_output()
{
    if( !getValue( HMI__STMSG_SBW_DrvPosn_Disp_Rq_TCM_AR ) )
    {
    //  message   SBW_DrvPosn_Disp_Rq_TCM_AR ID: 711 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _SBW_DrvPosn_Disp_Rq_TCM_AR_Cnt--;
        if( _SBW_DrvPosn_Disp_Rq_TCM_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            SBW_DrvPosn_Disp_Rq_TCM_AR_output();
            _SBW_DrvPosn_Disp_Rq_TCM_AR_Cnt = _SBW_DrvPosn_Disp_Rq_TCM_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            SBW_DrvPosn_Disp_Rq_TCM_AR_output();
            _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

SBW_DrvPosn_Disp_Rq_TCM_AR_init()
{   /* Botschaft SBW_DrvPosn_Disp_Rq_TCM_AR ID: 711 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 711 0;
BA_ "NmAsrMessage" BO_ 711 0;
BA_ "GenMsgMinAcceptLength" BO_ 711 8;
BA_ "GenMsgILSupport" BO_ 711 1;
BA_ "DiagState" BO_ 711 0;
BA_ "DiagRequest" BO_ 711 0;
BA_ "DiagResponse" BO_ 711 0;
BA_ "GenMsgStartValue" BO_ 711 "0";
BA_ "GenMsgDelayTime" BO_ 711 20;
BA_ "GenMsgNrOfRepetitions" BO_ 711 0;
BA_ "GenMsgCycleTime" BO_ 711 200;
BA_ "GenMsgSendType" BO_ 711 5;
    */
    _SBW_DrvPosn_Disp_Rq_TCM_AR_Timebase =         c_tDBKomTimer_20ms;
    _SBW_DrvPosn_Disp_Rq_TCM_AR_CycleCount =     200 / _SBW_DrvPosn_Disp_Rq_TCM_AR_Timebase;
    _SBW_DrvPosn_Disp_Rq_TCM_AR_StartDelay =       0 / _SBW_DrvPosn_Disp_Rq_TCM_AR_Timebase;
    _SBW_DrvPosn_Disp_Rq_TCM_AR_Cnt = _SBW_DrvPosn_Disp_Rq_TCM_AR_StartDelay;
    _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_SBW_DrvPosn_Disp_Rq_TCM_AR, _SBW_DrvPosn_Disp_Rq_TCM_AR_StartDelay * _SBW_DrvPosn_Disp_Rq_TCM_AR_Timebase );

    _mSBW_DrvPosn_Disp_Rq_TCM_AR.Gr_Target_Disp_Rq_V2.phys = getValue( HMI_Gr_Target_Disp_Rq_V2 );
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.RaceStartMd_Disp_Rq_AMG.phys = getValue( HMI_RaceStartMd_Disp_Rq_AMG);
//    _mSBW_DrvPosn_Disp_Rq_TCM_AR.Rsrv1_SBW_Drv_Pk_Posn_TCM.phys = getValue( HMI_Rsrv1_SBW_Drv_Pk_Posn_TCM );
//    _mSBW_DrvPosn_Disp_Rq_TCM_AR.Rsrv2_SBW_Drv_Pk_Posn_TCM.phys = getValue( HMI_Rsrv2_SBW_Drv_Pk_Posn_TCM );
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.SBW_Msg_Disp_Rq_TCM.phys = getValue( HMI_SBW_Msg_Disp_Rq_TCM);
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.SBW_ShiftLk_Msg_RevGr_TCM.phys = getValue( HMI_SBW_ShiftLk_Msg_RevGr_TCM );
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.TCM_LHOM_Stat.phys = getValue( HMI_TCM_LHOM_Stat );
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.TCM_PkPosn_Flt_Stat.phys = getValue( HMI_TCM_PkPosn_Flt_Stat );
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.TCM_Temp_Flt_Stat.phys = getValue( HMI_TCM_Temp_Flt_Stat );
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.TSL_MtnLk1_Disp_Rq_TCM_V2.phys = getValue( HMI_TSL_MtnLk1_Disp_Rq_TCM_V2 );
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.TSL_MtnLk2_Disp_Rq_TCM_V2.phys = getValue( HMI_TSL_MtnLk2_Disp_Rq_TCM_V2 );
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.TSL_MtnLk3_Disp_Rq_TCM_V2.phys = getValue( HMI_TSL_MtnLk3_Disp_Rq_TCM_V2 );
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.TxDrvPosn_Disp_Rq_TCM.phys = getValue( HMI_TxDrvPosn_Disp_Rq_TCM);
    /* sofort */   _mSBW_DrvPosn_Disp_Rq_TCM_AR.TxDrvProg_Disp_Rq_TCM.phys = getValue( HMI_TxDrvProg_Disp_Rq_TCM);
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.TxShiftRcmmnd_Disp_Rq_TCM.phys = getValue( HMI_TxShiftRcmmnd_Disp_Rq_TCM);
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.SBW_Msg_Disp_Rq2_TCM.phys = getValue( HMI_SBW_Msg_Disp_Rq2_TCM);
}

SBW_DrvPosn_Disp_Rq_TCM_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_SBW_Drv_Pk_Posn_TCM ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_SBW_Drv_Pk_Posn_TCM_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _SBW_DrvPosn_Disp_Rq_TCM_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _SBW_DrvPosn_Disp_Rq_TCM_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_SBW_Drv_Pk_Posn_TCM_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _SBW_DrvPosn_Disp_Rq_TCM_AR_SQC_WrongSeqJump != 0 ) &&
            ( _SBW_DrvPosn_Disp_Rq_TCM_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _SBW_DrvPosn_Disp_Rq_TCM_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _SBW_DrvPosn_Disp_Rq_TCM_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _SBW_DrvPosn_Disp_Rq_TCM_AR_SQC_RepeatedCnt ) &&
            ( _SBW_DrvPosn_Disp_Rq_TCM_AR_E2E_Armed == 1  )    )
        {
            _SBW_DrvPosn_Disp_Rq_TCM_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_SBW_Drv_Pk_Posn_TCM, SQC_help );
    }
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.SQC_SBW_Drv_Pk_Posn_TCM = SQC_help;

    if( getValue( HMI_CRC_SBW_Drv_Pk_Posn_TCM_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_SBW_Drv_Pk_Posn_TCM_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mSBW_DrvPosn_Disp_Rq_TCM_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mSBW_DrvPosn_Disp_Rq_TCM_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mSBW_DrvPosn_Disp_Rq_TCM_AR.byte( 2 ) ];
//            crc = crctable_profile02[ crc ^ _mSBW_DrvPosn_Disp_Rq_TCM_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mSBW_DrvPosn_Disp_Rq_TCM_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mSBW_DrvPosn_Disp_Rq_TCM_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mSBW_DrvPosn_Disp_Rq_TCM_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mSBW_DrvPosn_Disp_Rq_TCM_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _SBW_DrvPosn_Disp_Rq_TCM_AR_CRC_Offset[ _mSBW_DrvPosn_Disp_Rq_TCM_AR.SQC_SBW_Drv_Pk_Posn_TCM ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _SBW_DrvPosn_Disp_Rq_TCM_AR_CRC_ErrorCnt   && ( _SBW_DrvPosn_Disp_Rq_TCM_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_SBW_Drv_Pk_Posn_TCM_Invalid )                                         )    )
            {
                crc++;
                if( _SBW_DrvPosn_Disp_Rq_TCM_AR_CRC_ErrorCnt > 0 )
                    _SBW_DrvPosn_Disp_Rq_TCM_AR_CRC_ErrorCnt--; 
            }
            _mSBW_DrvPosn_Disp_Rq_TCM_AR.CRC_SBW_Drv_Pk_Posn_TCM = crc;
            putValue( HMI_CRC_SBW_Drv_Pk_Posn_TCM, crc );
        }
        else
            _mSBW_DrvPosn_Disp_Rq_TCM_AR.CRC_SBW_Drv_Pk_Posn_TCM = getValue( HMI_CRC_SBW_Drv_Pk_Posn_TCM );
    }
    else
    {
        if( !getValue( HMI_CRC_SBW_Drv_Pk_Posn_TCM_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mSBW_DrvPosn_Disp_Rq_TCM_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mSBW_DrvPosn_Disp_Rq_TCM_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mSBW_DrvPosn_Disp_Rq_TCM_AR.byte( 2 ) ];
//            crc = crctable[ crc ^ _mSBW_DrvPosn_Disp_Rq_TCM_AR.byte( 3 ) ];
//            crc = crctable[ crc ^ _mSBW_DrvPosn_Disp_Rq_TCM_AR.byte( 4 ) ];
//            crc = crctable[ crc ^ _mSBW_DrvPosn_Disp_Rq_TCM_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mSBW_DrvPosn_Disp_Rq_TCM_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mSBW_DrvPosn_Disp_Rq_TCM_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _SBW_DrvPosn_Disp_Rq_TCM_AR_CRC_ErrorCnt   && ( _SBW_DrvPosn_Disp_Rq_TCM_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_SBW_Drv_Pk_Posn_TCM_Invalid )                                         )    )
            {
                crc++;
                if( _SBW_DrvPosn_Disp_Rq_TCM_AR_CRC_ErrorCnt > 0 )
                    _SBW_DrvPosn_Disp_Rq_TCM_AR_CRC_ErrorCnt--; 
            }
            _mSBW_DrvPosn_Disp_Rq_TCM_AR.CRC_SBW_Drv_Pk_Posn_TCM = crc;
            putValue( HMI_CRC_SBW_Drv_Pk_Posn_TCM, crc );
        }
        else
            _mSBW_DrvPosn_Disp_Rq_TCM_AR.CRC_SBW_Drv_Pk_Posn_TCM = getValue( HMI_CRC_SBW_Drv_Pk_Posn_TCM );
    }
    if( ( _SBW_DrvPosn_Disp_Rq_TCM_AR_MSG_DropCnt > 0 ) &&
        ( _SBW_DrvPosn_Disp_Rq_TCM_AR_E2E_Armed == 1  )    )
    {
        _SBW_DrvPosn_Disp_Rq_TCM_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mSBW_DrvPosn_Disp_Rq_TCM_AR );
        
    if( _SBW_DrvPosn_Disp_Rq_TCM_AR_E2E_Armed == 1 )
    {
        if ( ( _SBW_DrvPosn_Disp_Rq_TCM_AR_MSG_DropCnt == 0      ) &&
             ( _SBW_DrvPosn_Disp_Rq_TCM_AR_CRC_ErrorCnt == 0     ) &&
             ( _SBW_DrvPosn_Disp_Rq_TCM_AR_SQC_RepeatedCnt == 0  ) &&
             ( _SBW_DrvPosn_Disp_Rq_TCM_AR_SQC_WrongSeqJump == 0 )    )
        {
            _SBW_DrvPosn_Disp_Rq_TCM_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_SBW_Drv_Pk_Posn_TCM_State, 0 );
        }
    }
}

SBW_DrvPosn_Disp_Rq_TCM_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SBW_DrvPosn_Disp_Rq_TCM_AR\n", 40, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSSBW_DrvPosn_Disp_Rq_TCM := %X\n", getValue( HMI__STMSG_SBW_DrvPosn_Disp_Rq_TCM_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSSBW_DrvPosn_Disp_Rq__01 := %X\n", getValue( HMI__STMSGT_SBW_DrvPosn_Disp_Rq_TCM_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Gr_Target_Disp_Rq_V2 := %X\n", getValue( HMI_Gr_Target_Disp_Rq_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RaceStartMd_Disp_Rq_AMG := %X\n", getValue( HMI_RaceStartMd_Disp_Rq_AMG ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SBW_Msg_Disp_Rq_TCM := %X\n", getValue( HMI_SBW_Msg_Disp_Rq_TCM ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SBW_ShiftLk_Msg_RevGr_TCM := %X\n", getValue( HMI_SBW_ShiftLk_Msg_RevGr_TCM ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCM_LHOM_Stat := %X\n", getValue( HMI_TCM_LHOM_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCM_PkPosn_Flt_Stat := %X\n", getValue( HMI_TCM_PkPosn_Flt_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCM_Temp_Flt_Stat := %X\n", getValue( HMI_TCM_Temp_Flt_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSL_MtnLk1_Disp_Rq_TCM_V2 := %X\n", getValue( HMI_TSL_MtnLk1_Disp_Rq_TCM_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSL_MtnLk2_Disp_Rq_TCM_V2 := %X\n", getValue( HMI_TSL_MtnLk2_Disp_Rq_TCM_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSL_MtnLk3_Disp_Rq_TCM_V2 := %X\n", getValue( HMI_TSL_MtnLk3_Disp_Rq_TCM_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TxDrvPosn_Disp_Rq_TCM := %X\n", getValue( HMI_TxDrvPosn_Disp_Rq_TCM ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TxDrvProg_Disp_Rq_TCM := %X\n", getValue( HMI_TxDrvProg_Disp_Rq_TCM ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TxShiftRcmmnd_Disp_Rq_TCM := %X\n", getValue( HMI_TxShiftRcmmnd_Disp_Rq_TCM ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SBW_Msg_Disp_Rq2_TCM := %X\n", getValue( HMI_SBW_Msg_Disp_Rq2_TCM ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tSBW_DrvPosn_Disp_Rq_TCM_AR
{
    putValue( HMI__STMSG_SBW_DrvPosn_Disp_Rq_TCM_AR, 0 );
}

on EnvVar HMI__STMSG_SBW_DrvPosn_Disp_Rq_TCM_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SBW_DrvPosn_Disp_Rq_TCM_AR );
        if( tDelay > 0)    
            setTimer( _tSBW_DrvPosn_Disp_Rq_TCM_AR, tDelay );
        else
            putValue( HMI__STMSG_SBW_DrvPosn_Disp_Rq_TCM_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_SBW_DrvPosn_Disp_Rq_TCM_AR
{
    if( getValue( this ) )
        openPanel("SBW_DrvPosn_Disp_Rq_TCM_AR");
}

on envVar HMI_E2E_SBW_Drv_Pk_Posn_TCM_Inject
{
    if( getValue( this ) )
    {
        _SBW_DrvPosn_Disp_Rq_TCM_AR_CRC_ErrorCnt = getValue( HMI_CRC_SBW_Drv_Pk_Posn_TCM_ErrorCount );
        _SBW_DrvPosn_Disp_Rq_TCM_AR_SQC_TriggPos = getValue( HMI_SQC_SBW_Drv_Pk_Posn_TCM_TriggerPosition );
        _SBW_DrvPosn_Disp_Rq_TCM_AR_SQC_WrongSeqJump = getValue( HMI_SQC_SBW_Drv_Pk_Posn_TCM_WrongSeq );
        _SBW_DrvPosn_Disp_Rq_TCM_AR_SQC_RepeatedCnt = getValue( HMI_SQC_SBW_Drv_Pk_Posn_TCM_Repeated );
        _SBW_DrvPosn_Disp_Rq_TCM_AR_MSG_DropCnt = getValue( HMI_SQC_SBW_Drv_Pk_Posn_TCM_MSG_DropCnt );
        putValue( HMI_E2E_SBW_Drv_Pk_Posn_TCM_State, 2 );
        _SBW_DrvPosn_Disp_Rq_TCM_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_Gr_Target_Disp_Rq_V2
{
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.Gr_Target_Disp_Rq_V2.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag = 1;
}

on EnvVar HMI_RaceStartMd_Disp_Rq_AMG
{
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.RaceStartMd_Disp_Rq_AMG.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag = 1;
}

on EnvVar HMI_SBW_Msg_Disp_Rq_TCM
{
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.SBW_Msg_Disp_Rq_TCM.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag = 1;
}

on envVar HMI_SBW_ShiftLk_Msg_RevGr_TCM
{
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.SBW_ShiftLk_Msg_RevGr_TCM.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag = 1;
}

on envVar HMI_TCM_LHOM_Stat
{
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.TCM_LHOM_Stat.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag = 1;
}

on envVar HMI_TCM_PkPosn_Flt_Stat
{
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.TCM_PkPosn_Flt_Stat.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag = 1;
}

on envVar HMI_TCM_Temp_Flt_Stat
{
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.TCM_Temp_Flt_Stat.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSL_MtnLk1_Disp_Rq_TCM_V2
{
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.TSL_MtnLk1_Disp_Rq_TCM_V2.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSL_MtnLk2_Disp_Rq_TCM_V2
{
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.TSL_MtnLk2_Disp_Rq_TCM_V2.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSL_MtnLk3_Disp_Rq_TCM_V2
{
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.TSL_MtnLk3_Disp_Rq_TCM_V2.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag = 1;
}

on EnvVar HMI_TxDrvPosn_Disp_Rq_TCM
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cGearIndNMRequest );
        setTimer( t_GearIndNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.TxDrvPosn_Disp_Rq_TCM.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag = 1;
}

on EnvVar HMI_TxDrvProg_Disp_Rq_TCM
{
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.TxDrvProg_Disp_Rq_TCM.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag = 1;
}

on EnvVar HMI_TxShiftRcmmnd_Disp_Rq_TCM
{
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.TxShiftRcmmnd_Disp_Rq_TCM.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag = 1;
}

on EnvVar HMI_SBW_Msg_Disp_Rq2_TCM
{
    _mSBW_DrvPosn_Disp_Rq_TCM_AR.SBW_Msg_Disp_Rq2_TCM.phys = getValue(this);
    _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag = 1;
}

Seat_3L_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_Seat_3L_Stat_AR ) )
    {
    //  Botschaft Seat_3L_Stat_AR ID: 954 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _Seat_3L_Stat_AR_Cnt--;
        if( _Seat_3L_Stat_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            Seat_3L_Stat_AR_output();
            _Seat_3L_Stat_AR_Cnt = _Seat_3L_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _Seat_3L_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _Seat_3L_Stat_AR_SpontanFlag )
        {
            Seat_3L_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _Seat_3L_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

Seat_3L_Stat_AR_init()
{   /* Botschaft Seat_3L_Stat_AR ID: 954 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 954 0;
BA_ "NmAsrMessage" BO_ 954 0;
BA_ "GenMsgMinAcceptLength" BO_ 954 8;
BA_ "GenMsgILSupport" BO_ 954 1;
BA_ "DiagState" BO_ 954 0;
BA_ "DiagRequest" BO_ 954 0;
BA_ "DiagResponse" BO_ 954 0;
BA_ "GenMsgStartValue" BO_ 954 "0";
BA_ "GenMsgDelayTime" BO_ 954 5;
BA_ "GenMsgNrOfRepetition" BO_ 954 0;
BA_ "GenMsgCycleTime" BO_ 954 500;
BA_ "GenMsgSendType" BO_ 954 5;
    */
    _Seat_3L_Stat_AR_Timebase =         c_tDBKomTimer_20ms;
    _Seat_3L_Stat_AR_CycleCount =     500 / _Seat_3L_Stat_AR_Timebase;
    _Seat_3L_Stat_AR_StartDelay =       0 / _Seat_3L_Stat_AR_Timebase;
    _Seat_3L_Stat_AR_Cnt = _Seat_3L_Stat_AR_StartDelay;
    _Seat_3L_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_Seat_3L_Stat_AR, _Seat_3L_Stat_AR_StartDelay * _Seat_3L_Stat_AR_Timebase );
    
    _mSeat_3L_Stat_AR.SeatBkRst_3L_Adj_Stat.phys = getValue( HMI_SeatBkRst_3L_Adj_Stat );
    _mSeat_3L_Stat_AR.SeatBkRst_3L_Stat_SEAT.phys = getValue( HMI_SeatBkRst_3L_Stat_SEAT );
    _mSeat_3L_Stat_AR.SeatBkRstPosn_3L.phys = getValue( HMI_SeatBkRstPosn_3L );
    _mSeat_3L_Stat_AR.SeatBkRst_3L_Lock_Stat.phys = getValue( HMI_SeatBkRst_3L_Lock_Stat );
    _mSeat_3L_Stat_AR.SeatBkRst_3L_LockPosn.phys = getValue( HMI_SeatBkRst_3L_LockPosn );
}

void Seat_3L_Stat_AR_output(void)
{
    output( _mSeat_3L_Stat_AR );
}

void Seat_3L_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Seat_3L_Stat_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Seat_3_Stat := %X\n", getValue( HMI__STMSG_Seat_3L_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Seat_3_Stat := %X\n", getValue( HMI__STMSGT_Seat_3L_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_3L_Adj_Stat := %X\n", getValue( HMI_SeatBkRst_3L_Adj_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_3L_Stat_SEAT := %X\n", getValue( HMI_SeatBkRst_3L_Stat_SEAT ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRstPosn_3L := %X\n", getValue( HMI_SeatBkRstPosn_3L ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_3L_Lock_Stat := %X\n", getValue( HMI_SeatBkRst_3L_Lock_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_3L_LockPosn := %X\n", getValue( HMI_SeatBkRst_3L_LockPosn ) );      filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tSeat_3L_Stat_AR
{
    putValue( HMI__STMSG_Seat_3L_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_Seat_3L_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Seat_3L_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tSeat_3L_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_Seat_3L_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Seat_3L_Stat_AR
{
    if( getValue( this ) )
        openPanel("Seat_XX_Stat_AR");
}

on EnvVar HMI_SeatBkRstPosn_3L
{
    _mSeat_3L_Stat_AR.SeatBkRstPosn_3L.phys = getValue(this);
    _Seat_3L_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_3L_Stat_SEAT
{
    _mSeat_3L_Stat_AR.SeatBkRst_3L_Stat_SEAT.phys = getValue(this);
    _Seat_3L_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_3L_Adj_Stat
{
    _mSeat_3L_Stat_AR.SeatBkRst_3L_Adj_Stat.phys = getValue(this);
    _Seat_3L_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_3L_Lock_Stat
{
    _mSeat_3L_Stat_AR.SeatBkRst_3L_Lock_Stat.phys = getValue(this);
    _Seat_3L_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_3L_LockPosn
{
    _mSeat_3L_Stat_AR.SeatBkRst_3L_LockPosn.phys = getValue(this);
    _Seat_3L_Stat_AR_SpontanFlag = 1;
}

//
Seat_3R_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_Seat_3R_Stat_AR ) )
    {
    //  Botschaft Seat_3R_Stat_AR  --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _Seat_3R_Stat_AR_Cnt--;
        if( _Seat_3R_Stat_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            Seat_3R_Stat_AR_output();
            _Seat_3R_Stat_AR_Cnt = _Seat_3R_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _Seat_3R_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _Seat_3R_Stat_AR_SpontanFlag )
        {
            Seat_3R_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _Seat_3R_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

Seat_3R_Stat_AR_init()
{   /* Botschaft Seat_3R_Stat_AR  --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 954 0;
BA_ "NmAsrMessage" BO_ 954 0;
BA_ "GenMsgMinAcceptLength" BO_ 954 8;
BA_ "GenMsgILSupport" BO_ 954 1;
BA_ "DiagState" BO_ 954 0;
BA_ "DiagRequest" BO_ 954 0;
BA_ "DiagResponse" BO_ 954 0;
BA_ "GenMsgStartValue" BO_ 954 "0";
BA_ "GenMsgDelayTime" BO_ 954 5;
BA_ "GenMsgNrOfRepetition" BO_ 954 0;
BA_ "GenMsgCycleTime" BO_ 954 500;
BA_ "GenMsgSendType" BO_ 954 5;
    */
    _Seat_3R_Stat_AR_Timebase =         c_tDBKomTimer_20ms;
    _Seat_3R_Stat_AR_CycleCount =     500 / _Seat_3R_Stat_AR_Timebase;
    _Seat_3R_Stat_AR_StartDelay =       0 / _Seat_3R_Stat_AR_Timebase;
    _Seat_3R_Stat_AR_Cnt = _Seat_3R_Stat_AR_StartDelay;
    _Seat_3R_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_Seat_3R_Stat_AR, _Seat_3R_Stat_AR_StartDelay * _Seat_3R_Stat_AR_Timebase );
    
    _mSeat_3R_Stat_AR.SeatBkRst_3R_Adj_Stat.phys = getValue( HMI_SeatBkRst_3R_Adj_Stat );
    _mSeat_3R_Stat_AR.SeatBkRst_3R_Stat_SEAT.phys = getValue( HMI_SeatBkRst_3R_Stat_SEAT );
    _mSeat_3R_Stat_AR.SeatBkRstPosn_3R.phys = getValue( HMI_SeatBkRstPosn_3R );
    _mSeat_3R_Stat_AR.SeatBkRst_3R_Lock_Stat.phys = getValue( HMI_SeatBkRst_3R_Lock_Stat );
    _mSeat_3R_Stat_AR.SeatBkRst_3R_LockPosn.phys = getValue( HMI_SeatBkRst_3R_LockPosn );
}

void Seat_3R_Stat_AR_output(void)
{
    output( _mSeat_3R_Stat_AR );
}

void Seat_3R_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Seat_3R_Stat_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Seat_3_Stat := %X\n", getValue( HMI__STMSG_Seat_3R_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Seat_3_Stat := %X\n", getValue( HMI__STMSGT_Seat_3R_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_3R_Adj_Stat := %X\n", getValue( HMI_SeatBkRst_3R_Adj_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_3R_Stat_SEAT := %X\n", getValue( HMI_SeatBkRst_3R_Stat_SEAT ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRstPosn_3R := %X\n", getValue( HMI_SeatBkRstPosn_3R ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_3R_Lock_Stat := %X\n", getValue( HMI_SeatBkRst_3R_Lock_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_3R_LockPosn := %X\n", getValue( HMI_SeatBkRst_3R_LockPosn ) );      filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tSeat_3R_Stat_AR
{
    putValue( HMI__STMSG_Seat_3R_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_Seat_3R_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Seat_3R_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tSeat_3R_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_Seat_3R_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Seat_3R_Stat_AR
{
    if( getValue( this ) )
        openPanel("Seat_XX_Stat_AR");
}

on EnvVar HMI_SeatBkRstPosn_3R
{
    _mSeat_3R_Stat_AR.SeatBkRstPosn_3R.phys = getValue(this);
    _Seat_3R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_3R_Stat_SEAT
{
    _mSeat_3R_Stat_AR.SeatBkRst_3R_Stat_SEAT.phys = getValue(this);
    _Seat_3R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_3R_Adj_Stat
{
    _mSeat_3R_Stat_AR.SeatBkRst_3R_Adj_Stat.phys = getValue(this);
    _Seat_3R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_3R_Lock_Stat
{
    _mSeat_3R_Stat_AR.SeatBkRst_3R_Lock_Stat.phys = getValue(this);
    _Seat_3R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_3R_LockPosn
{
    _mSeat_3R_Stat_AR.SeatBkRst_3R_LockPosn.phys = getValue(this);
    _Seat_3R_Stat_AR_SpontanFlag = 1;
}


Seat_D_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_Seat_D_Stat_AR ) )
    {
    //  message   Seat_D_Stat_AR ID: 937 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _Seat_D_Stat_AR_Cnt--;
        if( _Seat_D_Stat_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            Seat_D_Stat_AR_output();
            _Seat_D_Stat_AR_Cnt = _Seat_D_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _Seat_D_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _Seat_D_Stat_AR_SpontanFlag )
        {
            // Nachricht wg. spontaner �nderung ausgeben
            Seat_D_Stat_AR_output();
            _Seat_D_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

Seat_D_Stat_AR_init()
{   /* Botschaft Seat_D_Stat_AR ID: 937 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 937 0;
BA_ "NmAsrMessage" BO_ 937 0;
BA_ "GenMsgMinAcceptLength" BO_ 937 4;
BA_ "GenMsgILSupport" BO_ 937 1;
BA_ "DiagState" BO_ 937 0;
BA_ "DiagRequest" BO_ 937 0;
BA_ "DiagResponse" BO_ 937 0;
BA_ "GenMsgStartValue" BO_ 937 "0";
BA_ "GenMsgDelayTime" BO_ 937 5;
BA_ "GenMsgNrOfRepetitions" BO_ 937 0;
BA_ "GenMsgCycleTime" BO_ 937 500;
BA_ "GenMsgSendType" BO_ 937 5;
    */
    _Seat_D_Stat_AR_Timebase =         c_tDBKomTimer_20ms;
    _Seat_D_Stat_AR_CycleCount =     500 / _Seat_D_Stat_AR_Timebase;
    _Seat_D_Stat_AR_StartDelay =       0 / _Seat_D_Stat_AR_Timebase;
    _Seat_D_Stat_AR_Cnt = _Seat_D_Stat_AR_StartDelay;
    _Seat_D_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_Seat_D_Stat_AR, _Seat_D_Stat_AR_StartDelay * _Seat_D_Stat_AR_Timebase );

    _mSeat_D_Stat_AR.EEH_SeatAdj_Stat.phys = getValue( HMI_EEH_SeatAdj_Stat );
    _mSeat_D_Stat_AR.EEH_StW_Adj_Stat.phys = getValue( HMI_EEH_StW_Adj_Stat );
    _mSeat_D_Stat_AR.FWLP_Pmp_Rq_D.phys = getValue( HMI_FWLP_Pmp_Rq_D );
    _mSeat_D_Stat_AR.Mem_D_Sv_Beep_Rq.phys = getValue( HMI_Mem_D_Sv_Beep_Rq );
    _mSeat_D_Stat_AR.Mem_D_Sv_Tgl.phys = getValue( HMI_Mem_D_Sv_Tgl );
    _mSeat_D_Stat_AR.Pers_AutoSeatPosn_D_Stat.phys = getValue( HMI_Pers_AutoSeatPosn_D_Stat );
    _mSeat_D_Stat_AR.Seat_D_collision.phys = getValue( HMI_Seat_D_collision );
    _mSeat_D_Stat_AR.Seat_D_Collision_Not_Avl.phys = getValue( HMI_Seat_D_Collision_Not_Avl );
    _mSeat_D_Stat_AR.Seat_D_Collision_Tm.phys = getValue( HMI_Seat_D_Collision_Tm );
    _mSeat_D_Stat_AR.Seat_D_IncorrPosn.phys = getValue( HMI_Seat_D_IncorrPosn );
    _mSeat_D_Stat_AR.SeatBkRst_D_Unlk.phys = getValue( HMI_SeatBkRst_D_Unlk );
	_mSeat_D_Stat_AR.Seat_D_collision_EE.phys = getValue( HMI_Seat_D_collision_EE );
    _mSeat_D_Stat_AR.Seat_D_MemPosn_Rc_Actv.phys = getValue( HMI_Seat_D_MemPosn_Rc_Actv );
}

void Seat_D_Stat_AR_output(void)
{
    if( !getValue( HMI_Mem_D_Sv_Tgl_Auto ) )
    {
       // berechne message counter
        if( _mSeat_D_Stat_AR.Mem_D_Sv_Tgl >= 1 ) _mSeat_D_Stat_AR.Mem_D_Sv_Tgl = 0;
        else _mSeat_D_Stat_AR.Mem_D_Sv_Tgl++;
        //putValue( HMI_Mem_D_Sv_Tgl, _mSeat_D_Stat_AR.Mem_D_Sv_Tgl);
    }
    else
          _mSeat_D_Stat_AR.Mem_D_Sv_Tgl = getValue( HMI_Mem_D_Sv_Tgl );

    output( _mSeat_D_Stat_AR );
}

void Seat_D_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Seat_D_Stat_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Seat_D_Stat := %X\n", getValue( HMI__STMSG_Seat_D_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Seat_D_Stat := %X\n", getValue( HMI__STMSGT_Seat_D_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EEH_SeatAdj_Stat := %X\n", getValue( HMI_EEH_SeatAdj_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EEH_StW_Adj_Stat := %X\n", getValue( HMI_EEH_StW_Adj_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FWLP_Pmp_Rq_D := %X\n", getValue( HMI_FWLP_Pmp_Rq_D ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mem_D_Sv_Beep_Rq := %X\n", getValue( HMI_Mem_D_Sv_Beep_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mem_D_Sv_Tgl := %X\n", getValue( HMI_Mem_D_Sv_Tgl ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Pers_AutoSeatPosn_D_Stat := %X\n", getValue( HMI_Pers_AutoSeatPosn_D_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_D_collision := %X\n", getValue( HMI_Seat_D_collision ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_D_Collision_Not_Avl := %X\n", getValue( HMI_Seat_D_Collision_Not_Avl ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_D_Collision_Tm := %X\n", getValue( HMI_Seat_D_Collision_Tm ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_D_IncorrPosn := %X\n", getValue( HMI_Seat_D_IncorrPosn ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_D_Unlk := %X\n", getValue( HMI_SeatBkRst_D_Unlk ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_D_collision_EE := %X\n", getValue( HMI_Seat_D_collision_EE ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_D_MemPosn_Rc_Actv := %X\n", getValue( HMI_Seat_D_MemPosn_Rc_Actv ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tSeat_D_Stat_AR
{
    putValue( HMI__STMSG_Seat_D_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_Seat_D_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Seat_D_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tSeat_D_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_Seat_D_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Seat_D_Stat_AR
{
    if( getValue( this ) )
        openPanel("Seat_XX_Stat_AR");
}

on EnvVar HMI_EEH_SeatAdj_Stat
{
    _mSeat_D_Stat_AR.EEH_SeatAdj_Stat.phys = getValue(this);
    _Seat_D_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_EEH_StW_Adj_Stat
{
    _mSeat_D_Stat_AR.EEH_StW_Adj_Stat.phys = getValue(this);
    _Seat_D_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FWLP_Pmp_Rq_D
{
    _mSeat_D_Stat_AR.FWLP_Pmp_Rq_D.phys = getValue(this);
    _Seat_D_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Mem_D_Sv_Beep_Rq
{
    _mSeat_D_Stat_AR.Mem_D_Sv_Beep_Rq.phys = getValue(this);
    _Seat_D_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Pers_AutoSeatPosn_D_Stat
{
    _mSeat_D_Stat_AR.Pers_AutoSeatPosn_D_Stat.phys = getValue(this);
    _Seat_D_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_D_collision
{
    _mSeat_D_Stat_AR.Seat_D_collision.phys = getValue(this);
    _Seat_D_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_D_Collision_Not_Avl
{
    _mSeat_D_Stat_AR.Seat_D_Collision_Not_Avl.phys = getValue(this);
    _Seat_D_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_D_Collision_Tm
{
    _mSeat_D_Stat_AR.Seat_D_Collision_Tm.phys = getValue(this);
    _Seat_D_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_D_IncorrPosn
{
    _mSeat_D_Stat_AR.Seat_D_IncorrPosn.phys = getValue(this);
    _Seat_D_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_D_Unlk
{
    _mSeat_D_Stat_AR.SeatBkRst_D_Unlk.phys = getValue(this);
    _Seat_D_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_D_collision_EE
{
    _mSeat_D_Stat_AR.Seat_D_collision_EE.phys = getValue(this);
    _Seat_D_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_D_MemPosn_Rc_Actv
{
    _mSeat_D_Stat_AR.Seat_D_MemPosn_Rc_Actv.phys = getValue(this);
    _Seat_D_Stat_AR_SpontanFlag = 1;
}

Seat_P_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_Seat_P_Stat_AR ) )
    {
    //  message   Seat_P_Stat_AR ID: 939 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _Seat_P_Stat_AR_Cnt--;
        if( _Seat_P_Stat_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            Seat_P_Stat_AR_output();
            _Seat_P_Stat_AR_Cnt = _Seat_P_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _Seat_P_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _Seat_P_Stat_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            Seat_P_Stat_AR_output();
            _Seat_P_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

Seat_P_Stat_AR_init()
{   /* Botschaft Seat_P_Stat_AR ID: 939 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 939 0;
BA_ "NmAsrMessage" BO_ 939 0;
BA_ "GenMsgMinAcceptLength" BO_ 939 4;
BA_ "GenMsgILSupport" BO_ 939 1;
BA_ "DiagState" BO_ 939 0;
BA_ "DiagRequest" BO_ 939 0;
BA_ "DiagResponse" BO_ 939 0;
BA_ "GenMsgStartValue" BO_ 939 "0";
BA_ "GenMsgDelayTime" BO_ 939 5;
BA_ "GenMsgNrOfRepetitions" BO_ 939 0;
BA_ "GenMsgCycleTime" BO_ 939 500;
BA_ "GenMsgSendType" BO_ 939 5;
    */
    _Seat_P_Stat_AR_Timebase =         c_tDBKomTimer_20ms;
    _Seat_P_Stat_AR_CycleCount =     500 / _Seat_P_Stat_AR_Timebase;
    _Seat_P_Stat_AR_StartDelay =       0 / _Seat_P_Stat_AR_Timebase;
    _Seat_P_Stat_AR_Cnt = _Seat_P_Stat_AR_StartDelay;
    _Seat_P_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_Seat_P_Stat_AR, _Seat_P_Stat_AR_StartDelay * _Seat_P_Stat_AR_Timebase );

    _mSeat_P_Stat_AR.FWLP_Pmp_Rq_P.phys = getValue( HMI_FWLP_Pmp_Rq_P );
    _mSeat_P_Stat_AR.CSL_SeatOprtn_R_Actv.phys = getValue( HMI_CSL_SeatOprtn_R_Actv );
    _mSeat_P_Stat_AR.Mem_P_Sv_Beep_Rq.phys = getValue( HMI_Mem_P_Sv_Beep_Rq );
    _mSeat_P_Stat_AR.Mem_P_Sv_Tgl.phys = getValue( HMI_Mem_P_Sv_Tgl );
    _mSeat_P_Stat_AR.Seat_P_collision.phys = getValue( HMI_Seat_P_collision );
    _mSeat_P_Stat_AR.Seat_P_Collision_Not_Avl.phys = getValue( HMI_Seat_P_Collision_Not_Avl);  
    _mSeat_P_Stat_AR.Seat_P_Collision_Tm.phys = getValue( HMI_Seat_P_Collision_Tm );    
    _mSeat_P_Stat_AR.Seat_P_IncorrPosn.phys = getValue( HMI_Seat_P_IncorrPosn );
    _mSeat_P_Stat_AR.Seat_P_MirrViewObstr.phys = getValue( HMI_Seat_P_MirrViewObstr );
    _mSeat_P_Stat_AR.SeatBkRst_P_Unlk.phys = getValue( HMI_SeatBkRst_P_Unlk );
    _mSeat_P_Stat_AR.SeatMemAdj_R_Enbl.phys = getValue( HMI_SeatMemAdj_R_Enbl );
	_mSeat_P_Stat_AR.Seat_P_collision_EE.phys = getValue( HMI_Seat_P_collision_EE );
	_mSeat_P_Stat_AR.SeatChauffPosnAutoReturn_Actv.phys = getValue( HMI_SeatChauffPosnAutoReturn_Actv );
    _mSeat_P_Stat_AR.Seat_P_MemPosn_Rc_Actv.phys = getValue( HMI_Seat_P_MemPosn_Rc_Actv );
}

void Seat_P_Stat_AR_output(void)
{
    if( !getValue( HMI_Mem_P_Sv_Tgl_Auto ) )
    {
       // berechne message counter
        if( _mSeat_P_Stat_AR.Mem_P_Sv_Tgl >= 1 ) _mSeat_P_Stat_AR.Mem_P_Sv_Tgl = 0;
        else _mSeat_P_Stat_AR.Mem_P_Sv_Tgl++;
        //putValue( HMI_Mem_P_Sv_Tgl, _mSeat_P_Stat_AR.Mem_P_Sv_Tgl);
    }
    else
          _mSeat_P_Stat_AR.Mem_P_Sv_Tgl = getValue( HMI_Mem_P_Sv_Tgl );

    output( _mSeat_P_Stat_AR );
}

Seat_P_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Seat_P_Stat_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Seat_P_Stat_AR := %X\n", getValue( HMI__STMSG_Seat_P_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Seat_P_Stat_AR := %X\n", getValue( HMI__STMSGT_Seat_P_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FWLP_Pmp_Rq_P := %X\n", getValue( HMI_FWLP_Pmp_Rq_P ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CSL_SeatOprtn_R_Actv := %X\n", getValue( HMI_CSL_SeatOprtn_R_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mem_P_Sv_Beep_Rq := %X\n", getValue( HMI_Mem_P_Sv_Beep_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mem_P_Sv_Tgl := %X\n", getValue( HMI_Mem_P_Sv_Tgl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_P_collision := %X\n", getValue( HMI_Seat_P_collision ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_P_Collision_Not_Avl := %X\n", getValue( HMI_Seat_P_Collision_Not_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_P_Collision_Tm := %X\n", getValue( HMI_Seat_P_Collision_Tm ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_P_IncorrPosn := %X\n", getValue( HMI_Seat_P_IncorrPosn ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_P_MirrViewObstr := %X\n", getValue( HMI_Seat_P_MirrViewObstr ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_P_Unlk := %X\n", getValue( HMI_SeatBkRst_P_Unlk ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatMemAdj_R_Enbl := %X\n", getValue( HMI_SeatMemAdj_R_Enbl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_P_collision_EE := %X\n", getValue( HMI_Seat_P_collision_EE ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatChauffPosnAutoReturn_Actv := %X\n", getValue( HMI_SeatChauffPosnAutoReturn_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_P_MemPosn_Rc_Actv := %X\n", getValue( HMI_Seat_P_MemPosn_Rc_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tSeat_P_Stat_AR
{
    putValue( HMI__STMSG_Seat_P_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_Seat_P_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Seat_P_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tSeat_P_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_Seat_P_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Seat_P_Stat_AR
{
    if( getValue( this ) )
        openPanel("Seat_XX_Stat_AR");
}

on EnvVar HMI_FWLP_Pmp_Rq_P
{
    _mSeat_P_Stat_AR.FWLP_Pmp_Rq_P.phys = getValue(this);
    _Seat_P_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_CSL_SeatOprtn_R_Actv
{
    _mSeat_P_Stat_AR.CSL_SeatOprtn_R_Actv.phys = getValue(this);
    _Seat_P_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatChauffPosnAutoReturn_Actv
{
    _mSeat_P_Stat_AR.SeatChauffPosnAutoReturn_Actv.phys = getValue(this);
    _Seat_P_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Mem_P_Sv_Beep_Rq
{
    _mSeat_P_Stat_AR.Mem_P_Sv_Beep_Rq.phys = getValue(this);
    _Seat_P_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_P_collision
{
    _mSeat_P_Stat_AR.Seat_P_collision.phys = getValue(this);
    _Seat_P_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_P_Collision_Not_Avl
{
    _mSeat_P_Stat_AR.Seat_P_Collision_Not_Avl.phys = getValue(this);
    _Seat_P_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_P_Collision_Tm
{
    _mSeat_P_Stat_AR.Seat_P_Collision_Tm.phys = getValue(this);
    _Seat_P_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_P_IncorrPosn
{
    _mSeat_P_Stat_AR.Seat_P_IncorrPosn.phys = getValue(this);
    _Seat_P_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_P_MirrViewObstr
{
    _mSeat_P_Stat_AR.Seat_P_MirrViewObstr.phys = getValue(this);
    _Seat_P_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_P_Unlk
{
    _mSeat_P_Stat_AR.SeatBkRst_P_Unlk.phys = getValue(this);
    _Seat_P_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatMemAdj_R_Enbl
{
    _mSeat_P_Stat_AR.SeatMemAdj_R_Enbl.phys = getValue(this);
    _Seat_P_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_P_collision_EE
{
    _mSeat_P_Stat_AR.Seat_P_collision_EE.phys = getValue(this);
    _Seat_P_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_P_MemPosn_Rc_Actv
{
    _mSeat_P_Stat_AR.Seat_P_MemPosn_Rc_Actv.phys = getValue(this);
    _Seat_P_Stat_AR_SpontanFlag = 1;
}

Seat_RL_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_Seat_RL_Stat_AR ) )
    {
    //  message   Seat_RL_Stat_AR ID: 941 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _Seat_RL_Stat_AR_Cnt--;
        if( _Seat_RL_Stat_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            Seat_RL_Stat_AR_output();
            _Seat_RL_Stat_AR_Cnt = _Seat_RL_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _Seat_RL_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _Seat_RL_Stat_AR_SpontanFlag )
        {
            // Nachricht wg. spontaner �nderung ausgeben
            Seat_RL_Stat_AR_output();
            _Seat_RL_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

Seat_RL_Stat_AR_init()
{   /* Botschaft Seat_RL_Stat_AR ID: 941 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 941 0;
BA_ "NmAsrMessage" BO_ 941 0;
BA_ "GenMsgMinAcceptLength" BO_ 941 4;
BA_ "GenMsgILSupport" BO_ 941 1;
BA_ "DiagState" BO_ 941 0;
BA_ "DiagRequest" BO_ 941 0;
BA_ "DiagResponse" BO_ 941 0;
BA_ "GenMsgStartValue" BO_ 941 "0";
BA_ "GenMsgDelayTime" BO_ 941 5;
BA_ "GenMsgNrOfRepetitions" BO_ 941 0;
BA_ "GenMsgCycleTime" BO_ 941 500;
BA_ "GenMsgSendType" BO_ 941 5;
    */
    _Seat_RL_Stat_AR_Timebase =         c_tDBKomTimer_20ms;
    _Seat_RL_Stat_AR_CycleCount =   500 / _Seat_RL_Stat_AR_Timebase;
    _Seat_RL_Stat_AR_StartDelay =     0 / _Seat_RL_Stat_AR_Timebase;
    _Seat_RL_Stat_AR_Cnt = _Seat_RL_Stat_AR_StartDelay;
    _Seat_RL_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_Seat_RL_Stat_AR, _Seat_RL_Stat_AR_StartDelay * _Seat_RL_Stat_AR_Timebase );

    _mSeat_RL_Stat_AR.Mem_RL_Sv_Beep_Rq.phys = getValue( HMI_Mem_RL_Sv_Beep_Rq );
    _mSeat_RL_Stat_AR.Mem_RL_Sv_Tgl.phys = getValue( HMI_Mem_RL_Sv_Tgl );
    _mSeat_RL_Stat_AR.Seat_EE_RL_Stat.phys = getValue( HMI_Seat_EE_RL_Stat );
    _mSeat_RL_Stat_AR.Seat_RL_Collision_Rq.phys = getValue( HMI_Seat_RL_Collision_Rq );
    _mSeat_RL_Stat_AR.SeatBkRst_RL_Adj_Stat.phys = getValue( HMI_SeatBkRst_RL_Adj_Stat );
    _mSeat_RL_Stat_AR.SeatBkRst_RL_Stat_SEAT.phys = getValue( HMI_SeatBkRst_RL_Stat_SEAT );
    _mSeat_RL_Stat_AR.SeatBkRst_RM_Stat_SEAT.phys = getValue( HMI_SeatBkRst_RM_Stat_SEAT );
    _mSeat_RL_Stat_AR.SeatCsn_RL_Stat_SEAT.phys = getValue( HMI_SeatCsn_RL_Stat_SEAT );
    _mSeat_RL_Stat_AR.SeatHdRst_RL_Dn_Actv.phys = getValue( HMI_SeatHdRst_RL_Dn_Actv );
    _mSeat_RL_Stat_AR.SeatRestPosn_RL.phys = getValue( HMI_SeatRestPosn_RL );
    _mSeat_RL_Stat_AR.CSL_SeatOprtn_RL_Actv.phys = getValue( HMI_CSL_SeatOprtn_RL_Actv );    
    _mSeat_RL_Stat_AR.Seat_RL_collision.phys = getValue( HMI_Seat_RL_collision );    
    _mSeat_RL_Stat_AR.Drawer_CenCnsl_Opn.phys = getValue( HMI_Drawer_CenCnsl_Opn );
    _mSeat_RL_Stat_AR.Seat_R_ArmRst_Fld.phys = getValue( HMI_Seat_R_ArmRst_Fld );
    _mSeat_RL_Stat_AR.Seat_R_ArmRst_Fld_Stat.phys = getValue( HMI_Seat_R_ArmRst_Fld_Stat );
	_mSeat_RL_Stat_AR.Seat_RL_MemPosn_Rc_Actv.phys = getValue( HMI_Seat_RL_MemPosn_Rc_Actv );
}

void Seat_RL_Stat_AR_output(void)
{
    if( !getValue( HMI_Mem_RL_Sv_Tgl_Auto ) )
    {
       // berechne message counter
        if( _mSeat_RL_Stat_AR.Mem_RL_Sv_Tgl >= 1 ) _mSeat_RL_Stat_AR.Mem_RL_Sv_Tgl = 0;
        else _mSeat_RL_Stat_AR.Mem_RL_Sv_Tgl++;
        //putValue( HMI_Mem_RL_Sv_Tgl, _mSeat_RL_Stat_AR.Mem_RL_Sv_Tgl);
    }
    else
          _mSeat_RL_Stat_AR.Mem_RL_Sv_Tgl = getValue( HMI_Mem_RL_Sv_Tgl);

    output( _mSeat_RL_Stat_AR );
}

Seat_RL_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Seat_RL_Stat_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Seat_RL_Stat := %X\n", getValue( HMI__STMSG_Seat_RL_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Seat_RL_Stat := %X\n", getValue( HMI__STMSGT_Seat_RL_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mem_RL_Sv_Beep_Rq := %X\n", getValue( HMI_Mem_RL_Sv_Beep_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mem_RL_Sv_Tgl := %X\n", getValue( HMI_Mem_RL_Sv_Tgl ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_EE_RL_Stat := %X\n", getValue( HMI_Seat_EE_RL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_RL_Collision_Rq := %X\n", getValue( HMI_Seat_RL_Collision_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_RL_Adj_Stat := %X\n", getValue( HMI_SeatBkRst_RL_Adj_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_RL_Stat_SEAT := %X\n", getValue( HMI_SeatBkRst_RL_Stat_SEAT ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_RM_Stat_SEAT := %X\n", getValue( HMI_SeatBkRst_RM_Stat_SEAT ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatCsn_RL_Stat_SEAT := %X\n", getValue( HMI_SeatCsn_RL_Stat_SEAT ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatHdRst_RL_Dn_Actv := %X\n", getValue( HMI_SeatHdRst_RL_Dn_Actv ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatRestPosn_RL := %X\n", getValue( HMI_SeatRestPosn_RL ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_RL_collision := %X\n", getValue( HMI_Seat_RL_collision ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount(buffer), "0.0000 HMI_CSL_SeatOprtn_RL_Actv := %X\n", getValue( HMI_CSL_SeatOprtn_RL_Actv ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_Drawer_CenCnsl_Opn := %X\n", getValue( HMI_Drawer_CenCnsl_Opn ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_Seat_R_ArmRst_Fld := %X\n", getValue( HMI_Seat_R_ArmRst_Fld ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_Seat_R_ArmRst_Fld_Stat := %X\n", getValue( HMI_Seat_R_ArmRst_Fld_Stat ) );        filePutString( buffer, elcount(buffer), hFile);
	snprintf( buffer, elcount(buffer), "0.0000 HMI_Seat_RL_MemPosn_Rc_Actv := %X\n", getValue( HMI_Seat_RL_MemPosn_Rc_Actv ) );        filePutString( buffer, elcount(buffer), hFile);
}

on timer _tSeat_RL_Stat_AR
{
    putValue( HMI__STMSG_Seat_RL_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_Seat_RL_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Seat_RL_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tSeat_RL_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_Seat_RL_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Seat_RL_Stat_AR
{
    if( getValue( this ) )
        openPanel("Seat_XX_Stat_AR");
}

on EnvVar HMI_Mem_RL_Sv_Beep_Rq
{
    _mSeat_RL_Stat_AR.Mem_RL_Sv_Beep_Rq.phys = getValue(this);
    _Seat_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Mem_RL_Sv_Tgl
{
    _mSeat_RL_Stat_AR.Mem_RL_Sv_Tgl.phys = getValue(this);
    _Seat_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_EE_RL_Stat
{
    _mSeat_RL_Stat_AR.Seat_EE_RL_Stat.phys = getValue(this);
    _Seat_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_RL_Collision_Rq
{
    _mSeat_RL_Stat_AR.Seat_RL_Collision_Rq.phys = getValue(this);
    _Seat_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_RL_Adj_Stat
{
    _mSeat_RL_Stat_AR.SeatBkRst_RL_Adj_Stat.phys = getValue(this);
    _Seat_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_RL_Stat_SEAT
{
    _mSeat_RL_Stat_AR.SeatBkRst_RL_Stat_SEAT.phys = getValue(this);
    _Seat_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_RM_Stat_SEAT
{
    _mSeat_RL_Stat_AR.SeatBkRst_RM_Stat_SEAT.phys = getValue(this);
    _Seat_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatCsn_RL_Stat_SEAT
{
    _mSeat_RL_Stat_AR.SeatCsn_RL_Stat_SEAT.phys = getValue(this);
    _Seat_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatHdRst_RL_Dn_Actv
{
    _mSeat_RL_Stat_AR.SeatHdRst_RL_Dn_Actv.phys = getValue(this);
    _Seat_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_RL_collision
{
    _mSeat_RL_Stat_AR.Seat_RL_collision.phys = getValue(this);
    _Seat_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatRestPosn_RL
{
    _mSeat_RL_Stat_AR.SeatRestPosn_RL.phys = getValue(this);
    _Seat_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_CSL_SeatOprtn_RL_Actv
{
    _mSeat_RL_Stat_AR.CSL_SeatOprtn_RL_Actv.phys = getValue(this);
    _Seat_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_R_ArmRst_Fld
{
    _mSeat_RL_Stat_AR.Seat_R_ArmRst_Fld.phys = getValue(this);
    _Seat_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Drawer_CenCnsl_Opn
{
    _mSeat_RL_Stat_AR.Drawer_CenCnsl_Opn.phys = getValue(this);
    _Seat_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_R_ArmRst_Fld_Stat
{
    _mSeat_RL_Stat_AR.Seat_R_ArmRst_Fld_Stat.phys = getValue(this);
    _Seat_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_RL_MemPosn_Rc_Actv
{
    _mSeat_RL_Stat_AR.Seat_RL_MemPosn_Rc_Actv.phys = getValue(this);
    _Seat_RL_Stat_AR_SpontanFlag = 1;
}

Seat_RR_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_Seat_RR_Stat_AR ) )
    {
    //  message   Seat_RR_Stat_AR ID: 943 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _Seat_RR_Stat_AR_Cnt--;
        if( _Seat_RR_Stat_AR_Cnt < 1 )
        {
            Seat_RR_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _Seat_RR_Stat_AR_Cnt = _Seat_RR_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _Seat_RR_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _Seat_RR_Stat_AR_SpontanFlag )
        {
            Seat_RR_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _Seat_RR_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

Seat_RR_Stat_AR_init()
{   /* Botschaft Seat_RR_Stat_AR ID: 943 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 943 0;
BA_ "NmAsrMessage" BO_ 943 0;
BA_ "GenMsgMinAcceptLength" BO_ 943 4;
BA_ "GenMsgILSupport" BO_ 943 1;
BA_ "DiagState" BO_ 943 0;
BA_ "DiagRequest" BO_ 943 0;
BA_ "DiagResponse" BO_ 943 0;
BA_ "GenMsgStartValue" BO_ 943 "0";
BA_ "GenMsgDelayTime" BO_ 943 5;
BA_ "GenMsgNrOfRepetitions" BO_ 943 0;
BA_ "GenMsgCycleTime" BO_ 943 500;
BA_ "GenMsgSendType" BO_ 943 5;
    */
    _Seat_RR_Stat_AR_Timebase =         c_tDBKomTimer_20ms;
    _Seat_RR_Stat_AR_CycleCount =     500 / _Seat_RR_Stat_AR_Timebase;
    _Seat_RR_Stat_AR_StartDelay =       0 / _Seat_RR_Stat_AR_Timebase;
    _Seat_RR_Stat_AR_Cnt = _Seat_RR_Stat_AR_StartDelay;
    _Seat_RR_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_Seat_RR_Stat_AR, _Seat_RR_Stat_AR_StartDelay * _Seat_RR_Stat_AR_Timebase );

    _mSeat_RR_Stat_AR.Mem_RR_Sv_Beep_Rq.phys = getValue( HMI_Mem_RR_Sv_Beep_Rq );
    _mSeat_RR_Stat_AR.Mem_RR_Sv_Tgl.phys = getValue( HMI_Mem_RR_Sv_Tgl );
    _mSeat_RR_Stat_AR.Seat_EE_RR_Stat.phys = getValue( HMI_Seat_EE_RR_Stat );
    //_mSeat_RR_Stat_AR.Seat_R_ArmRst_Fld.phys = getValue( HMI_Seat_R_ArmRst_Fld );
    _mSeat_RR_Stat_AR.Seat_RR_Collision_Rq.phys = getValue( HMI_Seat_RR_Collision_Rq );
    _mSeat_RR_Stat_AR.Seat_RR_collision.phys = getValue( HMI_Seat_RR_collision );
    _mSeat_RR_Stat_AR.SeatBkRst_RR_Stat_SEAT.phys = getValue( HMI_SeatBkRst_RR_Stat_SEAT );
    _mSeat_RR_Stat_AR.SeatCsn_RR_Stat_SEAT.phys = getValue( HMI_SeatCsn_RR_Stat_SEAT );
    _mSeat_RR_Stat_AR.SeatHdRst_R_Rq.phys = getValue( HMI_SeatHdRst_R_Rq );
    _mSeat_RR_Stat_AR.SeatRestPosn_RR.phys = getValue( HMI_SeatRestPosn_RR );
  _mSeat_RR_Stat_AR.CSL_SeatOprtn_RR_Actv.phys = getValue( HMI_CSL_SeatOprtn_RR_Actv );
  _mSeat_RR_Stat_AR.Seat_RR_MemPosn_Rc_Actv.phys = getValue( HMI_Seat_RR_MemPosn_Rc_Actv );
  _mSeat_RR_Stat_AR.SeatBkRst_RR_Adj_Stat.phys = getValue( HMI_SeatBkRst_RR_Adj_Stat );
}

void Seat_RR_Stat_AR_output(void)
{
    if( !getValue( HMI_Mem_RR_Sv_Tgl_Auto ) )
    {
       // berechne message counter
        if( _mSeat_RR_Stat_AR.Mem_RR_Sv_Tgl >= 1 ) _mSeat_RR_Stat_AR.Mem_RR_Sv_Tgl = 0;
        else _mSeat_RR_Stat_AR.Mem_RR_Sv_Tgl++;
        //putValue( HMI_Mem_RR_Sv_Tgl, _mSeat_RR_Stat_AR.Mem_RR_Sv_Tgl);
    }
    else
          _mSeat_RR_Stat_AR.Mem_RR_Sv_Tgl = getValue( HMI_Mem_RR_Sv_Tgl);

    output( _mSeat_RR_Stat_AR );
}

Seat_RR_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Seat_RR_Stat_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Seat_RR_Stat := %X\n", getValue( HMI__STMSG_Seat_RR_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Seat_RR_Stat := %X\n", getValue( HMI__STMSGT_Seat_RR_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mem_RR_Sv_Beep_Rq := %X\n", getValue( HMI_Mem_RR_Sv_Beep_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mem_RR_Sv_Tgl := %X\n", getValue( HMI_Mem_RR_Sv_Tgl ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_EE_RR_Stat := %X\n", getValue( HMI_Seat_EE_RR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    //snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_R_ArmRst_Fld := %X\n", getValue( HMI_Seat_R_ArmRst_Fld ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_RR_Collision_Rq := %X\n", getValue( HMI_Seat_RR_Collision_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_RR_collision := %X\n", getValue( HMI_Seat_RR_collision ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatHdRst_R_Rq := %X\n", getValue( HMI_SeatHdRst_R_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_RR_Stat_SEAT := %X\n", getValue( HMI_SeatBkRst_RR_Stat_SEAT ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatCsn_RR_Stat_SEAT := %X\n", getValue( HMI_SeatCsn_RR_Stat_SEAT ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatRestPosn_RR := %X\n", getValue( HMI_SeatRestPosn_RR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CSL_SeatOprtn_RR_Actv := %X\n", getValue( HMI_CSL_SeatOprtn_RR_Actv ) );        filePutString( buffer, elcount(buffer), hFile);
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_RR_MemPosn_Rc_Actv := %X\n", getValue( HMI_Seat_RR_MemPosn_Rc_Actv ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatBkRst_RR_Adj_Stat := %X\n", getValue( HMI_SeatBkRst_RR_Adj_Stat ) );        filePutString( buffer, elcount(buffer), hFile);
}

on timer _tSeat_RR_Stat_AR
{
    putValue( HMI__STMSG_Seat_RR_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_Seat_RR_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Seat_RR_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tSeat_RR_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_Seat_RR_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Seat_RR_Stat_AR
{
    if( getValue( this ) )
        openPanel("Seat_XX_Stat_AR");
}

on EnvVar HMI_CSL_SeatOprtn_RR_Actv
{
    _mSeat_RR_Stat_AR.CSL_SeatOprtn_RR_Actv.phys = getValue(this);
    _Seat_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Mem_RR_Sv_Beep_Rq
{
    _mSeat_RR_Stat_AR.Mem_RR_Sv_Beep_Rq.phys = getValue(this);
    _Seat_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Mem_RR_Sv_Tgl
{
    _mSeat_RR_Stat_AR.Mem_RR_Sv_Tgl.phys = getValue(this);
    _Seat_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_EE_RR_Stat
{
    _mSeat_RR_Stat_AR.Seat_EE_RR_Stat.phys = getValue(this);
    _Seat_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_RR_collision
{
    _mSeat_RR_Stat_AR.Seat_RR_collision.phys = getValue(this);
    _Seat_RR_Stat_AR_SpontanFlag = 1;
}

//on EnvVar HMI_Seat_R_ArmRst_Fld
//{
//    _mSeat_RR_Stat_AR.Seat_R_ArmRst_Fld.phys = getValue(this);
//    _Seat_RR_Stat_AR_SpontanFlag = 1;
//}

on EnvVar HMI_Seat_RR_Collision_Rq
{
    _mSeat_RR_Stat_AR.Seat_RR_Collision_Rq.phys = getValue(this);
    _Seat_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_RR_Stat_SEAT
{
    _mSeat_RR_Stat_AR.SeatBkRst_RR_Stat_SEAT.phys = getValue(this);
    _Seat_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatCsn_RR_Stat_SEAT
{
    _mSeat_RR_Stat_AR.SeatCsn_RR_Stat_SEAT.phys = getValue(this);
    _Seat_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatHdRst_R_Rq
{
    _mSeat_RR_Stat_AR.SeatHdRst_R_Rq.phys = getValue(this);
    _Seat_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatRestPosn_RR
{
    _mSeat_RR_Stat_AR.SeatRestPosn_RR.phys = getValue(this);
    _Seat_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_RR_MemPosn_Rc_Actv
{
    _mSeat_RR_Stat_AR.Seat_RR_MemPosn_Rc_Actv.phys = getValue(this);
    _Seat_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatBkRst_RR_Adj_Stat
{
    _mSeat_RR_Stat_AR.SeatBkRst_RR_Adj_Stat.phys = getValue(this);
    _Seat_RR_Stat_AR_SpontanFlag = 1;
}

SeatCM_D_Stat_HU_AR_check_output()
{
    if( !getValue( HMI__STMSG_SeatCM_D_Stat_HU_AR ) )
    {
    //  message   SeatCM_D_Stat_HU_AR ID: 1140 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _SeatCM_D_Stat_HU_AR_DelayCnt > 0) _SeatCM_D_Stat_HU_AR_DelayCnt--; // Mindestsendeabstand
        _SeatCM_D_Stat_HU_AR_Cnt--;
        if( _SeatCM_D_Stat_HU_AR_Cnt < 1 )
        {
            if( _SeatCM_D_Stat_HU_AR_DelayCnt < 1 )
            {
                SeatCM_D_Stat_HU_AR_output();  // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                 _SeatCM_D_Stat_HU_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SeatCM_D_Stat_HU_AR_DelayCnt = _SeatCM_D_Stat_HU_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _SeatCM_D_Stat_HU_AR_SpontanFlag = 1;
            }
            _SeatCM_D_Stat_HU_AR_Cnt = _SeatCM_D_Stat_HU_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _SeatCM_D_Stat_HU_AR_SpontanFlag )
        {
            if( _SeatCM_D_Stat_HU_AR_DelayCnt < 1 )
            {
                SeatCM_D_Stat_HU_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _SeatCM_D_Stat_HU_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SeatCM_D_Stat_HU_AR_DelayCnt = _SeatCM_D_Stat_HU_AR_MinDelay;
            }
        }
    }
}

SeatCM_D_Stat_HU_AR_init()
{   /* Botschaft SeatCM_D_Stat_HU_AR ID: 1140 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1140 0;
BA_ "NmAsrMessage" BO_ 1140 0;
BA_ "GenMsgMinAcceptLength" BO_ 1140 4;
BA_ "GenMsgILSupport" BO_ 1140 1;
BA_ "DiagState" BO_ 1140 0;
BA_ "DiagRequest" BO_ 1140 0;
BA_ "DiagResponse" BO_ 1140 0;
BA_ "GenMsgStartValue" BO_ 1140 "0";
BA_ "GenMsgDelayTime" BO_ 1140 100;
BA_ "GenMsgNrOfRepetition" BO_ 1140 0;
BA_ "GenMsgCycleTime" BO_ 1140 500;
BA_ "GenMsgSendType" BO_ 1140 5;

    */
    _SeatCM_D_Stat_HU_AR_Timebase =          c_tDBKomTimer_20ms;
    _SeatCM_D_Stat_HU_AR_CycleCount =       500 / _SeatCM_D_Stat_HU_AR_Timebase;
    _SeatCM_D_Stat_HU_AR_StartDelay =         0 / _SeatCM_D_Stat_HU_AR_Timebase;
    _SeatCM_D_Stat_HU_AR_MinDelay =         100 / _SeatCM_D_Stat_HU_AR_Timebase;
    _SeatCM_D_Stat_HU_AR_Cnt = _SeatCM_D_Stat_HU_AR_StartDelay;
    _SeatCM_D_Stat_HU_AR_SpontanFlag = 0;
    _SeatCM_D_Stat_HU_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_SeatCM_D_Stat_HU_AR, _SeatCM_D_Stat_HU_AR_StartDelay * _SeatCM_D_Stat_HU_AR_Timebase );

    _mSeatCM_D_Stat_HU_AR.SEAT_D_CM_Adj_Stat.phys =      getValue( HMI_SEAT_D_CM_Adj_Stat );
    _mSeatCM_D_Stat_HU_AR.SEAT_D_CM_LD_Stat.phys =  			getValue( HMI_SEAT_D_CM_LD_Stat );
    _mSeatCM_D_Stat_HU_AR.SEAT_D_CM_OnOff_Stat.phys =     getValue( HMI_SEAT_D_CM_OnOff_Stat );
    _mSeatCM_D_Stat_HU_AR.SEAT_D_CM_Time_Stat.phys =      getValue( HMI_SEAT_D_CM_Time_Stat );	
}

SeatCM_D_Stat_HU_AR_output(void)
{
    output( _mSeatCM_D_Stat_HU_AR );
}

SeatCM_D_Stat_HU_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SeatCM_D_Stat_HU_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SeatCM_D_Stat_HU_AR := %X\n", getValue( HMI__STMSG_SeatCM_D_Stat_HU_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SeatCM_D_Stat_HU_AR := %X\n", getValue( HMI__STMSGT_SeatCM_D_Stat_HU_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SEAT_D_CM_Adj_Stat := %X\n", getValue( HMI_SEAT_D_CM_Adj_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SEAT_D_CM_LD_Stat := %X\n", getValue( HMI_SEAT_D_CM_LD_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SEAT_D_CM_OnOff_Stat := %X\n", getValue( HMI_SEAT_D_CM_OnOff_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SEAT_D_CM_Time_Stat := %X\n", getValue( HMI_SEAT_D_CM_Time_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tSeatCM_D_Stat_HU_AR
{
    putValue( HMI__STMSG_SeatCM_D_Stat_HU_AR, 0 );
}

on EnvVar HMI__STMSG_SeatCM_D_Stat_HU_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SeatCM_D_Stat_HU_AR );
        if( tDelay > 0)    
            setTimer( _tSeatCM_D_Stat_HU_AR, tDelay );
        else
            putValue( HMI__STMSG_SeatCM_D_Stat_HU_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_SeatCM_D_Stat_HU_AR
{
    if( getValue( this ) )
        openPanel("SeatCM_D_Stat_HU_AR");
}

on EnvVar HMI_SEAT_D_CM_Adj_Stat
{
    _mSeatCM_D_Stat_HU_AR.SEAT_D_CM_Adj_Stat.phys = getValue(this);
    _SeatCM_D_Stat_HU_AR_SpontanFlag = 1;
}

on EnvVar HMI_SEAT_D_CM_LD_Stat
{
    _mSeatCM_D_Stat_HU_AR.SEAT_D_CM_LD_Stat.phys = getValue(this);
    _SeatCM_D_Stat_HU_AR_SpontanFlag = 1;
}

on EnvVar HMI_SEAT_D_CM_OnOff_Stat
{
    _mSeatCM_D_Stat_HU_AR.SEAT_D_CM_OnOff_Stat.phys = getValue(this);
    _SeatCM_D_Stat_HU_AR_SpontanFlag = 1;
}

on EnvVar HMI_SEAT_D_CM_Time_Stat
{
    _mSeatCM_D_Stat_HU_AR.SEAT_D_CM_Time_Stat.phys = getValue(this);
    _SeatCM_D_Stat_HU_AR_SpontanFlag = 1;
}

SeatCM_P_Stat_HU_AR_check_output()
{
    if( !getValue( HMI__STMSG_SeatCM_P_Stat_HU_AR ) )
    {
    //  message   SeatCM_P_Stat_HU_AR ID: 1144 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _SeatCM_P_Stat_HU_AR_DelayCnt > 0) _SeatCM_P_Stat_HU_AR_DelayCnt--; // Mindestsendeabstand
        _SeatCM_P_Stat_HU_AR_Cnt--;
        if( _SeatCM_P_Stat_HU_AR_Cnt < 1 )
        {
            if( _SeatCM_P_Stat_HU_AR_DelayCnt < 1 )
            {
                SeatCM_P_Stat_HU_AR_output();  // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                 _SeatCM_P_Stat_HU_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SeatCM_P_Stat_HU_AR_DelayCnt = _SeatCM_P_Stat_HU_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _SeatCM_P_Stat_HU_AR_SpontanFlag = 1;
            }
            _SeatCM_P_Stat_HU_AR_Cnt = _SeatCM_P_Stat_HU_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _SeatCM_P_Stat_HU_AR_SpontanFlag )
        {
            if( _SeatCM_P_Stat_HU_AR_DelayCnt < 1 )
            {
                SeatCM_P_Stat_HU_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _SeatCM_P_Stat_HU_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SeatCM_P_Stat_HU_AR_DelayCnt = _SeatCM_P_Stat_HU_AR_MinDelay;
            }
        }
    }
}

SeatCM_P_Stat_HU_AR_init()
{   /* Botschaft SeatCM_P_Stat_HU_AR ID: 1144 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1144 0;
BA_ "NmAsrMessage" BO_ 1144 0;
BA_ "GenMsgMinAcceptLength" BO_ 1144 4;
BA_ "GenMsgILSupport" BO_ 1144 1;
BA_ "DiagState" BO_ 1144 0;
BA_ "DiagRequest" BO_ 1144 0;
BA_ "DiagResponse" BO_ 1144 0;
BA_ "GenMsgStartValue" BO_ 1144 "0";
BA_ "GenMsgDelayTime" BO_ 1144 100;
BA_ "GenMsgNrOfRepetition" BO_ 1144 0;
BA_ "GenMsgCycleTime" BO_ 1144 500;
BA_ "GenMsgSendType" BO_ 1144 5;
    */
    _SeatCM_P_Stat_HU_AR_Timebase =          c_tDBKomTimer_20ms;
    _SeatCM_P_Stat_HU_AR_CycleCount =       500 / _SeatCM_P_Stat_HU_AR_Timebase;
    _SeatCM_P_Stat_HU_AR_StartDelay =         0 / _SeatCM_P_Stat_HU_AR_Timebase;
    _SeatCM_P_Stat_HU_AR_MinDelay =         100 / _SeatCM_P_Stat_HU_AR_Timebase;
    _SeatCM_P_Stat_HU_AR_Cnt = _SeatCM_P_Stat_HU_AR_StartDelay;
    _SeatCM_P_Stat_HU_AR_SpontanFlag = 0;
    _SeatCM_P_Stat_HU_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_SeatCM_P_Stat_HU_AR, _SeatCM_P_Stat_HU_AR_StartDelay * _SeatCM_P_Stat_HU_AR_Timebase );

    _mSeatCM_P_Stat_HU_AR.SEAT_P_CM_Adj_Stat.phys =      getValue( HMI_SEAT_P_CM_Adj_Stat );
    _mSeatCM_P_Stat_HU_AR.SEAT_P_CM_LD_Stat.phys =  			getValue( HMI_SEAT_P_CM_LD_Stat );
    _mSeatCM_P_Stat_HU_AR.SEAT_P_CM_OnOff_Stat.phys =     getValue( HMI_SEAT_P_CM_OnOff_Stat );
    _mSeatCM_P_Stat_HU_AR.SEAT_P_CM_Time_Stat.phys =      getValue( HMI_SEAT_P_CM_Time_Stat );	
}

SeatCM_P_Stat_HU_AR_output(void)
{
    output( _mSeatCM_P_Stat_HU_AR );
}

SeatCM_P_Stat_HU_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SeatCM_P_Stat_HU_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SeatCM_P_Stat_HU_AR := %X\n", getValue( HMI__STMSG_SeatCM_P_Stat_HU_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SeatCM_P_Stat_HU_AR := %X\n", getValue( HMI__STMSGT_SeatCM_P_Stat_HU_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SEAT_P_CM_Adj_Stat := %X\n", getValue( HMI_SEAT_P_CM_Adj_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SEAT_P_CM_LD_Stat := %X\n", getValue( HMI_SEAT_P_CM_LD_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SEAT_P_CM_OnOff_Stat := %X\n", getValue( HMI_SEAT_P_CM_OnOff_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SEAT_P_CM_Time_Stat := %X\n", getValue( HMI_SEAT_P_CM_Time_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tSeatCM_P_Stat_HU_AR
{
    putValue( HMI__STMSG_SeatCM_P_Stat_HU_AR, 0 );
}

on EnvVar HMI__STMSG_SeatCM_P_Stat_HU_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SeatCM_P_Stat_HU_AR );
        if( tDelay > 0)    
            setTimer( _tSeatCM_P_Stat_HU_AR, tDelay );
        else
            putValue( HMI__STMSG_SeatCM_P_Stat_HU_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_SeatCM_P_Stat_HU_AR
{
    if( getValue( this ) )
        openPanel("SeatCM_P_Stat_HU_AR");
}

on EnvVar HMI_SEAT_P_CM_Adj_Stat
{
    _mSeatCM_P_Stat_HU_AR.SEAT_P_CM_Adj_Stat.phys = getValue(this);
    _SeatCM_P_Stat_HU_AR_SpontanFlag = 1;
}

on EnvVar HMI_SEAT_P_CM_LD_Stat
{
    _mSeatCM_P_Stat_HU_AR.SEAT_P_CM_LD_Stat.phys = getValue(this);
    _SeatCM_P_Stat_HU_AR_SpontanFlag = 1;
}

on EnvVar HMI_SEAT_P_CM_OnOff_Stat
{
    _mSeatCM_P_Stat_HU_AR.SEAT_P_CM_OnOff_Stat.phys = getValue(this);
    _SeatCM_P_Stat_HU_AR_SpontanFlag = 1;
}

on EnvVar HMI_SEAT_P_CM_Time_Stat
{
    _mSeatCM_P_Stat_HU_AR.SEAT_P_CM_Time_Stat.phys = getValue(this);
    _SeatCM_P_Stat_HU_AR_SpontanFlag = 1;
}

SeatHtVn_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_SeatHtVn_Stat_AR ) )
    {
    //  message   SeatHtVn_Stat_AR ID: 915 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _SeatHtVn_Stat_AR_Cnt--;
        if( _SeatHtVn_Stat_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            SeatHtVn_Stat_AR_output();
            _SeatHtVn_Stat_AR_Cnt = _SeatHtVn_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _SeatHtVn_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _SeatHtVn_Stat_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            SeatHtVn_Stat_AR_output();
            _SeatHtVn_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

SeatHtVn_Stat_AR_init()
{   /* Botschaft SeatHtVn_Stat_AR ID: 915 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 915 0;
BA_ "NmAsrMessage" BO_ 915 0;
BA_ "GenMsgMinAcceptLength" BO_ 915 8;
BA_ "GenMsgILSupport" BO_ 915 1;
BA_ "DiagState" BO_ 915 0;
BA_ "DiagRequest" BO_ 915 0;
BA_ "DiagResponse" BO_ 915 0;
BA_ "GenMsgStartValue" BO_ 915 "0";
BA_ "GenMsgDelayTime" BO_ 915 5;
BA_ "GenMsgNrOfRepetitions" BO_ 915 0;
BA_ "GenMsgCycleTime" BO_ 915 1000;
BA_ "GenMsgSendType" BO_ 915 5;
    */
    _SeatHtVn_Stat_AR_Timebase =               c_tDBKomTimer_20ms;
    _SeatHtVn_Stat_AR_CycleCount =           1000 / _SeatHtVn_Stat_AR_Timebase;
    _SeatHtVn_Stat_AR_StartDelay =              0 / _SeatHtVn_Stat_AR_Timebase;
    _SeatHtVn_Stat_AR_Cnt = _SeatHtVn_Stat_AR_StartDelay;
    _SeatHtVn_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_SeatHtVn_Stat_AR, _SeatHtVn_Stat_AR_StartDelay * _SeatHtVn_Stat_AR_Timebase );

    _mSeatHtVn_Stat_AR.HotStn_FL_Stat.phys = getValue( HMI_HotStn_FL_Stat );
    _mSeatHtVn_Stat_AR.HotStn_FR_Stat.phys = getValue( HMI_HotStn_FR_Stat );
    _mSeatHtVn_Stat_AR.HotStn_RL_Stat.phys = getValue( HMI_HotStn_RL_Stat );
    _mSeatHtVn_Stat_AR.HotStn_RR_Stat.phys = getValue( HMI_HotStn_RR_Stat );
    _mSeatHtVn_Stat_AR.SEAT_D_Ht_Blnc_Stat.phys = getValue( HMI_SEAT_D_Ht_Blnc_Stat );
    _mSeatHtVn_Stat_AR.Seat_HtVn_PreCond2_Actv.phys = getValue( HMI_Seat_HtVn_PreCond2_Actv );
    _mSeatHtVn_Stat_AR.SEAT_P_Ht_Blnc_Stat.phys = getValue( HMI_SEAT_P_Ht_Blnc_Stat );
    _mSeatHtVn_Stat_AR.SEAT_RL_Ht_Blnc_Stat.phys = getValue( HMI_SEAT_RL_Ht_Blnc_Stat );
    _mSeatHtVn_Stat_AR.SEAT_RR_Ht_Blnc_Stat.phys = getValue( HMI_SEAT_RR_Ht_Blnc_Stat );
    _mSeatHtVn_Stat_AR.SeatHt_FL_Stat.phys = getValue( HMI_SeatHt_FL_Stat );
    _mSeatHtVn_Stat_AR.SeatHt_FR_Stat.phys = getValue( HMI_SeatHt_FR_Stat );
    _mSeatHtVn_Stat_AR.SeatHt_RL_Stat.phys = getValue( HMI_SeatHt_RL_Stat );
    _mSeatHtVn_Stat_AR.SeatHt_RR_Stat.phys = getValue( HMI_SeatHt_RR_Stat );
    _mSeatHtVn_Stat_AR.SeatVn_FL_Stat.phys = getValue( HMI_SeatVn_FL_Stat );
    _mSeatHtVn_Stat_AR.SeatVn_FR_Stat.phys = getValue( HMI_SeatVn_FR_Stat );
    _mSeatHtVn_Stat_AR.SeatVn_RL_Stat.phys = getValue( HMI_SeatVn_RL_Stat );
    _mSeatHtVn_Stat_AR.SeatVn_RR_Stat.phys = getValue( HMI_SeatVn_RR_Stat );
}

SeatHtVn_Stat_AR_output(void)
{
    output( _mSeatHtVn_Stat_AR );
}

SeatHtVn_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SeatHtVn_Stat_AR\n", 30, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SeatHtVn_Stat := %X\n", getValue( HMI__STMSG_SeatHtVn_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SeatHtVn_Stat := %X\n", getValue( HMI__STMSGT_SeatHtVn_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HotStn_FL_Stat := %X\n", getValue( HMI_HotStn_FL_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HotStn_FR_Stat := %X\n", getValue( HMI_HotStn_FR_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HotStn_RL_Stat := %X\n", getValue( HMI_HotStn_RL_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HotStn_RR_Stat := %X\n", getValue( HMI_HotStn_RR_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SEAT_D_Ht_Blnc_Stat := %X\n", getValue( HMI_SEAT_D_Ht_Blnc_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Seat_HtVn_PreCond2_Actv := %X\n", getValue( HMI_Seat_HtVn_PreCond2_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SEAT_P_Ht_Blnc_Stat := %X\n", getValue( HMI_SEAT_P_Ht_Blnc_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SEAT_RL_Ht_Blnc_Stat := %X\n", getValue( HMI_SEAT_RL_Ht_Blnc_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SEAT_RR_Ht_Blnc_Stat := %X\n", getValue( HMI_SEAT_RR_Ht_Blnc_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatHt_FL_Stat := %X\n", getValue( HMI_SeatHt_FL_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatHt_FR_Stat := %X\n", getValue( HMI_SeatHt_FR_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatHt_RL_Stat := %X\n", getValue( HMI_SeatHt_RL_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatHt_RR_Stat := %X\n", getValue( HMI_SeatHt_RR_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatVn_FL_Stat := %X\n", getValue( HMI_SeatVn_FL_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatVn_FR_Stat := %X\n", getValue( HMI_SeatVn_FR_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatVn_RL_Stat := %X\n", getValue( HMI_SeatVn_RL_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatVn_RR_Stat := %X\n", getValue( HMI_SeatVn_RR_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tSeatHtVn_Stat_AR
{
    putValue( HMI__STMSG_SeatHtVn_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_SeatHtVn_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SeatHtVn_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tSeatHtVn_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_SeatHtVn_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_SeatHtVn_Stat_AR
{
    if( getValue( this ) )
        openPanel("SeatHtVn_Stat_AR");
}

on EnvVar HMI_HotStn_FL_Stat
{
    _mSeatHtVn_Stat_AR.HotStn_FL_Stat.phys = getValue(this);
    _SeatHtVn_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_HotStn_FR_Stat
{
    _mSeatHtVn_Stat_AR.HotStn_FR_Stat.phys = getValue(this);
    _SeatHtVn_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_HotStn_RL_Stat
{
    _mSeatHtVn_Stat_AR.HotStn_RL_Stat.phys = getValue(this);
    _SeatHtVn_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_HotStn_RR_Stat
{
    _mSeatHtVn_Stat_AR.HotStn_RR_Stat.phys = getValue(this);
    _SeatHtVn_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SEAT_D_Ht_Blnc_Stat
{
    _mSeatHtVn_Stat_AR.SEAT_D_Ht_Blnc_Stat.phys = getValue(this);
    _SeatHtVn_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Seat_HtVn_PreCond2_Actv
{
    _mSeatHtVn_Stat_AR.Seat_HtVn_PreCond2_Actv.phys = getValue(this);
    _SeatHtVn_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SEAT_P_Ht_Blnc_Stat
{
    _mSeatHtVn_Stat_AR.SEAT_P_Ht_Blnc_Stat.phys = getValue(this);
    _SeatHtVn_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SEAT_RL_Ht_Blnc_Stat
{
    _mSeatHtVn_Stat_AR.SEAT_RL_Ht_Blnc_Stat.phys = getValue(this);
    _SeatHtVn_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SEAT_RR_Ht_Blnc_Stat
{
    _mSeatHtVn_Stat_AR.SEAT_RR_Ht_Blnc_Stat.phys = getValue(this);
    _SeatHtVn_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatHt_FL_Stat
{
    _mSeatHtVn_Stat_AR.SeatHt_FL_Stat.phys = getValue(this);
    _SeatHtVn_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatHt_FR_Stat
{
    _mSeatHtVn_Stat_AR.SeatHt_FR_Stat.phys = getValue(this);
    _SeatHtVn_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatHt_RL_Stat
{
    _mSeatHtVn_Stat_AR.SeatHt_RL_Stat.phys = getValue(this);
    _SeatHtVn_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatHt_RR_Stat
{
    _mSeatHtVn_Stat_AR.SeatHt_RR_Stat.phys = getValue(this);
    _SeatHtVn_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatVn_FL_Stat
{
    _mSeatHtVn_Stat_AR.SeatVn_FL_Stat.phys = getValue(this);
    _SeatHtVn_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatVn_FR_Stat
{
    _mSeatHtVn_Stat_AR.SeatVn_FR_Stat.phys = getValue(this);
    _SeatHtVn_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatVn_RL_Stat
{
    _mSeatHtVn_Stat_AR.SeatVn_RL_Stat.phys = getValue(this);
    _SeatHtVn_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatVn_RR_Stat
{
    _mSeatHtVn_Stat_AR.SeatVn_RR_Stat.phys = getValue(this);
    _SeatHtVn_Stat_AR_SpontanFlag = 1;
}

SeatHtVn_Stat2_AR_check_output()
{
    if( !getValue( HMI__STMSG_SeatHtVn_Stat2_AR ) )
    {
    //  message   SeatHtVn_Stat2_AR ID: 916 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _SeatHtVn_Stat2_AR_DelayCnt > 0) _SeatHtVn_Stat2_AR_DelayCnt--; // Mindestsendeabstand
        _SeatHtVn_Stat2_AR_Cnt--;
        if( _SeatHtVn_Stat2_AR_Cnt < 1 )
        {
            if( _SeatHtVn_Stat2_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                SeatHtVn_Stat2_AR_output();
                _SeatHtVn_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SeatHtVn_Stat2_AR_DelayCnt = _SeatHtVn_Stat2_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _SeatHtVn_Stat2_AR_SpontanFlag = 1;
            }
            _SeatHtVn_Stat2_AR_Cnt = _SeatHtVn_Stat2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _SeatHtVn_Stat2_AR_SpontanFlag)
        {
            if( _SeatHtVn_Stat2_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                SeatHtVn_Stat2_AR_output();
                _SeatHtVn_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SeatHtVn_Stat2_AR_DelayCnt = _SeatHtVn_Stat2_AR_MinDelay;
            }
        }
    }
}

SeatHtVn_Stat2_AR_init()
{   /* Botschaft SeatHtVn_Stat2_AR ID: 916 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 916 0;
BA_ "NmAsrMessage" BO_ 916 0;
BA_ "GenMsgMinAcceptLength" BO_ 916 4;
BA_ "GenMsgILSupport" BO_ 916 1;
BA_ "DiagState" BO_ 916 0;
BA_ "DiagRequest" BO_ 916 0;
BA_ "DiagResponse" BO_ 916 0;
BA_ "GenMsgStartValue" BO_ 916 "0";
BA_ "GenMsgDelayTime" BO_ 916 200;
BA_ "GenMsgNrOfRepetitions" BO_ 916 0;
BA_ "GenMsgCycleTime" BO_ 916 1000;
BA_ "GenMsgSendType" BO_ 916 5;
    */
    _SeatHtVn_Stat2_AR_Timebase =      c_tDBKomTimer_20ms;
    _SeatHtVn_Stat2_AR_CycleCount =   1000 / _SeatHtVn_Stat2_AR_Timebase;
    _SeatHtVn_Stat2_AR_StartDelay =      0 / _SeatHtVn_Stat2_AR_Timebase;
    _SeatHtVn_Stat2_AR_MinDelay =      200 / _SeatHtVn_Stat2_AR_Timebase;
    _SeatHtVn_Stat2_AR_Cnt = _SeatHtVn_Stat2_AR_StartDelay;
    _SeatHtVn_Stat2_AR_SpontanFlag = 0;
    _SeatHtVn_Stat2_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_SeatHtVn_Stat2_AR, _SeatHtVn_Stat2_AR_StartDelay * _SeatHtVn_Stat2_AR_Timebase );

    _mSeatHtVn_Stat2_AR.SeatCond_ActvComf_Seat_FL_Stat.phys = getValue( HMI_SeatCond_ActvComf_Seat_FL_Stat );
    _mSeatHtVn_Stat2_AR.SeatCond_ActvComf_Seat_FR_Stat.phys = getValue( HMI_SeatCond_ActvComf_Seat_FR_Stat );
    _mSeatHtVn_Stat2_AR.SeatCond_ActvComf_Seat_RL_Stat.phys = getValue( HMI_SeatCond_ActvComf_Seat_RL_Stat );
    _mSeatHtVn_Stat2_AR.SeatCond_ActvComf_Seat_RR_Stat.phys = getValue( HMI_SeatCond_ActvComf_Seat_RR_Stat );
}

SeatHtVn_Stat2_AR_output(void)
{
    output( _mSeatHtVn_Stat2_AR );
}

SeatHtVn_Stat2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SeatHtVn_Stat2_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SeatHtVn_Stat2_AR := %X\n", getValue( HMI__STMSG_SeatHtVn_Stat2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SeatHtVn_Stat2_AR := %X\n", getValue( HMI__STMSGT_SeatHtVn_Stat2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatCond_ActvComf_Seat_FL_Stat := %X\n", getValue( HMI_SeatCond_ActvComf_Seat_FL_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatCond_ActvComf_Seat_FR_Stat := %X\n", getValue( HMI_SeatCond_ActvComf_Seat_FR_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatCond_ActvComf_Seat_RL_Stat := %X\n", getValue( HMI_SeatCond_ActvComf_Seat_RL_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatCond_ActvComf_Seat_RR_Stat := %X\n", getValue( HMI_SeatCond_ActvComf_Seat_RR_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tSeatHtVn_Stat2_AR
{
    putValue( HMI__STMSG_SeatHtVn_Stat2_AR, 0 );
}

on EnvVar HMI__STMSG_SeatHtVn_Stat2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SeatHtVn_Stat2_AR );
        if( tDelay > 0)    
            setTimer( _tSeatHtVn_Stat2_AR, tDelay );
        else
            putValue( HMI__STMSG_SeatHtVn_Stat2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_SeatHtVn_Stat2_AR
{
    if( getValue( this ) )
        openPanel("SeatHtVn_Stat2_AR");
}

on EnvVar HMI_SeatCond_ActvComf_Seat_FL_Stat
{
    _mSeatHtVn_Stat2_AR.SeatCond_ActvComf_Seat_FL_Stat.phys = getValue(this);
    _SeatHtVn_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatCond_ActvComf_Seat_FR_Stat
{
    _mSeatHtVn_Stat2_AR.SeatCond_ActvComf_Seat_FR_Stat.phys = getValue(this);
    _SeatHtVn_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatCond_ActvComf_Seat_RL_Stat
{
    _mSeatHtVn_Stat2_AR.SeatCond_ActvComf_Seat_RL_Stat.phys = getValue(this);
    _SeatHtVn_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatCond_ActvComf_Seat_RR_Stat
{
    _mSeatHtVn_Stat2_AR.SeatCond_ActvComf_Seat_RR_Stat.phys = getValue(this);
    _SeatHtVn_Stat2_AR_SpontanFlag = 1;
}

SeatMat_Stat_AR_check_output()
{
	if( !getValue( HMI__STMSG_SeatMat_Stat_AR ) )
	{
	//message SeatMat_Stat_AR ID: 502 
	 if( _SeatMat_Stat_AR_DelayCnt > 0) _SeatMat_Stat_AR_DelayCnt--; // Mindestsendeabstand
	_SeatMat_Stat_AR_Cnt--;
	if( _SeatMat_Stat_AR_Cnt < 1 )
	{
		if( _SeatMat_Stat_AR_DelayCnt < 1 )
		SeatMat_Stat_AR_output(); // Nachright wg. abgelaufenem Zyklus ausgeben
	    _SeatMat_Stat_AR_Cnt = _SeatMat_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
	    _SeatMat_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
	}
	else if( _SeatMat_Stat_AR_SpontanFlag)
	{
	     SeatMat_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
	    _SeatMat_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
	}
	}
}

SeatMat_Stat_AR_init()
{
/* Botschaft WPT_Stat2_AR ID: 502 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 502 0;
BA_ "NmAsrMessage" BO_ 502 0;
BA_ "GenMsgMinAcceptLength" BO_ 502 8;
BA_ "GenMsgILSupport" BO_ 502 1;
BA_ "DiagState" BO_ 502 0;
BA_ "DiagRequest" BO_ 502 0;
BA_ "DiagResponse" BO_ 502 0;
BA_ "GenMsgStartValue" BO_ 502 "0";
BA_ "GenMsgDelayTime" BO_ 502 20;
BA_ "GenMsgNrOfRepetition" BO_ 502 0;
BA_ "GenMsgCycleTime" BO_ 502 200;
BA_ "GenMsgSendType" BO_ 502 5;
    */
	_SeatMat_Stat_AR_Timebase=       c_tDBKomTimer_20ms;
	_SeatMat_Stat_AR_CycleCount =     200 / _SeatMat_Stat_AR_Timebase;
    _SeatMat_Stat_AR_StartDelay =       0 / _SeatMat_Stat_AR_Timebase;
	_SeatMat_Stat_AR_MinDelay =               100 / _SeatMat_Stat_AR_Timebase;
    _SeatMat_Stat_AR_Cnt = _SeatMat_Stat_AR_StartDelay;
    _SeatMat_Stat_AR_SpontanFlag = 0;
	_SeatMat_Stat_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_SeatMat_Stat_AR, _SeatMat_Stat_AR_StartDelay * _SeatMat_Stat_AR_Timebase );

    _mSeatMat_Stat_AR.SecondRowCenterPresenceState.phys = getValue( HMI_SecondRowCenterPresenceState );
    _mSeatMat_Stat_AR.SecondRowLeftPresenceState.phys = getValue( HMI_SecondRowLeftPresenceState );
    _mSeatMat_Stat_AR.SecondRowRightPresenceState.phys = getValue( HMI_SecondRowRightPresenceState );
    _mSeatMat_Stat_AR.ThirdRowCenterPresenceState.phys = getValue( HMI_ThirdRowCenterPresenceState );
    _mSeatMat_Stat_AR.ThirdRowLeftPresenceState.phys = getValue( HMI_ThirdRowLeftPresenceState );
    _mSeatMat_Stat_AR.ThirdRowRightPresenceState.phys = getValue( HMI_ThirdRowRightPresenceState );
}

SeatMat_Stat_AR_output()
{
	output( _mSeatMat_Stat_AR );
}

SeatMat_Stat_AR_saveEnvVars( dword hFile )
{
filePutString("\n// Knoten EIS: SeatMat_Stat_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SeatMat_Stat_AR := %X\n", getValue( HMI__STMSG_SeatMat_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SeatMat_Stat_AR := %X\n", getValue( HMI__STMSGT_SeatMat_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SecondRowCenterPresenceState := %X\n", getValue( HMI_SecondRowCenterPresenceState ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SecondRowLeftPresenceState := %X\n", getValue( HMI_SecondRowLeftPresenceState ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SecondRowRightPresenceState := %X\n", getValue( HMI_SecondRowRightPresenceState ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ThirdRowCenterPresenceState := %X\n", getValue( HMI_ThirdRowCenterPresenceState ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ThirdRowLeftPresenceState := %X\n", getValue( HMI_ThirdRowLeftPresenceState ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ThirdRowRightPresenceState := %X\n", getValue( HMI_ThirdRowRightPresenceState ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tSeatMat_Stat_AR
{
	putValue( HMI__STMSG_SeatMat_Stat_AR, 0);
}

on EnvVar HMI__STMSG_SeatMat_Stat_AR
{
	long tDelay;
	if( getValue( this ) == 2 )
		{
		tDelay = getValue(HMI__STMSGT_SeatMat_Stat_AR );
		if(tDelay > 0)
			setTimer( _tSeatMat_Stat_AR, tDelay );
		else
			putValue( HMI__STMSG_SeatMat_Stat_AR, 0);
		}
}

on envVar HMI__STMSG_PO_SeatMat_Stat_AR
{
	if( getValue( this ) )
		openPanel("SeatMat_Stat_AR");
}

on EnvVar HMI_SecondRowCenterPresenceState
{
	_mSeatMat_Stat_AR.SecondRowCenterPresenceState.phys = getValue(this);
	_SeatMat_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SecondRowLeftPresenceState
{
	_mSeatMat_Stat_AR.SecondRowLeftPresenceState.phys = getValue(this);
	_SeatMat_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SecondRowRightPresenceState
{
	_mSeatMat_Stat_AR.SecondRowRightPresenceState.phys = getValue(this);
	_SeatMat_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ThirdRowCenterPresenceState
{
	_mSeatMat_Stat_AR.ThirdRowCenterPresenceState.phys = getValue(this);
	_SeatMat_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ThirdRowLeftPresenceState
{
	_mSeatMat_Stat_AR.ThirdRowLeftPresenceState.phys = getValue(this);
	_SeatMat_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ThirdRowRightPresenceState
{
	_mSeatMat_Stat_AR.ThirdRowRightPresenceState.phys = getValue(this);
	_SeatMat_Stat_AR_SpontanFlag = 1;
}

void SeatMem_D_Rq_AR_Activity(int active)
{
      if( active)
      {
          if( _SeatMem_D_Rq_AR_SigActivity == 0)
            _SeatMem_D_Rq_AR_Cnt = 1;
        _SeatMem_D_Rq_AR_SigActivity++;
      }
      else
    {
        _SeatMem_D_Rq_AR_SigActivity--;
      }
}

int SeatMem_D_Rq_AR_Change(int lastValue, int sigValue, int inActValue)
{
    bActiveHelper = (sigValue != inActValue);
      if( !lastValue && bActiveHelper)
        SeatMem_D_Rq_AR_Activity( 1 );
      else if( lastValue && !bActiveHelper)
        SeatMem_D_Rq_AR_Activity(0 );
    return bActiveHelper;
}

SeatMem_D_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_SeatMem_D_Rq_AR ) )
    {
    //  message   SeatMem_D_Rq_AR ID: 297 --- Sendeart 2 cyclicIfActive --- 
        if( _SeatMem_D_Rq_AR_SigActivity )
            _SeatMem_D_Rq_AR_Cnt--;
        if( _SeatMem_D_Rq_AR_Cnt < 1 )
        {
            SeatMem_D_Rq_AR_output(); // Zyklus abgelaufen, Nachricht senden
            _SeatMem_D_Rq_AR_Cnt = _SeatMem_D_Rq_AR_CycleCount;
        }
    }
}

SeatMem_D_Rq_AR_init()
{   /* Botschaft SeatMem_D_Rq_AR ID: 297 --- Sendeart 2 cyclicIfActive --- 
BA_ "ApplMessage" BO_ 297 0;
BA_ "NmAsrMessage" BO_ 297 0;
BA_ "GenMsgMinAcceptLength" BO_ 297 3;
BA_ "GenMsgILSupport" BO_ 297 1;
BA_ "DiagState" BO_ 297 0;
BA_ "DiagRequest" BO_ 297 0;
BA_ "DiagResponse" BO_ 297 0;
BA_ "GenMsgStartValue" BO_ 297 "0";
BA_ "GenMsgStartDelayTime" BO_ 297 0;
BA_ "GenMsgDelayTime" BO_ 297 5;
BA_ "GenMsgCycleTime" BO_ 297 0;
BA_ "GenMsgCycleTimeActive" BO_ 297 40;
BA_ "GenMsgSendType" BO_ 297 2;
    */
    _SeatMem_D_Rq_AR_Timebase =           c_tDBKomTimer_5ms;
    _SeatMem_D_Rq_AR_CycleCount =       40 / _SeatMem_D_Rq_AR_Timebase;
    _SeatMem_D_Rq_AR_StartDelay =        0 / _SeatMem_D_Rq_AR_Timebase;
    _SeatMem_D_Rq_AR_Cnt = _SeatMem_D_Rq_AR_StartDelay;
    _SeatMem_D_Rq_AR_Active = 0;
    _SeatMem_D_Rq_AR_SigActivity = 0;

    putValue( HMI__STMSGSD_SeatMem_D_Rq_AR, _SeatMem_D_Rq_AR_StartDelay * _SeatMem_D_Rq_AR_Timebase );

    _mSeatMem_D_Rq_AR.MCMS_DrvPosn_D_Rq.phys =     getValue( HMI_MCMS_DrvPosn_D_Rq );
    _mSeatMem_D_Rq_AR.MCMS_DrvPosn_D_Sv_Rq.phys =  getValue( HMI_MCMS_DrvPosn_D_Sv_Rq );
    _mSeatMem_D_Rq_AR.MCMS_EEH_Posn_Rq.phys =       getValue( HMI_MCMS_EEH_Posn_Rq );
    _mSeatMem_D_Rq_AR.MCMS_HomePosn_D_Rq.phys =       getValue( HMI_MCMS_HomePosn_D_Rq );
    _mSeatMem_D_Rq_AR.MCMS_HomePosn_D_Sv_Rq.phys =       getValue( HMI_MCMS_HomePosn_D_Sv_Rq );
    _mSeatMem_D_Rq_AR.Mem_D_Posn_Rq.phys =       getValue( HMI_Mem_D_Posn_Rq );
    _mSeatMem_D_Rq_AR.Mem_D_Prof_Posn_Rq.phys =       getValue( HMI_Mem_D_Prof_Posn_Rq );
    _mSeatMem_D_Rq_AR.Mem_D_Rc_Rq.phys =         getValue( HMI_Mem_D_Rc_Rq );
    _mSeatMem_D_Rq_AR.Mem_D_Sv_Rq.phys =         getValue( HMI_Mem_D_Sv_Rq );
    _mSeatMem_D_Rq_AR.MirrDrvPosn_Rq.phys =      getValue( HMI_MirrDrvPosn_Rq );
    _mSeatMem_D_Rq_AR.MirrDrvPosn_Sv_Rq.phys =   getValue( HMI_MirrDrvPosn_Sv_Rq );
    _mSeatMem_D_Rq_AR.HUD_DrvPosn_D_Sv_Rq.phys =   getValue( HMI_HUD_DrvPosn_D_Sv_Rq );
    _mSeatMem_D_Rq_AR.HUD_DrvPosn_D_Rq.phys =   getValue( HMI_HUD_DrvPosn_D_Rq );
    _SeatMem_D_Rq_AR_MCMS_DrvPosn_D_Rq_LastState = SeatMem_D_Rq_AR_Change( _SeatMem_D_Rq_AR_MCMS_DrvPosn_D_Rq_LastState, _mSeatMem_D_Rq_AR.MCMS_DrvPosn_D_Rq, 0);
    _SeatMem_D_Rq_AR_MCMS_DrvPosn_D_Sv_Rq_LastState = SeatMem_D_Rq_AR_Change( _SeatMem_D_Rq_AR_MCMS_DrvPosn_D_Sv_Rq_LastState, _mSeatMem_D_Rq_AR.MCMS_DrvPosn_D_Sv_Rq, 0);
    _SeatMem_D_Rq_AR_MCMS_EEH_Posn_Rq_LastState = SeatMem_D_Rq_AR_Change( _SeatMem_D_Rq_AR_MCMS_EEH_Posn_Rq_LastState, _mSeatMem_D_Rq_AR.MCMS_EEH_Posn_Rq, 0);
    _SeatMem_D_Rq_AR_MCMS_HomePosn_D_Rq_LastState = SeatMem_D_Rq_AR_Change( _SeatMem_D_Rq_AR_MCMS_HomePosn_D_Rq_LastState, _mSeatMem_D_Rq_AR.MCMS_HomePosn_D_Rq, 0);
    _SeatMem_D_Rq_AR_MCMS_HomePosn_D_Sv_Rq_LastState = SeatMem_D_Rq_AR_Change( _SeatMem_D_Rq_AR_MCMS_HomePosn_D_Sv_Rq_LastState, _mSeatMem_D_Rq_AR.MCMS_HomePosn_D_Sv_Rq, 0);
    _SeatMem_D_Rq_AR_Mem_D_Posn_Rq_LastState = SeatMem_D_Rq_AR_Change( _SeatMem_D_Rq_AR_Mem_D_Posn_Rq_LastState, _mSeatMem_D_Rq_AR.Mem_D_Posn_Rq, 0);
    _SeatMem_D_Rq_AR_Mem_D_Prof_Posn_Rq_LastState = SeatMem_D_Rq_AR_Change( _SeatMem_D_Rq_AR_Mem_D_Prof_Posn_Rq_LastState, _mSeatMem_D_Rq_AR.Mem_D_Prof_Posn_Rq, 0);
    _SeatMem_D_Rq_AR_Mem_D_Rc_Rq_LastState = SeatMem_D_Rq_AR_Change( _SeatMem_D_Rq_AR_Mem_D_Rc_Rq_LastState, _mSeatMem_D_Rq_AR.Mem_D_Rc_Rq, 0);
    _SeatMem_D_Rq_AR_Mem_D_Sv_Rq_LastState = SeatMem_D_Rq_AR_Change( _SeatMem_D_Rq_AR_Mem_D_Sv_Rq_LastState, _mSeatMem_D_Rq_AR.Mem_D_Sv_Rq, 0);
    _SeatMem_D_Rq_AR_MirrDrvPosn_Rq_LastState = SeatMem_D_Rq_AR_Change( _SeatMem_D_Rq_AR_MirrDrvPosn_Rq_LastState, _mSeatMem_D_Rq_AR.MirrDrvPosn_Rq, 0);
    _SeatMem_D_Rq_AR_MirrDrvPosn_Sv_Rq_LastState = SeatMem_D_Rq_AR_Change( _SeatMem_D_Rq_AR_MirrDrvPosn_Sv_Rq_LastState, _mSeatMem_D_Rq_AR.MirrDrvPosn_Sv_Rq, 0);
}

SeatMem_D_Rq_AR_output()
{
    output( _mSeatMem_D_Rq_AR );
}

SeatMem_D_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SeatMem_D_Rq_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SeatMem_D_Rq_AR := %X\n", getValue( HMI__STMSG_SeatMem_D_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SeatMem_D_Rq_AR := %X\n", getValue( HMI__STMSGT_SeatMem_D_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_DrvPosn_D_Rq := %X\n", getValue( HMI_MCMS_DrvPosn_D_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_DrvPosn_D_Sv_Rq := %X\n", getValue( HMI_MCMS_DrvPosn_D_Sv_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_EEH_Posn_Rq := %X\n", getValue( HMI_MCMS_EEH_Posn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_HomePosn_D_Rq := %X\n", getValue( HMI_MCMS_HomePosn_D_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_HomePosn_D_Sv_Rq := %X\n", getValue( HMI_MCMS_HomePosn_D_Sv_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mem_D_Posn_Rq := %X\n", getValue( HMI_Mem_D_Posn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mem_D_Prof_Posn_Rq := %X\n", getValue( HMI_Mem_D_Prof_Posn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mem_D_Rc_Rq := %X\n", getValue( HMI_Mem_D_Rc_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mem_D_Sv_Rq := %X\n", getValue( HMI_Mem_D_Sv_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MirrDrvPosn_Rq := %X\n", getValue( HMI_MirrDrvPosn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MirrDrvPosn_Sv_Rq := %X\n", getValue( HMI_MirrDrvPosn_Sv_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HUD_DrvPosn_D_Rq := %X\n", getValue( HMI_HUD_DrvPosn_D_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HUD_DrvPosn_D_Sv_Rq := %X\n", getValue( HMI_HUD_DrvPosn_D_Sv_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tSeatMem_D_Rq_AR
{
    putValue( HMI__STMSG_SeatMem_D_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_SeatMem_D_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SeatMem_D_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tSeatMem_D_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_SeatMem_D_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_SeatMem_D_Rq_AR
{
    if( getValue( this ) )
        openPanel("SeatMem_D_Rq_AR");
}

on EnvVar HMI_MCMS_DrvPosn_D_Rq
{
    _mSeatMem_D_Rq_AR.MCMS_DrvPosn_D_Rq.phys = getValue(this);
    _SeatMem_D_Rq_AR_MCMS_DrvPosn_D_Rq_LastState = SeatMem_D_Rq_AR_Change(_SeatMem_D_Rq_AR_MCMS_DrvPosn_D_Rq_LastState, _mSeatMem_D_Rq_AR.MCMS_DrvPosn_D_Rq, 0 );
}

on EnvVar HMI_MCMS_DrvPosn_D_Sv_Rq
{
    _mSeatMem_D_Rq_AR.MCMS_DrvPosn_D_Sv_Rq.phys = getValue(this);
    _SeatMem_D_Rq_AR_MCMS_DrvPosn_D_Sv_Rq_LastState = SeatMem_D_Rq_AR_Change(_SeatMem_D_Rq_AR_MCMS_DrvPosn_D_Sv_Rq_LastState, _mSeatMem_D_Rq_AR.MCMS_DrvPosn_D_Sv_Rq, 0 );
}

on EnvVar HMI_MCMS_EEH_Posn_Rq
{
    _mSeatMem_D_Rq_AR.MCMS_EEH_Posn_Rq.phys = getValue(this);
    _SeatMem_D_Rq_AR_MCMS_EEH_Posn_Rq_LastState = SeatMem_D_Rq_AR_Change(_SeatMem_D_Rq_AR_MCMS_EEH_Posn_Rq_LastState, _mSeatMem_D_Rq_AR.MCMS_EEH_Posn_Rq, 0 );
}

on EnvVar HMI_MCMS_HomePosn_D_Rq
{
    _mSeatMem_D_Rq_AR.MCMS_HomePosn_D_Rq.phys = getValue(this);
    _SeatMem_D_Rq_AR_MCMS_HomePosn_D_Rq_LastState = SeatMem_D_Rq_AR_Change(_SeatMem_D_Rq_AR_MCMS_HomePosn_D_Rq_LastState, _mSeatMem_D_Rq_AR.MCMS_HomePosn_D_Rq, 0 );
}

on EnvVar HMI_MCMS_HomePosn_D_Sv_Rq
{
    _mSeatMem_D_Rq_AR.MCMS_HomePosn_D_Sv_Rq.phys = getValue(this);
    _SeatMem_D_Rq_AR_MCMS_HomePosn_D_Sv_Rq_LastState = SeatMem_D_Rq_AR_Change(_SeatMem_D_Rq_AR_MCMS_HomePosn_D_Sv_Rq_LastState, _mSeatMem_D_Rq_AR.MCMS_HomePosn_D_Sv_Rq, 0 );
}

on EnvVar HMI_Mem_D_Posn_Rq
{
    _mSeatMem_D_Rq_AR.Mem_D_Posn_Rq.phys = getValue(this);
    _SeatMem_D_Rq_AR_Mem_D_Posn_Rq_LastState = SeatMem_D_Rq_AR_Change(_SeatMem_D_Rq_AR_Mem_D_Posn_Rq_LastState, _mSeatMem_D_Rq_AR.Mem_D_Posn_Rq, 0 );
}

on EnvVar HMI_Mem_D_Prof_Posn_Rq
{
    _mSeatMem_D_Rq_AR.Mem_D_Prof_Posn_Rq.phys = getValue(this);
    _SeatMem_D_Rq_AR_Mem_D_Prof_Posn_Rq_LastState = SeatMem_D_Rq_AR_Change(_SeatMem_D_Rq_AR_Mem_D_Prof_Posn_Rq_LastState, _mSeatMem_D_Rq_AR.Mem_D_Prof_Posn_Rq, 0 );
}

on EnvVar HMI_Mem_D_Rc_Rq
{
    _mSeatMem_D_Rq_AR.Mem_D_Rc_Rq.phys = getValue(this);
    _SeatMem_D_Rq_AR_Mem_D_Rc_Rq_LastState = SeatMem_D_Rq_AR_Change(_SeatMem_D_Rq_AR_Mem_D_Rc_Rq_LastState, _mSeatMem_D_Rq_AR.Mem_D_Rc_Rq, 0 );
}

on EnvVar HMI_Mem_D_Sv_Rq
{
    _mSeatMem_D_Rq_AR.Mem_D_Sv_Rq.phys = getValue(this);
    _SeatMem_D_Rq_AR_Mem_D_Sv_Rq_LastState = SeatMem_D_Rq_AR_Change(_SeatMem_D_Rq_AR_Mem_D_Sv_Rq_LastState, _mSeatMem_D_Rq_AR.Mem_D_Sv_Rq, 0 );
}

on EnvVar HMI_MirrDrvPosn_Rq
{
    _mSeatMem_D_Rq_AR.MirrDrvPosn_Rq.phys = getValue(this);
    _SeatMem_D_Rq_AR_MirrDrvPosn_Rq_LastState = SeatMem_D_Rq_AR_Change(_SeatMem_D_Rq_AR_MirrDrvPosn_Rq_LastState, _mSeatMem_D_Rq_AR.MirrDrvPosn_Rq, 0 );
}

on EnvVar HMI_MirrDrvPosn_Sv_Rq
{
    _mSeatMem_D_Rq_AR.MirrDrvPosn_Sv_Rq.phys = getValue(this);
    _SeatMem_D_Rq_AR_MirrDrvPosn_Sv_Rq_LastState = SeatMem_D_Rq_AR_Change(_SeatMem_D_Rq_AR_MirrDrvPosn_Sv_Rq_LastState, _mSeatMem_D_Rq_AR.MirrDrvPosn_Sv_Rq, 0 );
}

on EnvVar HMI_HUD_DrvPosn_D_Rq
{
    _mSeatMem_D_Rq_AR.HUD_DrvPosn_D_Rq.phys = getValue(this);
}

on EnvVar HMI_HUD_DrvPosn_D_Sv_Rq
{
    _mSeatMem_D_Rq_AR.HUD_DrvPosn_D_Sv_Rq.phys = getValue(this);
}

SeatPosn_Abs_D_AR_check_output()
{
    if( !getValue( HMI__STMSG_SeatPosn_Abs_D_AR ) )
    {
    //  message   SeatPosn_Abs_D_AR ID: 961 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _SeatPosn_Abs_D_AR_DelayCnt > 0) _SeatPosn_Abs_D_AR_DelayCnt--; // Mindestsendeabstand
        _SeatPosn_Abs_D_AR_Cnt--;
        if( _SeatPosn_Abs_D_AR_Cnt < 1 )
        {
            if( _SeatPosn_Abs_D_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                SeatPosn_Abs_D_AR_output();
                _SeatPosn_Abs_D_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SeatPosn_Abs_D_AR_DelayCnt = _SeatPosn_Abs_D_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _SeatPosn_Abs_D_AR_SpontanFlag = 1;
            }
            _SeatPosn_Abs_D_AR_Cnt = _SeatPosn_Abs_D_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _SeatPosn_Abs_D_AR_SpontanFlag)
        {
            if( _SeatPosn_Abs_D_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                SeatPosn_Abs_D_AR_output();
                _SeatPosn_Abs_D_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SeatPosn_Abs_D_AR_DelayCnt = _SeatPosn_Abs_D_AR_MinDelay;
            }
        }
    }
}

SeatPosn_Abs_D_AR_init()
{   /* Botschaft SeatPosn_Abs_D_AR ID: 961 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 961 0;
BA_ "NmAsrMessage" BO_ 961 0;
BA_ "GenMsgMinAcceptLength" BO_ 961 8;
BA_ "GenMsgILSupport" BO_ 961 1;
BA_ "DiagState" BO_ 961 0;
BA_ "DiagRequest" BO_ 961 0;
BA_ "DiagResponse" BO_ 961 0;
BA_ "GenMsgStartValue" BO_ 961 "0";
BA_ "GenMsgDelayTime" BO_ 961 100;
BA_ "GenMsgNrOfRepetitions" BO_ 961 0;
BA_ "GenMsgCycleTime" BO_ 961 1000;
BA_ "GenMsgSendType" BO_ 961 5;
    */
    _SeatPosn_Abs_D_AR_Timebase =        c_tDBKomTimer_20ms;
    _SeatPosn_Abs_D_AR_CycleCount =    1000 / _SeatPosn_Abs_D_AR_Timebase;
    _SeatPosn_Abs_D_AR_StartDelay =       0 / _SeatPosn_Abs_D_AR_Timebase;
    _SeatPosn_Abs_D_AR_MinDelay =       100 / _SeatPosn_Abs_D_AR_Timebase;
    _SeatPosn_Abs_D_AR_Cnt = _SeatPosn_Abs_D_AR_StartDelay;
    _SeatPosn_Abs_D_AR_SpontanFlag = 0;
    _SeatPosn_Abs_D_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_SeatPosn_Abs_D_AR, _SeatPosn_Abs_D_AR_StartDelay * _SeatPosn_Abs_D_AR_Timebase );

    _mSeatPosn_Abs_D_AR.SeatLgthHghtPosn_D_Vld.phys = getValue( HMI_SeatLgthHghtPosn_D_Vld );
    _mSeatPosn_Abs_D_AR.SeatLgthHghtPosnAbs_D.phys = getValue( HMI_SeatLgthHghtPosnAbs_D );
    _mSeatPosn_Abs_D_AR.SeatLgthHghtPosnRel_D.phys = getValue( HMI_SeatLgthHghtPosnRel_D );
    _mSeatPosn_Abs_D_AR.SeatLgthPosn_D_Vld.phys = getValue( HMI_SeatLgthPosn_D_Vld );
    _mSeatPosn_Abs_D_AR.SeatLgthPosnAbs_D.phys = getValue( HMI_SeatLgthPosnAbs_D );
    _mSeatPosn_Abs_D_AR.SeatLgthPosnRel_D.phys = getValue( HMI_SeatLgthPosnRel_D );
}

SeatPosn_Abs_D_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_SeatPosn_Abs_D ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_SeatPosn_Abs_D_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _SeatPosn_Abs_D_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _SeatPosn_Abs_D_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_SeatPosn_Abs_D_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _SeatPosn_Abs_D_AR_SQC_WrongSeqJump != 0 ) &&
            ( _SeatPosn_Abs_D_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _SeatPosn_Abs_D_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _SeatPosn_Abs_D_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _SeatPosn_Abs_D_AR_SQC_RepeatedCnt ) &&
            ( _SeatPosn_Abs_D_AR_E2E_Armed == 1  )    )
        {
            _SeatPosn_Abs_D_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_SeatPosn_Abs_D, SQC_help );
    }
    _mSeatPosn_Abs_D_AR.SQC_SeatPosn_Abs_D = SQC_help;

    if( getValue( HMI_CRC_SeatPosn_Abs_D_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_SeatPosn_Abs_D_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mSeatPosn_Abs_D_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mSeatPosn_Abs_D_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mSeatPosn_Abs_D_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mSeatPosn_Abs_D_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mSeatPosn_Abs_D_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mSeatPosn_Abs_D_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mSeatPosn_Abs_D_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mSeatPosn_Abs_D_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _SeatPosn_Abs_D_AR_CRC_Offset[ _mSeatPosn_Abs_D_AR.SQC_SeatPosn_Abs_D ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _SeatPosn_Abs_D_AR_CRC_ErrorCnt   && ( _SeatPosn_Abs_D_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_SeatPosn_Abs_D_Invalid )                                         )    )
            {
                crc++;
                if( _SeatPosn_Abs_D_AR_CRC_ErrorCnt > 0 )
                    _SeatPosn_Abs_D_AR_CRC_ErrorCnt--; 
            }
            _mSeatPosn_Abs_D_AR.CRC_SeatPosn_Abs_D = crc;
            putValue( HMI_CRC_SeatPosn_Abs_D, crc );
        }
        else
            _mSeatPosn_Abs_D_AR.CRC_SeatPosn_Abs_D = getValue( HMI_CRC_SeatPosn_Abs_D );
    }
    if( ( _SeatPosn_Abs_D_AR_MSG_DropCnt > 0 ) &&
        ( _SeatPosn_Abs_D_AR_E2E_Armed == 1  )    )
    {
        _SeatPosn_Abs_D_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mSeatPosn_Abs_D_AR );
        
    if( _SeatPosn_Abs_D_AR_E2E_Armed == 1 )
    {
        if ( ( _SeatPosn_Abs_D_AR_MSG_DropCnt == 0      ) &&
             ( _SeatPosn_Abs_D_AR_CRC_ErrorCnt == 0     ) &&
             ( _SeatPosn_Abs_D_AR_SQC_RepeatedCnt == 0  ) &&
             ( _SeatPosn_Abs_D_AR_SQC_WrongSeqJump == 0 )    )
        {
            _SeatPosn_Abs_D_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_SeatPosn_Abs_D_State, 0 );
        }
    }
}

SeatPosn_Abs_D_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SeatPosn_Abs_D_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SeatPosn_Abs_D := %X\n", getValue( HMI__STMSG_SeatPosn_Abs_D_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SeatPosn_Abs_D := %X\n", getValue( HMI__STMSGT_SeatPosn_Abs_D_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatLgthHghtPosn_D_Vld := %X\n", getValue( HMI_SeatLgthHghtPosn_D_Vld ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatLgthHghtPosnAbs_D := %X\n", getValue( HMI_SeatLgthHghtPosnAbs_D ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatLgthHghtPosnRel_D := %X\n", getValue( HMI_SeatLgthHghtPosnRel_D ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatLgthPosn_D_Vld := %X\n", getValue( HMI_SeatLgthPosn_D_Vld ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatLgthPosnAbs_D := %X\n", getValue( HMI_SeatLgthPosnAbs_D ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatLgthPosnRel_D := %X\n", getValue( HMI_SeatLgthPosnRel_D ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tSeatPosn_Abs_D_AR
{
    putValue( HMI__STMSG_SeatPosn_Abs_D_AR, 0 );
}

on EnvVar HMI__STMSG_SeatPosn_Abs_D_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SeatPosn_Abs_D_AR );
        if( tDelay > 0)    
            setTimer( _tSeatPosn_Abs_D_AR, tDelay );
        else
            putValue( HMI__STMSG_SeatPosn_Abs_D_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_SeatPosn_Abs_D_AR
{
    if( getValue( this ) )
        openPanel("SeatPosn_Abs_D_AR");
}

on envVar HMI_E2E_SeatPosn_Abs_D_Inject
{
    if( getValue( this ) )
    {
        _SeatPosn_Abs_D_AR_CRC_ErrorCnt = getValue( HMI_CRC_SeatPosn_Abs_D_ErrorCount );
        _SeatPosn_Abs_D_AR_SQC_TriggPos = getValue( HMI_SQC_SeatPosn_Abs_D_TriggerPosition );
        _SeatPosn_Abs_D_AR_SQC_WrongSeqJump = getValue( HMI_SQC_SeatPosn_Abs_D_WrongSeq );
        _SeatPosn_Abs_D_AR_SQC_RepeatedCnt = getValue( HMI_SQC_SeatPosn_Abs_D_Repeated );
        _SeatPosn_Abs_D_AR_MSG_DropCnt = getValue( HMI_SQC_SeatPosn_Abs_D_MSG_DropCnt );
        putValue( HMI_E2E_SeatPosn_Abs_D_State, 2 );
        _SeatPosn_Abs_D_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_SeatLgthPosn_D_Vld
{
    _mSeatPosn_Abs_D_AR.SeatLgthPosn_D_Vld.phys = getValue(this);
    _SeatPosn_Abs_D_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatLgthPosnAbs_D
{
    _mSeatPosn_Abs_D_AR.SeatLgthPosnAbs_D.phys = getValue(this);
    _SeatPosn_Abs_D_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatLgthPosnRel_D
{
    _mSeatPosn_Abs_D_AR.SeatLgthPosnRel_D.phys = getValue(this);
    _SeatPosn_Abs_D_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatLgthHghtPosn_D_Vld
{
    _mSeatPosn_Abs_D_AR.SeatLgthHghtPosn_D_Vld.phys = getValue(this);
    _SeatPosn_Abs_D_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatLgthHghtPosnAbs_D
{
    _mSeatPosn_Abs_D_AR.SeatLgthHghtPosnAbs_D.phys = getValue(this);
    _SeatPosn_Abs_D_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatLgthHghtPosnRel_D
{
    _mSeatPosn_Abs_D_AR.SeatLgthHghtPosnRel_D.phys = getValue(this);
    _SeatPosn_Abs_D_AR_SpontanFlag = 1;
}

SeatPosn_Abs_P_AR_check_output()
{
    if( !getValue( HMI__STMSG_SeatPosn_Abs_P_AR ) )
    {
    //  message   SeatPosn_Abs_P_AR ID: 963 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _SeatPosn_Abs_P_AR_DelayCnt > 0) _SeatPosn_Abs_P_AR_DelayCnt--; // Mindestsendeabstand
        _SeatPosn_Abs_P_AR_Cnt--;
        if( _SeatPosn_Abs_P_AR_Cnt < 1 )
        {
            if( _SeatPosn_Abs_P_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                SeatPosn_Abs_P_AR_output();
                _SeatPosn_Abs_P_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SeatPosn_Abs_P_AR_DelayCnt = _SeatPosn_Abs_P_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _SeatPosn_Abs_P_AR_SpontanFlag = 1;
            }
            _SeatPosn_Abs_P_AR_Cnt = _SeatPosn_Abs_P_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _SeatPosn_Abs_P_AR_SpontanFlag)
        {
            if( _SeatPosn_Abs_P_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                SeatPosn_Abs_P_AR_output();
                _SeatPosn_Abs_P_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SeatPosn_Abs_P_AR_DelayCnt = _SeatPosn_Abs_P_AR_MinDelay;
            }
        }
    }
}

SeatPosn_Abs_P_AR_init()
{   /* Botschaft SeatPosn_Abs_P_AR ID: 963 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 963 0;
BA_ "NmAsrMessage" BO_ 963 0;
BA_ "GenMsgMinAcceptLength" BO_ 963 8;
BA_ "GenMsgILSupport" BO_ 963 1;
BA_ "DiagState" BO_ 963 0;
BA_ "DiagRequest" BO_ 963 0;
BA_ "DiagResponse" BO_ 963 0;
BA_ "GenMsgStartValue" BO_ 963 "0";
BA_ "GenMsgDelayTime" BO_ 963 100;
BA_ "GenMsgNrOfRepetitions" BO_ 963 0;
BA_ "GenMsgCycleTime" BO_ 963 1000;
BA_ "GenMsgSendType" BO_ 963 5;
    */
    _SeatPosn_Abs_P_AR_Timebase =        c_tDBKomTimer_20ms;
    _SeatPosn_Abs_P_AR_CycleCount =    1000 / _SeatPosn_Abs_P_AR_Timebase;
    _SeatPosn_Abs_P_AR_StartDelay =       0 / _SeatPosn_Abs_P_AR_Timebase;
    _SeatPosn_Abs_P_AR_MinDelay =       100 / _SeatPosn_Abs_P_AR_Timebase;
    _SeatPosn_Abs_P_AR_Cnt = _SeatPosn_Abs_P_AR_StartDelay;
    _SeatPosn_Abs_P_AR_SpontanFlag = 0;
    _SeatPosn_Abs_P_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_SeatPosn_Abs_P_AR, _SeatPosn_Abs_P_AR_StartDelay * _SeatPosn_Abs_P_AR_Timebase );

    _mSeatPosn_Abs_P_AR.SeatLgthHghtPosn_P_Vld.phys = getValue( HMI_SeatLgthHghtPosn_P_Vld );
    _mSeatPosn_Abs_P_AR.SeatLgthHghtPosnAbs_P.phys = getValue( HMI_SeatLgthHghtPosnAbs_P );
    _mSeatPosn_Abs_P_AR.SeatLgthHghtPosnRel_P.phys = getValue( HMI_SeatLgthHghtPosnRel_P );
    _mSeatPosn_Abs_P_AR.SeatLgthPosn_P_Vld.phys = getValue( HMI_SeatLgthPosn_P_Vld );
    _mSeatPosn_Abs_P_AR.SeatLgthPosnAbs_P.phys = getValue( HMI_SeatLgthPosnAbs_P );
    _mSeatPosn_Abs_P_AR.SeatLgthPosnRel_P.phys = getValue( HMI_SeatLgthPosnRel_P );
}

SeatPosn_Abs_P_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_SeatPosn_Abs_P ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_SeatPosn_Abs_P_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _SeatPosn_Abs_P_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _SeatPosn_Abs_P_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_SeatPosn_Abs_P_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _SeatPosn_Abs_P_AR_SQC_WrongSeqJump != 0 ) &&
            ( _SeatPosn_Abs_P_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _SeatPosn_Abs_P_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _SeatPosn_Abs_P_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _SeatPosn_Abs_P_AR_SQC_RepeatedCnt ) &&
            ( _SeatPosn_Abs_P_AR_E2E_Armed == 1  )    )
        {
            _SeatPosn_Abs_P_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_SeatPosn_Abs_P, SQC_help );
    }
    _mSeatPosn_Abs_P_AR.SQC_SeatPosn_Abs_P = SQC_help;

    if( getValue( HMI_CRC_SeatPosn_Abs_P_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_SeatPosn_Abs_P_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mSeatPosn_Abs_P_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mSeatPosn_Abs_P_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mSeatPosn_Abs_P_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mSeatPosn_Abs_P_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mSeatPosn_Abs_P_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mSeatPosn_Abs_P_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mSeatPosn_Abs_P_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mSeatPosn_Abs_P_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _SeatPosn_Abs_P_AR_CRC_Offset[ _mSeatPosn_Abs_P_AR.SQC_SeatPosn_Abs_P ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _SeatPosn_Abs_P_AR_CRC_ErrorCnt   && ( _SeatPosn_Abs_P_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_SeatPosn_Abs_P_Invalid )                                         )    )
            {
                crc++;
                if( _SeatPosn_Abs_P_AR_CRC_ErrorCnt > 0 )
                    _SeatPosn_Abs_P_AR_CRC_ErrorCnt--; 
            }
            _mSeatPosn_Abs_P_AR.CRC_SeatPosn_Abs_P = crc;
            putValue( HMI_CRC_SeatPosn_Abs_P, crc );
        }
        else
            _mSeatPosn_Abs_P_AR.CRC_SeatPosn_Abs_P = getValue( HMI_CRC_SeatPosn_Abs_P );
    }
    if( ( _SeatPosn_Abs_P_AR_MSG_DropCnt > 0 ) &&
        ( _SeatPosn_Abs_P_AR_E2E_Armed == 1  )    )
    {
        _SeatPosn_Abs_P_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mSeatPosn_Abs_P_AR );
        
    if( _SeatPosn_Abs_P_AR_E2E_Armed == 1 )
    {
        if ( ( _SeatPosn_Abs_P_AR_MSG_DropCnt == 0      ) &&
             ( _SeatPosn_Abs_P_AR_CRC_ErrorCnt == 0     ) &&
             ( _SeatPosn_Abs_P_AR_SQC_RepeatedCnt == 0  ) &&
             ( _SeatPosn_Abs_P_AR_SQC_WrongSeqJump == 0 )    )
        {
            _SeatPosn_Abs_P_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_SeatPosn_Abs_P_State, 0 );
        }
    }
}

SeatPosn_Abs_P_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SeatPosn_Abs_P_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SeatPosn_Abs_P := %X\n", getValue( HMI__STMSG_SeatPosn_Abs_P_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SeatPosn_Abs_P := %X\n", getValue( HMI__STMSGT_SeatPosn_Abs_P_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatLgthHghtPosn_P_Vld := %X\n", getValue( HMI_SeatLgthHghtPosn_P_Vld ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatLgthHghtPosnAbs_P := %X\n", getValue( HMI_SeatLgthHghtPosnAbs_P ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatLgthHghtPosnRel_P := %X\n", getValue( HMI_SeatLgthHghtPosnRel_P ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatLgthPosn_P_Vld := %X\n", getValue( HMI_SeatLgthPosn_P_Vld ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatLgthPosnAbs_P := %X\n", getValue( HMI_SeatLgthPosnAbs_P ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatLgthPosnRel_P := %X\n", getValue( HMI_SeatLgthPosnRel_P ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tSeatPosn_Abs_P_AR
{
    putValue( HMI__STMSG_SeatPosn_Abs_P_AR, 0 );
}

on EnvVar HMI__STMSG_SeatPosn_Abs_P_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SeatPosn_Abs_P_AR );
        if( tDelay > 0)    
            setTimer( _tSeatPosn_Abs_P_AR, tDelay );
        else
            putValue( HMI__STMSG_SeatPosn_Abs_P_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_SeatPosn_Abs_P_AR
{
    if( getValue( this ) )
        openPanel("SeatPosn_Abs_P_AR");
}

on envVar HMI_E2E_SeatPosn_Abs_P_Inject
{
    if( getValue( this ) )
    {
        _SeatPosn_Abs_P_AR_CRC_ErrorCnt = getValue( HMI_CRC_SeatPosn_Abs_P_ErrorCount );
        _SeatPosn_Abs_P_AR_SQC_TriggPos = getValue( HMI_SQC_SeatPosn_Abs_P_TriggerPosition );
        _SeatPosn_Abs_P_AR_SQC_WrongSeqJump = getValue( HMI_SQC_SeatPosn_Abs_P_WrongSeq );
        _SeatPosn_Abs_P_AR_SQC_RepeatedCnt = getValue( HMI_SQC_SeatPosn_Abs_P_Repeated );
        _SeatPosn_Abs_P_AR_MSG_DropCnt = getValue( HMI_SQC_SeatPosn_Abs_P_MSG_DropCnt );
        putValue( HMI_E2E_SeatPosn_Abs_P_State, 2 );
        _SeatPosn_Abs_P_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_SeatLgthHghtPosn_P_Vld
{
    _mSeatPosn_Abs_P_AR.SeatLgthHghtPosn_P_Vld.phys = getValue(this);
    _SeatPosn_Abs_P_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatLgthHghtPosnAbs_P
{
    _mSeatPosn_Abs_P_AR.SeatLgthHghtPosnAbs_P.phys = getValue(this);
    _SeatPosn_Abs_P_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatLgthHghtPosnRel_P
{
    _mSeatPosn_Abs_P_AR.SeatLgthHghtPosnRel_P.phys = getValue(this);
    _SeatPosn_Abs_P_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatLgthPosn_P_Vld
{
    _mSeatPosn_Abs_P_AR.SeatLgthPosn_P_Vld.phys = getValue(this);
    _SeatPosn_Abs_P_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatLgthPosnAbs_P
{
    _mSeatPosn_Abs_P_AR.SeatLgthPosnAbs_P.phys = getValue(this);
    _SeatPosn_Abs_P_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatLgthPosnRel_P
{
    _mSeatPosn_Abs_P_AR.SeatLgthPosnRel_P.phys = getValue(this);
    _SeatPosn_Abs_P_AR_SpontanFlag = 1;
}

SND_GEN_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_SND_GEN_Stat_AR ) )
    {
    //  message   SND_GEN_Stat_AR ID: 1210 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _SND_GEN_Stat_AR_DelayCnt > 0) _SND_GEN_Stat_AR_DelayCnt--; // Mindestsendeabstand
        _SND_GEN_Stat_AR_Cnt--;
        if( _SND_GEN_Stat_AR_Cnt < 1 )
        {
            if( _SND_GEN_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                SND_GEN_Stat_AR_output();
                _SND_GEN_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SND_GEN_Stat_AR_DelayCnt = _SND_GEN_Stat_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _SND_GEN_Stat_AR_SpontanFlag = 1;
            }
            _SND_GEN_Stat_AR_Cnt = _SND_GEN_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _SND_GEN_Stat_AR_SpontanFlag)
        {
            if( _SND_GEN_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                SND_GEN_Stat_AR_output();
                _SND_GEN_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SND_GEN_Stat_AR_DelayCnt = _SND_GEN_Stat_AR_MinDelay;
            }
        }
    }
}

SND_GEN_Stat_AR_init()
{   /* Botschaft SND_GEN_Stat_AR ID: 1210 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1210 0;
BA_ "NmAsrMessage" BO_ 1210 0;
BA_ "GenMsgMinAcceptLength" BO_ 1210 1;
BA_ "GenMsgILSupport" BO_ 1210 1;
BA_ "DiagState" BO_ 1210 0;
BA_ "DiagRequest" BO_ 1210 0;
BA_ "DiagResponse" BO_ 1210 0;
BA_ "GenMsgStartValue" BO_ 1210 "0";
BA_ "GenMsgDelayTime" BO_ 1210 100;
BA_ "GenMsgNrOfRepetitions" BO_ 1210 0;
BA_ "GenMsgCycleTime" BO_ 1210 600;
BA_ "GenMsgSendType" BO_ 1210 5;
    */
    _SND_GEN_Stat_AR_Timebase =            c_tDBKomTimer_20ms;
    _SND_GEN_Stat_AR_CycleCount =         600 / _SND_GEN_Stat_AR_Timebase;
    _SND_GEN_Stat_AR_StartDelay =           0 / _SND_GEN_Stat_AR_Timebase;
    _SND_GEN_Stat_AR_MinDelay =           100 / _SND_GEN_Stat_AR_Timebase;
    _SND_GEN_Stat_AR_Cnt = _SND_GEN_Stat_AR_StartDelay;
    _SND_GEN_Stat_AR_SpontanFlag = 0;
    _SND_GEN_Stat_AR_DelayCnt = 0;
    
    putValue( HMI__STMSGSD_SND_GEN_Stat_AR, _SND_GEN_Stat_AR_StartDelay * _SND_GEN_Stat_AR_Timebase );

    _mSND_GEN_Stat_AR.SND_GEN_Err.phys = getValue( HMI_SND_GEN_Err );
    _mSND_GEN_Stat_AR.SND_GEN_Md_Stat.phys = getValue( HMI_SND_GEN_Md_Stat );
}

SND_GEN_Stat_AR_output()
{
    output( _mSND_GEN_Stat_AR );
}

SND_GEN_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SND_GEN_Stat_AR\n", 37, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SND_GEN_Stat_AR := %X\n", getValue( HMI__STMSG_SND_GEN_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SND_GEN_Stat_AR := %X\n", getValue( HMI__STMSGT_SND_GEN_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SND_GEN_Err := %X\n", getValue( HMI_SND_GEN_Err ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SND_GEN_Md_Stat := %X\n", getValue( HMI_SND_GEN_Md_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tSND_GEN_Stat_AR
{
    putValue( HMI__STMSG_SND_GEN_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_SND_GEN_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SND_GEN_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tSND_GEN_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_SND_GEN_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_SND_GEN_Stat_AR
{
    if( getValue( this ) )
        openPanel("SND_GEN_Stat_AR");
}

on EnvVar HMI_SND_GEN_Err
{
    _mSND_GEN_Stat_AR.SND_GEN_Err.phys = getValue(this);
    _SND_GEN_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SND_GEN_Md_Stat
{
    _mSND_GEN_Stat_AR.SND_GEN_Md_Stat.phys = getValue(this);
    _SND_GEN_Stat_AR_SpontanFlag = 1;
}

SONAR_A1_AR2_DAI_check_output()
{
    if( !getValue( HMI__STMSG_SONAR_A1_AR2_DAI ) )
    {
    //  message   SONAR_A1_AR2_DAI ID: 2429288448 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _SONAR_A1_AR2_DAI_DelayCnt > 0) _SONAR_A1_AR2_DAI_DelayCnt--; // Mindestsendeabstand
        _SONAR_A1_AR2_DAI_Cnt--;
        if( _SONAR_A1_AR2_DAI_Cnt < 1 )
        {
            if( _SONAR_A1_AR2_DAI_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                SONAR_A1_AR2_DAI_output();
                _SONAR_A1_AR2_DAI_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SONAR_A1_AR2_DAI_DelayCnt = _SONAR_A1_AR2_DAI_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _SONAR_A1_AR2_DAI_SpontanFlag = 1;
            }
            _SONAR_A1_AR2_DAI_Cnt = _SONAR_A1_AR2_DAI_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _SONAR_A1_AR2_DAI_SpontanFlag)
        {
            if( _SONAR_A1_AR2_DAI_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                SONAR_A1_AR2_DAI_output();
                _SONAR_A1_AR2_DAI_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SONAR_A1_AR2_DAI_DelayCnt = _SONAR_A1_AR2_DAI_MinDelay;
            }
        }
    }
}

SONAR_A1_AR2_DAI_init()
{   /* Botschaft SONAR_A1_AR2_DAI ID: 2429288448   --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 2429288448 0;
BA_ "NmAsrMessage" BO_ 2429288448 0;
BA_ "GenMsgMinAcceptLength" BO_ 2429288448 8;
BA_ "GenMsgILSupport" BO_ 2429288448 1;
BA_ "DiagState" BO_ 2429288448 0;
BA_ "DiagRequest" BO_ 2429288448 0;
BA_ "DiagResponse" BO_ 2429288448 0;
BA_ "GenMsgStartValue" BO_ 2429288448 "0";
BA_ "GenMsgDelayTime" BO_ 2429288448 100;
BA_ "GenMsgNrOfRepetitions" BO_ 2429288448 0;
BA_ "GenMsgCycleTime" BO_ 2429288448 500;
BA_ "GenMsgSendType" BO_ 2429288448 5;
    */
    _SONAR_A1_AR2_DAI_Timebase =                c_tDBKomTimer_20ms;
    _SONAR_A1_AR2_DAI_CycleCount =             500 / _SONAR_A1_AR2_DAI_Timebase;
    _SONAR_A1_AR2_DAI_StartDelay =               0 / _SONAR_A1_AR2_DAI_Timebase;
    _SONAR_A1_AR2_DAI_MinDelay =               100 / _SONAR_A1_AR2_DAI_Timebase;
    _SONAR_A1_AR2_DAI_Cnt = _SONAR_A1_AR2_DAI_StartDelay;
    _SONAR_A1_AR2_DAI_SpontanFlag = 0;
    _SONAR_A1_AR2_DAI_DelayCnt = 0;
	
	putValue( HMI__STMSGSD_SONAR_A1_AR2_DAI, _SONAR_A1_AR2_DAI_StartDelay * _SONAR_A1_AR2_DAI_Timebase );

    _mSONAR_A1_AR2_DAI.BSWson_ActivationDisplay.phys = getValue( HMI_BSWson_ActivationDisplay );
    _mSONAR_A1_AR2_DAI.BSWson_ActivationState.phys = getValue( HMI_BSWson_ActivationState );
    _mSONAR_A1_AR2_DAI.BSWson_FailureDisplayRequest.phys = getValue( HMI_BSWson_FailureDisplayRequest );
    _mSONAR_A1_AR2_DAI.FrontParkAssistState.phys = getValue( HMI_FrontParkAssistState );
	_mSONAR_A1_AR2_DAI.ParkAssistSensitivityStatus.phys = getValue( HMI_ParkAssistSensitivityStatus );
    _mSONAR_A1_AR2_DAI.PSM_DisplayRequest.phys = getValue( HMI_PSM_DisplayRequest );
    _mSONAR_A1_AR2_DAI.PSM_SoundRequest.phys = getValue( HMI_PSM_SoundRequest );
    _mSONAR_A1_AR2_DAI.PSM_WarningDisplayRequest.phys = getValue( HMI_PSM_WarningDisplayRequest );
    _mSONAR_A1_AR2_DAI.RearParkAssistState.phys = getValue( HMI_RearParkAssistState );
    _mSONAR_A1_AR2_DAI.SlotLeftDifficultyLevel.phys = getValue( HMI_SlotLeftDifficultyLevel );
    _mSONAR_A1_AR2_DAI.SlotLeftSuitableForDisplay.phys = getValue( HMI_SlotLeftSuitableForDisplay );
    _mSONAR_A1_AR2_DAI.SlotRightDifficultyLevel.phys = getValue( HMI_SlotRightDifficultyLevel );
    _mSONAR_A1_AR2_DAI.SlotRightSuitableForDisplay.phys = getValue( HMI_SlotRightSuitableForDisplay );
    _mSONAR_A1_AR2_DAI.SonarAutoDisplayState.phys = getValue( HMI_SonarAutoDisplayState );
    _mSONAR_A1_AR2_DAI.SonarSystemPauseStatus.phys = getValue( HMI_SonarSystemPauseStatus );
 
}

SONAR_A1_AR2_DAI_output(void)
{
    output( _mSONAR_A1_AR2_DAI );
}

SONAR_A1_AR2_DAI_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SONAR_A1_AR2_DAI\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SONAR_A1_AR2_DAI := %X\n", getValue( HMI__STMSG_SONAR_A1_AR2_DAI ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SONAR_A1_AR2_DAI := %X\n", getValue( HMI__STMSGT_SONAR_A1_AR2_DAI ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSWson_ActivationDisplay := %X\n", getValue( HMI_BSWson_ActivationDisplay ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSWson_ActivationState := %X\n", getValue( HMI_BSWson_ActivationState ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSWson_FailureDisplayRequest := %X\n", getValue( HMI_BSWson_FailureDisplayRequest ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FrontParkAssistState := %X\n", getValue( HMI_FrontParkAssistState ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkAssistSensitivityStatus := %X\n", getValue( HMI_ParkAssistSensitivityStatus ) );		filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PSM_DisplayRequest := %X\n", getValue( HMI_PSM_DisplayRequest ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PSM_SoundRequest := %X\n", getValue( HMI_PSM_SoundRequest ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PSM_WarningDisplayRequest := %X\n", getValue( HMI_PSM_WarningDisplayRequest ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RearParkAssistState := %X\n", getValue( HMI_RearParkAssistState ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SlotLeftDifficultyLevel := %X\n", getValue( HMI_SlotLeftDifficultyLevel ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SlotLeftSuitableForDisplay := %X\n", getValue( HMI_SlotLeftSuitableForDisplay ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SlotRightDifficultyLevel := %X\n", getValue( HMI_SlotRightDifficultyLevel ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SlotRightSuitableForDisplay := %X\n", getValue( HMI_SlotRightSuitableForDisplay ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_SonarAutoDisplayState := %X\n", getValue( HMI_SonarAutoDisplayState ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SonarSystemPauseStatus := %X\n", getValue( HMI_SonarSystemPauseStatus ) );        filePutString( buffer, elcount( buffer ), hFile );
   
}

on timer _tSONAR_A1_AR2_DAI
{
    putValue( HMI__STMSG_SONAR_A1_AR2_DAI, 0 );
}

on EnvVar HMI__STMSG_SONAR_A1_AR2_DAI
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SONAR_A1_AR2_DAI );
        if( tDelay > 0)    
            setTimer( _tSONAR_A1_AR2_DAI, tDelay );
        else
            putValue( HMI__STMSG_SONAR_A1_AR2_DAI, 0 );
    }
}

on envVar HMI__STMSG_PO_SONAR_A1_AR2_DAI
{
    if( getValue( this ) )
        openPanel("SONAR_A1_AR2_DAI");
}

on EnvVar HMI_BSWson_ActivationDisplay
{
    _mSONAR_A1_AR2_DAI.BSWson_ActivationDisplay.phys = getValue(this);
    _SONAR_A1_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_BSWson_ActivationState
{
    _mSONAR_A1_AR2_DAI.BSWson_ActivationState.phys = getValue(this);
    _SONAR_A1_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_BSWson_FailureDisplayRequest
{
    _mSONAR_A1_AR2_DAI.BSWson_FailureDisplayRequest.phys = getValue(this);
    _SONAR_A1_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FrontParkAssistState
{
    _mSONAR_A1_AR2_DAI.FrontParkAssistState.phys = getValue(this);
    _SONAR_A1_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_ParkAssistSensitivityStatus
{
	_mSONAR_A1_AR2_DAI.ParkAssistSensitivityStatus.phys = getValue(this);
	_SONAR_A1_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_RearParkAssistState
{
	_mSONAR_A1_AR2_DAI.RearParkAssistState.phys=getValue(this);
	_SONAR_A1_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_PSM_DisplayRequest
{
    _mSONAR_A1_AR2_DAI.PSM_DisplayRequest.phys = getValue(this);
    _SONAR_A1_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_PSM_SoundRequest
{
    _mSONAR_A1_AR2_DAI.PSM_SoundRequest.phys = getValue(this);
    _SONAR_A1_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_PSM_WarningDisplayRequest
{
    _mSONAR_A1_AR2_DAI.PSM_WarningDisplayRequest.phys = getValue(this);
    _SONAR_A1_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_SlotLeftDifficultyLevel
{
    _mSONAR_A1_AR2_DAI.SlotLeftDifficultyLevel.phys = getValue(this);
    _SONAR_A1_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_SlotLeftSuitableForDisplay
{
    _mSONAR_A1_AR2_DAI.SlotLeftSuitableForDisplay.phys = getValue(this);
    _SONAR_A1_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_SlotRightDifficultyLevel	
{
    _mSONAR_A1_AR2_DAI.SlotRightDifficultyLevel.phys = getValue(this);
    _SONAR_A1_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_SlotRightSuitableForDisplay	
{
    _mSONAR_A1_AR2_DAI.SlotRightSuitableForDisplay.phys = getValue(this);
    _SONAR_A1_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_SonarAutoDisplayState	
{
    _mSONAR_A1_AR2_DAI.SonarAutoDisplayState.phys = getValue(this);
    _SONAR_A1_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_SonarSystemPauseStatus	
{
    _mSONAR_A1_AR2_DAI.SonarSystemPauseStatus.phys = getValue(this);
    _SONAR_A1_AR2_DAI_SpontanFlag = 1;
}


SONAR_A3_AR2_DAI_check_output()
{
    if( !getValue( HMI__STMSG_SONAR_A3_AR2_DAI ) )
    {
    //  message   SONAR_A3_AR2_DAI ID: 2429550592 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _SONAR_A3_AR2_DAI_DelayCnt > 0) _SONAR_A3_AR2_DAI_DelayCnt--; // Mindestsendeabstand
        _SONAR_A3_AR2_DAI_Cnt--;
        if( _SONAR_A3_AR2_DAI_Cnt < 1 )
        {
            if( _SONAR_A3_AR2_DAI_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                SONAR_A3_AR2_DAI_output();
                _SONAR_A3_AR2_DAI_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SONAR_A3_AR2_DAI_DelayCnt = _SONAR_A3_AR2_DAI_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _SONAR_A3_AR2_DAI_SpontanFlag = 1;
            }
            _SONAR_A3_AR2_DAI_Cnt = _SONAR_A3_AR2_DAI_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _SONAR_A3_AR2_DAI_SpontanFlag)
        {
            if( _SONAR_A3_AR2_DAI_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                SONAR_A3_AR2_DAI_output();
                _SONAR_A3_AR2_DAI_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SONAR_A3_AR2_DAI_DelayCnt = _SONAR_A3_AR2_DAI_MinDelay;
            }
        }
    }
}

SONAR_A3_AR2_DAI_init()
{   /* Botschaft SONAR_A3_AR2_DAI ID: 2429550592   --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 2429550592 0;
BA_ "NmAsrMessage" BO_ 2429550592 0;
BA_ "GenMsgMinAcceptLength" BO_ 2429550592 8;
BA_ "GenMsgILSupport" BO_ 2429550592 1;
BA_ "DiagState" BO_ 2429550592 0;
BA_ "DiagRequest" BO_ 2429550592 0;
BA_ "DiagResponse" BO_ 2429550592 0;
BA_ "GenMsgStartValue" BO_ 2429550592 "0";
BA_ "GenMsgDelayTime" BO_ 2429550592 100;
BA_ "GenMsgNrOfRepetitions" BO_ 2429550592 0;
BA_ "GenMsgCycleTime" BO_ 2429550592 500;
BA_ "GenMsgSendType" BO_ 2429550592 5;
    */
    _SONAR_A3_AR2_DAI_Timebase =                c_tDBKomTimer_20ms;
    _SONAR_A3_AR2_DAI_CycleCount =             500 / _SONAR_A3_AR2_DAI_Timebase;
    _SONAR_A3_AR2_DAI_StartDelay =               0 / _SONAR_A3_AR2_DAI_Timebase;
    _SONAR_A3_AR2_DAI_MinDelay =               100 / _SONAR_A3_AR2_DAI_Timebase;
    _SONAR_A3_AR2_DAI_Cnt = _SONAR_A3_AR2_DAI_StartDelay;
    _SONAR_A3_AR2_DAI_SpontanFlag = 0;
    _SONAR_A3_AR2_DAI_DelayCnt = 0;
	
	putValue( HMI__STMSGSD_SONAR_A3_AR2_DAI, _SONAR_A3_AR2_DAI_StartDelay * _SONAR_A3_AR2_DAI_Timebase );

    _mSONAR_A3_AR2_DAI.FKP_ActivationStatus.phys = getValue( HMI_FKP_ActivationStatus );
    _mSONAR_A3_AR2_DAI.FKP_FrontFrontL_Hatch.phys = getValue( HMI_FKP_FrontFrontL_Hatch );
    _mSONAR_A3_AR2_DAI.FKP_FrontFrontL_Scan.phys = getValue( HMI_FKP_FrontFrontL_Scan );
    _mSONAR_A3_AR2_DAI.FKP_FrontFrontR_Hatch.phys = getValue( HMI_FKP_FrontFrontR_Hatch );
    _mSONAR_A3_AR2_DAI.FKP_FrontFrontR_Scan.phys = getValue( HMI_FKP_FrontFrontR_Scan );
    _mSONAR_A3_AR2_DAI.FKP_FrontMiddleL_Hatch.phys = getValue( HMI_FKP_FrontMiddleL_Hatch );
    //_mSONAR_A3_AR2_DAI.FKP_FrontMiddleL_Scan.phys = getValue( HMI__FKP_FrontMiddleL_Scan );
    _mSONAR_A3_AR2_DAI.FKP_FrontMiddleR_Hatch.phys = getValue( HMI_FKP_FrontMiddleR_Hatch );
    _mSONAR_A3_AR2_DAI.FKP_FrontMiddleR_Scan.phys = getValue( HMI_FKP_FrontMiddleR_Scan );
    _mSONAR_A3_AR2_DAI.FKP_ImageDisplayRequest.phys = getValue( HMI_FKP_ImageDisplayRequest );
    _mSONAR_A3_AR2_DAI.FKP_ObstacleZone_LF.phys = getValue( HMI_FKP_ObstacleZone_LF );
    _mSONAR_A3_AR2_DAI.FKP_ObstacleZone_LFC.phys = getValue( HMI_FKP_ObstacleZone_LFC );
    _mSONAR_A3_AR2_DAI.FKP_ObstacleZone_LRC.phys = getValue( HMI_FKP_ObstacleZone_LRC );
	_mSONAR_A3_AR2_DAI.FKP_ObstacleZone_RF.phys = getValue( HMI_FKP_ObstacleZone_RF );
    _mSONAR_A3_AR2_DAI.FKP_ObstacleZone_RFC.phys = getValue( HMI_FKP_ObstacleZone_RFC );
    _mSONAR_A3_AR2_DAI.FKP_ObstacleZone_RL.phys = getValue( HMI_FKP_ObstacleZone_RL );
    _mSONAR_A3_AR2_DAI.FKP_ObstacleZone_RR.phys = getValue( HMI_FKP_ObstacleZone_RR );
    _mSONAR_A3_AR2_DAI.FKP_ObstacleZone_RRC.phys = getValue( HMI_FKP_ObstacleZone_RRC );
    _mSONAR_A3_AR2_DAI.FKP_RearMiddleL_Hatch.phys = getValue( HMI_FKP_RearMiddleL_Hatch );
    _mSONAR_A3_AR2_DAI.FKP_RearMiddleL_Scan.phys = getValue( HMI_FKP_RearMiddleL_Scan );
    _mSONAR_A3_AR2_DAI.FKP_RearMiddleR_Hatch.phys = getValue( HMI_FKP_RearMiddleR_Hatch );
    _mSONAR_A3_AR2_DAI.FKP_RearMiddleR_Scan.phys = getValue( HMI_FKP_RearMiddleR_Scan );
    _mSONAR_A3_AR2_DAI.FKP_RearRearL_Hatch.phys = getValue( HMI_FKP_RearRearL_Hatch );
    _mSONAR_A3_AR2_DAI.FKP_RearRearL_Scan.phys = getValue( HMI_FKP_RearRearL_Scan );
    _mSONAR_A3_AR2_DAI.FKP_RearRearR_Hatch.phys = getValue( HMI_FKP_RearRearR_Hatch );
    _mSONAR_A3_AR2_DAI.FKP_RearRearR_Scan.phys = getValue( HMI_FKP_RearRearR_Scan );
    _mSONAR_A3_AR2_DAI.UPA_FrontLeft_Hatch.phys = getValue( HMI_UPA_FrontLeft_Hatch );
	_mSONAR_A3_AR2_DAI.UPA_FrontLeft_Hatch.phys = getValue( HMI_UPA_FrontLeft_Hatch );
    _mSONAR_A3_AR2_DAI.UPA_FrontMiddle_Hatch.phys = getValue( HMI_UPA_FrontMiddle_Hatch );
    _mSONAR_A3_AR2_DAI.UPA_FrontRight_Hatch.phys = getValue( HMI_UPA_FrontRight_Hatch );
    _mSONAR_A3_AR2_DAI.UPA_RearLeft_Hatch.phys = getValue( HMI_UPA_RearLeft_Hatch );
    _mSONAR_A3_AR2_DAI.UPA_RearMiddle_Hatch.phys = getValue( HMI_UPA_RearMiddle_Hatch );
 
	
}

SONAR_A3_AR2_DAI_output(void)
{
    output( _mSONAR_A3_AR2_DAI );
}

SONAR_A3_AR2_DAI_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SONAR_A3_AR2_DAI\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SONAR_A3_AR2_DAI := %X\n", getValue( HMI__STMSG_SONAR_A3_AR2_DAI ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SONAR_A3_AR2_DAI := %X\n", getValue( HMI__STMSGT_SONAR_A3_AR2_DAI ) );        filePutString( buffer, elcount( buffer ), hFile );
   
   snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_ActivationStatus := %X\n", getValue( HMI_FKP_ActivationStatus ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_FrontFrontL_Hatch := %X\n", getValue( HMI_FKP_FrontFrontL_Hatch ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_FrontFrontL_Scan := %X\n", getValue( HMI_FKP_FrontFrontL_Scan ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_FrontFrontR_Hatch := %X\n", getValue( HMI_FKP_FrontFrontR_Hatch ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_FrontFrontR_Scan := %X\n", getValue( HMI_FKP_FrontFrontR_Scan ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_FrontMiddleL_Hatch := %X\n", getValue( HMI_FKP_FrontMiddleL_Hatch ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_FrontMiddleL_Scan := %X\n", getValue( HMI_FKP_FrontMiddleL_Scan ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_FrontMiddleR_Hatch := %X\n", getValue( HMI_FKP_FrontMiddleR_Hatch ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_FrontMiddleR_Scan := %X\n", getValue( HMI_FKP_FrontMiddleR_Scan ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_ImageDisplayRequest := %X\n", getValue( HMI_FKP_ImageDisplayRequest ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_ObstacleZone_LF := %X\n", getValue( HMI_FKP_ObstacleZone_LF ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_ObstacleZone_LFC := %X\n", getValue( HMI_FKP_ObstacleZone_LFC ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_ObstacleZone_LRC := %X\n", getValue( HMI_FKP_ObstacleZone_LRC ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_ObstacleZone_RF := %X\n", getValue( HMI_FKP_ObstacleZone_RF ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_ObstacleZone_RFC := %X\n", getValue( HMI_FKP_ObstacleZone_RFC ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_ObstacleZone_RL := %X\n", getValue( HMI_FKP_ObstacleZone_RL ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_ObstacleZone_RR := %X\n", getValue( HMI_FKP_ObstacleZone_RR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_ObstacleZone_RRC := %X\n", getValue( HMI_FKP_ObstacleZone_RRC ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_RearMiddleL_Hatch := %X\n", getValue( HMI_FKP_RearMiddleL_Hatch ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_RearMiddleL_Scan := %X\n", getValue( HMI_FKP_RearMiddleL_Scan ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_RearMiddleR_Hatch := %X\n", getValue( HMI_FKP_RearMiddleR_Hatch ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_RearMiddleR_Scan := %X\n", getValue( HMI_FKP_RearMiddleR_Scan ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_RearRearL_Hatch := %X\n", getValue( HMI_FKP_RearRearL_Hatch ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_RearRearL_Scan := %X\n", getValue( HMI_FKP_RearRearL_Scan ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_RearRearR_Hatch := %X\n", getValue( HMI_FKP_RearRearR_Hatch ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FKP_RearRearR_Scan := %X\n", getValue( HMI_FKP_RearRearR_Scan ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_FrontLeft_Hatch := %X\n", getValue( HMI_UPA_FrontLeft_Hatch ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_FrontMiddle_Hatch := %X\n", getValue( HMI_UPA_FrontMiddle_Hatch ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_FrontRight_Hatch := %X\n", getValue( HMI_UPA_FrontRight_Hatch ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_RearLeft_Hatch := %X\n", getValue( HMI_UPA_RearLeft_Hatch ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_RearMiddle_Hatch := %X\n", getValue( HMI_UPA_RearMiddle_Hatch ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_RearRight_Hatch := %X\n", getValue( HMI_UPA_RearRight_Hatch ) );        filePutString( buffer, elcount( buffer ), hFile );
   
}

on timer _tSONAR_A3_AR2_DAI
{
    putValue( HMI__STMSG_SONAR_A3_AR2_DAI, 0 );
}

on EnvVar HMI__STMSG_SONAR_A3_AR2_DAI
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SONAR_A3_AR2_DAI );
        if( tDelay > 0)    
            setTimer( _tSONAR_A3_AR2_DAI, tDelay );
        else
            putValue( HMI__STMSG_SONAR_A3_AR2_DAI, 0 );
    }
}


on envVar HMI__STMSG_PO_SONAR_A3_AR2_DAI
{
    if( getValue( this ) )
        openPanel("SONAR_A3_AR2_DAI");
}


on EnvVar HMI_FKP_ActivationStatus
{
    _mSONAR_A3_AR2_DAI.FKP_ActivationStatus.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_FrontFrontL_Hatch
{
    _mSONAR_A3_AR2_DAI.FKP_FrontFrontL_Hatch.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_FrontFrontL_Scan
{
    _mSONAR_A3_AR2_DAI.FKP_FrontFrontL_Scan.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_FrontFrontR_Hatch
{
    _mSONAR_A3_AR2_DAI.FKP_FrontFrontR_Hatch.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_FrontFrontR_Scan
{
    _mSONAR_A3_AR2_DAI.FKP_FrontFrontR_Scan.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_FrontMiddleL_Hatch
{
    _mSONAR_A3_AR2_DAI.FKP_FrontMiddleL_Hatch.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_FrontMiddleL_Scan
{
    _mSONAR_A3_AR2_DAI.FKP_FrontMiddleL_Scan.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_FrontMiddleR_Hatch
{
    _mSONAR_A3_AR2_DAI.FKP_FrontMiddleR_Hatch.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_FrontMiddleR_Scan
{
    _mSONAR_A3_AR2_DAI.FKP_FrontMiddleR_Scan.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_ImageDisplayRequest	
{
    _mSONAR_A3_AR2_DAI.FKP_ImageDisplayRequest.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_ObstacleZone_LF	
{
    _mSONAR_A3_AR2_DAI.FKP_ObstacleZone_LF.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_ObstacleZone_LFC	
{
    _mSONAR_A3_AR2_DAI.FKP_ObstacleZone_LFC.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_ObstacleZone_LRC	
{
    _mSONAR_A3_AR2_DAI.FKP_ObstacleZone_LRC.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_ObstacleZone_RF	
{
    _mSONAR_A3_AR2_DAI.FKP_ObstacleZone_RF.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_ObstacleZone_RFC	
{
    _mSONAR_A3_AR2_DAI.FKP_ObstacleZone_RFC.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_ObstacleZone_RL	
{
    _mSONAR_A3_AR2_DAI.FKP_ObstacleZone_RL.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_ObstacleZone_RR	
{
    _mSONAR_A3_AR2_DAI.FKP_ObstacleZone_RR.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_ObstacleZone_RRC	
{
    _mSONAR_A3_AR2_DAI.FKP_ObstacleZone_RRC.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_RearMiddleL_Hatch	
{
    _mSONAR_A3_AR2_DAI.FKP_RearMiddleL_Hatch.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_RearMiddleL_Scan	
{
    _mSONAR_A3_AR2_DAI.FKP_RearMiddleL_Scan.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_RearMiddleR_Hatch	
{
    _mSONAR_A3_AR2_DAI.FKP_RearMiddleR_Hatch.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_RearMiddleR_Scan	
{
    _mSONAR_A3_AR2_DAI.FKP_RearMiddleR_Scan.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_RearRearL_Hatch	
{
    _mSONAR_A3_AR2_DAI.FKP_RearRearL_Hatch.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_RearRearL_Scan	
{
    _mSONAR_A3_AR2_DAI.FKP_RearRearL_Scan.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_RearRearR_Hatch	
{
    _mSONAR_A3_AR2_DAI.FKP_RearRearR_Hatch.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_FKP_RearRearR_Scan	
{
    _mSONAR_A3_AR2_DAI.FKP_RearRearR_Scan.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_FrontLeft_Hatch	
{
    _mSONAR_A3_AR2_DAI.UPA_FrontLeft_Hatch.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_FrontMiddle_Hatch	
{
    _mSONAR_A3_AR2_DAI.UPA_FrontMiddle_Hatch.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_FrontRight_Hatch	
{
    _mSONAR_A3_AR2_DAI.UPA_FrontRight_Hatch.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_RearLeft_Hatch	
{
    _mSONAR_A3_AR2_DAI.UPA_RearLeft_Hatch.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_RearMiddle_Hatch	
{
    _mSONAR_A3_AR2_DAI.UPA_RearMiddle_Hatch.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_RearRight_Hatch	
{
    _mSONAR_A3_AR2_DAI.UPA_RearRight_Hatch.phys = getValue(this);
    _SONAR_A3_AR2_DAI_SpontanFlag = 1;
}

SONAR_A4_AR2_DAI_check_output()
{
    if( !getValue( HMI__STMSG_SONAR_A4_AR2_DAI ) )
    {
    //  message   SONAR_A4_AR2_DAI ID: 2429288448 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _SONAR_A4_AR2_DAI_DelayCnt > 0) _SONAR_A4_AR2_DAI_DelayCnt--; // Mindestsendeabstand
        _SONAR_A4_AR2_DAI_Cnt--;
        if( _SONAR_A4_AR2_DAI_Cnt < 1 )
        {
            if( _SONAR_A4_AR2_DAI_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                SONAR_A4_AR2_DAI_output();
                _SONAR_A4_AR2_DAI_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SONAR_A4_AR2_DAI_DelayCnt = _SONAR_A4_AR2_DAI_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _SONAR_A4_AR2_DAI_SpontanFlag = 1;
            }
            _SONAR_A4_AR2_DAI_Cnt = _SONAR_A4_AR2_DAI_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _SONAR_A4_AR2_DAI_SpontanFlag)
        {
            if( _SONAR_A4_AR2_DAI_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                SONAR_A4_AR2_DAI_output();
                _SONAR_A4_AR2_DAI_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SONAR_A4_AR2_DAI_DelayCnt = _SONAR_A4_AR2_DAI_MinDelay;
            }
        }
    }
}

SONAR_A4_AR2_DAI_init()
{   /* Botschaft SONAR_A4_AR2_DAI ID: 2429812736   --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 2429812736 0;
BA_ "NmAsrMessage" BO_ 2429812736 0;
BA_ "GenMsgMinAcceptLength" BO_ 2429812736 8;
BA_ "GenMsgILSupport" BO_ 2429812736 1;
BA_ "DiagState" BO_ 2429812736 0;
BA_ "DiagRequest" BO_ 2429812736 0;
BA_ "DiagResponse" BO_ 2429812736 0;
BA_ "GenMsgStartValue" BO_ 2429812736 "0";
BA_ "GenMsgDelayTime" BO_ 2429812736 100;
BA_ "GenMsgNrOfRepetitions" BO_ 2429812736 0;
BA_ "GenMsgCycleTime" BO_ 2429812736 500;
BA_ "GenMsgSendType" BO_ 2429812736 5;
    */
    _SONAR_A4_AR2_DAI_Timebase =                c_tDBKomTimer_20ms;
    _SONAR_A4_AR2_DAI_CycleCount =             500 / _SONAR_A4_AR2_DAI_Timebase;
    _SONAR_A4_AR2_DAI_StartDelay =               0 / _SONAR_A4_AR2_DAI_Timebase;
    _SONAR_A4_AR2_DAI_MinDelay =               100 / _SONAR_A4_AR2_DAI_Timebase;
    _SONAR_A4_AR2_DAI_Cnt = _SONAR_A4_AR2_DAI_StartDelay;
    _SONAR_A4_AR2_DAI_SpontanFlag = 0;
    _SONAR_A4_AR2_DAI_DelayCnt = 0;
	
	putValue( HMI__STMSGSD_SONAR_A4_AR2_DAI, _SONAR_A4_AR2_DAI_StartDelay * _SONAR_A4_AR2_DAI_Timebase );

    _mSONAR_A4_AR2_DAI.BSWson_FunctionnalStatus.phys = getValue( HMI_BSWson_FunctionnalStatus );
    _mSONAR_A4_AR2_DAI.ParkAssistVolumeState.phys = getValue( HMI_ParkAssistVolumeState );
    _mSONAR_A4_AR2_DAI.SensorAvailabilityFrontCenter.phys = getValue( HMI_SensorAvailabilityFrontCenter );
    _mSONAR_A4_AR2_DAI.SensorAvailabilityFrontLeft.phys = getValue( HMI_SensorAvailabilityFrontLeft );
    _mSONAR_A4_AR2_DAI.SensorAvailabilityFrontRight.phys = getValue( HMI_SensorAvailabilityFrontRight );
    _mSONAR_A4_AR2_DAI.SensorAvailabilityRearCenter.phys = getValue( HMI_SensorAvailabilityRearCenter );
    _mSONAR_A4_AR2_DAI.SensorAvailabilityRearLeft.phys = getValue( HMI_SensorAvailabilityRearLeft );
    _mSONAR_A4_AR2_DAI.SensorAvailabilityRearRight.phys = getValue( HMI_SensorAvailabilityRearRight );
    _mSONAR_A4_AR2_DAI.SonarObstacleDistanceDisplay.phys = getValue( HMI_SonarObstacleDistanceDisplay );
    _mSONAR_A4_AR2_DAI.UPA_ClosingAuthorization.phys = getValue( HMI_UPA_ClosingAuthorization );
    _mSONAR_A4_AR2_DAI.UPA_Image_DisplayRequest.phys = getValue( HMI_UPA_Image_DisplayRequest );
    _mSONAR_A4_AR2_DAI.UPA_Obstacle_Zone_Front_Center.phys = getValue( HMI_UPA_Obstacle_Zone_Front_Center );
    _mSONAR_A4_AR2_DAI.UPA_Obstacle_Zone_Front_Left.phys = getValue( HMI_UPA_Obstacle_Zone_Front_Left );
    _mSONAR_A4_AR2_DAI.UPA_Obstacle_Zone_Front_Right.phys = getValue( HMI_UPA_Obstacle_Zone_Front_Right );
	_mSONAR_A4_AR2_DAI.UPA_Obstacle_Zone_Rear_Center.phys = getValue( HMI_UPA_Obstacle_Zone_Rear_Center );
    _mSONAR_A4_AR2_DAI.UPA_Obstacle_Zone_Rear_Left.phys = getValue( HMI_UPA_Obstacle_Zone_Rear_Left );
    _mSONAR_A4_AR2_DAI.UPA_Obstacle_Zone_Rear_Right.phys = getValue( HMI_UPA_Obstacle_Zone_Rear_Right );
    _mSONAR_A4_AR2_DAI.UPA_SoundActivationBeep.phys = getValue( HMI_UPA_SoundActivationBeep );
    _mSONAR_A4_AR2_DAI.UPA_SoundErrorBeep.phys = getValue( HMI_UPA_SoundErrorBeep );
    _mSONAR_A4_AR2_DAI.UPA_SoundObstacleZone.phys = getValue( HMI_UPA_SoundObstacleZone );
    _mSONAR_A4_AR2_DAI.UPA_SoundRecurrencePeriod.phys = getValue( HMI_UPA_SoundRecurrencePeriod );
    _mSONAR_A4_AR2_DAI.UPA_SoundRecurrenceType.phys = getValue( HMI_UPA_SoundRecurrenceType );
    _mSONAR_A4_AR2_DAI.UPA_SystemState.phys = getValue( HMI_UPA_SystemState );
    _mSONAR_A4_AR2_DAI.UPAStatusDisplayRequest.phys = getValue( HMI_UPAStatusDisplayRequest );
 
}

SONAR_A4_AR2_DAI_output(void)
{
    output( _mSONAR_A4_AR2_DAI );
}

SONAR_A4_AR2_DAI_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SONAR_A4_AR2_DAI\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SONAR_A4_AR2_DAI := %X\n", getValue( HMI__STMSG_SONAR_A4_AR2_DAI ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SONAR_A4_AR2_DAI := %X\n", getValue( HMI__STMSGT_SONAR_A4_AR2_DAI ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSWson_FunctionnalStatus := %X\n", getValue( HMI_BSWson_FunctionnalStatus ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkAssistVolumeState := %X\n", getValue( HMI_ParkAssistVolumeState ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SensorAvailabilityFrontCenter := %X\n", getValue( HMI_SensorAvailabilityFrontCenter ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SensorAvailabilityFrontLeft := %X\n", getValue( HMI_SensorAvailabilityFrontLeft ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SensorAvailabilityFrontRight := %X\n", getValue( HMI_SensorAvailabilityFrontRight ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SensorAvailabilityRearCenter := %X\n", getValue( HMI_SensorAvailabilityRearCenter ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SensorAvailabilityRearLeft := %X\n", getValue( HMI_SensorAvailabilityRearLeft ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SensorAvailabilityRearRight := %X\n", getValue( HMI_SensorAvailabilityRearRight ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SonarObstacleDistanceDisplay := %X\n", getValue( HMI_SonarObstacleDistanceDisplay ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_ClosingAuthorization := %X\n", getValue( HMI_UPA_ClosingAuthorization ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_Image_DisplayRequest := %X\n", getValue( HMI_UPA_Image_DisplayRequest ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_Obstacle_Zone_Front_Center := %X\n", getValue( HMI_UPA_Obstacle_Zone_Front_Center ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_Obstacle_Zone_Front_Left := %X\n", getValue( HMI_UPA_Obstacle_Zone_Front_Left ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_Obstacle_Zone_Front_Right := %X\n", getValue( HMI_UPA_Obstacle_Zone_Front_Right ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_Obstacle_Zone_Rear_Center := %X\n", getValue( HMI_UPA_Obstacle_Zone_Rear_Center ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_Obstacle_Zone_Rear_Left := %X\n", getValue( HMI_UPA_Obstacle_Zone_Rear_Left ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_Obstacle_Zone_Rear_Right := %X\n", getValue( HMI_UPA_Obstacle_Zone_Rear_Right ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_SoundActivationBeep := %X\n", getValue( HMI_UPA_SoundActivationBeep ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_SoundErrorBeep := %X\n", getValue( HMI_UPA_SoundErrorBeep ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_SoundObstacleZone := %X\n", getValue( HMI_UPA_SoundObstacleZone ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_SoundRecurrencePeriod := %X\n", getValue( HMI_UPA_SoundRecurrencePeriod ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_SoundRecurrenceType := %X\n", getValue( HMI_UPA_SoundRecurrenceType ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_SystemState := %X\n", getValue( HMI_UPA_SystemState ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_UPA_UPAStatusDisplayRequest := %X\n", getValue( HMI_UPAStatusDisplayRequest ) );        filePutString( buffer, elcount( buffer ), hFile );
	
}

on timer _tSONAR_A4_AR2_DAI
{
    putValue( HMI__STMSG_SONAR_A4_AR2_DAI, 0 );
}

on EnvVar HMI__STMSG_SONAR_A4_AR2_DAI
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SONAR_A4_AR2_DAI );
        if( tDelay > 0)    
            setTimer( _tSONAR_A4_AR2_DAI, tDelay );
        else
            putValue( HMI__STMSG_SONAR_A4_AR2_DAI, 0 );
    }
}

on envVar HMI__STMSG_PO_SONAR_A4_AR2_DAI
{
    if( getValue( this ) )
        openPanel("SONAR_A4_AR2_DAI");
}

on EnvVar HMI_BSWson_FunctionnalStatus
{
    _mSONAR_A4_AR2_DAI.BSWson_FunctionnalStatus.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_ParkAssistVolumeState
{
    _mSONAR_A4_AR2_DAI.ParkAssistVolumeState.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_SensorAvailabilityFrontCenter
{
    _mSONAR_A4_AR2_DAI.SensorAvailabilityFrontCenter.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_SensorAvailabilityFrontLeft
{
    _mSONAR_A4_AR2_DAI.SensorAvailabilityFrontLeft.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_SensorAvailabilityFrontRight
{
    _mSONAR_A4_AR2_DAI.SensorAvailabilityFrontRight.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_SensorAvailabilityRearCenter
{
    _mSONAR_A4_AR2_DAI.SensorAvailabilityRearCenter.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_SensorAvailabilityRearLeft
{
    _mSONAR_A4_AR2_DAI.SensorAvailabilityRearLeft.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_SensorAvailabilityRearRight
{
    _mSONAR_A4_AR2_DAI.SensorAvailabilityRearRight.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_SonarObstacleDistanceDisplay
{
    _mSONAR_A4_AR2_DAI.SonarObstacleDistanceDisplay.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_ClosingAuthorization	
{
    _mSONAR_A4_AR2_DAI.UPA_ClosingAuthorization.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_Image_DisplayRequest	
{
    _mSONAR_A4_AR2_DAI.UPA_Image_DisplayRequest.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_Obstacle_Zone_Front_Center
{
    _mSONAR_A4_AR2_DAI.UPA_Obstacle_Zone_Front_Center.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_Obstacle_Zone_Front_Left	
{
    _mSONAR_A4_AR2_DAI.UPA_Obstacle_Zone_Front_Left.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_Obstacle_Zone_Front_Right	
{
    _mSONAR_A4_AR2_DAI.UPA_Obstacle_Zone_Front_Right.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_Obstacle_Zone_Rear_Center	
{
    _mSONAR_A4_AR2_DAI.UPA_Obstacle_Zone_Rear_Center.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_Obstacle_Zone_Rear_Left	
{
    _mSONAR_A4_AR2_DAI.UPA_Obstacle_Zone_Rear_Left.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_Obstacle_Zone_Rear_Right	
{
    _mSONAR_A4_AR2_DAI.UPA_Obstacle_Zone_Rear_Right.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_SoundActivationBeep	
{
    _mSONAR_A4_AR2_DAI.UPA_SoundActivationBeep.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_SoundErrorBeep		
{
    _mSONAR_A4_AR2_DAI.UPA_SoundErrorBeep.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_SoundObstacleZone		
{
    _mSONAR_A4_AR2_DAI.UPA_SoundObstacleZone.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_SoundRecurrencePeriod	
{
    _mSONAR_A4_AR2_DAI.UPA_SoundRecurrencePeriod.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_SoundRecurrenceType	
{
    _mSONAR_A4_AR2_DAI.UPA_SoundRecurrenceType.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPA_SystemState	
{
    _mSONAR_A4_AR2_DAI.UPA_SystemState.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

on EnvVar HMI_UPAStatusDisplayRequest	
{
    _mSONAR_A4_AR2_DAI.UPAStatusDisplayRequest.phys = getValue(this);
    _SONAR_A4_AR2_DAI_SpontanFlag = 1;
}

SPC_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_SPC_Disp_Rq_AR ) )
    {
    //  message   SPC_Disp_Rq_AR ID: 635--- Sendeart 0 cyclicX --- 
        _SPC_Disp_Rq_AR_Cnt--;
        if( _SPC_Disp_Rq_AR_Cnt < 1 )
        {
            SPC_Disp_Rq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _SPC_Disp_Rq_AR_Cnt = _SPC_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

SPC_Disp_Rq_AR_init()
{   /* Botschaft SPC_Disp_Rq_AR  ID: 635 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 635 0;
BA_ "NmAsrMessage" BO_ 635 0;
BA_ "GenMsgMinAcceptLength" BO_ 635 8;
BA_ "GenMsgILSupport" BO_ 635 1;
BA_ "DiagState" BO_ 635 0;
BA_ "DiagRequest" BO_ 635 0;
BA_ "DiagResponse" BO_ 635 0;
BA_ "GenMsgStartValue" BO_ 635 "0";
BA_ "GenMsgCycleTime" BO_ 635 200;
BA_ "GenMsgSendType" BO_ 635 0;
    */
    _SPC_Disp_Rq_AR_Timebase =            c_tDBKomTimer_5ms;
    _SPC_Disp_Rq_AR_CycleCount =        200 / _SPC_Disp_Rq_AR_Timebase;
    _SPC_Disp_Rq_AR_StartDelay =          0 / _SPC_Disp_Rq_AR_Timebase;
    _SPC_Disp_Rq_AR_Cnt = _SPC_Disp_Rq_AR_StartDelay;

    putValue( HMI__STMSGSD_SPC_Disp_Rq_AR, _SPC_Disp_Rq_AR_StartDelay * _SPC_Disp_Rq_AR_Timebase );
   
    _mSPC_Disp_Rq_AR.DampRatio_FL_Disp_Rq.phys = getValue( HMI_DampRatio_FL_Disp_Rq );
    _mSPC_Disp_Rq_AR.DampRatio_FR_Disp_Rq.phys = getValue( HMI_DampRatio_FR_Disp_Rq );
    _mSPC_Disp_Rq_AR.DampRatio_RL_Disp_Rq.phys = getValue( HMI_DampRatio_RL_Disp_Rq );
    _mSPC_Disp_Rq_AR.DampRatio_RR_Disp_Rq.phys = getValue( HMI_DampRatio_RR_Disp_Rq );	
	_mSPC_Disp_Rq_AR.TrqRatio_FL_Disp_Rq.phys = getValue( HMI_TrqRatio_FL_Disp_Rq );
	_mSPC_Disp_Rq_AR.TrqRatio_FR_Disp_Rq.phys = getValue( HMI_TrqRatio_FR_Disp_Rq );
	_mSPC_Disp_Rq_AR.TrqRatio_RL_Disp_Rq.phys = getValue( HMI_TrqRatio_RL_Disp_Rq );
	_mSPC_Disp_Rq_AR.TrqRatio_RR_Disp_Rq.phys = getValue( HMI_TrqRatio_RR_Disp_Rq );
}

SPC_Disp_Rq_AR_output(void)
{
    output( _mSPC_Disp_Rq_AR );
}

SPC_Disp_Rq_AR_saveEnvVars(dword hFile )
{
    filePutString("\n// Knoten EIS: SPC_Disp_Rq_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SPC_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_SPC_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SPC_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_SPC_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DampRatio_FL_Disp_Rq := %X\n", getValue( HMI_DampRatio_FL_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DampRatio_FR_Disp_Rq := %X\n", getValue( HMI_DampRatio_FR_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DampRatio_RL_Disp_Rq := %X\n", getValue( HMI_DampRatio_RL_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DampRatio_RR_Disp_Rq := %X\n", getValue( HMI_DampRatio_RR_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TrqRatio_FL_Disp_Rq := %X\n", getValue( HMI_TrqRatio_FL_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TrqRatio_FR_Disp_Rq := %X\n", getValue( HMI_TrqRatio_FR_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TrqRatio_RL_Disp_Rq := %X\n", getValue( HMI_TrqRatio_RL_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TrqRatio_RR_Disp_Rq := %X\n", getValue( HMI_TrqRatio_RR_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tSPC_Disp_Rq_AR
{
    putValue( HMI__STMSG_SPC_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_SPC_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SPC_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tSPC_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_SPC_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_SPC_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("SPC_Disp_Rq_AR");
}

on EnvVar HMI_DampRatio_FL_Disp_Rq
{
    _mSPC_Disp_Rq_AR.DampRatio_FL_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_DampRatio_FR_Disp_Rq
{
    _mSPC_Disp_Rq_AR.DampRatio_FR_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_DampRatio_RL_Disp_Rq
{
    _mSPC_Disp_Rq_AR.DampRatio_RL_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_DampRatio_RR_Disp_Rq
{
    _mSPC_Disp_Rq_AR.DampRatio_RR_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_TrqRatio_FL_Disp_Rq
{
    _mSPC_Disp_Rq_AR.TrqRatio_FL_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_TrqRatio_FR_Disp_Rq
{
    _mSPC_Disp_Rq_AR.TrqRatio_FR_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_TrqRatio_RL_Disp_Rq
{
    _mSPC_Disp_Rq_AR.TrqRatio_RL_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_TrqRatio_RR_Disp_Rq
{
    _mSPC_Disp_Rq_AR.TrqRatio_RR_Disp_Rq.phys = getValue(this);
}

SPV_Ret_Stat_VAN_AR_check_output()
{
    if( !getValue( HMI__STMSG_SPV_Ret_Stat_VAN_AR ) )
    {
    //  message   SPV_Ret_Stat_VAN_AR ID: 644 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _SPV_Ret_Stat_VAN_AR_DelayCnt > 0) _SPV_Ret_Stat_VAN_AR_DelayCnt--; // Mindestsendeabstand
        _SPV_Ret_Stat_VAN_AR_Cnt--;
        if( _SPV_Ret_Stat_VAN_AR_Cnt < 1 )
        {
            if( _SPV_Ret_Stat_VAN_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                SPV_Ret_Stat_VAN_AR_output();
                 _SPV_Ret_Stat_VAN_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SPV_Ret_Stat_VAN_AR_DelayCnt = _SPV_Ret_Stat_VAN_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _SPV_Ret_Stat_VAN_AR_SpontanFlag = 1;
            }
            _SPV_Ret_Stat_VAN_AR_Cnt = _SPV_Ret_Stat_VAN_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _SPV_Ret_Stat_VAN_AR_SpontanFlag)
        {
            if( _SPV_Ret_Stat_VAN_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                SPV_Ret_Stat_VAN_AR_output();
                _SPV_Ret_Stat_VAN_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SPV_Ret_Stat_VAN_AR_DelayCnt = _SPV_Ret_Stat_VAN_AR_MinDelay;
            }
        }
    }
}

SPV_Ret_Stat_VAN_AR_init()
{   /* Botschaft SPV_Ret_Stat_VAN_AR  ID: 644 --- Sendeart 5 cyclicAndSpontanWithDelay --- 

BA_ "ApplMessage" BO_ 644 0;
BA_ "NmAsrMessage" BO_ 644 0;
BA_ "GenMsgMinAcceptLength" BO_ 644 8;
BA_ "GenMsgILSupport" BO_ 644 1;
BA_ "DiagState" BO_ 644 0;
BA_ "DiagRequest" BO_ 644 0;
BA_ "DiagResponse" BO_ 644 0;
BA_ "GenMsgStartValue" BO_ 644 "0";
BA_ "GenMsgStartDelayTime" BO_ 644 30;
BA_ "GenMsgDelayTime" BO_ 644 20;
BA_ "GenMsgNrOfRepetition" BO_ 644 0;
BA_ "GenMsgCycleTime" BO_ 644 100;
BA_ "GenMsgSendType" BO_ 644 5;
    */

	
    _SPV_Ret_Stat_VAN_AR_Timebase =             c_tDBKomTimer_20ms;
    _SPV_Ret_Stat_VAN_AR_CycleCount =          100 / _SPV_Ret_Stat_VAN_AR_Timebase;
    _SPV_Ret_Stat_VAN_AR_StartDelay =           30 / _SPV_Ret_Stat_VAN_AR_Timebase;
    _SPV_Ret_Stat_VAN_AR_MinDelay =             20 / _SPV_Ret_Stat_VAN_AR_Timebase;
    _SPV_Ret_Stat_VAN_AR_Cnt = _SPV_Ret_Stat_VAN_AR_StartDelay;
    _SPV_Ret_Stat_VAN_AR_SpontanFlag = 0;
    _SPV_Ret_Stat_VAN_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_SPV_Ret_Stat_VAN_AR, _SPV_Ret_Stat_VAN_AR_StartDelay * _SPV_Ret_Stat_VAN_AR_Timebase);
    
    _mSPV_Ret_Stat_VAN_AR.BrkIntrvntn_Actv_Retarder.phys = getValue( HMI_BrkIntrvntn_Actv_Retarder );
    _mSPV_Ret_Stat_VAN_AR.Retarder_Flt.phys = getValue( HMI_Retarder_Flt );
    _mSPV_Ret_Stat_VAN_AR.Rsrv1_SPV_Ret_Stat_VAN.phys = getValue( HMI_Rsrv1_SPV_Ret_Stat_VAN );
    _mSPV_Ret_Stat_VAN_AR.Rsrv2_SPV_Ret_Stat_VAN.phys = getValue( HMI_Rsrv2_SPV_Ret_Stat_VAN );
    _mSPV_Ret_Stat_VAN_AR.Rsrv3_SPV_Ret_Stat_VAN.phys = getValue( HMI_Rsrv3_SPV_Ret_Stat_VAN );
}

SPV_Ret_Stat_VAN_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_SPV_Ret_Stat_VAN ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_SPV_Ret_Stat_VAN_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _SPV_Ret_Stat_VAN_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _SPV_Ret_Stat_VAN_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_SPV_Ret_Stat_VAN_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _SPV_Ret_Stat_VAN_AR_SQC_WrongSeqJump != 0 ) &&
            ( _SPV_Ret_Stat_VAN_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _SPV_Ret_Stat_VAN_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _SPV_Ret_Stat_VAN_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _SPV_Ret_Stat_VAN_AR_SQC_RepeatedCnt ) &&
            ( _SPV_Ret_Stat_VAN_AR_E2E_Armed == 1  )    )
        {
            _SPV_Ret_Stat_VAN_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_SPV_Ret_Stat_VAN, SQC_help );
    }
    _mSPV_Ret_Stat_VAN_AR.SQC_SPV_Ret_Stat_VAN = SQC_help;

    if( getValue( HMI_CRC_SPV_Ret_Stat_VAN_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_SPV_Ret_Stat_VAN_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable_profile02[ crc ^ _mSPV_Ret_Stat_VAN_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mSPV_Ret_Stat_VAN_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mSPV_Ret_Stat_VAN_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mSPV_Ret_Stat_VAN_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mSPV_Ret_Stat_VAN_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mSPV_Ret_Stat_VAN_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mSPV_Ret_Stat_VAN_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mSPV_Ret_Stat_VAN_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _SPV_Ret_Stat_VAN_AR_CRC_Offset[ _mSPV_Ret_Stat_VAN_AR.SQC_SPV_Ret_Stat_VAN ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _SPV_Ret_Stat_VAN_AR_CRC_ErrorCnt   && ( _SPV_Ret_Stat_VAN_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_SPV_Ret_Stat_VAN_Invalid )                                         )    )
            {
                crc++;
                if( _SPV_Ret_Stat_VAN_AR_CRC_ErrorCnt > 0 )
                    _SPV_Ret_Stat_VAN_AR_CRC_ErrorCnt--; 
            }
            _mSPV_Ret_Stat_VAN_AR.CRC_SPV_Ret_Stat_VAN = crc;
            putValue( HMI_CRC_SPV_Ret_Stat_VAN, crc );
        }
        else
            _mSPV_Ret_Stat_VAN_AR.CRC_SPV_Ret_Stat_VAN = getValue( HMI_CRC_SPV_Ret_Stat_VAN );
    }
    else
    {
        if( !getValue( HMI_CRC_SPV_Ret_Stat_VAN_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mSPV_Ret_Stat_VAN_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mSPV_Ret_Stat_VAN_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mSPV_Ret_Stat_VAN_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mSPV_Ret_Stat_VAN_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mSPV_Ret_Stat_VAN_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mSPV_Ret_Stat_VAN_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mSPV_Ret_Stat_VAN_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mSPV_Ret_Stat_VAN_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _SPV_Ret_Stat_VAN_AR_CRC_ErrorCnt   && ( _SPV_Ret_Stat_VAN_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_SPV_Ret_Stat_VAN_Invalid )                                         )    )
            {
                crc++;
                if( _SPV_Ret_Stat_VAN_AR_CRC_ErrorCnt > 0 )
                    _SPV_Ret_Stat_VAN_AR_CRC_ErrorCnt--; 
            }
            _mSPV_Ret_Stat_VAN_AR.CRC_SPV_Ret_Stat_VAN = crc;
            putValue( HMI_CRC_SPV_Ret_Stat_VAN, crc );
        }
        else
            _mSPV_Ret_Stat_VAN_AR.CRC_SPV_Ret_Stat_VAN = getValue( HMI_CRC_SPV_Ret_Stat_VAN );
    }
    if( ( _SPV_Ret_Stat_VAN_AR_MSG_DropCnt > 0 ) &&
        ( _SPV_Ret_Stat_VAN_AR_E2E_Armed == 1  )    )
    {
        _SPV_Ret_Stat_VAN_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mSPV_Ret_Stat_VAN_AR );
        
    if( _SPV_Ret_Stat_VAN_AR_E2E_Armed == 1 )
    {
        if ( ( _SPV_Ret_Stat_VAN_AR_MSG_DropCnt == 0      ) &&
             ( _SPV_Ret_Stat_VAN_AR_CRC_ErrorCnt == 0     ) &&
             ( _SPV_Ret_Stat_VAN_AR_SQC_RepeatedCnt == 0  ) &&
             ( _SPV_Ret_Stat_VAN_AR_SQC_WrongSeqJump == 0 )    )
        {
            _SPV_Ret_Stat_VAN_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_SPV_Ret_Stat_VAN_State, 0 );
        }
    }
}

SPV_Ret_Stat_VAN_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SPV_Ret_Stat_VAN_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SPV_Ret_Stat_VAN_AR := %X\n", getValue( HMI__STMSG_SPV_Ret_Stat_VAN_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SPV_Ret_Stat_VAN_AR := %X\n", getValue( HMI__STMSGT_SPV_Ret_Stat_VAN_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_SPV_Ret_Stat_VAN := %X\n", getValue( HMI_CRC_SPV_Ret_Stat_VAN ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_SPV_Ret_Stat_VAN_Auto := %X\n", getValue( HMI_CRC_SPV_Ret_Stat_VAN_Auto ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_SPV_Ret_Stat_VAN_Profile_02 := %X\n", getValue( HMI_CRC_SPV_Ret_Stat_VAN_Profile_02 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkIntrvntn_Actv_Retarder := %X\n", getValue( HMI_BrkIntrvntn_Actv_Retarder ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Retarder_Flt := %X\n", getValue( HMI_Retarder_Flt ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_SPV_Ret_Stat_VAN := %X\n", getValue( HMI_Rsrv1_SPV_Ret_Stat_VAN ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_SPV_Ret_Stat_VAN := %X\n", getValue( HMI_Rsrv2_SPV_Ret_Stat_VAN ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv3_SPV_Ret_Stat_VAN := %X\n", getValue( HMI_Rsrv3_SPV_Ret_Stat_VAN ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_SPV_Ret_Stat_VAN := %X\n", getValue( HMI_SQC_SPV_Ret_Stat_VAN ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_SPV_Ret_Stat_VAN_Auto := %X\n", getValue( HMI_SQC_SPV_Ret_Stat_VAN_Auto ) );    filePutString ( buffer, elcount( buffer ), hFile );	
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_FDC_MsgDisp_Func_Avl_RDU := %X\n", getValue( HMI_FDC_MsgDisp_Func_Avl_RDU ) );    filePutString ( buffer, elcount( buffer ), hFile );

    }

on timer _tSPV_Ret_Stat_VAN_AR
{
    putValue( HMI__STMSG_SPV_Ret_Stat_VAN_AR, 0 );
}

on EnvVar HMI__STMSG_SPV_Ret_Stat_VAN_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SPV_Ret_Stat_VAN_AR );
        if( tDelay > 0)    
            setTimer( _tSPV_Ret_Stat_VAN_AR, tDelay );
        else
            putValue( HMI__STMSG_SPV_Ret_Stat_VAN_AR, 0 );
    }
}

on envVar HMI_E2E_SPV_Ret_Stat_VAN_Inject
{
    if( getValue( this ) )
    {
        _SPV_Ret_Stat_VAN_AR_CRC_ErrorCnt = getValue( HMI_CRC_SPV_Ret_Stat_VAN_ErrorCount );
        _SPV_Ret_Stat_VAN_AR_SQC_TriggPos = getValue( HMI_SQC_SPV_Ret_Stat_VAN_TriggerPosition );
        _SPV_Ret_Stat_VAN_AR_SQC_WrongSeqJump = getValue( HMI_SQC_SPV_Ret_Stat_VAN_WrongSeq );
        _SPV_Ret_Stat_VAN_AR_SQC_RepeatedCnt = getValue( HMI_SQC_SPV_Ret_Stat_VAN_Repeated );
        _SPV_Ret_Stat_VAN_AR_MSG_DropCnt = getValue( HMI_SQC_SPV_Ret_Stat_VAN_MSG_DropCnt );
        putValue( HMI_E2E_SPV_Ret_Stat_VAN_State, 2 );
        _SPV_Ret_Stat_VAN_AR_E2E_Armed = 2;  //armed
    }
}

on envVar HMI__STMSG_PO_SPV_Ret_Stat_VAN_AR
{
    if( getValue( this ) )
        openPanel("SPV_Ret_Stat_VAN_AR");
}

on EnvVar HMI_BrkIntrvntn_Actv_Retarder
{
    _mSPV_Ret_Stat_VAN_AR.BrkIntrvntn_Actv_Retarder.phys = getValue(this);
    _SPV_Ret_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Retarder_Flt
{
    _mSPV_Ret_Stat_VAN_AR.Retarder_Flt.phys = getValue(this);
    _SPV_Ret_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_SPV_Ret_Stat_VAN
{
    _mSPV_Ret_Stat_VAN_AR.Rsrv1_SPV_Ret_Stat_VAN.phys = getValue(this);
    _SPV_Ret_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv2_SPV_Ret_Stat_VAN
{
    _mSPV_Ret_Stat_VAN_AR.Rsrv2_SPV_Ret_Stat_VAN.phys = getValue(this);
    _SPV_Ret_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv3_SPV_Ret_Stat_VAN
{
    _mSPV_Ret_Stat_VAN_AR.Rsrv3_SPV_Ret_Stat_VAN.phys = getValue(this);
    _SPV_Ret_Stat_VAN_AR_SpontanFlag = 1;
}

SPC_SwLED_Msg_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_SPC_SwLED_Msg_Rq_AR ) )
    {
    //  message   SPC_SwLED_Msg_Rq_AR --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _SPC_SwLED_Msg_Rq_AR_Cnt--;
        if( _SPC_SwLED_Msg_Rq_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            SPC_SwLED_Msg_Rq_AR_output();
            _SPC_SwLED_Msg_Rq_AR_Cnt = _SPC_SwLED_Msg_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _SPC_SwLED_Msg_Rq_AR_SpontanFlag)
        {
            SPC_SwLED_Msg_Rq_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

SPC_SwLED_Msg_Rq_AR_init()
{   /* Botschaft SPC_SwLED_Msg_Rq_AR ID: 1083 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1083 0;
BA_ "NmAsrMessage" BO_ 1083 0;
BA_ "GenMsgMinAcceptLength" BO_ 1083 8;
BA_ "GenMsgILSupport" BO_ 1083 1;
BA_ "DiagState" BO_ 1083 0;
BA_ "DiagRequest" BO_ 1083 0;
BA_ "DiagResponse" BO_ 1083 0;
BA_ "GenMsgStartValue" BO_ 1083 "0";
BA_ "GenMsgDelayTime" BO_ 1083 20;
BA_ "GenMsgNrOfRepetitions" BO_ 1083 0;
BA_ "GenMsgCycleTime" BO_ 1083 200;
BA_ "GenMsgSendType" BO_ 1083 5;
    */
    _SPC_SwLED_Msg_Rq_AR_Timebase =      c_tDBKomTimer_20ms;
    _SPC_SwLED_Msg_Rq_AR_CycleCount =    200 / _SPC_SwLED_Msg_Rq_AR_Timebase;
    _SPC_SwLED_Msg_Rq_AR_StartDelay =      0 / _SPC_SwLED_Msg_Rq_AR_Timebase;
    _SPC_SwLED_Msg_Rq_AR_Cnt = _SPC_SwLED_Msg_Rq_AR_StartDelay;
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_SPC_SwLED_Msg_Rq_AR, _SPC_SwLED_Msg_Rq_AR_StartDelay * _SPC_SwLED_Msg_Rq_AR_Timebase );


    _mSPC_SwLED_Msg_Rq_AR.ADC_SwLED_Rq_V2.phys = getValue( HMI_ADC_SwLED_Rq_V2 );
    _mSPC_SwLED_Msg_Rq_AR.DPC_Md_Susp_Rs_V2.phys = getValue( HMI_DPC_Md_Susp_Rs_V2 );
    _mSPC_SwLED_Msg_Rq_AR.Preview_Stat_Disp_Rq.phys = getValue( HMI_Preview_Stat_Disp_Rq );
    _mSPC_SwLED_Msg_Rq_AR.SPC_ErrMsg6_Disp_Rq.phys = getValue( HMI_SPC_ErrMsg6_Disp_Rq );
    _mSPC_SwLED_Msg_Rq_AR.SPC_ErrMsg1_Disp_Rq_V2.phys = getValue( HMI_SPC_ErrMsg1_Disp_Rq_V2 );
    _mSPC_SwLED_Msg_Rq_AR.SPC_ErrMsg2_Disp_Rq_V2.phys = getValue( HMI_SPC_ErrMsg2_Disp_Rq_V2 );
    _mSPC_SwLED_Msg_Rq_AR.SPC_ErrMsg3_Disp_Rq_V2.phys = getValue( HMI_SPC_ErrMsg3_Disp_Rq_V2 );
    _mSPC_SwLED_Msg_Rq_AR.SPC_ErrMsg4_Disp_Rq_V2.phys = getValue( HMI_SPC_ErrMsg4_Disp_Rq_V2 );
    _mSPC_SwLED_Msg_Rq_AR.SPC_ErrMsg5_Disp_Rq_V2.phys = getValue( HMI_SPC_ErrMsg5_Disp_Rq_V2 );
    _mSPC_SwLED_Msg_Rq_AR.SPC_Flt_Stat.phys = getValue( HMI_SPC_Flt_Stat );
	  _mSPC_SwLED_Msg_Rq_AR.SPC_IndLmp_On_Rq.phys = getValue( HMI_SPC_IndLmp_On_Rq );
	  _mSPC_SwLED_Msg_Rq_AR.SPC_Id.phys = getValue( HMI_SPC_Id );
    _mSPC_SwLED_Msg_Rq_AR.SPC_LvlMsg_Disp_Rq.phys = getValue( HMI_SPC_LvlMsg_Disp_Rq );
    _mSPC_SwLED_Msg_Rq_AR.SPC_LvlMsg_Disp_Rq_TrgRq.phys = getValue( HMI_SPC_LvlMsg_Disp_Rq_TrgRq );
    _mSPC_SwLED_Msg_Rq_AR.SPC_LvlMsg_NoCnfrm.phys = getValue( HMI_SPC_LvlMsg_NoCnfrm );
    _mSPC_SwLED_Msg_Rq_AR.SPC_Msg1_Disp_Rq.phys = getValue( HMI_SPC_Msg1_Disp_Rq );
    _mSPC_SwLED_Msg_Rq_AR.SPC_Msg2_Disp_Rq.phys = getValue( HMI_SPC_Msg2_Disp_Rq );
    _mSPC_SwLED_Msg_Rq_AR.SPC_Msg3_Disp_Rq.phys = getValue( HMI_SPC_Msg3_Disp_Rq );
    _mSPC_SwLED_Msg_Rq_AR.SPC_Msg4_Disp_Rq.phys = getValue( HMI_SPC_Msg4_Disp_Rq );
    _mSPC_SwLED_Msg_Rq_AR.SPC_Msg5_Disp_Rq.phys = getValue( HMI_SPC_Msg5_Disp_Rq );
    _mSPC_SwLED_Msg_Rq_AR.SPC_Msg6_Disp_Rq.phys = getValue( HMI_SPC_Msg6_Disp_Rq );
    _mSPC_SwLED_Msg_Rq_AR.SPC_Msg7_Disp_Rq.phys = getValue( HMI_SPC_Msg7_Disp_Rq );
    _mSPC_SwLED_Msg_Rq_AR.SPC_Msg13_Disp_Rq.phys = getValue( HMI_SPC_Msg13_Disp_Rq );
    _mSPC_SwLED_Msg_Rq_AR.SPC_WarnMsg_Disp_Rq.phys = getValue( HMI_SPC_WarnMsg_Disp_Rq );
    _mSPC_SwLED_Msg_Rq_AR.SuspLvlAdjSwLED_Rq.phys = getValue( HMI_SuspLvlAdjSwLED_Rq );
}

SPC_SwLED_Msg_Rq_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_SPC_Msg_Rq ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_SPC_Msg_Rq_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _SPC_SwLED_Msg_Rq_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _SPC_SwLED_Msg_Rq_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_SPC_Msg_Rq_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _SPC_SwLED_Msg_Rq_AR_SQC_WrongSeqJump != 0 ) &&
            ( _SPC_SwLED_Msg_Rq_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _SPC_SwLED_Msg_Rq_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _SPC_SwLED_Msg_Rq_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _SPC_SwLED_Msg_Rq_AR_SQC_RepeatedCnt ) &&
            ( _SPC_SwLED_Msg_Rq_AR_E2E_Armed == 1  )    )
        {
            _SPC_SwLED_Msg_Rq_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_SPC_Msg_Rq, SQC_help );
    }
    _mSPC_SwLED_Msg_Rq_AR.SQC_SPC_Msg_Rq = SQC_help;

    if( getValue( HMI_CRC_SPC_Msg_Rq_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_SPC_Msg_Rq_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mSPC_SwLED_Msg_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mSPC_SwLED_Msg_Rq_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mSPC_SwLED_Msg_Rq_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mSPC_SwLED_Msg_Rq_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mSPC_SwLED_Msg_Rq_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mSPC_SwLED_Msg_Rq_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mSPC_SwLED_Msg_Rq_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mSPC_SwLED_Msg_Rq_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _SPC_SwLED_Msg_Rq_AR_CRC_Offset[ _mSPC_SwLED_Msg_Rq_AR.SQC_SPC_Msg_Rq ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _SPC_SwLED_Msg_Rq_AR_CRC_ErrorCnt   && ( _SPC_SwLED_Msg_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_SPC_Msg_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _SPC_SwLED_Msg_Rq_AR_CRC_ErrorCnt > 0 )
                    _SPC_SwLED_Msg_Rq_AR_CRC_ErrorCnt--; 
            }
            _mSPC_SwLED_Msg_Rq_AR.CRC_SPC_Msg_Rq = crc;
            putValue( HMI_CRC_SPC_Msg_Rq, crc );
        }
        else
            _mSPC_SwLED_Msg_Rq_AR.CRC_SPC_Msg_Rq = getValue( HMI_CRC_SPC_Msg_Rq );
    }
    else
    {
        if( !getValue( HMI_CRC_SPC_Msg_Rq_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mSPC_SwLED_Msg_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mSPC_SwLED_Msg_Rq_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mSPC_SwLED_Msg_Rq_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mSPC_SwLED_Msg_Rq_AR.byte( 3 ) ];
//            crc = crctable[ crc ^ _mSPC_SwLED_Msg_Rq_AR.byte( 4 ) ];
//            crc = crctable[ crc ^ _mSPC_SwLED_Msg_Rq_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mSPC_SwLED_Msg_Rq_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mSPC_SwLED_Msg_Rq_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _SPC_SwLED_Msg_Rq_AR_CRC_ErrorCnt   && ( _SPC_SwLED_Msg_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_SPC_Msg_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _SPC_SwLED_Msg_Rq_AR_CRC_ErrorCnt > 0 )
                    _SPC_SwLED_Msg_Rq_AR_CRC_ErrorCnt--; 
            }
            _mSPC_SwLED_Msg_Rq_AR.CRC_SPC_Msg_Rq = crc;
            putValue( HMI_CRC_SPC_Msg_Rq, crc );
        }
        else
            _mSPC_SwLED_Msg_Rq_AR.CRC_SPC_Msg_Rq = getValue( HMI_CRC_SPC_Msg_Rq );
    }
    if( ( _SPC_SwLED_Msg_Rq_AR_MSG_DropCnt > 0 ) &&
        ( _SPC_SwLED_Msg_Rq_AR_E2E_Armed == 1  )    )
    {
        _SPC_SwLED_Msg_Rq_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mSPC_SwLED_Msg_Rq_AR );
        
    if( _SPC_SwLED_Msg_Rq_AR_E2E_Armed == 1 )
    {
        if ( ( _SPC_SwLED_Msg_Rq_AR_MSG_DropCnt == 0      ) &&
             ( _SPC_SwLED_Msg_Rq_AR_CRC_ErrorCnt == 0     ) &&
             ( _SPC_SwLED_Msg_Rq_AR_SQC_RepeatedCnt == 0  ) &&
             ( _SPC_SwLED_Msg_Rq_AR_SQC_WrongSeqJump == 0 )    )
        {
            _SPC_SwLED_Msg_Rq_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_SPC_Msg_Rq_State, 0 );
        }
    }
}

SPC_SwLED_Msg_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SPC_SwLED_Msg_Rq_AR\n", 37, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SPC_SwLED_Msg_Rq_HMI := %X\n", getValue( HMI__STMSG_SPC_SwLED_Msg_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SPC_SwLED_Msg_Rq_HMI := %X\n", getValue( HMI__STMSGT_SPC_SwLED_Msg_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ADC_SwLED_Rq_V2 := %X\n", getValue( HMI_ADC_SwLED_Rq_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_Susp_Rs_V2 := %X\n", getValue( HMI_DPC_Md_Susp_Rs_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Preview_Stat_Disp_Rq := %X\n", getValue( HMI_Preview_Stat_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_ErrMsg6_Disp_Rq := %X\n", getValue( HMI_SPC_ErrMsg6_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_ErrMsg1_Disp_Rq_V2 := %X\n", getValue( HMI_SPC_ErrMsg1_Disp_Rq_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_ErrMsg2_Disp_Rq_V2 := %X\n", getValue( HMI_SPC_ErrMsg2_Disp_Rq_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_ErrMsg3_Disp_Rq_V2 := %X\n", getValue( HMI_SPC_ErrMsg3_Disp_Rq_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_ErrMsg4_Disp_Rq_V2 := %X\n", getValue( HMI_SPC_ErrMsg4_Disp_Rq_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_ErrMsg5_Disp_Rq_V2 := %X\n", getValue( HMI_SPC_ErrMsg5_Disp_Rq_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_Flt_Stat := %X\n", getValue( HMI_SPC_Flt_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_IndLmp_On_Rq := %X\n", getValue( HMI_SPC_IndLmp_On_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_Id := %X\n", getValue( HMI_SPC_Id ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_LvlMsg_Disp_Rq := %X\n", getValue( HMI_SPC_LvlMsg_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_LvlMsg_Disp_Rq_TrgRq := %X\n", getValue( HMI_SPC_LvlMsg_Disp_Rq_TrgRq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_LvlMsg_NoCnfrm := %X\n", getValue( HMI_SPC_LvlMsg_NoCnfrm ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_Msg1_Disp_Rq := %X\n", getValue( HMI_SPC_Msg1_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_Msg2_Disp_Rq := %X\n", getValue( HMI_SPC_Msg2_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_Msg3_Disp_Rq := %X\n", getValue( HMI_SPC_Msg3_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_Msg4_Disp_Rq := %X\n", getValue( HMI_SPC_Msg4_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_Msg5_Disp_Rq := %X\n", getValue( HMI_SPC_Msg5_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_Msg6_Disp_Rq := %X\n", getValue( HMI_SPC_Msg6_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_Msg7_Disp_Rq := %X\n", getValue( HMI_SPC_Msg7_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_Msg13_Disp_Rq := %X\n", getValue( HMI_SPC_Msg13_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_WarnMsg_Disp_Rq := %X\n", getValue( HMI_SPC_WarnMsg_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SuspLvlAdjSwLED_Rq := %X\n", getValue( HMI_SuspLvlAdjSwLED_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tSPC_SwLED_Msg_Rq_AR
{
    putValue( HMI__STMSG_SPC_SwLED_Msg_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_SPC_SwLED_Msg_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SPC_SwLED_Msg_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tSPC_SwLED_Msg_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_SPC_SwLED_Msg_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_SPC_SwLED_Msg_Rq_AR
{
    if( getValue( this ) )
        openPanel("SPC_SwLED_Msg_Rq_AR");
}

on envVar HMI_E2E_SPC_Msg_Rq_Inject
{
    if( getValue( this ) )
    {
        _SPC_SwLED_Msg_Rq_AR_CRC_ErrorCnt = getValue( HMI_CRC_SPC_Msg_Rq_ErrorCount );
        _SPC_SwLED_Msg_Rq_AR_SQC_TriggPos = getValue( HMI_SQC_SPC_Msg_Rq_TriggerPosition );
        _SPC_SwLED_Msg_Rq_AR_SQC_WrongSeqJump = getValue( HMI_SQC_SPC_Msg_Rq_WrongSeq );
        _SPC_SwLED_Msg_Rq_AR_SQC_RepeatedCnt = getValue( HMI_SQC_SPC_Msg_Rq_Repeated );
        _SPC_SwLED_Msg_Rq_AR_MSG_DropCnt = getValue( HMI_SQC_SPC_Msg_Rq_MSG_DropCnt );
        putValue( HMI_E2E_SPC_Msg_Rq_State, 2 );
        _SPC_SwLED_Msg_Rq_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_ADC_SwLED_Rq_V2
{
    _mSPC_SwLED_Msg_Rq_AR.ADC_SwLED_Rq_V2.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_Susp_Rs_V2
{
    _mSPC_SwLED_Msg_Rq_AR.DPC_Md_Susp_Rs_V2.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Preview_Stat_Disp_Rq
{
    _mSPC_SwLED_Msg_Rq_AR.Preview_Stat_Disp_Rq.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_ErrMsg6_Disp_Rq
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_ErrMsg6_Disp_Rq.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_ECU_Stat
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_ECU_Stat.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_IndLmp_On_Rq
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_IndLmp_On_Rq.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_ErrMsg1_Disp_Rq_V2
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_ErrMsg1_Disp_Rq_V2.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_ErrMsg2_Disp_Rq_V2
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_ErrMsg2_Disp_Rq_V2.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_ErrMsg3_Disp_Rq_V2
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_ErrMsg3_Disp_Rq_V2.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_ErrMsg4_Disp_Rq_V2
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_ErrMsg4_Disp_Rq_V2.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_ErrMsg5_Disp_Rq_V2
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_ErrMsg5_Disp_Rq_V2.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_Flt_Stat
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_Flt_Stat.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_Id
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_Id.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_LvlMsg_Disp_Rq
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_LvlMsg_Disp_Rq.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_LvlMsg_Disp_Rq_TrgRq
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_LvlMsg_Disp_Rq_TrgRq.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_LvlMsg_NoCnfrm
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_LvlMsg_NoCnfrm.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_Msg1_Disp_Rq
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_Msg1_Disp_Rq.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_Msg2_Disp_Rq
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_Msg2_Disp_Rq.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_Msg3_Disp_Rq
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_Msg3_Disp_Rq.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_Msg4_Disp_Rq
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_Msg4_Disp_Rq.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_Msg5_Disp_Rq
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_Msg5_Disp_Rq.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_Msg6_Disp_Rq
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_Msg6_Disp_Rq.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_Msg7_Disp_Rq
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_Msg7_Disp_Rq.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_Msg13_Disp_Rq
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_Msg13_Disp_Rq.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_WarnMsg_Disp_Rq
{
    _mSPC_SwLED_Msg_Rq_AR.SPC_WarnMsg_Disp_Rq.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SuspLvlAdjSwLED_Rq
{
    _mSPC_SwLED_Msg_Rq_AR.SuspLvlAdjSwLED_Rq.phys = getValue(this);
    _SPC_SwLED_Msg_Rq_AR_SpontanFlag = 1;
}

SPV_Disp_Rq_VAN_AR_check_output()
{
    if( !getValue( HMI__STMSG_SPV_Disp_Rq_VAN_AR ) )
    {
    //  Botschaft SPV_Disp_Rq_VAN_AR ID: 892 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _SPV_Disp_Rq_VAN_AR_Cnt--;
        if( _SPV_Disp_Rq_VAN_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            SPV_Disp_Rq_VAN_AR_output();
            _SPV_Disp_Rq_VAN_AR_Cnt = _SPV_Disp_Rq_VAN_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _SPV_Disp_Rq_VAN_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _SPV_Disp_Rq_VAN_AR_SpontanFlag)
        {
            SPV_Disp_Rq_VAN_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _SPV_Disp_Rq_VAN_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

SPV_Disp_Rq_VAN_AR_init()
{   /* Botschaft SPV_Disp_Rq_VAN_AR ID: 892 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 892 0;
BA_ "NmAsrMessage" BO_ 892 0;
BA_ "GenMsgMinAcceptLength" BO_ 892 8;
BA_ "GenMsgILSupport" BO_ 892 1;
BA_ "DiagState" BO_ 892 0;
BA_ "DiagRequest" BO_ 892 0;
BA_ "DiagResponse" BO_ 892 0;
BA_ "GenMsgStartValue" BO_ 892 "0";
BA_ "GenMsgDelayTime" BO_ 892 5;
BA_ "GenMsgNrOfRepetition" BO_ 892 0;
BA_ "GenMsgCycleTime" BO_ 892 1000;
BA_ "GenMsgSendType" BO_ 892 5;
    */
    _SPV_Disp_Rq_VAN_AR_Timebase =      c_tDBKomTimer_20ms;
    _SPV_Disp_Rq_VAN_AR_CycleCount =   1000 / _SPV_Disp_Rq_VAN_AR_Timebase;
    _SPV_Disp_Rq_VAN_AR_StartDelay =      0 / _SPV_Disp_Rq_VAN_AR_Timebase;
    _SPV_Disp_Rq_VAN_AR_Cnt = _SPV_Disp_Rq_VAN_AR_StartDelay;
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_SPV_Disp_Rq_VAN_AR, _SPV_Disp_Rq_VAN_AR_StartDelay * _SPV_Disp_Rq_VAN_AR_Timebase );


    _mSPV_Disp_Rq_VAN_AR.MPM_Msg1_Disp_Rq.phys = getValue( HMI_MPM_Msg1_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg2_Disp_Rq.phys = getValue( HMI_MPM_Msg2_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg3_Disp_Rq.phys = getValue( HMI_MPM_Msg3_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg4_Disp_Rq.phys = getValue( HMI_MPM_Msg4_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg5_Disp_Rq.phys = getValue( HMI_MPM_Msg5_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg6_Disp_Rq.phys = getValue( HMI_MPM_Msg6_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg7_Disp_Rq.phys = getValue( HMI_MPM_Msg7_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg8_Disp_Rq.phys = getValue( HMI_MPM_Msg8_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg9_Disp_Rq.phys = getValue( HMI_MPM_Msg9_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg10_Disp_Rq.phys = getValue( HMI_MPM_Msg10_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg11_Disp_Rq.phys = getValue( HMI_MPM_Msg11_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg12_Disp_Rq.phys = getValue( HMI_MPM_Msg12_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg13_Disp_Rq.phys = getValue( HMI_MPM_Msg13_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg14_Disp_Rq.phys = getValue( HMI_MPM_Msg14_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg15_Disp_Rq.phys = getValue( HMI_MPM_Msg15_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg16_Disp_Rq.phys = getValue( HMI_MPM_Msg16_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg17_Disp_Rq.phys = getValue( HMI_MPM_Msg17_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg18_Disp_Rq.phys = getValue( HMI_MPM_Msg18_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg19_Disp_Rq.phys = getValue( HMI_MPM_Msg19_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg20_Disp_Rq.phys = getValue( HMI_MPM_Msg20_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg21_Disp_Rq.phys = getValue( HMI_MPM_Msg21_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg22_Disp_Rq.phys = getValue( HMI_MPM_Msg22_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg23_Disp_Rq.phys = getValue( HMI_MPM_Msg23_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg24_Disp_Rq.phys = getValue( HMI_MPM_Msg24_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg25_Disp_Rq.phys = getValue( HMI_MPM_Msg25_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg26_Disp_Rq.phys = getValue( HMI_MPM_Msg26_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg27_Disp_Rq.phys = getValue( HMI_MPM_Msg27_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg28_Disp_Rq.phys = getValue( HMI_MPM_Msg28_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg29_Disp_Rq.phys = getValue( HMI_MPM_Msg29_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg30_Disp_Rq.phys = getValue( HMI_MPM_Msg30_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg31_Disp_Rq.phys = getValue( HMI_MPM_Msg31_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg32_Disp_Rq.phys = getValue( HMI_MPM_Msg32_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg33_Disp_Rq.phys = getValue( HMI_MPM_Msg33_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg34_Disp_Rq.phys = getValue( HMI_MPM_Msg34_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg35_Disp_Rq.phys = getValue( HMI_MPM_Msg35_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg36_Disp_Rq.phys = getValue( HMI_MPM_Msg36_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg37_Disp_Rq.phys = getValue( HMI_MPM_Msg37_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg38_Disp_Rq.phys = getValue( HMI_MPM_Msg38_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg39_Disp_Rq.phys = getValue( HMI_MPM_Msg39_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg40_Disp_Rq.phys = getValue( HMI_MPM_Msg40_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg41_Disp_Rq.phys = getValue( HMI_MPM_Msg41_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg42_Disp_Rq.phys = getValue( HMI_MPM_Msg42_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg43_Disp_Rq.phys = getValue( HMI_MPM_Msg43_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg44_Disp_Rq.phys = getValue( HMI_MPM_Msg44_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg45_Disp_Rq.phys = getValue( HMI_MPM_Msg45_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg46_Disp_Rq.phys = getValue( HMI_MPM_Msg46_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg47_Disp_Rq.phys = getValue( HMI_MPM_Msg47_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg48_Disp_Rq.phys = getValue( HMI_MPM_Msg48_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg49_Disp_Rq.phys = getValue( HMI_MPM_Msg49_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg50_Disp_Rq.phys = getValue( HMI_MPM_Msg50_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg51_Disp_Rq.phys = getValue( HMI_MPM_Msg51_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg52_Disp_Rq.phys = getValue( HMI_MPM_Msg52_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg53_Disp_Rq.phys = getValue( HMI_MPM_Msg53_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg54_Disp_Rq.phys = getValue( HMI_MPM_Msg54_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg55_Disp_Rq.phys = getValue( HMI_MPM_Msg55_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg56_Disp_Rq.phys = getValue( HMI_MPM_Msg56_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg57_Disp_Rq.phys = getValue( HMI_MPM_Msg57_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg58_Disp_Rq.phys = getValue( HMI_MPM_Msg58_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg59_Disp_Rq.phys = getValue( HMI_MPM_Msg59_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg60_Disp_Rq.phys = getValue( HMI_MPM_Msg60_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg61_Disp_Rq.phys = getValue( HMI_MPM_Msg61_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg62_Disp_Rq.phys = getValue( HMI_MPM_Msg62_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg63_Disp_Rq.phys = getValue( HMI_MPM_Msg63_Disp_Rq );
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg64_Disp_Rq.phys = getValue( HMI_MPM_Msg64_Disp_Rq );
}

SPV_Disp_Rq_VAN_AR_output()
{
    output( _mSPV_Disp_Rq_VAN_AR );
}

SPV_Disp_Rq_VAN_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SPV_Disp_Rq_VAN_AR\n", 37, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SPV_Disp_Rq_VAN_AR := %X\n", getValue( HMI__STMSG_SPV_Disp_Rq_VAN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SPV_Disp_Rq_VAN_AR := %X\n", getValue( HMI__STMSGT_SPV_Disp_Rq_VAN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg1_Disp_Rq := %X\n", getValue( HMI_MPM_Msg1_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg2_Disp_Rq := %X\n", getValue( HMI_MPM_Msg2_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg3_Disp_Rq := %X\n", getValue( HMI_MPM_Msg3_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg4_Disp_Rq := %X\n", getValue( HMI_MPM_Msg4_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg5_Disp_Rq := %X\n", getValue( HMI_MPM_Msg5_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg6_Disp_Rq := %X\n", getValue( HMI_MPM_Msg6_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg7_Disp_Rq := %X\n", getValue( HMI_MPM_Msg7_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg8_Disp_Rq := %X\n", getValue( HMI_MPM_Msg8_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg9_Disp_Rq := %X\n", getValue( HMI_MPM_Msg9_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg10_Disp_Rq := %X\n", getValue( HMI_MPM_Msg10_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg11_Disp_Rq := %X\n", getValue( HMI_MPM_Msg11_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg12_Disp_Rq := %X\n", getValue( HMI_MPM_Msg12_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg13_Disp_Rq := %X\n", getValue( HMI_MPM_Msg13_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg14_Disp_Rq := %X\n", getValue( HMI_MPM_Msg14_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg15_Disp_Rq := %X\n", getValue( HMI_MPM_Msg15_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg16_Disp_Rq := %X\n", getValue( HMI_MPM_Msg16_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg17_Disp_Rq := %X\n", getValue( HMI_MPM_Msg17_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg18_Disp_Rq := %X\n", getValue( HMI_MPM_Msg18_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg19_Disp_Rq := %X\n", getValue( HMI_MPM_Msg19_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg20_Disp_Rq := %X\n", getValue( HMI_MPM_Msg20_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg21_Disp_Rq := %X\n", getValue( HMI_MPM_Msg21_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg22_Disp_Rq := %X\n", getValue( HMI_MPM_Msg22_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg23_Disp_Rq := %X\n", getValue( HMI_MPM_Msg23_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg24_Disp_Rq := %X\n", getValue( HMI_MPM_Msg24_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg25_Disp_Rq := %X\n", getValue( HMI_MPM_Msg25_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg26_Disp_Rq := %X\n", getValue( HMI_MPM_Msg26_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg27_Disp_Rq := %X\n", getValue( HMI_MPM_Msg27_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg28_Disp_Rq := %X\n", getValue( HMI_MPM_Msg28_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg29_Disp_Rq := %X\n", getValue( HMI_MPM_Msg29_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg30_Disp_Rq := %X\n", getValue( HMI_MPM_Msg30_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg31_Disp_Rq := %X\n", getValue( HMI_MPM_Msg31_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg32_Disp_Rq := %X\n", getValue( HMI_MPM_Msg32_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg33_Disp_Rq := %X\n", getValue( HMI_MPM_Msg33_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg34_Disp_Rq := %X\n", getValue( HMI_MPM_Msg34_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg35_Disp_Rq := %X\n", getValue( HMI_MPM_Msg35_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg36_Disp_Rq := %X\n", getValue( HMI_MPM_Msg36_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg37_Disp_Rq := %X\n", getValue( HMI_MPM_Msg37_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg38_Disp_Rq := %X\n", getValue( HMI_MPM_Msg38_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg39_Disp_Rq := %X\n", getValue( HMI_MPM_Msg39_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg40_Disp_Rq := %X\n", getValue( HMI_MPM_Msg40_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg41_Disp_Rq := %X\n", getValue( HMI_MPM_Msg41_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg42_Disp_Rq := %X\n", getValue( HMI_MPM_Msg42_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg43_Disp_Rq := %X\n", getValue( HMI_MPM_Msg43_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg44_Disp_Rq := %X\n", getValue( HMI_MPM_Msg44_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg45_Disp_Rq := %X\n", getValue( HMI_MPM_Msg45_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg46_Disp_Rq := %X\n", getValue( HMI_MPM_Msg46_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg47_Disp_Rq := %X\n", getValue( HMI_MPM_Msg47_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg48_Disp_Rq := %X\n", getValue( HMI_MPM_Msg48_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg49_Disp_Rq := %X\n", getValue( HMI_MPM_Msg49_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg50_Disp_Rq := %X\n", getValue( HMI_MPM_Msg50_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg51_Disp_Rq := %X\n", getValue( HMI_MPM_Msg51_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg52_Disp_Rq := %X\n", getValue( HMI_MPM_Msg52_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg53_Disp_Rq := %X\n", getValue( HMI_MPM_Msg53_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg54_Disp_Rq := %X\n", getValue( HMI_MPM_Msg54_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg55_Disp_Rq := %X\n", getValue( HMI_MPM_Msg55_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg56_Disp_Rq := %X\n", getValue( HMI_MPM_Msg56_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg57_Disp_Rq := %X\n", getValue( HMI_MPM_Msg57_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg58_Disp_Rq := %X\n", getValue( HMI_MPM_Msg58_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg59_Disp_Rq := %X\n", getValue( HMI_MPM_Msg59_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg60_Disp_Rq := %X\n", getValue( HMI_MPM_Msg60_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg61_Disp_Rq := %X\n", getValue( HMI_MPM_Msg61_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg62_Disp_Rq := %X\n", getValue( HMI_MPM_Msg62_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg63_Disp_Rq := %X\n", getValue( HMI_MPM_Msg63_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg64_Disp_Rq := %X\n", getValue( HMI_MPM_Msg64_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tSPV_Disp_Rq_VAN_AR
{
    putValue( HMI__STMSG_SPV_Disp_Rq_VAN_AR, 0 );
}

on EnvVar HMI__STMSG_SPV_Disp_Rq_VAN_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SPV_Disp_Rq_VAN_AR );
        if( tDelay > 0)    
            setTimer( _tSPV_Disp_Rq_VAN_AR, tDelay );
        else
            putValue( HMI__STMSG_SPV_Disp_Rq_VAN_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_SPV_Disp_Rq_VAN_AR
{
    if( getValue( this ) )
        openPanel("SPV_Disp_Rq_VAN_AR");
}

on EnvVar HMI_MPM_Msg1_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg1_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg2_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg2_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg3_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg3_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg4_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg4_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg5_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg5_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg6_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg6_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg7_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg7_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg8_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg8_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg9_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg9_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg10_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg10_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg11_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg11_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg12_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg12_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg13_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg13_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg14_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg14_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg15_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg15_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg16_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg16_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg17_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg17_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg18_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg18_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg19_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg19_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg20_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg20_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg21_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg21_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg22_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg22_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg23_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg23_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg24_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg24_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg25_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg25_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg26_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg26_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg27_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg27_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg28_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg28_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg29_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg29_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg30_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg30_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg31_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg31_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg32_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg32_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg33_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg33_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg34_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg34_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg35_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg35_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg36_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg36_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg37_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg37_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg38_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg38_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg39_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg39_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg40_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg40_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg41_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg41_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg42_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg42_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg43_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg43_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg44_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg44_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg45_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg45_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg46_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg46_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg47_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg47_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg48_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg48_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg49_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg49_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg50_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg50_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg51_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg51_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg52_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg52_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg53_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg53_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg54_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg54_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg55_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg55_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg56_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg56_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg57_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg57_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg58_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg58_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg59_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg59_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg60_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg60_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg61_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg61_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg62_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg62_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg63_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg63_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPM_Msg64_Disp_Rq
{
    _mSPV_Disp_Rq_VAN_AR.MPM_Msg64_Disp_Rq.phys = getValue(this);
    _SPV_Disp_Rq_VAN_AR_SpontanFlag = 1;
}

SPV_Disp_Rq2_VAN_AR_check_output()
{
    if( !getValue( HMI__STMSG_SPV_Disp_Rq2_VAN_AR ) )
    {
    //  Botschaft SPV_Disp_Rq2_VAN_AR ID: 2351169536 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _SPV_Disp_Rq2_VAN_AR_Cnt--;
        if( _SPV_Disp_Rq2_VAN_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            SPV_Disp_Rq2_VAN_AR_output();
            _SPV_Disp_Rq2_VAN_AR_Cnt = _SPV_Disp_Rq2_VAN_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _SPV_Disp_Rq2_VAN_AR_SpontanFlag)
        {
            SPV_Disp_Rq2_VAN_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

SPV_Disp_Rq2_VAN_AR_init()
{   /* Botschaft SPV_Disp_Rq2_VAN_AR ID: 2351169536 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 2351169536 0;
BA_ "NmAsrMessage" BO_ 2351169536 0;
BA_ "GenMsgMinAcceptLength" BO_ 2351169536 8;
BA_ "GenMsgILSupport" BO_ 2351169536 1;
BA_ "DiagState" BO_ 2351169536 0;
BA_ "DiagRequest" BO_ 2351169536 0;
BA_ "DiagResponse" BO_ 2351169536 0;
BA_ "GenMsgStartValue" BO_ 2351169536 "0";
BA_ "GenMsgDelayTime" BO_ 2351169536 5;
BA_ "GenMsgNrOfRepetition" BO_ 2351169536 0;
BA_ "GenMsgCycleTime" BO_ 2351169536 1000;
BA_ "GenMsgSendType" BO_ 2351169536 5;
    */
    _SPV_Disp_Rq2_VAN_AR_Timebase =      c_tDBKomTimer_20ms;
    _SPV_Disp_Rq2_VAN_AR_CycleCount =   1000 / _SPV_Disp_Rq2_VAN_AR_Timebase;
    _SPV_Disp_Rq2_VAN_AR_StartDelay =      0 / _SPV_Disp_Rq2_VAN_AR_Timebase;
    _SPV_Disp_Rq2_VAN_AR_Cnt = _SPV_Disp_Rq2_VAN_AR_StartDelay;
    _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_SPV_Disp_Rq2_VAN_AR, _SPV_Disp_Rq2_VAN_AR_StartDelay * _SPV_Disp_Rq2_VAN_AR_Timebase );


    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg65_Disp_Rq.phys = getValue( HMI_MPM_Msg65_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg66_Disp_Rq.phys = getValue( HMI_MPM_Msg66_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg67_Disp_Rq.phys = getValue( HMI_MPM_Msg67_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg68_Disp_Rq.phys = getValue( HMI_MPM_Msg68_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg69_Disp_Rq.phys = getValue( HMI_MPM_Msg69_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg70_Disp_Rq.phys = getValue( HMI_MPM_Msg70_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg71_Disp_Rq.phys = getValue( HMI_MPM_Msg71_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg72_Disp_Rq.phys = getValue( HMI_MPM_Msg72_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg73_Disp_Rq.phys = getValue( HMI_MPM_Msg73_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg74_Disp_Rq.phys = getValue( HMI_MPM_Msg74_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg75_Disp_Rq.phys = getValue( HMI_MPM_Msg75_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg76_Disp_Rq.phys = getValue( HMI_MPM_Msg76_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg77_Disp_Rq.phys = getValue( HMI_MPM_Msg77_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg78_Disp_Rq.phys = getValue( HMI_MPM_Msg78_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg79_Disp_Rq.phys = getValue( HMI_MPM_Msg79_Disp_Rq );
	  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg80_Disp_Rq.phys = getValue( HMI_MPM_Msg80_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg81_Disp_Rq.phys = getValue( HMI_MPM_Msg81_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg82_Disp_Rq.phys = getValue( HMI_MPM_Msg82_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg83_Disp_Rq.phys = getValue( HMI_MPM_Msg83_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg84_Disp_Rq.phys = getValue( HMI_MPM_Msg84_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg85_Disp_Rq.phys = getValue( HMI_MPM_Msg85_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg86_Disp_Rq.phys = getValue( HMI_MPM_Msg86_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg87_Disp_Rq.phys = getValue( HMI_MPM_Msg87_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg88_Disp_Rq.phys = getValue( HMI_MPM_Msg88_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg89_Disp_Rq.phys = getValue( HMI_MPM_Msg89_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg90_Disp_Rq.phys = getValue( HMI_MPM_Msg90_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg91_Disp_Rq.phys = getValue( HMI_MPM_Msg91_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg92_Disp_Rq.phys = getValue( HMI_MPM_Msg92_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg93_Disp_Rq.phys = getValue( HMI_MPM_Msg93_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg94_Disp_Rq.phys = getValue( HMI_MPM_Msg94_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg95_Disp_Rq.phys = getValue( HMI_MPM_Msg95_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg96_Disp_Rq.phys = getValue( HMI_MPM_Msg96_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg97_Disp_Rq.phys = getValue( HMI_MPM_Msg97_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg98_Disp_Rq.phys = getValue( HMI_MPM_Msg98_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg99_Disp_Rq.phys = getValue( HMI_MPM_Msg99_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg100_Disp_Rq.phys = getValue( HMI_MPM_Msg100_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg101_Disp_Rq.phys = getValue( HMI_MPM_Msg101_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg102_Disp_Rq.phys = getValue( HMI_MPM_Msg102_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg103_Disp_Rq.phys = getValue( HMI_MPM_Msg103_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg104_Disp_Rq.phys = getValue( HMI_MPM_Msg104_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg105_Disp_Rq.phys = getValue( HMI_MPM_Msg105_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg106_Disp_Rq.phys = getValue( HMI_MPM_Msg106_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg107_Disp_Rq.phys = getValue( HMI_MPM_Msg107_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg108_Disp_Rq.phys = getValue( HMI_MPM_Msg108_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg109_Disp_Rq.phys = getValue( HMI_MPM_Msg109_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg110_Disp_Rq.phys = getValue( HMI_MPM_Msg110_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg111_Disp_Rq.phys = getValue( HMI_MPM_Msg111_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg112_Disp_Rq.phys = getValue( HMI_MPM_Msg112_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg113_Disp_Rq.phys = getValue( HMI_MPM_Msg113_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg114_Disp_Rq.phys = getValue( HMI_MPM_Msg114_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg115_Disp_Rq.phys = getValue( HMI_MPM_Msg115_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg116_Disp_Rq.phys = getValue( HMI_MPM_Msg116_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg117_Disp_Rq.phys = getValue( HMI_MPM_Msg117_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg118_Disp_Rq.phys = getValue( HMI_MPM_Msg118_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg119_Disp_Rq.phys = getValue( HMI_MPM_Msg119_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg120_Disp_Rq.phys = getValue( HMI_MPM_Msg120_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg121_Disp_Rq.phys = getValue( HMI_MPM_Msg121_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg122_Disp_Rq.phys = getValue( HMI_MPM_Msg122_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg123_Disp_Rq.phys = getValue( HMI_MPM_Msg123_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg124_Disp_Rq.phys = getValue( HMI_MPM_Msg124_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg125_Disp_Rq.phys = getValue( HMI_MPM_Msg125_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg126_Disp_Rq.phys = getValue( HMI_MPM_Msg126_Disp_Rq );
    _mSPV_Disp_Rq2_VAN_AR.MPM_Msg127_Disp_Rq.phys = getValue( HMI_MPM_Msg127_Disp_Rq );
	_mSPV_Disp_Rq2_VAN_AR.MPM_Msg128_Disp_Rq.phys = getValue( HMI_MPM_Msg128_Disp_Rq );
}

SPV_Disp_Rq2_VAN_AR_output()
{
    output( _mSPV_Disp_Rq2_VAN_AR );
}

SPV_Disp_Rq2_VAN_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SPV_Disp_Rq2_VAN_AR\n", 37, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SPV_Disp_Rq2_VAN_AR := %X\n", getValue( HMI__STMSG_SPV_Disp_Rq2_VAN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SPV_Disp_Rq2_VAN_AR := %X\n", getValue( HMI__STMSGT_SPV_Disp_Rq2_VAN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg65_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg65_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg66_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg66_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg67_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg67_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg68_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg68_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg69_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg69_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg70_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg70_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg71_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg71_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg72_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg72_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg73_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg73_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg74_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg74_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg75_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg75_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg76_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg76_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg77_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg77_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg78_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg78_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg79_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg79_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg80_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg80_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg81_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg81_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg82_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg82_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg83_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg83_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg84_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg84_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg85_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg85_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg86_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg86_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg87_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg87_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg88_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg88_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg89_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg89_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg90_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg90_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg91_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg91_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg92_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg92_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg93_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg93_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg94_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg94_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg95_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg95_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg96_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg96_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg97_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg97_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg98_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg98_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg99_Disp_Rq  := %X\n", getValue( HMI_MPM_Msg99_Disp_Rq  ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg100_Disp_Rq := %X\n", getValue( HMI_MPM_Msg100_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg101_Disp_Rq := %X\n", getValue( HMI_MPM_Msg101_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg102_Disp_Rq := %X\n", getValue( HMI_MPM_Msg102_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg103_Disp_Rq := %X\n", getValue( HMI_MPM_Msg103_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg104_Disp_Rq := %X\n", getValue( HMI_MPM_Msg104_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg105_Disp_Rq := %X\n", getValue( HMI_MPM_Msg105_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg106_Disp_Rq := %X\n", getValue( HMI_MPM_Msg106_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg107_Disp_Rq := %X\n", getValue( HMI_MPM_Msg107_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg108_Disp_Rq := %X\n", getValue( HMI_MPM_Msg108_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg109_Disp_Rq := %X\n", getValue( HMI_MPM_Msg109_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg110_Disp_Rq := %X\n", getValue( HMI_MPM_Msg110_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg111_Disp_Rq := %X\n", getValue( HMI_MPM_Msg111_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg112_Disp_Rq := %X\n", getValue( HMI_MPM_Msg112_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg113_Disp_Rq := %X\n", getValue( HMI_MPM_Msg113_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg114_Disp_Rq := %X\n", getValue( HMI_MPM_Msg114_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg115_Disp_Rq := %X\n", getValue( HMI_MPM_Msg115_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg116_Disp_Rq := %X\n", getValue( HMI_MPM_Msg116_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg117_Disp_Rq := %X\n", getValue( HMI_MPM_Msg117_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg118_Disp_Rq := %X\n", getValue( HMI_MPM_Msg118_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg119_Disp_Rq := %X\n", getValue( HMI_MPM_Msg119_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg120_Disp_Rq := %X\n", getValue( HMI_MPM_Msg120_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg121_Disp_Rq := %X\n", getValue( HMI_MPM_Msg121_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg122_Disp_Rq := %X\n", getValue( HMI_MPM_Msg122_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg123_Disp_Rq := %X\n", getValue( HMI_MPM_Msg123_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg124_Disp_Rq := %X\n", getValue( HMI_MPM_Msg124_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
