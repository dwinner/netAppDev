/*@!Encoding:1252*/
/*
Copyright ( C ) Continental AG 2012



Based on Version  1.0, 12.05.10   from M.Dangelmeyr      IBD im Auftrag von EP/ESE   Daimler AG

Date of creation :  14.04.2011

Created by :                 Hans J�rgen Hipp


Version info

1.0        10.2013      Inital versioning introduced
1.1     04.11.2013      HMI_2013_42a database
1.2     07.01.2014      _PERI eliminated from EnvVars
1.3     11.06.2014      HMI_2014_17a database
// #VERSION#
// #VERSION_END#
*/


Variables
{
    const TRUE =    0xAA;
    const FALSE =   0x00;
    const cManual = 0x00;
    const cAuto =   0xAA;

    msTimer t_DBKomTimer_20ms;      // Timer zum zyklischen Aufruf der DBKom-Task
    int c_tDBKomTimer_20ms = 20;    // msec
    msTimer t_DBKomTimer_5ms;       // Timer zum zyklischen Aufruf der DBKom-Task
    int c_tDBKomTimer_5ms = 5;      // msec

   struct stRstReason
  {
    int rstCode;
    char rstMessage[100];
  };

  struct stRstReason RstReasons[10] = {
      {0x01, "SW-Reset"},
      {0x02, "Watch Dog Timer 0 reset"},
      {0x04, "Watch Dog Timer 1 reset"},
      {0x08, "Main Osc Clock Monitor (CLMA0) reset"},
      {0x100, "External Reset"},
      {0x200, "Power-On-Clear 0 reset"},
      {0x400, "ISO area reset (Wakeup from deepstop mode)"},
      {0x4000, "Error Control Module Reset"},
      {0x8000, "Isolated-Area power reset"},
      {0x0, "Unknown Reset Cause"}};

    // BA_DEF_ BO_  "GenMsgSendType" ENUM
    //  0 : cyclicX
    //  1 : spontanX
    //  2 : cyclicIfActiveX
    //  3 : spontanWithDelay
    //  4 : cyclicAndSpontanX
    //  5 : cyclicAndSpontanWithDelay
    //  6 : spontanWithRepitition
    //  7 : cyclicIfActiveAndSpontanWD
    //  8 : cyclicIfActiveFast
    //  9 : cyclicWithRepeatOnDemand
    //  10 : none

// #VAR_DEF#

//  message   AB_R_Stat_AR  ID: 819 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   AB_R_Stat_AR _mAB_R_Stat_AR;
    int      _AB_R_Stat_AR_Timebase;
    int      _AB_R_Stat_AR_CycleCount;
    int      _AB_R_Stat_AR_Cnt;
    int      _AB_R_Stat_AR_StartDelay;
    int      _AB_R_Stat_AR_SpontanFlag;
    int      _AB_R_Stat_AR_MinDelay;
    int      _AB_R_Stat_AR_DelayCnt;
    msTimer _tAB_R_Stat_AR;

//  message   Adapt_Seat_D_Stat_AR ID: 1206 --- Sendeart 0 cyclicX --- 
//    message   Adapt_Seat_D_Stat_AR _mAdapt_Seat_D_Stat_AR;
//    int      _Adapt_Seat_D_Stat_AR_Timebase;
//    int      _Adapt_Seat_D_Stat_AR_CycleCount;
//    int      _Adapt_Seat_D_Stat_AR_StartDelay;
//    int      _Adapt_Seat_D_Stat_AR_Cnt;
//    int      _Adapt_Seat_D_Stat_AR_SpontanFlag;
//    msTimer _tAdapt_Seat_D_Stat_AR;

//  message   Adblue_Disp_Rq_AR ID: 734 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Adblue_Disp_Rq_AR _mAdblue_Disp_Rq_AR;
    int      _Adblue_Disp_Rq_AR_Timebase;
    int      _Adblue_Disp_Rq_AR_CycleCount;
    int      _Adblue_Disp_Rq_AR_StartDelay;
    int      _Adblue_Disp_Rq_AR_MinDelay;
    int      _Adblue_Disp_Rq_AR_Cnt;
    int      _Adblue_Disp_Rq_AR_SpontanFlag;
    int      _Adblue_Disp_Rq_AR_DelayCnt;
    msTimer _tAdblue_Disp_Rq_AR;

//  message   Adblue_Disp_Warn_Rq_AR ID: 1209 --- Sendeart 0 cyclicX --- 
    message   Adblue_Disp_Warn_Rq_AR _mAdblue_Disp_Warn_Rq_AR;
    int      _Adblue_Disp_Warn_Rq_AR_Timebase = 10;
    int      _Adblue_Disp_Warn_Rq_AR_CycleCount;
    int      _Adblue_Disp_Warn_Rq_AR_StartDelay;
    int      _Adblue_Disp_Warn_Rq_AR_Cnt;
    msTimer _tAdblue_Disp_Warn_Rq_AR;

//  message   APPL_ECU_HIL_TO_IC1 --- Sendeart 1 spontanX --- 
    message   APPL_ECU_HIL_TO_IC1 _mAPPL_ECU_HIL_TO_IC1;
    int      _APPL_ECU_HIL_TO_IC1_Timebase;
    int      _APPL_ECU_HIL_TO_IC1_SpontanFlag;
	
//  message   AQS_Data_HU_AR ID: 2457862144 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   AQS_Data_HU_AR _mAQS_Data_HU_AR;
    int      _AQS_Data_HU_AR_Timebase;
    int      _AQS_Data_HU_AR_CycleCount;
    int      _AQS_Data_HU_AR_StartDelay;
    int      _AQS_Data_HU_AR_MinDelay;
    int      _AQS_Data_HU_AR_Cnt;
    int      _AQS_Data_HU_AR_SpontanFlag;
    int      _AQS_Data_HU_AR_DelayCnt;
    msTimer _tAQS_Data_HU_AR;

  
//  message   ARB_Stat_AR ID: 2440036352 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   ARB_Stat_AR _mARB_Stat_AR;
    int      _ARB_Stat_AR_Timebase;
    int      _ARB_Stat_AR_CycleCount;
    int      _ARB_Stat_AR_StartDelay;
    int      _ARB_Stat_AR_MinDelay;
    int      _ARB_Stat_AR_Cnt;
    int      _ARB_Stat_AR_SpontanFlag;
    int      _ARB_Stat_AR_DelayCnt;
    msTimer _tARB_Stat_AR;  
  
//  message   ARC_Stat_AR  ID: 1014 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   ARC_Stat_AR _mARC_Stat_AR;
    int      _ARC_Stat_AR_Timebase;
    int      _ARC_Stat_AR_CycleCount;
    int      _ARC_Stat_AR_Cnt;
    int      _ARC_Stat_AR_StartDelay;
    int      _ARC_Stat_AR_SpontanFlag;
    int      _ARC_Stat_AR_MinDelay;
    int      _ARC_Stat_AR_DelayCnt;
//    msTimer _tARC_Stat_AR;	

//  message   Assyst_Stat_AR ID: 487 --- Sendeart 0 cyclicX --- 
    message   Assyst_Stat_AR _mAssyst_Stat_AR;
    int      _Assyst_Stat_AR_Timebase;
    int      _Assyst_Stat_AR_CycleCount;
    int      _Assyst_Stat_AR_StartDelay;
    int      _Assyst_Stat_AR_Cnt;
    msTimer _tAssyst_Stat_AR;

//  message   Assyst_Stat2_AR ID: 485 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Assyst_Stat2_AR _mAssyst_Stat2_AR;
    int      _Assyst_Stat2_AR_Timebase;
    int      _Assyst_Stat2_AR_CycleCount;
    int      _Assyst_Stat2_AR_StartDelay;
    int      _Assyst_Stat2_AR_MinDelay;
    int      _Assyst_Stat2_AR_Cnt;
    int      _Assyst_Stat2_AR_SpontanFlag;
    int      _Assyst_Stat2_AR_DelayCnt;
    msTimer _tAssyst_Stat2_AR;

//  message   Assyst_Stat3_AR ID: 1065 --- Sendeart 0 cyclicX --- 
    message   Assyst_Stat3_AR _mAssyst_Stat3_AR;
    int      _Assyst_Stat3_AR_Timebase;
    int      _Assyst_Stat3_AR_CycleCount;
    int      _Assyst_Stat3_AR_StartDelay;
    int      _Assyst_Stat3_AR_MinDelay;
    int      _Assyst_Stat3_AR_Cnt;
    int      _Assyst_Stat3_AR_SpontanFlag;
    int      _Assyst_Stat3_AR_DelayCnt;
    msTimer _tAssyst_Stat3_AR;

//  message   AWD_TCASE_Disp_Rq_AR ID: 1184 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   AWD_TCASE_Disp_Rq_AR _mAWD_TCASE_Disp_Rq_AR;
    int      _AWD_TCASE_Disp_Rq_AR_Timebase;
    int      _AWD_TCASE_Disp_Rq_AR_CycleCount;
    int      _AWD_TCASE_Disp_Rq_AR_StartDelay;
    int      _AWD_TCASE_Disp_Rq_AR_MinDelay;
    int      _AWD_TCASE_Disp_Rq_AR_Cnt;
    int      _AWD_TCASE_Disp_Rq_AR_SpontanFlag;
    int      _AWD_TCASE_Disp_Rq_AR_DelayCnt;
    msTimer _tAWD_TCASE_Disp_Rq_AR;

//  message BC_Stat1_VAN_AR ID: 1156 --- Sendeart 5 cyclicAndSpontanWithDelay ---
	message BC_Stat1_VAN_AR _mBC_Stat1_VAN_AR;
	int		_BC_Stat1_VAN_AR_Timebase;
	int		_BC_Stat1_VAN_AR_CycleCount;
	int		_BC_Stat1_VAN_AR_StartDelay;
	int		_BC_Stat1_VAN_AR_MinDelay;
	int		_BC_Stat1_VAN_AR_Cnt;
	int		_BC_Stat1_VAN_AR_SpontanFlag;
	int		_BC_Stat1_VAN_AR_DelayCnt;
	msTimer _tBC_Stat1_VAN_AR;
	
//  message   BC_F_Disp_Rq_AR ID: 823 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   BC_F_Disp_Rq_AR _mBC_F_Disp_Rq_AR;
    int      _BC_F_Disp_Rq_AR_Timebase;
    int      _BC_F_Disp_Rq_AR_CycleCount;
    int      _BC_F_Disp_Rq_AR_StartDelay;
    int      _BC_F_Disp_Rq_AR_Cnt;
    int      _BC_F_Disp_Rq_AR_SpontanFlag;
    msTimer _tBC_F_Disp_Rq_AR;

//  Message   BC_F_Stat1_AR ID: 825 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   BC_F_Stat1_AR _mBC_F_Stat1_AR;
    int      _BC_F_Stat1_AR_Timebase;
    int      _BC_F_Stat1_AR_CycleCount;
    int      _BC_F_Stat1_AR_StartDelay;
    int      _BC_F_Stat1_AR_MinDelay;
    int      _BC_F_Stat1_AR_Cnt;
    int      _BC_F_Stat1_AR_SpontanFlag;
    int      _BC_F_Stat1_AR_DelayCnt;
    msTimer  _tBC_F_Stat1_AR;

//  Message   BC_F_Stat2_AR ID: 821 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   BC_F_Stat2_AR _mBC_F_Stat2_AR;
    int      _BC_F_Stat2_AR_Timebase;
    int      _BC_F_Stat2_AR_CycleCount;
    int      _BC_F_Stat2_AR_StartDelay;
    int      _BC_F_Stat2_AR_Cnt;
    int      _BC_F_Stat2_AR_SpontanFlag;
    msTimer  _tBC_F_Stat2_AR;

//  message   BC_R_Stat1_AR ID: 849 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   BC_R_Stat1_AR _mBC_R_Stat1_AR;
    int      _BC_R_Stat1_AR_Timebase;
    int      _BC_R_Stat1_AR_CycleCount;
    int      _BC_R_Stat1_AR_StartDelay;
    int      _BC_R_Stat1_AR_Cnt;
    int      _BC_R_Stat1_AR_SpontanFlag;
    msTimer _tBC_R_Stat1_AR;

//  message   BC_R_Stat2_AR ID: 869 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   BC_R_Stat2_AR _mBC_R_Stat2_AR;
    int      _BC_R_Stat2_AR_Timebase;
    int      _BC_R_Stat2_AR_CycleCount;
    int      _BC_R_Stat2_AR_StartDelay;
    int      _BC_R_Stat2_AR_Cnt;
    int      _BC_R_Stat2_AR_SpontanFlag;
    msTimer _tBC_R_Stat2_AR;

//  message   BODY_HMI_R0_AR ID: 1111 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   BODY_HMI_R0_AR _mBODY_HMI_R0_AR;
    int      _BODY_HMI_R0_AR_Timebase;
    int      _BODY_HMI_R0_AR_CycleCount;
    int      _BODY_HMI_R0_AR_StartDelay;
    int      _BODY_HMI_R0_AR_Cnt;
    int      _BODY_HMI_R0_AR_SpontanFlag;
    msTimer _tBODY_HMI_R0_AR;

//  message   BODY_HMI_R1_AR ID: 543 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   BODY_HMI_R1_AR _mBODY_HMI_R1_AR;
    int      _BODY_HMI_R1_AR_Timebase;
    int      _BODY_HMI_R1_AR_CycleCount;
    int      _BODY_HMI_R1_AR_StartDelay;
    int      _BODY_HMI_R1_AR_Cnt;
    int      _BODY_HMI_R1_AR_SpontanFlag;
    msTimer _tBODY_HMI_R1_AR;

//  message   BODY_HMI_R2_AR --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   BODY_HMI_R2_AR _mBODY_HMI_R2_AR;
    int      _BODY_HMI_R2_AR_Timebase;
    int      _BODY_HMI_R2_AR_CycleCount;
    int      _BODY_HMI_R2_AR_StartDelay;
    int      _BODY_HMI_R2_AR_Cnt;
    int      _BODY_HMI_R2_AR_SpontanFlag;
    msTimer _tBODY_HMI_R2_AR;

//  message   BSM_Disp_Warn_Rq_AR ID: 1049 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   BSM_Disp_Warn_Rq_AR _mBSM_Disp_Warn_Rq_AR;
    int      _BSM_Disp_Warn_Rq_AR_Timebase;
    int      _BSM_Disp_Warn_Rq_AR_CycleCount;
    int      _BSM_Disp_Warn_Rq_AR_StartDelay;
    int      _BSM_Disp_Warn_Rq_AR_MinDelay;
    int      _BSM_Disp_Warn_Rq_AR_Cnt;
    int      _BSM_Disp_Warn_Rq_AR_SpontanFlag;
    int      _BSM_Disp_Warn_Rq_AR_DelayCnt;
    msTimer _tBSM_Disp_Warn_Rq_AR;
	
//	message	 BSM_M_Lat_FreeSp_AR ID: 2360344576 --- Sendeart 0 cyclicX ---
	message	 BSM_M_Lat_FreeSp_AR _mBSM_M_Lat_FreeSp_AR;
	int		_BSM_M_Lat_FreeSp_AR_Timebase;
	int		_BSM_M_Lat_FreeSp_AR_CycleCount;
	int		_BSM_M_Lat_FreeSp_AR_StartDelay;
	int		_BSM_M_Lat_FreeSp_AR_Cnt;
	int		_BSM_M_Lat_FreeSp_AR_SpontanFlag;
	msTimer	_tBSM_M_Lat_FreeSp_AR;
	
//	message	BSM_S_Lat_FreeSp_AR ID: 2360606720 --- Sendeart 0 cyclicX ---
	message	BSM_S_Lat_FreeSp_AR	_mBSM_S_Lat_FreeSp_AR;
	int		_BSM_S_Lat_FreeSp_AR_Timebase;
	int		_BSM_S_Lat_FreeSp_AR_CycleCount;
	int		_BSM_S_Lat_FreeSp_AR_StartDelay;
	int		_BSM_S_Lat_FreeSp_AR_Cnt;
	int		_BSM_S_Lat_FreeSp_AR_SpontanFlag;
	msTimer	_tBSM_S_Lat_FreeSp_AR;

//  message   CamLane_Disp_Warn_Rq_AR  ID: 1035 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   CamLane_Disp_Warn_Rq_AR _mCamLane_Disp_Warn_Rq_AR;
    int      _CamLane_Disp_Warn_Rq_AR_Timebase;
    int      _CamLane_Disp_Warn_Rq_AR_CycleCount;
    int      _CamLane_Disp_Warn_Rq_AR_StartDelay;
    int      _CamLane_Disp_Warn_Rq_AR_MinDelay;
    int      _CamLane_Disp_Warn_Rq_AR_Cnt;
    int      _CamLane_Disp_Warn_Rq_AR_SpontanFlag;
    int      _CamLane_Disp_Warn_Rq_AR_DelayCnt;

    byte     _CamLane_Disp_Warn_Rq_AR_E2E_Armed;
    byte     _CamLane_Disp_Warn_Rq_AR_CRC_ErrorCnt;
    byte     _CamLane_Disp_Warn_Rq_AR_SQC_TriggPos;
    int      _CamLane_Disp_Warn_Rq_AR_SQC_WrongSeqJump;
    byte     _CamLane_Disp_Warn_Rq_AR_SQC_RepeatedCnt;
    byte     _CamLane_Disp_Warn_Rq_AR_MSG_DropCnt;
    byte     _CamLane_Disp_Warn_Rq_AR_CRC_Offset[16] = { 227,  71, 166, 10, 105, 200,  44, 139, 234,  78, 173,  17, 112, 207,  51, 146 };
    msTimer _tCamLane_Disp_Warn_Rq_AR;

	//	message	 CamLane_LaneAttr2_AR ID: 547
	message	CamLane_LaneAttr2_AR _mCamLane_LaneAttr2_AR;
	int	 _CamLane_LaneAttr2_AR_Timebase;
	int	 _CamLane_LaneAttr2_AR_CycleCount;
	int	 _CamLane_LaneAttr2_AR_StartDelay;
	int	 _CamLane_LaneAttr2_AR_MinDelay;
	int	 _CamLane_LaneAttr2_AR_Cnt;
	int	 _CamLane_LaneAttr2_AR_SpontanFlag;
	int	 _CamLane_LaneAttr2_AR_DelayCnt;
	
    byte     _CamLane_LaneAttr2_AR_E2E_Armed;
    byte     _CamLane_LaneAttr2_AR_CRC_ErrorCnt;
    byte     _CamLane_LaneAttr2_AR_SQC_TriggPos;
    int      _CamLane_LaneAttr2_AR_SQC_WrongSeqJump;
    byte     _CamLane_LaneAttr2_AR_SQC_RepeatedCnt;
    byte     _CamLane_LaneAttr2_AR_MSG_DropCnt;
    byte     _CamLane_LaneAttr2_AR_CRC_Offset[16] = { 95, 30, 216, 151, 86, 21, 207, 142, 77, 12, 198, 133, 68, 3, 189, 124 };
	msTimer _tCamLane_LaneAttr2_AR;
	
	//	message	 LDP_Disp_Rq_AR ID: 547
	message	LDP_Disp_Rq_AR _mLDP_Disp_Rq_AR;
	int	 _LDP_Disp_Rq_AR_Timebase;
	int	 _LDP_Disp_Rq_AR_CycleCount;
	int	 _LDP_Disp_Rq_AR_StartDelay;
	int	 _LDP_Disp_Rq_AR_MinDelay;
	int	 _LDP_Disp_Rq_AR_Cnt;
	int	 _LDP_Disp_Rq_AR_SpontanFlag;
	int	 _LDP_Disp_Rq_AR_DelayCnt;
	
    byte     _LDP_Disp_Rq_AR_E2E_Armed;
    byte     _LDP_Disp_Rq_AR_CRC_ErrorCnt;
    byte     _LDP_Disp_Rq_AR_SQC_TriggPos;
    int      _LDP_Disp_Rq_AR_SQC_WrongSeqJump;
    byte     _LDP_Disp_Rq_AR_SQC_RepeatedCnt;
    byte     _LDP_Disp_Rq_AR_MSG_DropCnt;
    byte     _LDP_Disp_Rq_AR_CRC_Offset[16] = { 95, 30, 216, 151, 86, 21, 207, 142, 77, 12, 198, 133, 68, 3, 189, 124 };
	msTimer _tLDP_Disp_Rq_AR;
	
//	message CamLane_LaneAttr6_AR ID: 488
	message CamLane_LaneAttr6_AR _mCamLane_LaneAttr6_AR;
	int	 _CamLane_LaneAttr6_AR_Timebase;
	int	 _CamLane_LaneAttr6_AR_CycleCount;
	int	 _CamLane_LaneAttr6_AR_StartDelay;
	int	 _CamLane_LaneAttr6_AR_MinDelay;
	int	 _CamLane_LaneAttr6_AR_Cnt;
	int	 _CamLane_LaneAttr6_AR_SpontanFlag;
	int	 _CamLane_LaneAttr6_AR_DelayCnt;
	
	byte     _CamLane_LaneAttr6_AR_E2E_Armed;
    byte     _CamLane_LaneAttr6_AR_CRC_ErrorCnt;
    byte     _CamLane_LaneAttr6_AR_SQC_TriggPos;
    int      _CamLane_LaneAttr6_AR_SQC_WrongSeqJump;
    byte     _CamLane_LaneAttr6_AR_SQC_RepeatedCnt;
    byte     _CamLane_LaneAttr6_AR_MSG_DropCnt;
    byte     _CamLane_LaneAttr6_AR_CRC_Offset[16] = { 202, 193, 184, 175, 166, 157, 148, 139, 130, 121, 112, 103, 94, 85, 76, 63 };
    msTimer _tCamLane_LaneAttr6_AR;

//  message   CamLane_LaneAttr7_AR  ID: 1035 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   CamLane_LaneAttr7_AR _mCamLane_LaneAttr7_AR;
    int      _CamLane_LaneAttr7_AR_Timebase;
    int      _CamLane_LaneAttr7_AR_CycleCount;
    int      _CamLane_LaneAttr7_AR_StartDelay;
    int      _CamLane_LaneAttr7_AR_MinDelay;
    int      _CamLane_LaneAttr7_AR_Cnt;
    int      _CamLane_LaneAttr7_AR_SpontanFlag;
    int      _CamLane_LaneAttr7_AR_DelayCnt;

    byte     _CamLane_LaneAttr7_AR_E2E_Armed;
    byte     _CamLane_LaneAttr7_AR_CRC_ErrorCnt;
    byte     _CamLane_LaneAttr7_AR_SQC_TriggPos;
    int      _CamLane_LaneAttr7_AR_SQC_WrongSeqJump;
    byte     _CamLane_LaneAttr7_AR_SQC_RepeatedCnt;
    byte     _CamLane_LaneAttr7_AR_MSG_DropCnt;
    byte     _CamLane_LaneAttr7_AR_CRC_Offset[16] = { 102, 163, 224, 34, 95, 156, 217, 27, 88, 149, 210, 20, 81, 142, 203, 13 };
    msTimer _tCamLane_LaneAttr7_AR;

////  message   CHASS_PERIPH_HMI_Camlane_R1_AR ID: 382 --- Sendeart 0 cyclicX --- 
//    message   CHASS_PERIPH_HMI_Camlane_R1_AR _mCHASS_PERIPH_HMI_Camlane_R1_AR;
//    int      _CHASS_PERIPH_HMI_Camlane_R1_AR_Timebase;
//    int      _CHASS_PERIPH_HMI_Camlane_R1_AR_CycleCount;
//    int      _CHASS_PERIPH_HMI_Camlane_R1_AR_StartDelay;
//    int      _CHASS_PERIPH_HMI_Camlane_R1_AR_Cnt;
//    int      _CHASS_PERIPH_HMI_Camlane_R1_AR_SpontanFlag;
//    msTimer _tCHASS_PERIPH_HMI_Camlane_R1_AR;
//	
////  message   CHASS_PERIPH_HMI_Camlane_R2_AR ID: 387 --- Sendeart 0 cyclicX --- 
//    message   CHASS_PERIPH_HMI_Camlane_R2_AR _mCHASS_PERIPH_HMI_Camlane_R2_AR;
//    int      _CHASS_PERIPH_HMI_Camlane_R2_AR_Timebase;
//    int      _CHASS_PERIPH_HMI_Camlane_R2_AR_CycleCount;
//    int      _CHASS_PERIPH_HMI_Camlane_R2_AR_StartDelay;
//    int      _CHASS_PERIPH_HMI_Camlane_R2_AR_Cnt;
//    int      _CHASS_PERIPH_HMI_Camlane_R2_AR_SpontanFlag;
//    msTimer _tCHASS_PERIPH_HMI_Camlane_R2_AR;

////  message   CHASS_PERIPH_HMI_Camlane_R3_AR ID: 399 --- Sendeart 0 cyclicX --- 
//    message   CHASS_PERIPH_HMI_Camlane_R3_AR _mCHASS_PERIPH_HMI_Camlane_R3_AR;
//    int      _CHASS_PERIPH_HMI_Camlane_R3_AR_Timebase;
//    int      _CHASS_PERIPH_HMI_Camlane_R3_AR_CycleCount;
//    int      _CHASS_PERIPH_HMI_Camlane_R3_AR_StartDelay;
//    int      _CHASS_PERIPH_HMI_Camlane_R3_AR_Cnt;
//    int      _CHASS_PERIPH_HMI_Camlane_R3_AR_SpontanFlag;
//    msTimer _tCHASS_PERIPH_HMI_Camlane_R3_AR;

//  message   CHASSIS_HMI_Radar_R1_AR ID: 1066 --- Sendeart 0 cyclicX --- 
    message   CHASSIS_HMI_Radar_R1_AR _mCHASSIS_HMI_Radar_R1_AR;
    int      _CHASSIS_HMI_Radar_R1_AR_Timebase;
    int      _CHASSIS_HMI_Radar_R1_AR_CycleCount;
    int      _CHASSIS_HMI_Radar_R1_AR_StartDelay;
    int      _CHASSIS_HMI_Radar_R1_AR_Cnt;
    int      _CHASSIS_HMI_Radar_R1_AR_SpontanFlag;
    msTimer _tCHASSIS_HMI_Radar_R1_AR;

//  message   CHASSIS_HMI_Radar_R2_AR ID: 1080 --- Sendeart 0 cyclicX --- 
    message   CHASSIS_HMI_Radar_R2_AR _mCHASSIS_HMI_Radar_R2_AR;
    int      _CHASSIS_HMI_Radar_R2_AR_Timebase;
    int      _CHASSIS_HMI_Radar_R2_AR_CycleCount;
    int      _CHASSIS_HMI_Radar_R2_AR_StartDelay;
    int      _CHASSIS_HMI_Radar_R2_AR_Cnt;
    int      _CHASSIS_HMI_Radar_R2_AR_SpontanFlag;
    msTimer _tCHASSIS_HMI_Radar_R2_AR;

//  message   CHASSIS_HMI_Radar_R3_AR ID: 1132 --- Sendeart 0 cyclicX --- 
    message   CHASSIS_HMI_Radar_R3_AR _mCHASSIS_HMI_Radar_R3_AR;
    int      _CHASSIS_HMI_Radar_R3_AR_Timebase;
    int      _CHASSIS_HMI_Radar_R3_AR_CycleCount;
    int      _CHASSIS_HMI_Radar_R3_AR_StartDelay;
    int      _CHASSIS_HMI_Radar_R3_AR_Cnt;
    int      _CHASSIS_HMI_Radar_R3_AR_SpontanFlag;
    msTimer _tCHASSIS_HMI_Radar_R3_AR;

//  message   CHASSIS_HMI_Radar_R4_AR ID: 1134 --- Sendeart 0 cyclicX --- 
    message   CHASSIS_HMI_Radar_R4_AR _mCHASSIS_HMI_Radar_R4_AR;
    int      _CHASSIS_HMI_Radar_R4_AR_Timebase;
    int      _CHASSIS_HMI_Radar_R4_AR_CycleCount;
    int      _CHASSIS_HMI_Radar_R4_AR_StartDelay;
    int      _CHASSIS_HMI_Radar_R4_AR_Cnt;
    int      _CHASSIS_HMI_Radar_R4_AR_SpontanFlag;
    msTimer _tCHASSIS_HMI_Radar_R4_AR;

//  message   CHASSIS_HMI_Radar_R5_AR ID: 1044 --- Sendeart 0 cyclicX --- 
    message   CHASSIS_HMI_Radar_R5_AR _mCHASSIS_HMI_Radar_R5_AR;
    int      _CHASSIS_HMI_Radar_R5_AR_Timebase;
    int      _CHASSIS_HMI_Radar_R5_AR_CycleCount;
    int      _CHASSIS_HMI_Radar_R5_AR_StartDelay;
    int      _CHASSIS_HMI_Radar_R5_AR_Cnt;
    int      _CHASSIS_HMI_Radar_R5_AR_SpontanFlag;
    msTimer _tCHASSIS_HMI_Radar_R5_AR;	

//  message   CHASSIS_HMI_R0_AR --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   CHASSIS_HMI_R0_AR _mCHASSIS_HMI_R0_AR;
    int      _CHASSIS_HMI_R0_AR_Timebase;
    int      _CHASSIS_HMI_R0_AR_CycleCount;
    int      _CHASSIS_HMI_R0_AR_StartDelay;
    int      _CHASSIS_HMI_R0_AR_Cnt;
    int      _CHASSIS_HMI_R0_AR_SpontanFlag;
    msTimer _tCHASSIS_HMI_R0_AR;

//  message   CHASSIS_HMI_R1_AR ID: 1107 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   CHASSIS_HMI_R1_AR _mCHASSIS_HMI_R1_AR;
    int      _CHASSIS_HMI_R1_AR_Timebase;
    int      _CHASSIS_HMI_R1_AR_CycleCount;
    int      _CHASSIS_HMI_R1_AR_StartDelay;
    int      _CHASSIS_HMI_R1_AR_Cnt;
    int      _CHASSIS_HMI_R1_AR_SpontanFlag;
    msTimer _tCHASSIS_HMI_R1_AR;

//  message   CHASSIS_HMI_R2_AR ID: 615 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   CHASSIS_HMI_R2_AR _mCHASSIS_HMI_R2_AR;
    int      _CHASSIS_HMI_R2_AR_Timebase;
    int      _CHASSIS_HMI_R2_AR_CycleCount;
    int      _CHASSIS_HMI_R2_AR_StartDelay;
    int      _CHASSIS_HMI_R2_AR_Cnt;
    int      _CHASSIS_HMI_R2_AR_SpontanFlag;
    msTimer _tCHASSIS_HMI_R2_AR;

//  message   CHASSIS_HMI_R3_AR ID: 617 --- Sendeart 0 cyclic --- 
    message   CHASSIS_HMI_R3_AR _mCHASSIS_HMI_R3_AR;
    int      _CHASSIS_HMI_R3_AR_Timebase;
    int      _CHASSIS_HMI_R3_AR_CycleCount;
    int      _CHASSIS_HMI_R3_AR_StartDelay;
    int      _CHASSIS_HMI_R3_AR_Cnt;
    int      _CHASSIS_HMI_R3_AR_SpontanFlag;

    byte     _CHASSIS_HMI_R3_AR_E2E_Armed;
    byte     _CHASSIS_HMI_R3_AR_CRC_ErrorCnt;
    byte     _CHASSIS_HMI_R3_AR_SQC_TriggPos;
    int      _CHASSIS_HMI_R3_AR_SQC_WrongSeqJump;
    byte     _CHASSIS_HMI_R3_AR_SQC_RepeatedCnt;
    byte     _CHASSIS_HMI_R3_AR_MSG_DropCnt;
    byte     _CHASSIS_HMI_R3_AR_CRC_Offset[16] = {  18,  46,  74, 102, 130, 158, 186, 214, 242,  19,  47,  75, 103, 131, 159, 187 };
    msTimer _tCHASSIS_HMI_R3_AR;

//  message   CHASSIS_HMI_R4_AR ID: 619 --- Sendeart 0 cyclic --- 
    message   CHASSIS_HMI_R4_AR _mCHASSIS_HMI_R4_AR;
    int      _CHASSIS_HMI_R4_AR_Timebase;
    int      _CHASSIS_HMI_R4_AR_CycleCount;
    int      _CHASSIS_HMI_R4_AR_StartDelay;
    int      _CHASSIS_HMI_R4_AR_Cnt;
    msTimer _tCHASSIS_HMI_R4_AR;
	
//  message   CHASSIS_HMI_R5_AR ID: 1040 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
//    message   CHASSIS_HMI_R5_AR _mCHASSIS_HMI_R5_AR;
//    int      _CHASSIS_HMI_R5_AR_Timebase;
//    int      _CHASSIS_HMI_R5_AR_CycleCount;
//    int      _CHASSIS_HMI_R5_AR_StartDelay;
//    int      _CHASSIS_HMI_R5_AR_MinDelay;
//    int      _CHASSIS_HMI_R5_AR_Cnt;
//    int      _CHASSIS_HMI_R5_AR_SpontanFlag;
//    int      _CHASSIS_HMI_R5_AR_DelayCnt;
//    msTimer _tCHASSIS_HMI_R5_AR;

//	message		CHASSIS_HMI_DTR_R2_AR ID: 2366636032 --- Sendeart 0 cyclicX ---
	message		CHASSIS_HMI_DTR_R2_AR _mCHASSIS_HMI_DTR_R2_AR;
	int		_CHASSIS_HMI_DTR_R2_AR_Timebase;
	int		_CHASSIS_HMI_DTR_R2_AR_CycleCount;
	int		_CHASSIS_HMI_DTR_R2_AR_StartDelay;
	int		_CHASSIS_HMI_DTR_R2_AR_Cnt;
	int		_CHASSIS_HMI_DTR_R2_AR_SpontanFlag;
	msTimer	_tCHASSIS_HMI_DTR_R2_AR;

//  message   CHASSISPERIPHERY_HMI_R1_AR --- Sendeart 0 cyclic --- 
    message   CHASSISPERIPHERY_HMI_R1_AR _mCHASSISPERIPHERY_HMI_R1_AR;
    int      _CHASSISPERIPHERY_HMI_R1_AR_Timebase;
    int      _CHASSISPERIPHERY_HMI_R1_AR_CycleCount = 2;
    int      _CHASSISPERIPHERY_HMI_R1_AR_StartDelay;
    int      _CHASSISPERIPHERY_HMI_R1_AR_Cnt;
    msTimer _tCHASSISPERIPHERY_HMI_R1_AR;
	
//  message   CHASSISPERIPHERY_HMI_R2_AR ID: 377 --- Sendeart 0 cyclicX --- 
    message   CHASSISPERIPHERY_HMI_R2_AR _mCHASSISPERIPHERY_HMI_R2_AR;
    int      _CHASSISPERIPHERY_HMI_R2_AR_Timebase;
    int      _CHASSISPERIPHERY_HMI_R2_AR_CycleCount;
    int      _CHASSISPERIPHERY_HMI_R2_AR_StartDelay;
    int      _CHASSISPERIPHERY_HMI_R2_AR_Cnt;
    int      _CHASSISPERIPHERY_HMI_R2_AR_SpontanFlag;
    msTimer _tCHASSISPERIPHERY_HMI_R2_AR;

//  message   CLkS_Rq_AR ID: 775 --- Sendeart 8 cyclicIfActiveFast --- 
    message   CLkS_Rq_AR _mCLkS_Rq_AR;
    int      _CLkS_Rq_AR_Timebase;
    int      _CLkS_Rq_AR_CycleCountSlow;
    int      _CLkS_Rq_AR_CycleCountFast;
    int      _CLkS_Rq_AR_StartDelay;
    int      _CLkS_Rq_AR_Cnt;
    int      _CLkS_Rq_AR_SigActivity;

    int      _CLkS_Rq_AR_CLkS_DL_Act_Rq_LastState = 0;
    int      _CLkS_Rq_AR_CLkS_DL_Rq_LastState = 0;
    int      _CLkS_Rq_AR_CLkS_Dr_FL_Rq_LastState = 0;
    int      _CLkS_Rq_AR_CLkS_Dr_FR_Rq_LastState = 0;
    int      _CLkS_Rq_AR_CLkS_Dr_RL_Rq_LastState = 0;
    int      _CLkS_Rq_AR_CLkS_Dr_RR_Rq_LastState = 0;
    int      _CLkS_Rq_AR_CLkS_Ext_Rq_LastState = 0;
    int      _CLkS_Rq_AR_CLkS_Gas_Dr_Rq_LastState = 0;
    int      _CLkS_Rq_AR_CLkS_Src_V2_LastState = 0;
    int      _CLkS_Rq_AR_CLkS_TurnLmp_Rq_LastState = 0;
    int      _CLkS_Rq_AR_Key_Sw4_Psd_LastState = 0;
    int      _CLkS_Rq_AR_KeyLine_LastState = 0;
    int      _CLkS_Rq_AR_RemAlm_Rq_MPM_LastState = 0;
    int      _CLkS_Rq_AR_TDP_Sw_Cls_Rq_EIS_LastState = 0;
    msTimer _tCLkS_Ext_Rq_Auto;
    msTimer _tCLkS_Rq_AR;

//  message   CLkS_State_AR ID: 763 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   CLkS_State_AR _mCLkS_State_AR;
    int      _CLkS_State_AR_Timebase;
    int      _CLkS_State_AR_CycleCount;
    int      _CLkS_State_AR_StartDelay;
    int      _CLkS_State_AR_Cnt;
    int      _CLkS_State_AR_SpontanFlag;
    msTimer _tCLkS_State_AR;

//  message   ClockSync_Stat_AR ID: 427 --- Sendeart 1 spontanX --- 
    message   ClockSync_Stat_AR _mClockSync_Stat_AR;
    int      _ClockSync_Stat_AR_Timebase;
    int      _ClockSync_Stat_AR_CycleCount;
    int      _ClockSync_Stat_AR_StartDelay;
    int      _ClockSync_Stat_AR_Cnt;
    int      _ClockSync_Stat_AR_SpontanFlag;

    byte     _ClockSync_Stat_AR_E2E_Armed;
    byte     _ClockSync_Stat_AR_CRC_ErrorCnt;
    byte     _ClockSync_Stat_AR_SQC_TriggPos;
    int      _ClockSync_Stat_AR_SQC_WrongSeqJump;
    byte     _ClockSync_Stat_AR_SQC_RepeatedCnt;
    byte     _ClockSync_Stat_AR_MSG_DropCnt;
    byte     _ClockSync_Stat_AR_CRC_Offset[16] = { 1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16 }; // DUMMY !!!
    msTimer _tClockSync_Stat_AR;

//  message   CMS_PI_Sd_Stat_MMR_F1_AR ID: 298 --- Sendeart 1 spontanX --- 
    message   CMS_PI_Sd_Stat_MMR_F1_AR _mCMS_PI_Sd_Stat_MMR_F1_AR;
    int      _CMS_PI_Sd_Stat_MMR_F1_AR_Timebase;
    int      _CMS_PI_Sd_Stat_MMR_F1_AR_CycleCount;
    int      _CMS_PI_Sd_Stat_MMR_F1_AR_StartDelay;
    int      _CMS_PI_Sd_Stat_MMR_F1_AR_Cnt;
    int      _CMS_PI_Sd_Stat_MMR_F1_AR_SpontanFlag;

    byte     _CMS_PI_Sd_Stat_MMR_F1_AR_E2E_Armed;
    byte     _CMS_PI_Sd_Stat_MMR_F1_AR_CRC_ErrorCnt;
    byte     _CMS_PI_Sd_Stat_MMR_F1_AR_SQC_TriggPos;
    int      _CMS_PI_Sd_Stat_MMR_F1_AR_SQC_WrongSeqJump;
    byte     _CMS_PI_Sd_Stat_MMR_F1_AR_SQC_RepeatedCnt;
    byte     _CMS_PI_Sd_Stat_MMR_F1_AR_MSG_DropCnt;
    byte     _CMS_PI_Sd_Stat_MMR_F1_AR_CRC_Offset[16] = {   9,  60, 111, 162, 213,  13,  64, 115, 166, 217,  17,  68, 119, 170, 221,  21 };
    msTimer _tCMS_PI_Sd_Stat_MMR_F1_AR;

//  message   CMS_PI_Sd_Stat_MMR_F4_AR ID: 300 --- Sendeart 1 spontanX --- 
    message   CMS_PI_Sd_Stat_MMR_F4_AR _mCMS_PI_Sd_Stat_MMR_F4_AR;
    int      _CMS_PI_Sd_Stat_MMR_F4_AR_Timebase;
    int      _CMS_PI_Sd_Stat_MMR_F4_AR_CycleCount;
    int      _CMS_PI_Sd_Stat_MMR_F4_AR_StartDelay;
    int      _CMS_PI_Sd_Stat_MMR_F4_AR_Cnt;
    int      _CMS_PI_Sd_Stat_MMR_F4_AR_SpontanFlag;

    byte     _CMS_PI_Sd_Stat_MMR_F4_AR_E2E_Armed;
    byte     _CMS_PI_Sd_Stat_MMR_F4_AR_CRC_ErrorCnt;
    byte     _CMS_PI_Sd_Stat_MMR_F4_AR_SQC_TriggPos;
    int      _CMS_PI_Sd_Stat_MMR_F4_AR_SQC_WrongSeqJump;
    byte     _CMS_PI_Sd_Stat_MMR_F4_AR_SQC_RepeatedCnt;
    byte     _CMS_PI_Sd_Stat_MMR_F4_AR_MSG_DropCnt;
    byte     _CMS_PI_Sd_Stat_MMR_F4_AR_CRC_Offset[16] = { 178, 120,  62,   4, 197, 139,  81,  23, 216, 158, 100,  42, 235, 177, 119,  61 };
    msTimer _tCMS_PI_Sd_Stat_MMR_F4_AR;

//  message   CMS_PI_Stat_AR ID: 165 --- Sendeart 0 cyclicX --- 
    message   CMS_PI_Stat_AR _mCMS_PI_Stat_AR;
    int      _CMS_PI_Stat_AR_Timebase;
    int      _CMS_PI_Stat_AR_CycleCount;
    int      _CMS_PI_Stat_AR_StartDelay;
    int      _CMS_PI_Stat_AR_Cnt;

    byte     _CMS_PI_Stat_AR_E2E_Armed;
    byte     _CMS_PI_Stat_AR_CRC_ErrorCnt;
    byte     _CMS_PI_Stat_AR_SQC_TriggPos;
    int      _CMS_PI_Stat_AR_SQC_WrongSeqJump;
    byte     _CMS_PI_Stat_AR_SQC_RepeatedCnt;
    byte     _CMS_PI_Stat_AR_MSG_DropCnt;
    byte     _CMS_PI_Stat_AR_CRC_Offset[16] = { 240, 207, 174, 141, 108,  75,  42,   9, 227, 194, 161, 128,  95,  62,  29, 247 };
    msTimer _tCMS_PI_Stat_AR;

//  message   CNG_Disp_Rq_AR --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   CNG_Disp_Rq_AR _mCNG_Disp_Rq_AR;
    int      _CNG_Disp_Rq_AR_Timebase;
    int      _CNG_Disp_Rq_AR_CycleCount;
    int      _CNG_Disp_Rq_AR_StartDelay;
    int      _CNG_Disp_Rq_AR_MinDelay;
    int      _CNG_Disp_Rq_AR_Cnt;
    int      _CNG_Disp_Rq_AR_SpontanFlag;
    int      _CNG_Disp_Rq_AR_DelayCnt;
    msTimer _tCNG_Disp_Rq_AR;

//  message   COM_Call_Stat_AR ID: 708 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   COM_Call_Stat_AR _mCOM_Call_Stat_AR;
    int      _COM_Call_Stat_AR_Timebase;
    int      _COM_Call_Stat_AR_CycleCount;
    int      _COM_Call_Stat_AR_StartDelay;
    int      _COM_Call_Stat_AR_Cnt;
    int      _COM_Call_Stat_AR_SpontanFlag;
    msTimer _tCOM_Call_Stat_AR;
	
//  message   COMM_EIS_TGW_AR ID: 186 --- Sendeart 1 spontanX --- 
    message   COMM_EIS_TGW_AR _mCOMM_EIS_TGW_AR;
    int      _COMM_EIS_TGW_AR_Timebase;
    int      _COMM_EIS_TGW_AR_SpontanFlag;
    msTimer _tCOMM_EIS_TGW_AR;
	
//  message   COMM_EIS_WMI_AR ID: 122 --- Sendeart 1 spontanX --- 
    message   COMM_EIS_WMI_AR _mCOMM_EIS_WMI_AR;
    int      _COMM_EIS_WMI_AR_Timebase;
    int      _COMM_EIS_WMI_AR_SpontanFlag;
    msTimer _tCOMM_EIS_WMI_AR;

//  message   CRCM_Disp_Rq_AR ID: 1147 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   CRCM_Disp_Rq_AR _mCRCM_Disp_Rq_AR;
    int      _CRCM_Disp_Rq_AR_Timebase;
    int      _CRCM_Disp_Rq_AR_CycleCount;
    int      _CRCM_Disp_Rq_AR_StartDelay;
    int      _CRCM_Disp_Rq_AR_Cnt;
    int      _CRCM_Disp_Rq_AR_SpontanFlag;
    msTimer _tCRCM_Disp_Rq_AR;
	
//  message   CU_GNSS_Data1_AR ID: 704 --- Sendeart 0 cyclicX --- 
    message   CU_GNSS_Data1_AR _mCU_GNSS_Data1_AR;
    int      _CU_GNSS_Data1_AR_Timebase;
    int      _CU_GNSS_Data1_AR_CycleCount;
    int      _CU_GNSS_Data1_AR_StartDelay;
    int      _CU_GNSS_Data1_AR_Cnt;
    int      _CU_GNSS_Data1_AR_SpontanFlag;
    msTimer _tCU_GNSS_Data1_AR;    
    
//  message   CU_Pos1_AR ID: 880 --- Sendeart 0 cyclicX --- 
    message   CU_Pos1_AR _mCU_Pos1_AR;
    int      _CU_Pos1_AR_Timebase;
    int      _CU_Pos1_AR_CycleCount;
    int      _CU_Pos1_AR_StartDelay;
    int      _CU_Pos1_AR_Cnt;
    int      _CU_Pos1_AR_SpontanFlag;
    msTimer _tCU_Pos1_AR;
	
//  message   CU_Pos2_AR ID: 960 --- Sendeart 0 cyclicX --- 
    message   CU_Pos2_AR _mCU_Pos2_AR;
    int      _CU_Pos2_AR_Timebase;
    int      _CU_Pos2_AR_CycleCount;
    int      _CU_Pos2_AR_StartDelay;
    int      _CU_Pos2_AR_Cnt;
    int      _CU_Pos2_AR_SpontanFlag;
    msTimer _tCU_Pos2_AR;
	
    // Botschaft CU_UTC_AR2 ID: 992 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message CU_UTC_AR2 _mCU_UTC_AR2;
    int _CU_UTC_AR2_Timebase;
    int _CU_UTC_AR2_CycleCount;
    int _CU_UTC_AR2_StartDelay;
    int _CU_UTC_AR2_Cnt;
    int _CU_UTC_AR2_SpontanFlag;
	int _CU_UTC_AR2_DelayCnt;
    msTimer _tCU_UTC_AR2;
	

//  message   CU_RemFunc_Rq3_AR ID: 956 --- Sendeart 0 cyclicX --- 
    message   CU_RemFunc_Rq3_AR _mCU_RemFunc_Rq3_AR;
    int      _CU_RemFunc_Rq3_AR_Timebase;
    int      _CU_RemFunc_Rq3_AR_CycleCount;
    int      _CU_RemFunc_Rq3_AR_StartDelay;
    int      _CU_RemFunc_Rq3_AR_MinDelay;
    int      _CU_RemFunc_Rq3_AR_Cnt;
    int      _CU_RemFunc_Rq3_AR_SpontanFlag;
    int      _CU_RemFunc_Rq3_AR_DelayCnt;
    msTimer _tCU_RemFunc_Rq3_AR;
    
//  message   D_RQ_GLOBAL_UDS --- Sendeart 1 spontanX --- 
    message   D_RQ_GLOBAL_UDS _mD_RQ_GLOBAL_UDS;
    int      _D_RQ_GLOBAL_UDS_Timebase;
    int      _D_RQ_GLOBAL_UDS_Cnt;
    int      _D_RQ_GLOBAL_UDS_SpontanFlag;
    msTimer  _tD_RQ_GLOBAL_UDS;
    
//  message   D_RQ_IC --- Sendeart 1 spontanX --- 
    message   D_RQ_IC _mD_RQ_IC;
    int      _D_RQ_IC_Timebase;
    int      _D_RQ_IC_Cnt;
    int      _D_RQ_IC_SpontanFlag;
    msTimer  _tD_RQ_IC;
    
//  message   D_RQ_TCO --- Sendeart 1 spontanX --- 
    message   D_RQ_TCO _mD_RQ_TCO;
    int      _D_RQ_TCO_Timebase;
    int      _D_RQ_TCO_Cnt;
    int      _D_RQ_TCO_SpontanFlag;
    msTimer  _tD_RQ_TCO;

//  message   DidA_MBContact_State_AR ID: 1119 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   DidA_MBContact_State_AR _mDidA_MBContact_State_AR;
    int      _DidA_MBContact_State_AR_Timebase;
    int      _DidA_MBContact_State_AR_CycleCount;
    int      _DidA_MBContact_State_AR_StartDelay;
    int      _DidA_MBContact_State_AR_Cnt;
    int      _DidA_MBContact_State_AR_SpontanFlag;
    msTimer _tDidA_MBContact_State_AR;

//  message   Door_FL_Stat_AR ID: 919 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Door_FL_Stat_AR _mDoor_FL_Stat_AR;
    int      _Door_FL_Stat_AR_Timebase;
    int      _Door_FL_Stat_AR_CycleCount;
    int      _Door_FL_Stat_AR_StartDelay;
    int      _Door_FL_Stat_AR_MinDelay;
    int      _Door_FL_Stat_AR_Cnt;
    int      _Door_FL_Stat_AR_SpontanFlag;
    int      _Door_FL_Stat_AR_DelayCnt;

    byte     _Door_FL_Stat_AR_E2E_Armed;
    byte     _Door_FL_Stat_AR_CRC_ErrorCnt;
    byte     _Door_FL_Stat_AR_SQC_TriggPos;
    int      _Door_FL_Stat_AR_SQC_WrongSeqJump;
    byte     _Door_FL_Stat_AR_SQC_RepeatedCnt;
    byte     _Door_FL_Stat_AR_MSG_DropCnt;
    byte     _Door_FL_Stat_AR_CRC_Offset[16] = {  51, 140, 229,  67, 156, 245,  83, 172,  10,  99, 188,  26, 115, 204,  42, 131 };
    msTimer _tDoor_FL_Stat_AR;

//  message   Door_FR_Stat_AR ID: 923 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Door_FR_Stat_AR _mDoor_FR_Stat_AR;
    int      _Door_FR_Stat_AR_Timebase;
    int      _Door_FR_Stat_AR_CycleCount;
    int      _Door_FR_Stat_AR_StartDelay;
    int      _Door_FR_Stat_AR_MinDelay;
    int      _Door_FR_Stat_AR_Cnt;
    int      _Door_FR_Stat_AR_SpontanFlag;
    int      _Door_FR_Stat_AR_DelayCnt;

    byte     _Door_FR_Stat_AR_E2E_Armed;
    byte     _Door_FR_Stat_AR_CRC_ErrorCnt;
    byte     _Door_FR_Stat_AR_SQC_TriggPos;
    int      _Door_FR_Stat_AR_SQC_WrongSeqJump;
    byte     _Door_FR_Stat_AR_SQC_RepeatedCnt;
    byte     _Door_FR_Stat_AR_MSG_DropCnt;
    byte     _Door_FR_Stat_AR_CRC_Offset[16] = { 156,  86,  16, 197, 127,  57, 238, 168,  98,  28, 209, 139,  69, 250, 180, 110 };
    msTimer _tDoor_FR_Stat_AR;

//  message   Door_RL_Stat_AR ID: 931 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Door_RL_Stat_AR _mDoor_RL_Stat_AR;
    int      _Door_RL_Stat_AR_Timebase;
    int      _Door_RL_Stat_AR_CycleCount;
    int      _Door_RL_Stat_AR_StartDelay;
    int      _Door_RL_Stat_AR_MinDelay;
    int      _Door_RL_Stat_AR_Cnt;
    int      _Door_RL_Stat_AR_SpontanFlag;
    int      _Door_RL_Stat_AR_DelayCnt;

    byte     _Door_RL_Stat_AR_E2E_Armed;
    byte     _Door_RL_Stat_AR_CRC_ErrorCnt;
    byte     _Door_RL_Stat_AR_SQC_TriggPos;
    int      _Door_RL_Stat_AR_SQC_WrongSeqJump;
    byte     _Door_RL_Stat_AR_SQC_RepeatedCnt;
    byte     _Door_RL_Stat_AR_MSG_DropCnt;
    byte     _Door_RL_Stat_AR_CRC_Offset[16] = {  72, 221, 119,  17, 166,  64, 213, 111,   9, 158,  56, 205, 103, 252, 150,  48 };
    msTimer _tDoor_RL_Stat_AR;

//  message   Door_RR_Stat_AR ID: 933 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Door_RR_Stat_AR _mDoor_RR_Stat_AR;
    int      _Door_RR_Stat_AR_Timebase;
    int      _Door_RR_Stat_AR_CycleCount;
    int      _Door_RR_Stat_AR_StartDelay;
    int      _Door_RR_Stat_AR_MinDelay;
    int      _Door_RR_Stat_AR_Cnt;
    int      _Door_RR_Stat_AR_SpontanFlag;
    int      _Door_RR_Stat_AR_DelayCnt;

    byte     _Door_RR_Stat_AR_E2E_Armed;
    byte     _Door_RR_Stat_AR_CRC_ErrorCnt;
    byte     _Door_RR_Stat_AR_SQC_TriggPos;
    int      _Door_RR_Stat_AR_SQC_WrongSeqJump;
    byte     _Door_RR_Stat_AR_SQC_RepeatedCnt;
    byte     _Door_RR_Stat_AR_MSG_DropCnt;
    byte     _Door_RR_Stat_AR_CRC_Offset[16] = { 184, 165, 146, 127, 108,  89,  70,  51,  32,  13, 245, 226, 207, 188, 169, 150 };
    msTimer _tDoor_RR_Stat_AR;

//  message   DPC_Disp_Rq_AR ID: 629 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   DPC_Disp_Rq_AR _mDPC_Disp_Rq_AR;
    int      _DPC_Disp_Rq_AR_Timebase;
    int      _DPC_Disp_Rq_AR_CycleCount;
    int      _DPC_Disp_Rq_AR_StartDelay;
    int      _DPC_Disp_Rq_AR_MinDelay;
    int      _DPC_Disp_Rq_AR_Cnt;
    int      _DPC_Disp_Rq_AR_SpontanFlag;
    int      _DPC_Disp_Rq_AR_DelayCnt;

    byte     _DPC_Disp_Rq_AR_E2E_Armed;
    byte     _DPC_Disp_Rq_AR_CRC_ErrorCnt;
    byte     _DPC_Disp_Rq_AR_SQC_TriggPos;
    int      _DPC_Disp_Rq_AR_SQC_WrongSeqJump;
    byte     _DPC_Disp_Rq_AR_SQC_RepeatedCnt;
    byte     _DPC_Disp_Rq_AR_MSG_DropCnt;
    byte     _DPC_Disp_Rq_AR_CRC_Offset[16] = {  12, 195, 127,  59, 242, 174, 106,  38, 221, 153,  85,  17, 200, 132,  64, 247 };
    msTimer _tDPC_Disp_Rq_AR;
	

//  message   DPC_IndMd_Stat_AR ID: 633 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   DPC_IndMd_Stat_AR _mDPC_IndMd_Stat_AR;
    int      _DPC_IndMd_Stat_AR_Timebase;
    int      _DPC_IndMd_Stat_AR_CycleCount;
    int      _DPC_IndMd_Stat_AR_StartDelay;
    int      _DPC_IndMd_Stat_AR_MinDelay;
    int      _DPC_IndMd_Stat_AR_Cnt;
    int      _DPC_IndMd_Stat_AR_SpontanFlag;
    int      _DPC_IndMd_Stat_AR_DelayCnt;

    byte     _DPC_IndMd_Stat_AR_E2E_Armed;
    byte     _DPC_IndMd_Stat_AR_CRC_ErrorCnt;
    byte     _DPC_IndMd_Stat_AR_SQC_TriggPos;
    int      _DPC_IndMd_Stat_AR_SQC_WrongSeqJump;
    byte     _DPC_IndMd_Stat_AR_SQC_RepeatedCnt;
    byte     _DPC_IndMd_Stat_AR_MSG_DropCnt;
    byte     _DPC_IndMd_Stat_AR_CRC_Offset[16] = { 175, 159, 143, 127, 111,  95,  79,  63,  47,  31,  15, 250, 234, 218, 202, 186 };
    msTimer _tDPC_IndMd_Stat_AR;

//  message   DPC_IndMd_Style_AR ID: 778 --- Sendeart 0 cyclic --- 
    message   DPC_IndMd_Style_AR _mDPC_IndMd_Style_AR;
    int      _DPC_IndMd_Style_AR_Timebase;
    int      _DPC_IndMd_Style_AR_CycleCount;
    int      _DPC_IndMd_Style_AR_StartDelay;
    int      _DPC_IndMd_Style_AR_Cnt;
    int      _DPC_IndMd_Style_AR_DelayCnt;

    byte     _DPC_IndMd_Style_AR_E2E_Armed;
    byte     _DPC_IndMd_Style_AR_CRC_ErrorCnt;
    byte     _DPC_IndMd_Style_AR_SQC_TriggPos;
    int      _DPC_IndMd_Style_AR_SQC_WrongSeqJump;
    byte     _DPC_IndMd_Style_AR_SQC_RepeatedCnt;
    byte     _DPC_IndMd_Style_AR_MSG_DropCnt;
    byte     _DPC_IndMd_Style_AR_CRC_Offset[16] = {  18,  30,  42,  54,  66,  78,  90, 102, 114, 126, 138, 150, 162, 174, 186, 198 };
    msTimer _tDPC_IndMd_Style_AR;

//  message   DPC_IndMd_Style2_AR --- Sendeart 0 cyclic --- 
    message   DPC_IndMd_Style2_AR _mDPC_IndMd_Style2_AR;
    int      _DPC_IndMd_Style2_AR_Timebase;
    int      _DPC_IndMd_Style2_AR_CycleCount;
    int      _DPC_IndMd_Style2_AR_StartDelay;
    int      _DPC_IndMd_Style2_AR_Cnt;

    byte     _DPC_IndMd_Style2_AR_E2E_Armed;
    byte     _DPC_IndMd_Style2_AR_CRC_ErrorCnt;
    byte     _DPC_IndMd_Style2_AR_SQC_TriggPos;
    int      _DPC_IndMd_Style2_AR_SQC_WrongSeqJump;
    byte     _DPC_IndMd_Style2_AR_SQC_RepeatedCnt;
    byte     _DPC_IndMd_Style2_AR_MSG_DropCnt;
    byte     _DPC_IndMd_Style2_AR_CRC_Offset[16] = {  44,  42,  40,  38,  36,  34,  32,  30,  28,  26,  24,  22,  20,  18,  16,  14 };
    msTimer _tDPC_IndMd_Style2_AR;

//  message   DPC_Master_Rq_AR ID: 625 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   DPC_Master_Rq_AR _mDPC_Master_Rq_AR;
    int      _DPC_Master_Rq_AR_Timebase;
    int      _DPC_Master_Rq_AR_CycleCount;
    int      _DPC_Master_Rq_AR_StartDelay;
    int      _DPC_Master_Rq_AR_MinDelay;
    int      _DPC_Master_Rq_AR_Cnt;
    int      _DPC_Master_Rq_AR_SpontanFlag;
    int      _DPC_Master_Rq_AR_DelayCnt;

    byte     _DPC_Master_Rq_AR_E2E_Armed;
    byte     _DPC_Master_Rq_AR_CRC_ErrorCnt;
    byte     _DPC_Master_Rq_AR_SQC_TriggPos;
    int      _DPC_Master_Rq_AR_SQC_WrongSeqJump;
    byte     _DPC_Master_Rq_AR_SQC_RepeatedCnt;
    byte     _DPC_Master_Rq_AR_MSG_DropCnt;
    byte     _DPC_Master_Rq_AR_CRC_Offset[16] = { 109, 219,  78, 188,  47, 157,  16, 126, 236,  95, 205,  64, 174,  33, 143, 253 };
    msTimer _tDPC_Master_Rq_AR;
	
//	message	 DPC_MdSel_Rs_AMG_AR ID: 988
	message	 DPC_MdSel_Rs_AMG_AR _mDPC_MdSel_Rs_AMG_AR;
	int		_DPC_MdSel_Rs_AMG_AR_Timebase;
	int		_DPC_MdSel_Rs_AMG_AR_CycleCount;
	int		_DPC_MdSel_Rs_AMG_AR_StartDelay;
	int		_DPC_MdSel_Rs_AMG_AR_MinDelay;
	int		_DPC_MdSel_Rs_AMG_AR_Cnt;
	int		_DPC_MdSel_Rs_AMG_AR_SpontanFlag;
	int		_DPC_MdSel_Rs_AMG_AR_DelayCnt;
	msTimer _tDPC_MdSel_Rs_AMG_AR;
//  message   DTQ_Traj_AR ID: 388 --- Sendeart 0 cyclicX --- 
    message   DTQ_Traj_AR _mDTQ_Traj_AR;
    int      _DTQ_Traj_AR_Timebase;
    int      _DTQ_Traj_AR_CycleCount;
    int      _DTQ_Traj_AR_StartDelay;
    int      _DTQ_Traj_AR_Cnt;
    int      _DTQ_Traj_AR_SpontanFlag;
    msTimer _tDTQ_Traj_AR;
	
//  message   DTR_Obj_Attr1_AR ID: 390 --- Sendeart 0 cyclicX --- 
    message   DTR_Obj_Attr1_AR _mDTR_Obj_Attr1_AR;
    int      _DTR_Obj_Attr1_AR_Timebase;
    int      _DTR_Obj_Attr1_AR_CycleCount;
    int      _DTR_Obj_Attr1_AR_StartDelay;
    int      _DTR_Obj_Attr1_AR_Cnt;
    int      _DTR_Obj_Attr1_AR_SpontanFlag;
    msTimer _tDTR_Obj_Attr1_AR;
	
//  message   DTR_Obj_Attr2_AR ID: 394 --- Sendeart 0 cyclicX --- 
    message   DTR_Obj_Attr2_AR _mDTR_Obj_Attr2_AR;
    int      _DTR_Obj_Attr2_AR_Timebase;
    int      _DTR_Obj_Attr2_AR_CycleCount;
    int      _DTR_Obj_Attr2_AR_StartDelay;
    int      _DTR_Obj_Attr2_AR_Cnt;
    int      _DTR_Obj_Attr2_AR_SpontanFlag;
    msTimer _tDTR_Obj_Attr2_AR;
	
//  message   DTR_Obj_Attr3_AR ID: 396 --- Sendeart 0 cyclicX --- 
    message   DTR_Obj_Attr3_AR _mDTR_Obj_Attr3_AR;
    int      _DTR_Obj_Attr3_AR_Timebase;
    int      _DTR_Obj_Attr3_AR_CycleCount;
    int      _DTR_Obj_Attr3_AR_StartDelay;
    int      _DTR_Obj_Attr3_AR_Cnt;
    int      _DTR_Obj_Attr3_AR_SpontanFlag;
    msTimer _tDTR_Obj_Attr3_AR;

//  message   ECO_Score_Disp_Rq_AR ID: 1129 --- Sendeart 0 cyclic --- 
    message   ECO_Score_Disp_Rq_AR _mECO_Score_Disp_Rq_AR;
    int      _ECO_Score_Disp_Rq_AR_Timebase;
    int      _ECO_Score_Disp_Rq_AR_CycleCount;
    int      _ECO_Score_Disp_Rq_AR_StartDelay;
    int      _ECO_Score_Disp_Rq_AR_Cnt;
    int      _ECO_Score_Disp_Rq_AR_DelayCnt;
    msTimer _tECO_Score_Disp_Rq_AR;

//  message   EL_Ft_Disp_Rq_AR ID: 827 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   EL_Ft_Disp_Rq_AR _mEL_Ft_Disp_Rq_AR;
    int      _EL_Ft_Disp_Rq_AR_Timebase;
    int      _EL_Ft_Disp_Rq_AR_CycleCount;
    int      _EL_Ft_Disp_Rq_AR_StartDelay;
    int      _EL_Ft_Disp_Rq_AR_Cnt;
    int      _EL_Ft_Disp_Rq_AR_SpontanFlag;

    byte     _EL_Ft_Disp_Rq_AR_E2E_Armed;
    byte     _EL_Ft_Disp_Rq_AR_CRC_ErrorCnt;
    byte     _EL_Ft_Disp_Rq_AR_SQC_TriggPos;
    int      _EL_Ft_Disp_Rq_AR_SQC_WrongSeqJump;
    byte     _EL_Ft_Disp_Rq_AR_SQC_RepeatedCnt;
    byte     _EL_Ft_Disp_Rq_AR_MSG_DropCnt;
    byte     _EL_Ft_Disp_Rq_AR_CRC_Offset[16] = { 165,  31, 148,  14, 131, 248, 114, 231,  97, 214,  80, 197,  63, 180,  46, 163 };
    msTimer _tEL_Ft_Disp_Rq_AR;

//  message   EL_R_Disp_Rq_AR ID: 897 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   EL_R_Disp_Rq_AR _mEL_R_Disp_Rq_AR;
    int      _EL_R_Disp_Rq_AR_Timebase;
    int      _EL_R_Disp_Rq_AR_CycleCount;
    int      _EL_R_Disp_Rq_AR_StartDelay;
    int      _EL_R_Disp_Rq_AR_Cnt;
    int      _EL_R_Disp_Rq_AR_SpontanFlag;

    byte     _EL_R_Disp_Rq_AR_E2E_Armed;
    byte     _EL_R_Disp_Rq_AR_CRC_ErrorCnt;
    byte     _EL_R_Disp_Rq_AR_SQC_TriggPos;
    int      _EL_R_Disp_Rq_AR_SQC_WrongSeqJump;
    byte     _EL_R_Disp_Rq_AR_SQC_RepeatedCnt;
    byte     _EL_R_Disp_Rq_AR_MSG_DropCnt;
    byte     _EL_R_Disp_Rq_AR_CRC_Offset[16] = { 124, 172, 220,  17,  65, 113, 161, 209,   6,  54, 102, 150, 198, 246,  43,  91 };
    msTimer _tEL_R_Disp_Rq_AR;

//  message   EL_Stat_AR ID: 829 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   EL_Stat_AR _mEL_Stat_AR;
    int      _EL_Stat_AR_Timebase;
    int      _EL_Stat_AR_CycleCount;
    int      _EL_Stat_AR_StartDelay;
    int      _EL_Stat_AR_Cnt;
    int      _EL_Stat_AR_SpontanFlag;

    byte     _EL_Stat_AR_E2E_Armed;
    byte     _EL_Stat_AR_CRC_ErrorCnt;
    byte     _EL_Stat_AR_SQC_TriggPos;
    int      _EL_Stat_AR_SQC_WrongSeqJump;
    byte     _EL_Stat_AR_SQC_RepeatedCnt;
    byte     _EL_Stat_AR_MSG_DropCnt;
    byte     _EL_Stat_AR_CRC_Offset[16] = { 189,  99,   9, 170,  80, 241, 151,  61, 222, 132,  42, 203, 113,  23, 184,  94 };
    msTimer _tEL_Stat_AR;

//  message   EL_TurnInd_Rq_AR ID: 287 --- Sendeart 1 spontanX --- 
    message   EL_TurnInd_Rq_AR _mEL_TurnInd_Rq_AR;
    int      _EL_TurnInd_Rq_AR_Timebase;
    int      _EL_TurnInd_Rq_AR_SpontanFlag;

    byte     _EL_TurnInd_Rq_AR_E2E_Armed;
    byte     _EL_TurnInd_Rq_AR_CRC_ErrorCnt;
    byte     _EL_TurnInd_Rq_AR_SQC_TriggPos;
    int      _EL_TurnInd_Rq_AR_SQC_WrongSeqJump;
    byte     _EL_TurnInd_Rq_AR_SQC_RepeatedCnt;
    byte     _EL_TurnInd_Rq_AR_MSG_DropCnt;
    byte     _EL_TurnInd_Rq_AR_CRC_Offset[16] = { 242, 201, 160, 119, 78, 37, 247, 206, 165, 124, 83, 42, 252, 211, 170, 129 };
    msTimer _tEL_TurnInd_Rq_AR;

//  message   Eng_Data_VAN_AR ID: 1158 --- Sendeart 0 cyclicX --- 
    message   Eng_Data_VAN_AR _mEng_Data_VAN_AR;
    int      _Eng_Data_VAN_AR_Timebase;
    int      _Eng_Data_VAN_AR_CycleCount;
    int      _Eng_Data_VAN_AR_StartDelay;
    int      _Eng_Data_VAN_AR_Cnt;
    msTimer _tEng_Data_VAN_AR;

//  message   Eng_Rs_EngCtrl_AR ID: 177 --- Sendeart 0 cyclicX --- 
    message   Eng_Rs_EngCtrl_AR _mEng_Rs_EngCtrl_AR;
    int      _Eng_Rs_EngCtrl_AR_Timebase;
    int      _Eng_Rs_EngCtrl_AR_CycleCount;
    int      _Eng_Rs_EngCtrl_AR_StartDelay;
    int      _Eng_Rs_EngCtrl_AR_Cnt;

    byte     _Eng_Rs_EngCtrl_AR_E2E_Armed;
    byte     _Eng_Rs_EngCtrl_AR_CRC_ErrorCnt;
    byte     _Eng_Rs_EngCtrl_AR_SQC_TriggPos;
    int      _Eng_Rs_EngCtrl_AR_SQC_WrongSeqJump;
    byte     _Eng_Rs_EngCtrl_AR_SQC_RepeatedCnt;
    byte     _Eng_Rs_EngCtrl_AR_MSG_DropCnt;
    byte     _Eng_Rs_EngCtrl_AR_CRC_Offset[16] = { 199, 227,   4,  32,  60,  88, 116, 144, 172, 200, 228,   5,  33,  61, 89, 117 };
    msTimer _tEng_Rs_EngCtrl_AR;

//  message   Eng_Rs2_AR ID: 119 --- Sendeart 0 cyclicX --- 
    message   Eng_Rs2_AR _mEng_Rs2_AR;
    int      _Eng_Rs2_AR_Timebase;
    int      _Eng_Rs2_AR_CycleCount;
    int      _Eng_Rs2_AR_StartDelay;
    int      _Eng_Rs2_AR_Cnt;

    byte     _Eng_Rs2_AR_E2E_Armed;
    byte     _Eng_Rs2_AR_CRC_ErrorCnt;
    byte     _Eng_Rs2_AR_SQC_TriggPos;
    int      _Eng_Rs2_AR_SQC_WrongSeqJump;
    byte     _Eng_Rs2_AR_SQC_RepeatedCnt;
    byte     _Eng_Rs2_AR_MSG_DropCnt;
    byte     _Eng_Rs2_AR_CRC_Offset[16] = {  88, 240, 141,  42, 194,  95, 247, 148,  49, 201, 102,   3, 155,  56, 208, 109 };
    msTimer _tEng_Rs2_AR;

//  message   EngCtrl_Disp_Rq_AR ID: 327 --- Sendeart 0 cyclicX --- 
    message   EngCtrl_Disp_Rq_AR _mEngCtrl_Disp_Rq_AR;
    int      _EngCtrl_Disp_Rq_AR_Timebase;
    int      _EngCtrl_Disp_Rq_AR_CycleCount;
    int      _EngCtrl_Disp_Rq_AR_StartDelay;
    int      _EngCtrl_Disp_Rq_AR_Cnt;
    msTimer _tEngCtrl_Disp_Rq_AR;

//  message   EngCtrl_Stat_AR ID: 697 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   EngCtrl_Stat_AR _mEngCtrl_Stat_AR;
    int      _EngCtrl_Stat_AR_Timebase;
    int      _EngCtrl_Stat_AR_CycleCount;
    int      _EngCtrl_Stat_AR_StartDelay;
    int      _EngCtrl_Stat_AR_Cnt;
    int      _EngCtrl_Stat_AR_SpontanFlag;
    msTimer _tEngCtrl_Stat_AR;

//  message   EPKB_Disp_IndLmp_Rq_2_AR ID: 1041 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   EPKB_Disp_IndLmp_Rq_2_AR _mEPKB_Disp_IndLmp_Rq_2_AR;
    int      _EPKB_Disp_IndLmp_Rq_2_AR_Timebase;
    int      _EPKB_Disp_IndLmp_Rq_2_AR_CycleCount;
    int      _EPKB_Disp_IndLmp_Rq_2_AR_StartDelay;
    int      _EPKB_Disp_IndLmp_Rq_2_AR_Cnt;
    int      _EPKB_Disp_IndLmp_Rq_2_AR_SpontanFlag;

    byte     _EPKB_Disp_IndLmp_Rq_2_AR_E2E_Armed;
    byte     _EPKB_Disp_IndLmp_Rq_2_AR_CRC_ErrorCnt;
    byte     _EPKB_Disp_IndLmp_Rq_2_AR_SQC_TriggPos;
    int      _EPKB_Disp_IndLmp_Rq_2_AR_SQC_WrongSeqJump;
    byte     _EPKB_Disp_IndLmp_Rq_2_AR_SQC_RepeatedCnt;
    byte     _EPKB_Disp_IndLmp_Rq_2_AR_MSG_DropCnt;
    byte     _EPKB_Disp_IndLmp_Rq_2_AR_CRC_Offset[16] = {   5,  63, 121, 179, 237,  44, 102, 160, 218,  25,  83, 141, 199,   6,  64, 122 };
    msTimer _tEPKB_Disp_IndLmp_Rq_2_AR;

//  message   EPS_Stat_Disp_Rq_AR ID: 1069 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   EPS_Stat_Disp_Rq_AR _mEPS_Stat_Disp_Rq_AR;
    int      _EPS_Stat_Disp_Rq_AR_Timebase;
    int      _EPS_Stat_Disp_Rq_AR_CycleCount;
    int      _EPS_Stat_Disp_Rq_AR_StartDelay;
    int      _EPS_Stat_Disp_Rq_AR_Cnt;
    int      _EPS_Stat_Disp_Rq_AR_SpontanFlag;

    byte     _EPS_Stat_Disp_Rq_AR_E2E_Armed;
    byte     _EPS_Stat_Disp_Rq_AR_CRC_ErrorCnt;
    byte     _EPS_Stat_Disp_Rq_AR_SQC_TriggPos;
    int      _EPS_Stat_Disp_Rq_AR_SQC_WrongSeqJump;
    byte     _EPS_Stat_Disp_Rq_AR_SQC_RepeatedCnt;
    byte     _EPS_Stat_Disp_Rq_AR_MSG_DropCnt;
    byte     _EPS_Stat_Disp_Rq_AR_CRC_Offset[16] = { 156, 188, 220, 252,  33,  65,  97, 129, 161, 193, 225,   6,  38, 70, 102, 134 };
    msTimer _tEPS_Stat_Disp_Rq_AR;

//  message   ESP_ATC_Stat_AMG_AR ID: 2345140224 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   ESP_ATC_Stat_AMG_AR _mESP_ATC_Stat_AMG_AR;
    int      _ESP_ATC_Stat_AMG_AR_Timebase;
    int      _ESP_ATC_Stat_AMG_AR_CycleCount;
    int      _ESP_ATC_Stat_AMG_AR_StartDelay;
    int      _ESP_ATC_Stat_AMG_AR_MinDelay;
    int      _ESP_ATC_Stat_AMG_AR_Cnt;
    int      _ESP_ATC_Stat_AMG_AR_SpontanFlag;
    int      _ESP_ATC_Stat_AMG_AR_DelayCnt;

    byte     _ESP_ATC_Stat_AMG_AR_E2E_Armed;
    byte     _ESP_ATC_Stat_AMG_AR_CRC_ErrorCnt;
    byte     _ESP_ATC_Stat_AMG_AR_SQC_TriggPos;
    int      _ESP_ATC_Stat_AMG_AR_SQC_WrongSeqJump;
    byte     _ESP_ATC_Stat_AMG_AR_SQC_RepeatedCnt;
    byte     _ESP_ATC_Stat_AMG_AR_MSG_DropCnt;
    byte     _ESP_ATC_Stat_AMG_AR_CRC_Offset[16] = {  229, 234, 239, 244, 249, 3, 8, 13, 18, 23, 28, 33, 38, 43, 48, 53 };
    msTimer _tESP_ATC_Stat_AMG_AR;    
    
//  message   ESP_Disp_Rq_AR ID: 555 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   ESP_Disp_Rq_AR _mESP_Disp_Rq_AR;
    int      _ESP_Disp_Rq_AR_Timebase;
    int      _ESP_Disp_Rq_AR_CycleCount;
    int      _ESP_Disp_Rq_AR_StartDelay;
    int      _ESP_Disp_Rq_AR_Cnt;
    int      _ESP_Disp_Rq_AR_SpontanFlag;

    byte     _ESP_Disp_Rq_AR_E2E_Armed;
    byte     _ESP_Disp_Rq_AR_CRC_ErrorCnt;
    byte     _ESP_Disp_Rq_AR_SQC_TriggPos;
    int      _ESP_Disp_Rq_AR_SQC_WrongSeqJump;
    byte     _ESP_Disp_Rq_AR_SQC_RepeatedCnt;
    byte     _ESP_Disp_Rq_AR_MSG_DropCnt;
    byte     _ESP_Disp_Rq_AR_CRC_Offset[16] = { 117,  92,  67,  42,  17, 243, 218, 193, 168, 143, 118,  93,  68,  43,  18, 244 };
    msTimer _tESP_Disp_Rq_AR;

//  message   ESP_Disp_Rq2_AR ID: 1177 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   ESP_Disp_Rq2_AR _mESP_Disp_Rq2_AR;
    int      _ESP_Disp_Rq2_AR_Timebase;
    int      _ESP_Disp_Rq2_AR_CycleCount;
    int      _ESP_Disp_Rq2_AR_StartDelay;
    int      _ESP_Disp_Rq2_AR_Cnt;
    int      _ESP_Disp_Rq2_AR_SpontanFlag;

    byte     _ESP_Disp_Rq2_AR_E2E_Armed;
    byte     _ESP_Disp_Rq2_AR_CRC_ErrorCnt;
    byte     _ESP_Disp_Rq2_AR_SQC_TriggPos;
    int      _ESP_Disp_Rq2_AR_SQC_WrongSeqJump;
    byte     _ESP_Disp_Rq2_AR_SQC_RepeatedCnt;
    byte     _ESP_Disp_Rq2_AR_MSG_DropCnt;
    byte     _ESP_Disp_Rq2_AR_CRC_Offset[16] = { 161,   8, 106, 204,  51, 149, 247,  94, 192,  39, 137, 235,  82, 180,  27, 125 };
    msTimer _tESP_Disp_Rq2_AR;

//  message   ESP_Disp_Rq3_AR ID: 920 --- Sendeart 0 cyclicX --- 
    message   ESP_Disp_Rq3_AR _mESP_Disp_Rq3_AR;
    int      _ESP_Disp_Rq3_AR_Timebase;
    int      _ESP_Disp_Rq3_AR_CycleCount;
    int      _ESP_Disp_Rq3_AR_StartDelay;
    int      _ESP_Disp_Rq3_AR_Cnt;
    msTimer _tESP_Disp_Rq3_AR;

//  message   ESP_Disp_Rq_AMG_AR ID: 365 --- Sendeart 0 cyclicX --- 
    message   ESP_Disp_Rq_AMG_AR _mESP_Disp_Rq_AMG_AR;
    int      _ESP_Disp_Rq_AMG_AR_Timebase;
    int      _ESP_Disp_Rq_AMG_AR_CycleCount;
    int      _ESP_Disp_Rq_AMG_AR_StartDelay;
    int      _ESP_Disp_Rq_AMG_AR_Cnt;
    msTimer _tESP_Disp_Rq_AMG_AR;
    
//  message   ESP_Stat1_VAN_AR ID: 628 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   ESP_Stat1_VAN_AR _mESP_Stat1_VAN_AR;
    int      _ESP_Stat1_VAN_AR_Timebase;
    int      _ESP_Stat1_VAN_AR_CycleCount;
    int      _ESP_Stat1_VAN_AR_StartDelay;
    int      _ESP_Stat1_VAN_AR_MinDelay;
    int      _ESP_Stat1_VAN_AR_Cnt;
    int      _ESP_Stat1_VAN_AR_SpontanFlag;
    int      _ESP_Stat1_VAN_AR_DelayCnt;

    byte     _ESP_Stat1_VAN_AR_E2E_Armed;
    byte     _ESP_Stat1_VAN_AR_CRC_ErrorCnt;
    byte     _ESP_Stat1_VAN_AR_SQC_TriggPos;
    int      _ESP_Stat1_VAN_AR_SQC_WrongSeqJump;
    byte     _ESP_Stat1_VAN_AR_SQC_RepeatedCnt;
    byte     _ESP_Stat1_VAN_AR_MSG_DropCnt;
    byte     _ESP_Stat1_VAN_AR_CRC_Offset[16] = { 210, 44, 129, 214, 48, 133, 218, 52, 137, 222, 56, 141, 226, 60, 145, 230 };
    msTimer _tESP_Stat1_VAN_AR;    

//  message   EVC_CfgBit_01_32_AR ID: 753 --- Sendeart 0 cyclicX --- 
    message   EVC_CfgBit_01_32_AR _mEVC_CfgBit_01_32_AR;
    int      _EVC_CfgBit_01_32_AR_Timebase;
    int      _EVC_CfgBit_01_32_AR_CycleCount;
    int      _EVC_CfgBit_01_32_AR_StartDelay;
    int      _EVC_CfgBit_01_32_AR_Cnt;

    byte     _EVC_CfgBit_01_32_AR_E2E_Armed;
    byte     _EVC_CfgBit_01_32_AR_CRC_ErrorCnt;
    byte     _EVC_CfgBit_01_32_AR_SQC_TriggPos;
    int      _EVC_CfgBit_01_32_AR_SQC_WrongSeqJump;
    byte     _EVC_CfgBit_01_32_AR_SQC_RepeatedCnt;
    byte     _EVC_CfgBit_01_32_AR_MSG_DropCnt;
    byte     _EVC_CfgBit_01_32_AR_CRC_Offset[16] = { 153, 210,  16,  73, 130, 187, 244,  50, 107, 164, 221,  27,  84, 141, 198,   4 };
    msTimer _tEVC_CfgBit_01_32_AR;

//  message   EVC_CfgBit_33_64_AR ID: 755 --- Sendeart 0 cyclicX --- 
    message   EVC_CfgBit_33_64_AR _mEVC_CfgBit_33_64_AR;
    int      _EVC_CfgBit_33_64_AR_Timebase;
    int      _EVC_CfgBit_33_64_AR_CycleCount;
    int      _EVC_CfgBit_33_64_AR_StartDelay;
    int      _EVC_CfgBit_33_64_AR_Cnt;

    byte     _EVC_CfgBit_33_64_AR_E2E_Armed;
    byte     _EVC_CfgBit_33_64_AR_CRC_ErrorCnt;
    byte     _EVC_CfgBit_33_64_AR_SQC_TriggPos;
    int      _EVC_CfgBit_33_64_AR_SQC_WrongSeqJump;
    byte     _EVC_CfgBit_33_64_AR_SQC_RepeatedCnt;
    byte     _EVC_CfgBit_33_64_AR_MSG_DropCnt;
    byte     _EVC_CfgBit_33_64_AR_CRC_Offset[16] = {  83, 104, 125, 146, 167, 188, 209, 230, 251,  21,  42,  63,  84, 105, 126, 147 };
    msTimer _tEVC_CfgBit_33_64_AR;

//  message   EVC_CfgBit_65_96_AR ID: 757 --- Sendeart 0 cyclicX --- 
    message   EVC_CfgBit_65_96_AR _mEVC_CfgBit_65_96_AR;
    int      _EVC_CfgBit_65_96_AR_Timebase;
    int      _EVC_CfgBit_65_96_AR_CycleCount;
    int      _EVC_CfgBit_65_96_AR_StartDelay;
    int      _EVC_CfgBit_65_96_AR_Cnt;

    byte     _EVC_CfgBit_65_96_AR_E2E_Armed;
    byte     _EVC_CfgBit_65_96_AR_CRC_ErrorCnt;
    byte     _EVC_CfgBit_65_96_AR_SQC_TriggPos;
    int      _EVC_CfgBit_65_96_AR_SQC_WrongSeqJump;
    byte     _EVC_CfgBit_65_96_AR_SQC_RepeatedCnt;
    byte     _EVC_CfgBit_65_96_AR_MSG_DropCnt;
    byte     _EVC_CfgBit_65_96_AR_CRC_Offset[16] = {  35,  85, 135, 185, 235,  34,  84, 134, 184, 234,  33,  83, 133, 183, 233,  32 };
    msTimer _tEVC_CfgBit_65_96_AR;

//  message   EVC_CfgBit_97_C8_AR ID: 910 --- Sendeart 0 cyclicX --- 
    message   EVC_CfgBit_97_C8_AR _mEVC_CfgBit_97_C8_AR;
    int      _EVC_CfgBit_97_C8_AR_Timebase;
    int      _EVC_CfgBit_97_C8_AR_CycleCount;
    int      _EVC_CfgBit_97_C8_AR_StartDelay;
    int      _EVC_CfgBit_97_C8_AR_Cnt;

    byte     _EVC_CfgBit_97_C8_AR_E2E_Armed;
    byte     _EVC_CfgBit_97_C8_AR_CRC_ErrorCnt;
    byte     _EVC_CfgBit_97_C8_AR_SQC_TriggPos;
    int      _EVC_CfgBit_97_C8_AR_SQC_WrongSeqJump;
    byte     _EVC_CfgBit_97_C8_AR_SQC_RepeatedCnt;
    byte     _EVC_CfgBit_97_C8_AR_MSG_DropCnt;
    byte     _EVC_CfgBit_97_C8_AR_CRC_Offset[16] = {  13, 128, 243, 107, 222,  86, 201,  65, 180,  44, 159,  23, 138, 253, 117, 232 };
    msTimer _tEVC_CfgBit_97_C8_AR;

//  message   EVC_CfgList_01_0C_AR ID: 759 --- Sendeart 0 cyclicX --- 
    message   EVC_CfgList_01_0C_AR _mEVC_CfgList_01_0C_AR;
    int      _EVC_CfgList_01_0C_AR_Timebase;
    int      _EVC_CfgList_01_0C_AR_CycleCount;
    int      _EVC_CfgList_01_0C_AR_StartDelay;
    int      _EVC_CfgList_01_0C_AR_Cnt;

    byte     _EVC_CfgList_01_0C_AR_E2E_Armed;
    byte     _EVC_CfgList_01_0C_AR_CRC_ErrorCnt;
    byte     _EVC_CfgList_01_0C_AR_SQC_TriggPos;
    int      _EVC_CfgList_01_0C_AR_SQC_WrongSeqJump;
    byte     _EVC_CfgList_01_0C_AR_SQC_RepeatedCnt;
    byte     _EVC_CfgList_01_0C_AR_MSG_DropCnt;
    byte     _EVC_CfgList_01_0C_AR_CRC_Offset[16] = { 198,  92, 237, 131,  25, 170,  64, 209, 103, 248, 142,  36, 181,  75, 220, 114 };
    msTimer _tEVC_CfgList_01_0C_AR;

//  message   EVC_CfgVAN_AR ID: 994 --- Sendeart 0 cyclicX --- 
    message   EVC_CfgVAN_AR _mEVC_CfgVAN_AR;
    int      _EVC_CfgVAN_AR_Timebase;
    int      _EVC_CfgVAN_AR_CycleCount;
    int      _EVC_CfgVAN_AR_StartDelay;
    int      _EVC_CfgVAN_AR_Cnt;

    byte     _EVC_CfgVAN_AR_E2E_Armed;
    byte     _EVC_CfgVAN_AR_CRC_ErrorCnt;
    byte     _EVC_CfgVAN_AR_SQC_TriggPos;
    int      _EVC_CfgVAN_AR_SQC_WrongSeqJump;
    byte     _EVC_CfgVAN_AR_SQC_RepeatedCnt;
    byte     _EVC_CfgVAN_AR_MSG_DropCnt;
    byte     _EVC_CfgVAN_AR_CRC_Offset[16] = {   4, 175,  95,  15, 186, 106,  26, 197, 117,  37, 208, 128,  48, 219, 139,  59 };
    msTimer _tEVC_CfgVAN_AR;
	
//  message   ExitWarn_Disp_Rq_AR  ID: 1008 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   ExitWarn_Disp_Rq_AR _mExitWarn_Disp_Rq_AR;
    int      _ExitWarn_Disp_Rq_AR_Timebase;
    int      _ExitWarn_Disp_Rq_AR_CycleCount;
    int      _ExitWarn_Disp_Rq_AR_Cnt;
    int      _ExitWarn_Disp_Rq_AR_StartDelay;
    int      _ExitWarn_Disp_Rq_AR_SpontanFlag;
    int      _ExitWarn_Disp_Rq_AR_MinDelay;
    int      _ExitWarn_Disp_Rq_AR_DelayCnt;
    msTimer _tExitWarn_Disp_Rq_AR;

//  message   FBL_CFG_Star2_AR ID: 104 --- Sendeart 0 cyclicX --- 
    message   FBL_CFG_Star2_AR _mFBL_CFG_Star2_AR;
    int      _FBL_CFG_Star2_AR_Timebase;
    int      _FBL_CFG_Star2_AR_CycleCount;
    int      _FBL_CFG_Star2_AR_StartDelay;
    int      _FBL_CFG_Star2_AR_Cnt;
    msTimer _tFBL_CFG_Star2_AR;

//  message   FCW_Disp_Rq_AR ID: 1173 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   FCW_Disp_Rq_AR _mFCW_Disp_Rq_AR;
    int      _FCW_Disp_Rq_AR_Timebase;
    int      _FCW_Disp_Rq_AR_CycleCount;
    int      _FCW_Disp_Rq_AR_StartDelay;
    int      _FCW_Disp_Rq_AR_MinDelay;
    int      _FCW_Disp_Rq_AR_Cnt;
    int      _FCW_Disp_Rq_AR_SpontanFlag;
    int      _FCW_Disp_Rq_AR_DelayCnt;
    msTimer _tFCW_Disp_Rq_AR;
    
//  message   FDC_Disp_Rq_AR ID: 2223505408 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   FDC_Disp_Rq_AR _mFDC_Disp_Rq_AR;
    int      _FDC_Disp_Rq_AR_Timebase;
    int      _FDC_Disp_Rq_AR_CycleCount;
    int      _FDC_Disp_Rq_AR_StartDelay;
    int      _FDC_Disp_Rq_AR_Cnt;
    int      _FDC_Disp_Rq_AR_SpontanFlag;
    int      _FDC_Disp_Rq_AR_DelayCnt;
    int      _FDC_Disp_Rq_AR_MinDelay;

    byte     _FDC_Disp_Rq_AR_E2E_Armed;
    byte     _FDC_Disp_Rq_AR_CRC_ErrorCnt;
    byte     _FDC_Disp_Rq_AR_SQC_TriggPos;
    int      _FDC_Disp_Rq_AR_SQC_WrongSeqJump;
    byte     _FDC_Disp_Rq_AR_SQC_RepeatedCnt;
    byte     _FDC_Disp_Rq_AR_MSG_DropCnt;
    byte     _FDC_Disp_Rq_AR_CRC_Offset[16] = { 197, 155, 113, 71, 29, 238, 196, 154, 112, 70, 28, 237, 195, 153, 111, 69 };
    msTimer _tFDC_Disp_Rq_AR;    

//  Botschaft FlashOverTheAir_Stat_AR ID: 1160 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   FlashOverTheAir_Stat_AR _mFlashOverTheAir_Stat_AR;
    int      _FlashOverTheAir_Stat_AR_Timebase;
    int      _FlashOverTheAir_Stat_AR_CycleCount;
    int      _FlashOverTheAir_Stat_AR_StartDelay;
    int      _FlashOverTheAir_Stat_AR_MinDelay;
    int      _FlashOverTheAir_Stat_AR_Cnt;
    int      _FlashOverTheAir_Stat_AR_SpontanFlag;
    int      _FlashOverTheAir_Stat_AR_DelayCnt;
    msTimer _tFlashOverTheAir_Stat_AR;

//  message   FuelLvl_Stat_AR ID: 766 --- Sendeart 0 cyclicX --- 
    message   FuelLvl_Stat_AR _mFuelLvl_Stat_AR;
    int      _FuelLvl_Stat_AR_Timebase;
    int      _FuelLvl_Stat_AR_CycleCount;
    int      _FuelLvl_Stat_AR_StartDelay;
    int      _FuelLvl_Stat_AR_Cnt;
    msTimer _tFuelLvl_Stat_AR;

//  message   Fuel_Stat2_AR ID: 1190 --- Sendeart 0 cyclicX --- 
    message   Fuel_Stat2_AR _mFuel_Stat2_AR;
    int      _Fuel_Stat2_AR_Timebase;
    int      _Fuel_Stat2_AR_CycleCount;
    int      _Fuel_Stat2_AR_StartDelay;
    int      _Fuel_Stat2_AR_Cnt;
    msTimer _tFuel_Stat2_AR;

//  message   FWLP_D_AR ID: 1191 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   FWLP_D_AR _mFWLP_D_AR;
    int      _FWLP_D_AR_Timebase;
    int      _FWLP_D_AR_CycleCount;
    int      _FWLP_D_AR_StartDelay;
    int      _FWLP_D_AR_MinDelay;
    int      _FWLP_D_AR_Cnt;
    int      _FWLP_D_AR_SpontanFlag;
    int      _FWLP_D_AR_DelayCnt;
    msTimer _tFWLP_D_AR;

//  message   FWLP_P_AR ID: 1189 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   FWLP_P_AR _mFWLP_P_AR;
    int      _FWLP_P_AR_Timebase;
    int      _FWLP_P_AR_CycleCount;
    int      _FWLP_P_AR_StartDelay;
    int      _FWLP_P_AR_MinDelay;
    int      _FWLP_P_AR_Cnt;
    int      _FWLP_P_AR_SpontanFlag;
    int      _FWLP_P_AR_DelayCnt;
    msTimer _tFWLP_P_AR;
	
//  message HAD_MDC_CamLane_MapLrn_Attr1_AR ID: 2434793472 --- Sendeart 5 cyclicAndSpontanWithDelay ---
	message HAD_MDC_CamLane_MapLrn_Attr1_AR _mHAD_MDC_CamLane_MapLrn_Attr1_AR;
	int		_HAD_MDC_CamLane_MapLrn_Attr1_AR_Timebase;
	int		_HAD_MDC_CamLane_MapLrn_Attr1_AR_CycleCount;
	int		_HAD_MDC_CamLane_MapLrn_Attr1_AR_StartDelay;
	int		_HAD_MDC_CamLane_MapLrn_Attr1_AR_MinDelay;
	int		_HAD_MDC_CamLane_MapLrn_Attr1_AR_Cnt;
	int		_HAD_MDC_CamLane_MapLrn_Attr1_AR_SpontanFlag;
	int		_HAD_MDC_CamLane_MapLrn_Attr1_AR_DelayCnt;
	msTimer	_tHAD_MDC_CamLane_MapLrn_Attr1_AR;
	
//	message HAD_MDC_CamObj_MapLrn_Attr1_AR ID: 2371092480 --- Sendeart 5 cyclicAndSpontanWithDelay ---
	message	HAD_MDC_CamObj_MapLrn_Attr1_AR _mHAD_MDC_CamObj_MapLrn_Attr1_AR;
	int		_HAD_MDC_CamObj_MapLrn_Attr1_AR_Timebase;
	int		_HAD_MDC_CamObj_MapLrn_Attr1_AR_CycleCount;
	int		_HAD_MDC_CamObj_MapLrn_Attr1_AR_StartDelay;
	int		_HAD_MDC_CamObj_MapLrn_Attr1_AR_MinDelay;
	int		_HAD_MDC_CamObj_MapLrn_Attr1_AR_Cnt;
	int		_HAD_MDC_CamObj_MapLrn_Attr1_AR_SpontanFlag;
	int		_HAD_MDC_CamObj_MapLrn_Attr1_AR_DelayCnt;
	msTimer	_tHAD_MDC_CamObj_MapLrn_Attr1_AR;
	
//	message	HAD_MDC_MapData2_AR ID: 2371354624 --- Sendeart 5 cyclicAndSpontanWithDelay ---
	message	HAD_MDC_MapData2_AR _mHAD_MDC_MapData2_AR;
	int		_HAD_MDC_MapData2_AR_Timebase;
	int		_HAD_MDC_MapData2_AR_CycleCount;
	int		_HAD_MDC_MapData2_AR_StartDelay;
	int		_HAD_MDC_MapData2_AR_MinDelay;
	int		_HAD_MDC_MapData2_AR_Cnt;
	int		_HAD_MDC_MapData2_AR_SpontanFlag;
	int		_HAD_MDC_MapData2_AR_DelayCnt;
	msTimer	_tHAD_MDC_MapData2_AR;
	
//	message HAD_MDC_MapLrn_Attr1_AR ID: 2431647744 --- Sendeart 5 cyclicAndSpontanWithDelay ---
	message	HAD_MDC_MapLrn_Attr1_AR	_mHAD_MDC_MapLrn_Attr1_AR;
	int		_HAD_MDC_MapLrn_Attr1_AR_Timebase;
	int		_HAD_MDC_MapLrn_Attr1_AR_CycleCount;
	int		_HAD_MDC_MapLrn_Attr1_AR_StartDelay;
	int		_HAD_MDC_MapLrn_Attr1_AR_MinDelay;
	int		_HAD_MDC_MapLrn_Attr1_AR_Cnt;
	int		_HAD_MDC_MapLrn_Attr1_AR_SpontanFlag;
	int		_HAD_MDC_MapLrn_Attr1_AR_DelayCnt;
	msTimer	_tHAD_MDC_MapLrn_Attr1_AR;
	
//	message	HAD_MDC_TSR_Sign_Attr1_AR ID: 1040 --- Sendeart 5 cyclicAndSpontanWithDelay ---
	message	HAD_MDC_TSR_Sign_Attr1_AR _mHAD_MDC_TSR_Sign_Attr1_AR;
	int		_HAD_MDC_TSR_Sign_Attr1_AR_Timebase;
	int		_HAD_MDC_TSR_Sign_Attr1_AR_CycleCount;
	int		_HAD_MDC_TSR_Sign_Attr1_AR_StartDelay;
	int		_HAD_MDC_TSR_Sign_Attr1_AR_MinDelay;
	int		_HAD_MDC_TSR_Sign_Attr1_AR_Cnt;
	int		_HAD_MDC_TSR_Sign_Attr1_AR_SpontanFlag;
	int		_HAD_MDC_TSR_Sign_Attr1_AR_DelayCnt;
	msTimer	_tHAD_MDC_TSR_Sign_Attr1_AR;
	
//	message	HAD_MDC_TSR_Sign_Attr2_AR ID: 2431909888 --- Sendeart 5 cyclicAndSpontanWithDelay ---
	message	HAD_MDC_TSR_Sign_Attr2_AR _mHAD_MDC_TSR_Sign_Attr2_AR;
	int		_HAD_MDC_TSR_Sign_Attr2_AR_Timebase;
	int		_HAD_MDC_TSR_Sign_Attr2_AR_CycleCount;
	int		_HAD_MDC_TSR_Sign_Attr2_AR_StartDelay;
	int		_HAD_MDC_TSR_Sign_Attr2_AR_MinDelay;
	int		_HAD_MDC_TSR_Sign_Attr2_AR_Cnt;
	int		_HAD_MDC_TSR_Sign_Attr2_AR_SpontanFlag;
	int		_HAD_MDC_TSR_Sign_Attr2_AR_DelayCnt;
	msTimer _tHAD_MDC_TSR_Sign_Attr2_AR;
	
//  message  HFP_R5_AR2_DAI ID: 2430074880 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   HFP_R5_AR2_DAI _mHFP_R5_AR2_DAI;
    int      _HFP_R5_AR2_DAI_Timebase;
    int      _HFP_R5_AR2_DAI_CycleCount;
    int      _HFP_R5_AR2_DAI_StartDelay;
    int      _HFP_R5_AR2_DAI_MinDelay;
    int      _HFP_R5_AR2_DAI_Cnt;
    int      _HFP_R5_AR2_DAI_SpontanFlag;
    int      _HFP_R5_AR2_DAI_DelayCnt;
    msTimer  _tHFP_R5_AR2_DAI;
	
//	message HMIG_Stat_AR ID: 2347761664
	message HMIG_Stat_AR _mHMIG_Stat_AR;
	int	 _HMIG_Stat_AR_Timebase;
	int	 _HMIG_Stat_AR_CycleCount;
	int	 _HMIG_Stat_AR_StartDelay;
	int	 _HMIG_Stat_AR_MinDelay;
	int	 _HMIG_Stat_AR_Cnt;
	int	 _HMIG_Stat_AR_SpontanFlag;
	int	 _HMIG_Stat_AR_DelayCnt;
	
	byte     _HMIG_Stat_AR_E2E_Armed;
    byte     _HMIG_Stat_AR_CRC_ErrorCnt;
    byte     _HMIG_Stat_AR_SQC_TriggPos;
    int      _HMIG_Stat_AR_SQC_WrongSeqJump;
    byte     _HMIG_Stat_AR_SQC_RepeatedCnt;
    byte     _HMIG_Stat_AR_MSG_DropCnt;
    byte     _HMIG_Stat_AR_CRC_Offset[16] = { 9, 169, 78, 238, 147, 56, 216, 125, 34, 194, 103, 12, 172, 81, 241, 150 };
    msTimer _tHMIG_Stat_AR;
	

//  message   HumanMachineIfc_AR ID:489 --- Sendeart 0 cyclicX --- 
    message   HumanMachineIfc_AR _mHumanMachineIfc_AR;
    int      _HumanMachineIfc_AR_Timebase;
    int      _HumanMachineIfc_AR_CycleCount;
    int      _HumanMachineIfc_AR_StartDelay;
    int      _HumanMachineIfc_AR_Cnt;
    int      _HumanMachineIfc_AR_SpontanFlag;
    msTimer _tHumanMachineIfc_AR;

//  message   HumanMachineIfc2_AR ID:1028 --- Sendeart 0 cyclicX --- 
    message   HumanMachineIfc2_AR _mHumanMachineIfc2_AR;
    int      _HumanMachineIfc2_AR_Timebase;
    int      _HumanMachineIfc2_AR_CycleCount;
    int      _HumanMachineIfc2_AR_StartDelay;
    int      _HumanMachineIfc2_AR_Cnt;
    int      _HumanMachineIfc2_AR_SpontanFlag;
    msTimer _tHumanMachineIfc2_AR;
	
//  message   HumanMachineIfc_Rq_AR ID: 269 --- Sendeart 0 cyclicX --- 
    message   HumanMachineIfc_Rq_AR _mHumanMachineIfc_Rq_AR;
    int      _HumanMachineIfc_Rq_AR_Timebase;
    int      _HumanMachineIfc_Rq_AR_CycleCount;
    int      _HumanMachineIfc_Rq_AR_StartDelay;
    int      _HumanMachineIfc_Rq_AR_Cnt;
    msTimer _tHumanMachineIfc_Rq_AR;

//  message   HVAC_Disp_Stat1_AR ID: 851 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   HVAC_Disp_Stat1_AR _mHVAC_Disp_Stat1_AR;
    int      _HVAC_Disp_Stat1_AR_Timebase;
    int      _HVAC_Disp_Stat1_AR_CycleCount;
    int      _HVAC_Disp_Stat1_AR_StartDelay;
    int      _HVAC_Disp_Stat1_AR_Cnt;
    int      _HVAC_Disp_Stat1_AR_SpontanFlag;
    msTimer _tHVAC_Disp_Stat1_AR;

//  message   HVAC_Disp_Stat2_AR ID: 853 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   HVAC_Disp_Stat2_AR _mHVAC_Disp_Stat2_AR;
    int      _HVAC_Disp_Stat2_AR_Timebase;
    int      _HVAC_Disp_Stat2_AR_CycleCount;
    int      _HVAC_Disp_Stat2_AR_StartDelay;
    int      _HVAC_Disp_Stat2_AR_Cnt;
    int      _HVAC_Disp_Stat2_AR_SpontanFlag;
    msTimer _tHVAC_Disp_Stat2_AR;

//  message   HVAC_Disp_Stat3_AR ID: 855 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   HVAC_Disp_Stat3_AR _mHVAC_Disp_Stat3_AR;
    int      _HVAC_Disp_Stat3_AR_Timebase;
    int      _HVAC_Disp_Stat3_AR_CycleCount;
    int      _HVAC_Disp_Stat3_AR_StartDelay;
    int      _HVAC_Disp_Stat3_AR_MinDelay;
    int      _HVAC_Disp_Stat3_AR_Cnt;
    int      _HVAC_Disp_Stat3_AR_SpontanFlag;
    int      _HVAC_Disp_Stat3_AR_DelayCnt;
    msTimer _tHVAC_Disp_Stat3_AR;

//  message   HVAC_Disp_Stat4_AR ID: 1120 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   HVAC_Disp_Stat4_AR _mHVAC_Disp_Stat4_AR;
    int      _HVAC_Disp_Stat4_AR_Timebase;
    int      _HVAC_Disp_Stat4_AR_CycleCount;
    int      _HVAC_Disp_Stat4_AR_StartDelay;
    int      _HVAC_Disp_Stat4_AR_MinDelay;
    int      _HVAC_Disp_Stat4_AR_Cnt;
    int      _HVAC_Disp_Stat4_AR_SpontanFlag;
    int      _HVAC_Disp_Stat4_AR_DelayCnt;
    msTimer _tHVAC_Disp_Stat4_AR;	
	
//  message   HVAC_State1_AR ID: 895 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   HVAC_State1_AR _mHVAC_State1_AR;
    int      _HVAC_State1_AR_Timebase;
    int      _HVAC_State1_AR_CycleCount;
    int      _HVAC_State1_AR_StartDelay;
    int      _HVAC_State1_AR_Cnt;
    int      _HVAC_State1_AR_SpontanFlag;
    msTimer _tHVAC_State1_AR;

//  message   ICH_PreTime_Stat_AR ID: 889 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   ICH_PreTime_Stat_AR _mICH_PreTime_Stat_AR;
    int      _ICH_PreTime_Stat_AR_Timebase;
    int      _ICH_PreTime_Stat_AR_CycleCount;
    int      _ICH_PreTime_Stat_AR_StartDelay;
    int      _ICH_PreTime_Stat_AR_Cnt;
    int      _ICH_PreTime_Stat_AR_SpontanFlag;
    msTimer _tICH_PreTime_Stat_AR;

//  message   ICH_Stat_AR ID: 887 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   ICH_Stat_AR _mICH_Stat_AR;
    int      _ICH_Stat_AR_Timebase;
    int      _ICH_Stat_AR_CycleCount;
    int      _ICH_Stat_AR_StartDelay;
    int      _ICH_Stat_AR_Cnt;
    int      _ICH_Stat_AR_SpontanFlag;
    msTimer _tICH_Stat_AR;

//  message   Ign_Veh_Stat_AR ID: 32 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Ign_Veh_Stat_AR _mIgn_Veh_Stat_AR;
    int      _Ign_Veh_Stat_AR_Timebase;
    int      _Ign_Veh_Stat_AR_CycleCount;
    int      _Ign_Veh_Stat_AR_StartDelay;
    int      _Ign_Veh_Stat_AR_Cnt;
    int      _Ign_Veh_Stat_AR_SpontanFlag;

    byte     _Ign_Veh_Stat_AR_E2E_Armed;
    byte     _Ign_Veh_Stat_AR_CRC_ErrorCnt;
    byte     _Ign_Veh_Stat_AR_SQC_TriggPos;
    int      _Ign_Veh_Stat_AR_SQC_WrongSeqJump;
    byte     _Ign_Veh_Stat_AR_SQC_RepeatedCnt;
    byte     _Ign_Veh_Stat_AR_MSG_DropCnt;
    byte     _Ign_Veh_Stat_AR_CRC_Offset[16] = { 167, 211,   4,  48,  92, 136, 180, 224,  17,  61, 105, 149, 193, 237,  30,  74 };
    msTimer _tIgn_Veh_Stat_AR;

//  message   IHC_Lgt_Stat_MPC_AR ID: 551 --- Sendeart 0 cyclicX --- 
    message   IHC_Lgt_Stat_MPC_AR _mIHC_Lgt_Stat_MPC_AR;
    int      _IHC_Lgt_Stat_MPC_AR_Timebase;
    int      _IHC_Lgt_Stat_MPC_AR_CycleCount;
    int      _IHC_Lgt_Stat_MPC_AR_StartDelay;
    int      _IHC_Lgt_Stat_MPC_AR_Cnt;

    byte     _IHC_Lgt_Stat_MPC_AR_E2E_Armed;
    byte     _IHC_Lgt_Stat_MPC_AR_CRC_ErrorCnt;
    byte     _IHC_Lgt_Stat_MPC_AR_SQC_TriggPos;
    int      _IHC_Lgt_Stat_MPC_AR_SQC_WrongSeqJump;
    byte     _IHC_Lgt_Stat_MPC_AR_SQC_RepeatedCnt;
    byte     _IHC_Lgt_Stat_MPC_AR_MSG_DropCnt;
    byte     _IHC_Lgt_Stat_MPC_AR_CRC_Offset[16] = {  79, 195,  60, 176,  41, 157,  22, 138,   3, 119, 235, 100, 216,  81, 197,  62 };
    msTimer _tIHC_Lgt_Stat_MPC_AR;

//  message   IL_AmbLgt_Disp_AR ID: 1067 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   IL_AmbLgt_Disp_AR _mIL_AmbLgt_Disp_AR;
    int      _IL_AmbLgt_Disp_AR_Timebase;
    int      _IL_AmbLgt_Disp_AR_CycleCount;
    int      _IL_AmbLgt_Disp_AR_StartDelay;
    int      _IL_AmbLgt_Disp_AR_Cnt;
    int      _IL_AmbLgt_Disp_AR_SpontanFlag;
    msTimer _tIL_AmbLgt_Disp_AR;

//  message   IL_AmbLgtCfg_Stat_AR --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   IL_AmbLgtCfg_Stat_AR _mIL_AmbLgtCfg_Stat_AR;
    int      _IL_AmbLgtCfg_Stat_AR_Timebase;
    int      _IL_AmbLgtCfg_Stat_AR_CycleCount;
    int      _IL_AmbLgtCfg_Stat_AR_StartDelay;
    int      _IL_AmbLgtCfg_Stat_AR_Cnt;
    int      _IL_AmbLgtCfg_Stat_AR_SpontanFlag;
    msTimer _tIL_AmbLgtCfg_Stat_AR;

//  message   IL_AmbLgtCfg_Stat_AR ID: 846 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   IL_AmbLgtCfg_Stat2_AR _mIL_AmbLgtCfg_Stat2_AR;
    int      _IL_AmbLgtCfg_Stat2_AR_Timebase;
    int      _IL_AmbLgtCfg_Stat2_AR_CycleCount;
    int      _IL_AmbLgtCfg_Stat2_AR_StartDelay;
    int      _IL_AmbLgtCfg_Stat2_AR_Cnt;
    int      _IL_AmbLgtCfg_Stat2_AR_SpontanFlag;
    msTimer _tIL_AmbLgtCfg_Stat2_AR;

//  message   IL_Stat2_AR ID: 830 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   IL_Stat2_AR _mIL_Stat2_AR;
    int      _IL_Stat2_AR_Timebase;
    int      _IL_Stat2_AR_CycleCount;
    int      _IL_Stat2_AR_StartDelay;
    int      _IL_Stat2_AR_Cnt;
    int      _IL_Stat2_AR_SpontanFlag;
    msTimer _tIL_Stat2_AR;

//  message   Immobilizer_Disp_Rq_AR ID: 1037 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Immobilizer_Disp_Rq_AR _mImmobilizer_Disp_Rq_AR;
    int      _Immobilizer_Disp_Rq_AR_Timebase;
    int      _Immobilizer_Disp_Rq_AR_CycleCount;
    int      _Immobilizer_Disp_Rq_AR_StartDelay;
    int      _Immobilizer_Disp_Rq_AR_Cnt;
    int      _Immobilizer_Disp_Rq_AR_SpontanFlag;
    msTimer _tImmobilizer_Disp_Rq_AR;

//  message   Immobilizer_IC_AR ID: 1039 --- Sendeart 0 cyclicX --- 
    message   Immobilizer_IC_AR _mImmobilizer_IC_AR;
    int      _Immobilizer_IC_AR_Timebase;
    int      _Immobilizer_IC_AR_CycleCount;
    int      _Immobilizer_IC_AR_StartDelay;
    int      _Immobilizer_IC_AR_Cnt;
    msTimer _tImmobilizer_IC_AR;

//  message   Immobilizer_KeyID_AR ID: 1038 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Immobilizer_KeyID_AR _mImmobilizer_KeyID_AR;
    int      _Immobilizer_KeyID_AR_Timebase;
    int      _Immobilizer_KeyID_AR_CycleCount;
    int      _Immobilizer_KeyID_AR_StartDelay;
    int      _Immobilizer_KeyID_AR_MinDelay;
    int      _Immobilizer_KeyID_AR_Cnt;
    int      _Immobilizer_KeyID_AR_SpontanFlag;
    int      _Immobilizer_KeyID_AR_DelayCnt;

    byte     _Immobilizer_KeyID_AR_E2E_Armed;
    byte     _Immobilizer_KeyID_AR_CRC_ErrorCnt;
    byte     _Immobilizer_KeyID_AR_SQC_TriggPos;
    int      _Immobilizer_KeyID_AR_SQC_WrongSeqJump;
    byte     _Immobilizer_KeyID_AR_SQC_RepeatedCnt;
    byte     _Immobilizer_KeyID_AR_MSG_DropCnt;
    byte     _Immobilizer_KeyID_AR_CRC_Offset[16] = {  20,  57,  94, 131, 168, 205, 242,  28,  65, 102, 139, 176, 213, 250,  36,  73 };
    msTimer _tImmobilizer_KeyID_AR;
    
//  message   KEP_MODE_DISP_RQ ID: 1115 --- Sendeart 0 cyclicX --- 
    message   KEP_MODE_DISP_RQ _mKEP_MODE_DISP_RQ;
    int      _KEP_MODE_DISP_RQ_Timebase;
    int      _KEP_MODE_DISP_RQ_CycleCount;
    int      _KEP_MODE_DISP_RQ_StartDelay;
    int      _KEP_MODE_DISP_RQ_Cnt;
    msTimer _tKEP_MODE_DISP_RQ;

//  message   KG_Msg_Disp_Rq_AR ID: 857 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   KG_Msg_Disp_Rq_AR _mKG_Msg_Disp_Rq_AR;
    int      _KG_Msg_Disp_Rq_AR_Timebase;
    int      _KG_Msg_Disp_Rq_AR_CycleCount;
    int      _KG_Msg_Disp_Rq_AR_StartDelay;
    int      _KG_Msg_Disp_Rq_AR_Cnt;
    int      _KG_Msg_Disp_Rq_AR_SpontanFlag;
    msTimer _tKG_Msg_Disp_Rq_AR;

//  message   KG_State_AR ID: 859 --- Sendeart 0 cyclicX --- 
    message   KG_State_AR _mKG_State_AR;
    int      _KG_State_AR_Timebase;
    int      _KG_State_AR_CycleCount;
    int      _KG_State_AR_StartDelay;
    int      _KG_State_AR_Cnt;

    byte     _KG_State_AR_E2E_Armed;
    byte     _KG_State_AR_CRC_ErrorCnt;
    byte     _KG_State_AR_SQC_TriggPos;
    int      _KG_State_AR_SQC_WrongSeqJump;
    byte     _KG_State_AR_SQC_RepeatedCnt;
    byte     _KG_State_AR_MSG_DropCnt;
    byte     _KG_State_AR_CRC_Offset[16] = { 191,  71, 202,  82, 213,  93, 224, 104, 235, 115, 246, 126,   6, 137,  17, 148 };
    msTimer _tKG_State_AR;

//  message   LDC_Disp_Rq_ESP_AR ID: 1047 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   LDC_Disp_Rq_ESP_AR _mLDC_Disp_Rq_ESP_AR;
    int      _LDC_Disp_Rq_ESP_AR_Timebase;
    int      _LDC_Disp_Rq_ESP_AR_CycleCount;
    int      _LDC_Disp_Rq_ESP_AR_StartDelay;
    int      _LDC_Disp_Rq_ESP_AR_Cnt;
    int      _LDC_Disp_Rq_ESP_AR_SpontanFlag;
    msTimer _tLDC_Disp_Rq_ESP_AR;
	
//  message   LDC_Disp_Rq2_ESP_AR ID: 1004 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   LDC_Disp_Rq2_ESP_AR _mLDC_Disp_Rq2_ESP_AR;
    int      _LDC_Disp_Rq2_ESP_AR_Timebase;
    int      _LDC_Disp_Rq2_ESP_AR_CycleCount;
    int      _LDC_Disp_Rq2_ESP_AR_StartDelay;
    int      _LDC_Disp_Rq2_ESP_AR_MinDelay;
    int      _LDC_Disp_Rq2_ESP_AR_Cnt;
    int      _LDC_Disp_Rq2_ESP_AR_SpontanFlag;
    int      _LDC_Disp_Rq2_ESP_AR_DelayCnt;
    msTimer _tLDC_Disp_Rq2_ESP_AR;	

//  message   LDC_Disp_Rq_RDU_AR ID: 1027 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   LDC_Disp_Rq_RDU_AR _mLDC_Disp_Rq_RDU_AR;
    int      _LDC_Disp_Rq_RDU_AR_Timebase;
    int      _LDC_Disp_Rq_RDU_AR_CycleCount;
    int      _LDC_Disp_Rq_RDU_AR_StartDelay;
    int      _LDC_Disp_Rq_RDU_AR_Cnt;
    int      _LDC_Disp_Rq_RDU_AR_SpontanFlag;
    msTimer _tLDC_Disp_Rq_RDU_AR;

//  message   LDC_Disp_Rq2_RDU_AR ID: 1020 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   LDC_Disp_Rq2_RDU_AR _mLDC_Disp_Rq2_RDU_AR;
    int      _LDC_Disp_Rq2_RDU_AR_Timebase;
    int      _LDC_Disp_Rq2_RDU_AR_CycleCount;
    int      _LDC_Disp_Rq2_RDU_AR_StartDelay;
    int      _LDC_Disp_Rq2_RDU_AR_MinDelay;
    int      _LDC_Disp_Rq2_RDU_AR_Cnt;
    int      _LDC_Disp_Rq2_RDU_AR_SpontanFlag;
    int      _LDC_Disp_Rq2_RDU_AR_DelayCnt;
    msTimer _tLDC_Disp_Rq2_RDU_AR;
	
//  message   LDP_Warn_Rq_AR ID: 1026 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   LDP_Warn_Rq_AR _mLDP_Warn_Rq_AR;
    int      _LDP_Warn_Rq_AR_Timebase;
    int      _LDP_Warn_Rq_AR_CycleCount;
    int      _LDP_Warn_Rq_AR_StartDelay;
    int      _LDP_Warn_Rq_AR_MinDelay;
    int      _LDP_Warn_Rq_AR_Cnt;
    int      _LDP_Warn_Rq_AR_SpontanFlag;
    int      _LDP_Warn_Rq_AR_DelayCnt;
    msTimer _tLDP_Warn_Rq_AR;

//  message   LgtSens_State_AR ID: 783 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   LgtSens_State_AR _mLgtSens_State_AR;
    int      _LgtSens_State_AR_Timebase;
    int      _LgtSens_State_AR_CycleCount;
    int      _LgtSens_State_AR_StartDelay;
    int      _LgtSens_State_AR_MinDelay;
    int      _LgtSens_State_AR_Cnt;
    int      _LgtSens_State_AR_SpontanFlag;
    int      _LgtSens_State_AR_DelayCnt;
    msTimer _tLgtSens_State_AR;

//  message   MCMS_FL_AR ID: 793 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   MCMS_FL_AR _mMCMS_FL_AR;
    int      _MCMS_FL_AR_Timebase;
    int      _MCMS_FL_AR_CycleCount;
    int      _MCMS_FL_AR_StartDelay;
    int      _MCMS_FL_AR_Cnt;
    int      _MCMS_FL_AR_SpontanFlag;
    msTimer _tMCMS_FL_AR;

//  message   MCMS_FL_Stat_AR ID: 795 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   MCMS_FL_Stat_AR _mMCMS_FL_Stat_AR;
    int      _MCMS_FL_Stat_AR_Timebase;
    int      _MCMS_FL_Stat_AR_CycleCount;
    int      _MCMS_FL_Stat_AR_StartDelay;
    int      _MCMS_FL_Stat_AR_Cnt;
    int      _MCMS_FL_Stat_AR_SpontanFlag;
    msTimer _tMCMS_FL_Stat_AR;

//  message   MCMS_FR_AR ID: 799 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   MCMS_FR_AR _mMCMS_FR_AR;
    int      _MCMS_FR_AR_Timebase;
    int      _MCMS_FR_AR_CycleCount;
    int      _MCMS_FR_AR_StartDelay;
    int      _MCMS_FR_AR_Cnt;
    int      _MCMS_FR_AR_SpontanFlag;
    msTimer _tMCMS_FR_AR;

//  message   MCMS_FR_Stat_AR ID: 801 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   MCMS_FR_Stat_AR _mMCMS_FR_Stat_AR;
    int      _MCMS_FR_Stat_AR_Timebase;
    int      _MCMS_FR_Stat_AR_CycleCount;
    int      _MCMS_FR_Stat_AR_StartDelay;
    int      _MCMS_FR_Stat_AR_Cnt;
    int      _MCMS_FR_Stat_AR_SpontanFlag;
    msTimer _tMCMS_FR_Stat_AR;

//  message   MCMS_RL_AR ID: 807 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   MCMS_RL_AR _mMCMS_RL_AR;
    int      _MCMS_RL_AR_Timebase;
    int      _MCMS_RL_AR_CycleCount;
    int      _MCMS_RL_AR_StartDelay;
    int      _MCMS_RL_AR_Cnt;
    int      _MCMS_RL_AR_SpontanFlag;
    msTimer _tMCMS_RL_AR;

//  message   MCMS_RL_Stat_AR ID: 809 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   MCMS_RL_Stat_AR _mMCMS_RL_Stat_AR;
    int      _MCMS_RL_Stat_AR_Timebase;
    int      _MCMS_RL_Stat_AR_CycleCount;
    int      _MCMS_RL_Stat_AR_StartDelay;
    int      _MCMS_RL_Stat_AR_Cnt;
    int      _MCMS_RL_Stat_AR_SpontanFlag;
    msTimer _tMCMS_RL_Stat_AR;

//  message   MCMS_RR_AR ID: 813 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   MCMS_RR_AR _mMCMS_RR_AR;
    int      _MCMS_RR_AR_Timebase;
    int      _MCMS_RR_AR_CycleCount;
    int      _MCMS_RR_AR_StartDelay;
    int      _MCMS_RR_AR_Cnt;
    int      _MCMS_RR_AR_SpontanFlag;
    msTimer _tMCMS_RR_AR;

//  message   MCMS_RR_Stat_AR ID: 815 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   MCMS_RR_Stat_AR _mMCMS_RR_Stat_AR;
    int      _MCMS_RR_Stat_AR_Timebase;
    int      _MCMS_RR_Stat_AR_CycleCount;
    int      _MCMS_RR_Stat_AR_StartDelay;
    int      _MCMS_RR_Stat_AR_Cnt;
    int      _MCMS_RR_Stat_AR_SpontanFlag;
    msTimer _tMCMS_RR_Stat_AR;

//  message   OffRoad_Disp_Rq_AR ID:  918 --- Sendeart 0 cyclicX --- 
    message   OffRoad_Disp_Rq_AR _mOffRoad_Disp_Rq_AR;
    int      _OffRoad_Disp_Rq_AR_Timebase;
    int      _OffRoad_Disp_Rq_AR_CycleCount;
    int      _OffRoad_Disp_Rq_AR_StartDelay;
    int      _OffRoad_Disp_Rq_AR_Cnt;
    int      _OffRoad_Disp_Rq_AR_SpontanFlag;
    msTimer _tOffRoad_Disp_Rq_AR;

//  message   Park_Disp_Rq_AR ID: 393 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Park_Disp_Rq_AR _mPark_Disp_Rq_AR;
    int      _Park_Disp_Rq_AR_Timebase;
    int      _Park_Disp_Rq_AR_CycleCount;
    int      _Park_Disp_Rq_AR_StartDelay;
    int      _Park_Disp_Rq_AR_MinDelay;
    int      _Park_Disp_Rq_AR_Cnt;
    int      _Park_Disp_Rq_AR_SpontanFlag;
    int      _Park_Disp_Rq_AR_DelayCnt;

    byte     _Park_Disp_Rq_AR_E2E_Armed;
    byte     _Park_Disp_Rq_AR_CRC_ErrorCnt;
    byte     _Park_Disp_Rq_AR_SQC_TriggPos;
    int      _Park_Disp_Rq_AR_SQC_WrongSeqJump;
    byte     _Park_Disp_Rq_AR_SQC_RepeatedCnt;
    byte     _Park_Disp_Rq_AR_MSG_DropCnt;
    byte     _Park_Disp_Rq_AR_CRC_Offset[16] = { 216,  19,  73, 127, 181, 235,  38,  92, 146, 200,   3,  57, 111, 165, 219,  22 };
    msTimer _tPark_Disp_Rq_AR;

//  message   Park_Set_Stat_AR ID: 1092 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Park_Set_Stat_AR _mPark_Set_Stat_AR;
    int      _Park_Set_Stat_AR_Timebase;
    int      _Park_Set_Stat_AR_CycleCount;
    int      _Park_Set_Stat_AR_StartDelay;
    int      _Park_Set_Stat_AR_MinDelay;
    int      _Park_Set_Stat_AR_Cnt;
    int      _Park_Set_Stat_AR_SpontanFlag;
    int      _Park_Set_Stat_AR_DelayCnt;
    msTimer _tPark_Set_Stat_AR;

//  message   Park_Stat_AR  ID: 1018 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Park_Stat_AR _mPark_Stat_AR;
    int      _Park_Stat_AR_Timebase;
    int      _Park_Stat_AR_CycleCount;
    int      _Park_Stat_AR_StartDelay;
    int      _Park_Stat_AR_MinDelay;
    int      _Park_Stat_AR_Cnt;
    int      _Park_Stat_AR_SpontanFlag;
    int      _Park_Stat_AR_DelayCnt;

    byte     _Park_Stat_AR_E2E_Armed;
    byte     _Park_Stat_AR_CRC_ErrorCnt;
    byte     _Park_Stat_AR_SQC_TriggPos;
    int      _Park_Stat_AR_SQC_WrongSeqJump;
    byte     _Park_Stat_AR_SQC_RepeatedCnt;
    byte     _Park_Stat_AR_MSG_DropCnt;
    byte     _Park_Stat_AR_CRC_Offset[16] = { 39, 136, 233, 79, 176, 22, 119, 216, 62, 159, 5, 102, 199, 45, 142, 239 };
    msTimer _tPark_Stat_AR;    
    
//  message   ParkSpace_Posn_AR ID: 1060 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   ParkSpace_Posn_AR _mParkSpace_Posn_AR;
    int      _ParkSpace_Posn_AR_Timebase;
    int      _ParkSpace_Posn_AR_CycleCount;
    int      _ParkSpace_Posn_AR_StartDelay;
    int      _ParkSpace_Posn_AR_MinDelay;
    int      _ParkSpace_Posn_AR_Cnt;
    int      _ParkSpace_Posn_AR_SpontanFlag;
    int      _ParkSpace_Posn_AR_DelayCnt;
    msTimer _tParkSpace_Posn_AR;
	
//  message   ParkSpaceMeas_Stat_AR ID: 675 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   ParkSpaceMeas_Stat_AR _mParkSpaceMeas_Stat_AR;
    int      _ParkSpaceMeas_Stat_AR_Timebase;
    int      _ParkSpaceMeas_Stat_AR_CycleCount;
    int      _ParkSpaceMeas_Stat_AR_StartDelay;
    int      _ParkSpaceMeas_Stat_AR_MinDelay;
    int      _ParkSpaceMeas_Stat_AR_Cnt;
    int      _ParkSpaceMeas_Stat_AR_SpontanFlag;
    int      _ParkSpaceMeas_Stat_AR_DelayCnt;
    msTimer _tParkSpaceMeas_Stat_AR;

//  message   ParkWarn_AR ID: 1075 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   ParkWarn_AR _mParkWarn_AR;
    int      _ParkWarn_AR_Timebase;
    int      _ParkWarn_AR_CycleCount;
    int      _ParkWarn_AR_StartDelay;
    int      _ParkWarn_AR_Cnt;
    int      _ParkWarn_AR_SpontanFlag;
    msTimer _tParkWarn_AR;

//  message   PERIPHERY_HMI_R1_AR ID: 611 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PERIPHERY_HMI_R1_AR _mPERIPHERY_HMI_R1_AR;
    int      _PERIPHERY_HMI_R1_AR_Timebase;
    int      _PERIPHERY_HMI_R1_AR_CycleCount;
    int      _PERIPHERY_HMI_R1_AR_StartDelay;
    int      _PERIPHERY_HMI_R1_AR_Cnt;
    int      _PERIPHERY_HMI_R1_AR_SpontanFlag;
    msTimer _tPERIPHERY_HMI_R1_AR;

//  message   PN14_Disp_Rq_AR ID: 833 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PN14_Disp_Rq_AR _mPN14_Disp_Rq_AR;
    int      _PN14_Disp_Rq_AR_Timebase;
    int      _PN14_Disp_Rq_AR_CycleCount;
    int      _PN14_Disp_Rq_AR_StartDelay;
    int      _PN14_Disp_Rq_AR_MinDelay;
    int      _PN14_Disp_Rq_AR_Cnt;
    int      _PN14_Disp_Rq_AR_SpontanFlag;
    int      _PN14_Disp_Rq_AR_DelayCnt;
    msTimer _tPN14_Disp_Rq_AR;

//  message   PN14_Disp_Rq2_AR --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PN14_Disp_Rq2_AR _mPN14_Disp_Rq2_AR;
    int      _PN14_Disp_Rq2_AR_Timebase;
    int      _PN14_Disp_Rq2_AR_CycleCount;
    int      _PN14_Disp_Rq2_AR_StartDelay;
    int      _PN14_Disp_Rq2_AR_MinDelay;
    int      _PN14_Disp_Rq2_AR_Cnt;
    int      _PN14_Disp_Rq2_AR_SpontanFlag;
    int      _PN14_Disp_Rq2_AR_DelayCnt;

    byte     _PN14_Disp_Rq2_AR_E2E_Armed;
    byte     _PN14_Disp_Rq2_AR_CRC_ErrorCnt;
    byte     _PN14_Disp_Rq2_AR_SQC_TriggPos;
    int      _PN14_Disp_Rq2_AR_SQC_WrongSeqJump;
    byte     _PN14_Disp_Rq2_AR_SQC_RepeatedCnt;
    byte     _PN14_Disp_Rq2_AR_MSG_DropCnt;
    byte     _PN14_Disp_Rq2_AR_CRC_Offset[16] = { 220, 170, 120,  70,  20, 221, 171, 121,  71,  21, 222, 172, 122,  72,  22, 223 };
    msTimer _tPN14_Disp_Rq2_AR;

//  message   PN14_Stat_AR ID: 290 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PN14_Stat_AR _mPN14_Stat_AR;
    int      _PN14_Stat_AR_Timebase;
    int      _PN14_Stat_AR_CycleCount;
    int      _PN14_Stat_AR_StartDelay;
    int      _PN14_Stat_AR_Cnt;
    int      _PN14_Stat_AR_SpontanFlag;
    msTimer _tPN14_Stat_AR;
	
//  message   PN14_Stat_VAN_AR  ID: 1204 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PN14_Stat_VAN_AR _mPN14_Stat_VAN_AR;
    int      _PN14_Stat_VAN_AR_Timebase;
    int      _PN14_Stat_VAN_AR_CycleCount;
    int      _PN14_Stat_VAN_AR_Cnt;
    int      _PN14_Stat_VAN_AR_StartDelay;
    int      _PN14_Stat_VAN_AR_SpontanFlag;
    int      _PN14_Stat_VAN_AR_MinDelay;
    int      _PN14_Stat_VAN_AR_DelayCnt;
    msTimer _tPN14_Stat_VAN_AR;

//  message   PN48_Bat_Stat_AR ID: 858 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PN48_Bat_Stat_AR _mPN48_Bat_Stat_AR;
    int      _PN48_Bat_Stat_AR_Timebase;
    int      _PN48_Bat_Stat_AR_CycleCount;
    int      _PN48_Bat_Stat_AR_StartDelay;
    int      _PN48_Bat_Stat_AR_MinDelay;
    int      _PN48_Bat_Stat_AR_Cnt;
    int      _PN48_Bat_Stat_AR_SpontanFlag;
    int      _PN48_Bat_Stat_AR_DelayCnt;
    msTimer _tPN48_Bat_Stat_AR;

//  message   PN48_Disp_Rq_AR ID: 1185 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PN48_Disp_Rq_AR _mPN48_Disp_Rq_AR;
    int      _PN48_Disp_Rq_AR_Timebase;
    int      _PN48_Disp_Rq_AR_CycleCount;
    int      _PN48_Disp_Rq_AR_StartDelay;
    int      _PN48_Disp_Rq_AR_MinDelay;
    int      _PN48_Disp_Rq_AR_Cnt;
    int      _PN48_Disp_Rq_AR_SpontanFlag;
    int      _PN48_Disp_Rq_AR_DelayCnt;
    msTimer _tPN48_Disp_Rq_AR;

//  message   PnHt_Stat_AR ID: 905 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PnHt_Stat_AR _mPnHt_Stat_AR;
    int      _PnHt_Stat_AR_Timebase;
    int      _PnHt_Stat_AR_CycleCount;
    int      _PnHt_Stat_AR_StartDelay;
    int      _PnHt_Stat_AR_Cnt;
    int      _PnHt_Stat_AR_SpontanFlag;
    msTimer _tPnHt_Stat_AR;

//  message   PNHV_Disp_Rq1_AR ID: 692 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PNHV_Disp_Rq1_AR _mPNHV_Disp_Rq1_AR;
    int      _PNHV_Disp_Rq1_AR_Timebase;
    int      _PNHV_Disp_Rq1_AR_CycleCount;
    int      _PNHV_Disp_Rq1_AR_StartDelay;
    int      _PNHV_Disp_Rq1_AR_MinDelay;
    int      _PNHV_Disp_Rq1_AR_Cnt;
    int      _PNHV_Disp_Rq1_AR_SpontanFlag;
    int      _PNHV_Disp_Rq1_AR_DelayCnt;
    msTimer _tPNHV_Disp_Rq1_AR;    

//  message   PNHV_Disp_Rq2_AR ID: 670 --- Sendeart 0 cyclicX --- 
    message   PNHV_Disp_Rq2_AR _mPNHV_Disp_Rq2_AR;
    int      _PNHV_Disp_Rq2_AR_Timebase;
    int      _PNHV_Disp_Rq2_AR_CycleCount;
    int      _PNHV_Disp_Rq2_AR_StartDelay;
    int      _PNHV_Disp_Rq2_AR_Cnt;
    int      _PNHV_Disp_Rq2_AR_DelayCnt;
    msTimer _tPNHV_Disp_Rq2_AR; 
    
//  message   PNHV_Energy_Rq_AR ID: 618 --- Sendeart 8 cyclicIfActiveFast --- 
    message   PNHV_Energy_Rq_AR _mPNHV_Energy_Rq_AR;
    int      _PNHV_Energy_Rq_AR_Timebase;
    int      _PNHV_Energy_Rq_AR_CycleCountSlow;
    int      _PNHV_Energy_Rq_AR_CycleCountFast;
    int      _PNHV_Energy_Rq_AR_StartDelay;
    int      _PNHV_Energy_Rq_AR_Cnt;
    int      _PNHV_Energy_Rq_AR_SigActivity;

    int      _PNHV_Energy_Rq_AR_PNHV_ActChrgOprtn_DistPred_LastState = 0;
    int      _PNHV_Energy_Rq_AR_PNHV_ActChrgOprtn_DistPred_V2_LastState = 0;
    int      _PNHV_Energy_Rq_AR_PNHV_Dist_ActSOC_LastState = 0;
    int      _PNHV_Energy_Rq_AR_PNHV_Dist_ActSOC_V2_LastState = 0;
    int      _PNHV_Energy_Rq_AR_PNHV_Pred_EnergyAmnt_LastState = 0;
    int      _PNHV_Energy_Rq_AR_PNHV_SCC_Actn_Rq_LastState = 0;
    int      _PNHV_Energy_Rq_AR_SCC_Restart_Trgr_LastState = 0;
    int      _PNHV_Energy_Rq_AR_TC_ElecEnergyLvl_Min_50_LastState = 0;
    msTimer _tPNHV_Energy_Rq_AR;
    
//  message   PNHV_EnergyMngmnt_Disp_Rq_AR ID: 1061 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PNHV_EnergyMngmnt_Disp_Rq_AR _mPNHV_EnergyMngmnt_Disp_Rq_AR;
    int      _PNHV_EnergyMngmnt_Disp_Rq_AR_Timebase;
    int      _PNHV_EnergyMngmnt_Disp_Rq_AR_CycleCount;
    int      _PNHV_EnergyMngmnt_Disp_Rq_AR_StartDelay;
    int      _PNHV_EnergyMngmnt_Disp_Rq_AR_MinDelay;
    int      _PNHV_EnergyMngmnt_Disp_Rq_AR_Cnt;
    int      _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag;
    int      _PNHV_EnergyMngmnt_Disp_Rq_AR_DelayCnt;
    msTimer _tPNHV_EnergyMngmnt_Disp_Rq_AR;
	
//  Botschaft PNHV_Bat_Warn_Rq_V2_AR2 ID: 2459172864 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PNHV_Bat_Warn_Rq_V2_AR2 _mPNHV_Bat_Warn_Rq_V2_AR2;
    int      _PNHV_Bat_Warn_Rq_V2_AR2_Timebase;
    int      _PNHV_Bat_Warn_Rq_V2_AR2_CycleCount;
    int      _PNHV_Bat_Warn_Rq_V2_AR2_StartDelay;
    int      _PNHV_Bat_Warn_Rq_V2_AR2_Cnt;
    int      _PNHV_Bat_Warn_Rq_V2_AR2_SpontanFlag;
	
	int		 _PNHV_Bat_Warn_Rq_V2_AR2_DelayCnt;
	int		 _PNHV_Bat_Warn_Rq_V2_AR2_MinDelay;
    byte     _PNHV_Bat_Warn_Rq_V2_AR2_E2E_Armed;
    byte     _PNHV_Bat_Warn_Rq_V2_AR2_CRC_ErrorCnt;
    byte     _PNHV_Bat_Warn_Rq_V2_AR2_SQC_TriggPos;
    int      _PNHV_Bat_Warn_Rq_V2_AR2_SQC_WrongSeqJump;
    byte     _PNHV_Bat_Warn_Rq_V2_AR2_SQC_RepeatedCnt;
    byte     _PNHV_Bat_Warn_Rq_V2_AR2_MSG_DropCnt;
    byte     _PNHV_Bat_Warn_Rq_V2_AR2_CRC_Offset[16] = {  208, 135, 62, 240, 167, 94, 21, 199, 126, 53, 231, 158, 85, 12, 190, 117 };
    msTimer _tPNHV_Bat_Warn_Rq_V2_AR2;
    
//  Botschaft PNHV_Bat_Warn_Rq_AR ID: 934 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PNHV_Bat_Warn_Rq_AR _mPNHV_Bat_Warn_Rq_AR;
    int      _PNHV_Bat_Warn_Rq_AR_Timebase;
    int      _PNHV_Bat_Warn_Rq_AR_CycleCount;
    int      _PNHV_Bat_Warn_Rq_AR_StartDelay;
    int      _PNHV_Bat_Warn_Rq_AR_Cnt;
    int      _PNHV_Bat_Warn_Rq_AR_SpontanFlag;

    byte     _PNHV_Bat_Warn_Rq_AR_E2E_Armed;
    byte     _PNHV_Bat_Warn_Rq_AR_CRC_ErrorCnt;
    byte     _PNHV_Bat_Warn_Rq_AR_SQC_TriggPos;
    int      _PNHV_Bat_Warn_Rq_AR_SQC_WrongSeqJump;
    byte     _PNHV_Bat_Warn_Rq_AR_SQC_RepeatedCnt;
    byte     _PNHV_Bat_Warn_Rq_AR_MSG_DropCnt;
    byte     _PNHV_Bat_Warn_Rq_AR_CRC_Offset[16] = {  208, 135, 62, 240, 167, 94, 21, 199, 126, 53, 231, 158, 85, 12, 190, 117 };
    msTimer _tPNHV_Bat_Warn_Rq_AR;

//  message   PNHV_EnergyMngmnt_Stat2_AR ID: 339 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PNHV_EnergyMngmnt_Stat2_AR _mPNHV_EnergyMngmnt_Stat2_AR;
    int      _PNHV_EnergyMngmnt_Stat2_AR_Timebase;
    int      _PNHV_EnergyMngmnt_Stat2_AR_CycleCount;
    int      _PNHV_EnergyMngmnt_Stat2_AR_StartDelay;
    int      _PNHV_EnergyMngmnt_Stat2_AR_MinDelay;
    int      _PNHV_EnergyMngmnt_Stat2_AR_Cnt;
    int      _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag;
    int      _PNHV_EnergyMngmnt_Stat2_AR_DelayCnt;
    msTimer _tPNHV_EnergyMngmnt_Stat2_AR;

//  message   PNHV_EnergyMngmntSet_Rs1_AR ID: 1155 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PNHV_EnergyMngmntSet_Rs1_AR _mPNHV_EnergyMngmntSet_Rs1_AR;
    int      _PNHV_EnergyMngmntSet_Rs1_AR_Timebase;
    int      _PNHV_EnergyMngmntSet_Rs1_AR_CycleCount;
    int      _PNHV_EnergyMngmntSet_Rs1_AR_StartDelay;
    int      _PNHV_EnergyMngmntSet_Rs1_AR_MinDelay;
    int      _PNHV_EnergyMngmntSet_Rs1_AR_Cnt;
    int      _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag;
    int      _PNHV_EnergyMngmntSet_Rs1_AR_DelayCnt;
    msTimer _tPNHV_EnergyMngmntSet_Rs1_AR;

//  message   PNHV_EnergyMngmntSet_Rs2_AR ID: 1073 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PNHV_EnergyMngmntSet_Rs2_AR _mPNHV_EnergyMngmntSet_Rs2_AR;
    int      _PNHV_EnergyMngmntSet_Rs2_AR_Timebase;
    int      _PNHV_EnergyMngmntSet_Rs2_AR_CycleCount;
    int      _PNHV_EnergyMngmntSet_Rs2_AR_StartDelay;
    int      _PNHV_EnergyMngmntSet_Rs2_AR_Cnt;
    int      _PNHV_EnergyMngmntSet_Rs2_AR_SpontanFlag;
    msTimer _tPNHV_EnergyMngmntSet_Rs2_AR;
    
//  message   PNHV_EnergyMngmntSet_Rs3_AR ID: 1073 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PNHV_EnergyMngmntSet_Rs3_AR _mPNHV_EnergyMngmntSet_Rs3_AR;
    int      _PNHV_EnergyMngmntSet_Rs3_AR_Timebase;
    int      _PNHV_EnergyMngmntSet_Rs3_AR_CycleCount;
    int      _PNHV_EnergyMngmntSet_Rs3_AR_StartDelay;
    int      _PNHV_EnergyMngmntSet_Rs3_AR_MinDelay;
    int      _PNHV_EnergyMngmntSet_Rs3_AR_DelayCnt;
    int      _PNHV_EnergyMngmntSet_Rs3_AR_Cnt;
    int      _PNHV_EnergyMngmntSet_Rs3_AR_SpontanFlag;
    msTimer _tPNHV_EnergyMngmntSet_Rs3_AR;
    
//  message   PNHV_Stat_VAN_AR ID: 2359033856 --- Sendeart 0 cyclicX --- 
    message   PNHV_Stat_VAN_AR _mPNHV_Stat_VAN_AR;
    int      _PNHV_Stat_VAN_AR_Timebase;
    int      _PNHV_Stat_VAN_AR_CycleCount;
    int      _PNHV_Stat_VAN_AR_StartDelay;
    int      _PNHV_Stat_VAN_AR_Cnt;
    msTimer _tPNHV_Stat_VAN_AR;
    
//  message   OBWlight_Message_VAN_AR ID: 2359033856 --- Sendeart 0 cyclicX --- 
    message   OBWlight_Message_VAN_AR _mOBWlight_Message_VAN_AR;
    int      _OBWlight_Message_VAN_AR_Timebase;
    int      _OBWlight_Message_VAN_AR_CycleCount;
    int      _OBWlight_Message_VAN_AR_StartDelay;
    int      _OBWlight_Message_VAN_AR_Cnt;
    msTimer _tOBWlight_Message_VAN_AR;
    
//  message   Tire_temp_VAN_AR ID: 2359033856 --- Sendeart 0 cyclicX --- 
    message   Tire_temp_VAN_AR _mTire_temp_VAN_AR;
    int      _Tire_temp_VAN_AR_Timebase;
    int      _Tire_temp_VAN_AR_CycleCount;
    int      _Tire_temp_VAN_AR_StartDelay;
    int      _Tire_temp_VAN_AR_Cnt;
    msTimer _tTire_temp_VAN_AR;

//  message   PNHV_WeekDepTmTbl_Stat_AR ID: 447 --- Sendeart 2 cyclicIfActive --- 
    message   PNHV_WeekDepTmTbl_Stat_AR _mPNHV_WeekDepTmTbl_Stat_AR;
    int      _PNHV_WeekDepTmTbl_Stat_AR_Timebase;
    int      _PNHV_WeekDepTmTbl_Stat_AR_CycleCount;
    int      _PNHV_WeekDepTmTbl_Stat_AR_StartDelay;
    int      _PNHV_WeekDepTmTbl_Stat_AR_Cnt;
    int      _PNHV_WeekDepTmTbl_Stat_AR_Active;
    int      _PNHV_WeekDepTmTbl_Stat_AR_SigActivity;

    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm01_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm02_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm03_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm04_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm05_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm06_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm07_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm08_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm09_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm10_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm11_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm12_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm13_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm14_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm15_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm16_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm17_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm18_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm19_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm20_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm21_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_1To4_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_5To8_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_9To12_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_13To16_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_17To20_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_21_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_WeekDepTmTbl_New_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_WeekDepTmTbl_PartId_LastState = 0;
    int      _PNHV_WeekDepTmTbl_Stat_AR_PNHV_WeekDepTmTbl_TxActv_LastState = 0;
    msTimer _tPNHV_WeekDepTmTbl_Stat_AR;

//  message   PreCond_CfgStat_AR ID: 1179 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PreCond_CfgStat_AR _mPreCond_CfgStat_AR;
    int      _PreCond_CfgStat_AR_Timebase;
    int      _PreCond_CfgStat_AR_CycleCount;
    int      _PreCond_CfgStat_AR_StartDelay;
    int      _PreCond_CfgStat_AR_Cnt;
    int      _PreCond_CfgStat_AR_SpontanFlag;
    msTimer _tPreCond_CfgStat_AR;

//  message   PresfCtrl_Rq_ESP_AR ID: 33 --- Sendeart 8 cyclicIfActiveFast --- 
    message   PresfCtrl_Rq_ESP_AR _mPresfCtrl_Rq_ESP_AR;
    int      _PresfCtrl_Rq_ESP_AR_Timebase;
    int      _PresfCtrl_Rq_ESP_AR_CycleCountSlow;
    int      _PresfCtrl_Rq_ESP_AR_CycleCountFast;
    int      _PresfCtrl_Rq_ESP_AR_StartDelay;
    int      _PresfCtrl_Rq_ESP_AR_Cnt;
    int      _PresfCtrl_Rq_ESP_AR_SigActivity;

    int      _PresfCtrl_Rq_ESP_AR_Rsrv6_PresfCtrl_Rq_ESP_LastState = 0;
    int      _PresfCtrl_Rq_ESP_AR_Rsrv5_PresfCtrl_Rq_ESP_LastState = 0;
    int      _PresfCtrl_Rq_ESP_AR_Rsrv4_PresfCtrl_Rq_ESP_LastState = 0;
    int      _PresfCtrl_Rq_ESP_AR_Rsrv3_PresfCtrl_Rq_ESP_LastState = 0;
    int      _PresfCtrl_Rq_ESP_AR_Rsrv2_PresfCtrl_Rq_ESP_LastState = 0;
    int      _PresfCtrl_Rq_ESP_AR_Rsrv1_PresfCtrl_Rq_ESP_LastState = 0;
    int      _PresfCtrl_Rq_ESP_AR_Presf_Lvl_V2_LastState = 0;

    byte     _PresfCtrl_Rq_ESP_AR_E2E_Armed;
    byte     _PresfCtrl_Rq_ESP_AR_CRC_ErrorCnt;
    byte     _PresfCtrl_Rq_ESP_AR_SQC_TriggPos;
    int      _PresfCtrl_Rq_ESP_AR_SQC_WrongSeqJump;
    byte     _PresfCtrl_Rq_ESP_AR_SQC_RepeatedCnt;
    byte     _PresfCtrl_Rq_ESP_AR_MSG_DropCnt;
    byte     _PresfCtrl_Rq_ESP_AR_CRC_Offset[16] = { 103, 114, 125, 136, 147, 158, 169, 180, 191, 202, 213, 224, 235, 246,   6,  17 };
    msTimer _tPresfCtrl_Rq_ESP_AR;

//  Botschaft PSL_L_Stat_AR ID: 934 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PSL_L_Stat_AR _mPSL_L_Stat_AR;
    int      _PSL_L_Stat_AR_Timebase;
    int      _PSL_L_Stat_AR_CycleCount;
    int      _PSL_L_Stat_AR_StartDelay;
    int      _PSL_L_Stat_AR_Cnt;
    int      _PSL_L_Stat_AR_SpontanFlag;

    byte     _PSL_L_Stat_AR_E2E_Armed;
    byte     _PSL_L_Stat_AR_CRC_ErrorCnt;
    byte     _PSL_L_Stat_AR_SQC_TriggPos;
    int      _PSL_L_Stat_AR_SQC_WrongSeqJump;
    byte     _PSL_L_Stat_AR_SQC_RepeatedCnt;
    byte     _PSL_L_Stat_AR_MSG_DropCnt;
    byte     _PSL_L_Stat_AR_CRC_Offset[16] = {  74, 204,  83, 213,  92, 222, 101, 231, 110, 240, 119, 249, 128,   7, 137,  16 };
    msTimer _tPSL_L_Stat_AR;

//  Botschaft PSL_R_Stat_AR ID: 936 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PSL_R_Stat_AR _mPSL_R_Stat_AR;
    int      _PSL_R_Stat_AR_Timebase;
    int      _PSL_R_Stat_AR_CycleCount;
    int      _PSL_R_Stat_AR_StartDelay;
    int      _PSL_R_Stat_AR_Cnt;
    int      _PSL_R_Stat_AR_SpontanFlag;

    byte     _PSL_R_Stat_AR_E2E_Armed;
    byte     _PSL_R_Stat_AR_CRC_ErrorCnt;
    byte     _PSL_R_Stat_AR_SQC_TriggPos;
    int      _PSL_R_Stat_AR_SQC_WrongSeqJump;
    byte     _PSL_R_Stat_AR_SQC_RepeatedCnt;
    byte     _PSL_R_Stat_AR_MSG_DropCnt;
    byte     _PSL_R_Stat_AR_CRC_Offset[16] = { 212,   8,  55, 102, 149, 196, 243,  39,  86, 133, 180, 227,  23,  70, 117, 164 };
    msTimer _tPSL_R_Stat_AR;

//  message   PT_Data_VAN_AR ID: 736 --- Sendeart 0 cyclicX --- 
    message   PT_Data_VAN_AR _mPT_Data_VAN_AR;
    int      _PT_Data_VAN_AR_Timebase;
    int      _PT_Data_VAN_AR_CycleCount;
    int      _PT_Data_VAN_AR_StartDelay;
    int      _PT_Data_VAN_AR_MinDelay;
    int      _PT_Data_VAN_AR_Cnt;
    int      _PT_Data_VAN_AR_SpontanFlag;
    int      _PT_Data_VAN_AR_DelayCnt;

    byte     _PT_Data_VAN_AR_E2E_Armed;
    byte     _PT_Data_VAN_AR_CRC_ErrorCnt;
    byte     _PT_Data_VAN_AR_SQC_TriggPos;
    int      _PT_Data_VAN_AR_SQC_WrongSeqJump;
    byte     _PT_Data_VAN_AR_SQC_RepeatedCnt;
    byte     _PT_Data_VAN_AR_MSG_DropCnt;
    byte     _PT_Data_VAN_AR_CRC_Offset[16] = { 204,  66, 179,  41, 154,  16, 129, 242, 104, 217,  79, 192,  54, 167,  29, 142 };
    msTimer _tPT_Data_VAN_AR;

//  message   PT_DataContain_Rq_AR ID: 1178 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PT_DataContain_Rq_AR _mPT_DataContain_Rq_AR;
    int      _PT_DataContain_Rq_AR_Timebase;
    int      _PT_DataContain_Rq_AR_CycleCount;
    int      _PT_DataContain_Rq_AR_StartDelay;
    int      _PT_DataContain_Rq_AR_MinDelay;
    int      _PT_DataContain_Rq_AR_Cnt;
    int      _PT_DataContain_Rq_AR_SpontanFlag;
    int      _PT_DataContain_Rq_AR_DelayCnt;
    msTimer _tPT_DataContain_Rq_AR;

//  message   PT_Disp_Rq2_AR ID: 656 --- Sendeart 0 cyclicX --- 
    message   PT_Disp_Rq2_AR _mPT_Disp_Rq2_AR;
    int      _PT_Disp_Rq2_AR_Timebase;
    int      _PT_Disp_Rq2_AR_CycleCount;
    int      _PT_Disp_Rq2_AR_StartDelay;
    int      _PT_Disp_Rq2_AR_Cnt;
    msTimer _tPT_Disp_Rq2_AR;

//  message   PtHyb_Mngmnt_Rq_AR ID: 1279 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   PtHyb_Mngmnt_Rq_AR _mPtHyb_Mngmnt_Rq_AR;
    int      _PtHyb_Mngmnt_Rq_AR_Timebase;
    int      _PtHyb_Mngmnt_Rq_AR_CycleCount;
    int      _PtHyb_Mngmnt_Rq_AR_StartDelay;
    int      _PtHyb_Mngmnt_Rq_AR_MinDelay;
    int      _PtHyb_Mngmnt_Rq_AR_Cnt;
    int      _PtHyb_Mngmnt_Rq_AR_SpontanFlag;
    int      _PtHyb_Mngmnt_Rq_AR_DelayCnt;
    msTimer _tPtHyb_Mngmnt_Rq_AR;

//  message   PtMngmnt_Disp_Rq_AR ID: 321 --- Sendeart 0 cyclicX --- 
    message   PtMngmnt_Disp_Rq_AR _mPtMngmnt_Disp_Rq_AR;
    int      _PtMngmnt_Disp_Rq_AR_Timebase;
    int      _PtMngmnt_Disp_Rq_AR_CycleCount;
    int      _PtMngmnt_Disp_Rq_AR_StartDelay;
    int      _PtMngmnt_Disp_Rq_AR_Cnt;
    msTimer _tPtMngmnt_Disp_Rq_AR;
	
//  message   Radar_EGO1_Obj_Attr1_AR ID: 2226913280 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Radar_EGO1_Obj_Attr1_AR _mRadar_EGO1_Obj_Attr1_AR;
    int      _Radar_EGO1_Obj_Attr1_AR_Timebase;
    int      _Radar_EGO1_Obj_Attr1_AR_CycleCount;
    int      _Radar_EGO1_Obj_Attr1_AR_StartDelay;
    int      _Radar_EGO1_Obj_Attr1_AR_MinDelay;
    int      _Radar_EGO1_Obj_Attr1_AR_Cnt;
    int      _Radar_EGO1_Obj_Attr1_AR_SpontanFlag;
    int      _Radar_EGO1_Obj_Attr1_AR_DelayCnt;

    byte     _Radar_EGO1_Obj_Attr1_AR_E2E_Armed;
    byte     _Radar_EGO1_Obj_Attr1_AR_CRC_ErrorCnt;
    byte     _Radar_EGO1_Obj_Attr1_AR_SQC_TriggPos;
    int      _Radar_EGO1_Obj_Attr1_AR_SQC_WrongSeqJump;
    byte     _Radar_EGO1_Obj_Attr1_AR_SQC_RepeatedCnt;
    byte     _Radar_EGO1_Obj_Attr1_AR_MSG_DropCnt;
    byte     _Radar_EGO1_Obj_Attr1_AR_CRC_Offset[16] = {89, 9, 180, 100, 20, 191, 111, 31, 202, 122, 42, 213, 133, 53, 224, 144}; 
    msTimer _tRadar_EGO1_Obj_Attr1_AR;
	
//  message    RDS_Data_HU_AR ID: 2457600000 --- Sendeart 5 cyclicAndSpontanWithDelay -
    message   RDS_Data_HU_AR _mRDS_Data_HU_AR;
    int      _RDS_Data_HU_AR_Timebase;
    int      _RDS_Data_HU_AR_CycleCount;
    int      _RDS_Data_HU_AR_StartDelay;
    int      _RDS_Data_HU_AR_MinDelay;
    int      _RDS_Data_HU_AR_Cnt;
    int      _RDS_Data_HU_AR_SpontanFlag;
    int      _RDS_Data_HU_AR_DelayCnt;
    msTimer  _tRDS_Data_HU_AR;

//  message   RDU_Disp_Rq_AR ID: 812 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   RDU_Disp_Rq_AR _mRDU_Disp_Rq_AR;
    int      _RDU_Disp_Rq_AR_Timebase;
    int      _RDU_Disp_Rq_AR_CycleCount;
    int      _RDU_Disp_Rq_AR_StartDelay;
    int      _RDU_Disp_Rq_AR_MinDelay;
    int      _RDU_Disp_Rq_AR_Cnt;
    int      _RDU_Disp_Rq_AR_SpontanFlag;
    int      _RDU_Disp_Rq_AR_DelayCnt;
    msTimer _tRDU_Disp_Rq_AR;

//  Botschaft RTC_Date_Time_AR ID: 779 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   RTC_Date_Time_AR _mRTC_Date_Time_AR;
    int      _RTC_Date_Time_AR_Timebase;
    int      _RTC_Date_Time_AR_CycleCount;
    int      _RTC_Date_Time_AR_StartDelay;
    int      _RTC_Date_Time_AR_MinDelay;
    int      _RTC_Date_Time_AR_Cnt;
    int      _RTC_Date_Time_AR_SpontanFlag;
    int      _RTC_Date_Time_AR_DelayCnt;
    msTimer _tRTC_Date_Time_AR;

//  Botschaft RTC_Stat1_AR ID: 1216 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   RTC_Stat1_AR _mRTC_Stat1_AR;
    int      _RTC_Stat1_AR_Timebase;
    int      _RTC_Stat1_AR_CycleCount;
    int      _RTC_Stat1_AR_StartDelay;
    int      _RTC_Stat1_AR_MinDelay;
    int      _RTC_Stat1_AR_Cnt;
    int      _RTC_Stat1_AR_SpontanFlag;
    int      _RTC_Stat1_AR_DelayCnt;
    msTimer _tRTC_Stat1_AR;

//  Botschaft RTC_Stat2_AR ID: 1152 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   RTC_Stat2_AR _mRTC_Stat2_AR;
    int      _RTC_Stat2_AR_Timebase;
    int      _RTC_Stat2_AR_CycleCount;
    int      _RTC_Stat2_AR_StartDelay;
    int      _RTC_Stat2_AR_MinDelay;
    int      _RTC_Stat2_AR_Cnt;
    int      _RTC_Stat2_AR_SpontanFlag;
    int      _RTC_Stat2_AR_DelayCnt;
    msTimer _tRTC_Stat2_AR;

//  message   RVC_SVS_Park_Stat_AR --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   RVC_SVS_Park_Stat_AR _mRVC_SVS_Park_Stat_AR;
    int      _RVC_SVS_Park_Stat_AR_Timebase;
    int      _RVC_SVS_Park_Stat_AR_CycleCount;
    int      _RVC_SVS_Park_Stat_AR_StartDelay;
    int      _RVC_SVS_Park_Stat_AR_MinDelay;
    int      _RVC_SVS_Park_Stat_AR_Cnt;
    int      _RVC_SVS_Park_Stat_AR_SpontanFlag;
    int      _RVC_SVS_Park_Stat_AR_DelayCnt;
    msTimer _tRVC_SVS_Park_Stat_AR;

//  message   SBW_DrvPosn_Disp_Rq_ISM_AR ID: 323 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   SBW_DrvPosn_Disp_Rq_ISM_AR _mSBW_DrvPosn_Disp_Rq_ISM_AR;
    int      _SBW_DrvPosn_Disp_Rq_ISM_AR_Timebase;
    int      _SBW_DrvPosn_Disp_Rq_ISM_AR_CycleCount;
    int      _SBW_DrvPosn_Disp_Rq_ISM_AR_StartDelay;
    int      _SBW_DrvPosn_Disp_Rq_ISM_AR_Cnt;
    int      _SBW_DrvPosn_Disp_Rq_ISM_AR_SpontanFlag;

    byte     _SBW_DrvPosn_Disp_Rq_ISM_AR_E2E_Armed;
    byte     _SBW_DrvPosn_Disp_Rq_ISM_AR_CRC_ErrorCnt;
    byte     _SBW_DrvPosn_Disp_Rq_ISM_AR_SQC_TriggPos;
    int      _SBW_DrvPosn_Disp_Rq_ISM_AR_SQC_WrongSeqJump;
    byte     _SBW_DrvPosn_Disp_Rq_ISM_AR_SQC_RepeatedCnt;
    byte     _SBW_DrvPosn_Disp_Rq_ISM_AR_MSG_DropCnt;
    byte     _SBW_DrvPosn_Disp_Rq_ISM_AR_CRC_Offset[16] = {  97, 226, 104, 233, 111, 240, 118, 247, 125,   3, 132,  10, 139,  17, 146,  24 };
    msTimer _tSBW_DrvPosn_Disp_Rq_ISM_AR;

//  message   SBW_DrvPosn_Disp_Rq_TCM_AR ID: 711 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   SBW_DrvPosn_Disp_Rq_TCM_AR _mSBW_DrvPosn_Disp_Rq_TCM_AR;
    int      _SBW_DrvPosn_Disp_Rq_TCM_AR_Timebase;
    int      _SBW_DrvPosn_Disp_Rq_TCM_AR_CycleCount;
    int      _SBW_DrvPosn_Disp_Rq_TCM_AR_StartDelay;
    int      _SBW_DrvPosn_Disp_Rq_TCM_AR_Cnt;
    int      _SBW_DrvPosn_Disp_Rq_TCM_AR_SpontanFlag;

    byte     _SBW_DrvPosn_Disp_Rq_TCM_AR_E2E_Armed;
    byte     _SBW_DrvPosn_Disp_Rq_TCM_AR_CRC_ErrorCnt;
    byte     _SBW_DrvPosn_Disp_Rq_TCM_AR_SQC_TriggPos;
    int      _SBW_DrvPosn_Disp_Rq_TCM_AR_SQC_WrongSeqJump;
    byte     _SBW_DrvPosn_Disp_Rq_TCM_AR_SQC_RepeatedCnt;
    byte     _SBW_DrvPosn_Disp_Rq_TCM_AR_MSG_DropCnt;
    byte     _SBW_DrvPosn_Disp_Rq_TCM_AR_CRC_Offset[16] = { 239, 121,   3, 136,  18, 151,  33, 166,  48, 181,  63, 196,  78, 211,  93, 226 };
    msTimer _tSBW_DrvPosn_Disp_Rq_TCM_AR;

//  Botschaft Seat_3L_Stat_AR ID: 954 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Seat_3L_Stat_AR _mSeat_3L_Stat_AR;
    int      _Seat_3L_Stat_AR_Timebase;
    int      _Seat_3L_Stat_AR_CycleCount;
    int      _Seat_3L_Stat_AR_StartDelay;
    int      _Seat_3L_Stat_AR_Cnt;
    int      _Seat_3L_Stat_AR_SpontanFlag;
    msTimer _tSeat_3L_Stat_AR;
    
//  Botschaft Seat_3R_Stat_AR 4 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Seat_3R_Stat_AR _mSeat_3R_Stat_AR;
    int      _Seat_3R_Stat_AR_Timebase;
    int      _Seat_3R_Stat_AR_CycleCount;
    int      _Seat_3R_Stat_AR_StartDelay;
    int      _Seat_3R_Stat_AR_Cnt;
    int      _Seat_3R_Stat_AR_SpontanFlag;
    msTimer _tSeat_3R_Stat_AR;

//  message   Seat_D_Stat_AR ID: 937 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Seat_D_Stat_AR _mSeat_D_Stat_AR;
    int      _Seat_D_Stat_AR_Timebase;
    int      _Seat_D_Stat_AR_CycleCount;
    int      _Seat_D_Stat_AR_StartDelay;
    int      _Seat_D_Stat_AR_Cnt;
    int      _Seat_D_Stat_AR_SpontanFlag;
    msTimer _tSeat_D_Stat_AR;

//  message   Seat_P_Stat_AR ID: 939 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Seat_P_Stat_AR _mSeat_P_Stat_AR;
    int      _Seat_P_Stat_AR_Timebase;
    int      _Seat_P_Stat_AR_CycleCount;
    int      _Seat_P_Stat_AR_StartDelay;
    int      _Seat_P_Stat_AR_Cnt;
    int      _Seat_P_Stat_AR_SpontanFlag;
    msTimer _tSeat_P_Stat_AR;

//  message   Seat_RL_Stat_AR ID: 941 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Seat_RL_Stat_AR _mSeat_RL_Stat_AR;
    int      _Seat_RL_Stat_AR_Timebase;
    int      _Seat_RL_Stat_AR_CycleCount;
    int      _Seat_RL_Stat_AR_StartDelay;
    int      _Seat_RL_Stat_AR_Cnt;
    int      _Seat_RL_Stat_AR_SpontanFlag;
    msTimer _tSeat_RL_Stat_AR;

//  message   Seat_RR_Stat_AR ID: 943 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Seat_RR_Stat_AR _mSeat_RR_Stat_AR;
    int      _Seat_RR_Stat_AR_Timebase;
    int      _Seat_RR_Stat_AR_CycleCount;
    int      _Seat_RR_Stat_AR_StartDelay;
    int      _Seat_RR_Stat_AR_Cnt;
    int      _Seat_RR_Stat_AR_SpontanFlag;
    msTimer _tSeat_RR_Stat_AR;
	
//  message   SeatCM_D_Stat_HU_AR ID: 1140 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   SeatCM_D_Stat_HU_AR _mSeatCM_D_Stat_HU_AR;
    int      _SeatCM_D_Stat_HU_AR_Timebase;
    int      _SeatCM_D_Stat_HU_AR_CycleCount;
    int      _SeatCM_D_Stat_HU_AR_StartDelay;
    int      _SeatCM_D_Stat_HU_AR_MinDelay;
    int      _SeatCM_D_Stat_HU_AR_Cnt;
    int      _SeatCM_D_Stat_HU_AR_SpontanFlag;
    int      _SeatCM_D_Stat_HU_AR_DelayCnt;
    msTimer _tSeatCM_D_Stat_HU_AR;
	
//  message   SeatCM_P_Stat_HU_AR ID: 1144 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   SeatCM_P_Stat_HU_AR _mSeatCM_P_Stat_HU_AR;
    int      _SeatCM_P_Stat_HU_AR_Timebase;
    int      _SeatCM_P_Stat_HU_AR_CycleCount;
    int      _SeatCM_P_Stat_HU_AR_StartDelay;
    int      _SeatCM_P_Stat_HU_AR_MinDelay;
    int      _SeatCM_P_Stat_HU_AR_Cnt;
    int      _SeatCM_P_Stat_HU_AR_SpontanFlag;
    int      _SeatCM_P_Stat_HU_AR_DelayCnt;
    msTimer _tSeatCM_P_Stat_HU_AR;
	
//  message   SeatHtVn_Stat_AR ID: 915 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   SeatHtVn_Stat_AR _mSeatHtVn_Stat_AR;
    int      _SeatHtVn_Stat_AR_Timebase;
    int      _SeatHtVn_Stat_AR_CycleCount;
    int      _SeatHtVn_Stat_AR_StartDelay;
    int      _SeatHtVn_Stat_AR_Cnt;
    int      _SeatHtVn_Stat_AR_SpontanFlag;
    msTimer _tSeatHtVn_Stat_AR;

//  message   SeatHtVn_Stat2_AR ID: 916 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   SeatHtVn_Stat2_AR _mSeatHtVn_Stat2_AR;
    int      _SeatHtVn_Stat2_AR_Timebase;
    int      _SeatHtVn_Stat2_AR_CycleCount;
    int      _SeatHtVn_Stat2_AR_StartDelay;
    int      _SeatHtVn_Stat2_AR_MinDelay;
    int      _SeatHtVn_Stat2_AR_Cnt;
    int      _SeatHtVn_Stat2_AR_SpontanFlag;
    int      _SeatHtVn_Stat2_AR_DelayCnt;
    msTimer _tSeatHtVn_Stat2_AR;
	
// message SeatMat_Stat_AR ID: 502 --- Sendeart 5 cyclicAndSpontanWithDelay ---
       message SeatMat_Stat_AR _mSeatMat_Stat_AR;
	int _SeatMat_Stat_AR_Timebase;
	int _SeatMat_Stat_AR_CycleCount;
	int _SeatMat_Stat_AR_StartDelay;
	int _SeatMat_Stat_AR_MinDelay;
	int _SeatMat_Stat_AR_Cnt;
	int _SeatMat_Stat_AR_SpontanFlag;
	int _SeatMat_Stat_AR_DelayCnt;
	msTimer _tSeatMat_Stat_AR;

//  message   SeatMem_D_Rq_AR ID: 297 --- Sendeart 2 cyclicIfActive --- 
    message   SeatMem_D_Rq_AR _mSeatMem_D_Rq_AR;
    int      _SeatMem_D_Rq_AR_Timebase;
    int      _SeatMem_D_Rq_AR_CycleCount;
    int      _SeatMem_D_Rq_AR_StartDelay;
    int      _SeatMem_D_Rq_AR_Cnt;
    int      _SeatMem_D_Rq_AR_Active;
    int      _SeatMem_D_Rq_AR_SigActivity;

    int      _SeatMem_D_Rq_AR_MCMS_DrvPosn_D_Rq_LastState = 0;
    int      _SeatMem_D_Rq_AR_MCMS_DrvPosn_D_Sv_Rq_LastState = 0;
    int      _SeatMem_D_Rq_AR_MCMS_EEH_Posn_Rq_LastState = 0;
    int      _SeatMem_D_Rq_AR_MCMS_HomePosn_D_Rq_LastState = 0;
    int      _SeatMem_D_Rq_AR_MCMS_HomePosn_D_Sv_Rq_LastState = 0;
    int      _SeatMem_D_Rq_AR_Mem_D_Posn_Rq_LastState = 0;
    int      _SeatMem_D_Rq_AR_Mem_D_Prof_Posn_Rq_LastState = 0;
    int      _SeatMem_D_Rq_AR_Mem_D_Rc_Rq_LastState = 0;
    int      _SeatMem_D_Rq_AR_Mem_D_Sv_Rq_LastState = 0;
    int      _SeatMem_D_Rq_AR_MirrDrvPosn_Rq_LastState = 0;
    int      _SeatMem_D_Rq_AR_MirrDrvPosn_Sv_Rq_LastState = 0;
    msTimer _tSeatMem_D_Rq_AR;

//  message   SeatPosn_Abs_D_AR ID: 961 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   SeatPosn_Abs_D_AR _mSeatPosn_Abs_D_AR;
    int      _SeatPosn_Abs_D_AR_Timebase;
    int      _SeatPosn_Abs_D_AR_CycleCount;
    int      _SeatPosn_Abs_D_AR_StartDelay;
    int      _SeatPosn_Abs_D_AR_MinDelay;
    int      _SeatPosn_Abs_D_AR_Cnt;
    int      _SeatPosn_Abs_D_AR_SpontanFlag;
    int      _SeatPosn_Abs_D_AR_DelayCnt;

    byte     _SeatPosn_Abs_D_AR_E2E_Armed;
    byte     _SeatPosn_Abs_D_AR_CRC_ErrorCnt;
    byte     _SeatPosn_Abs_D_AR_SQC_TriggPos;
    int      _SeatPosn_Abs_D_AR_SQC_WrongSeqJump;
    byte     _SeatPosn_Abs_D_AR_SQC_RepeatedCnt;
    byte     _SeatPosn_Abs_D_AR_MSG_DropCnt;
    byte     _SeatPosn_Abs_D_AR_CRC_Offset[16] = { 225, 124,  23, 173,  72, 222, 121,  20, 170,  69, 219, 118,  17, 167,  66, 216 };
    msTimer _tSeatPosn_Abs_D_AR;

//  message   SeatPosn_Abs_P_AR ID: 963 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   SeatPosn_Abs_P_AR _mSeatPosn_Abs_P_AR;
    int      _SeatPosn_Abs_P_AR_Timebase;
    int      _SeatPosn_Abs_P_AR_CycleCount;
    int      _SeatPosn_Abs_P_AR_StartDelay;
    int      _SeatPosn_Abs_P_AR_MinDelay;
    int      _SeatPosn_Abs_P_AR_Cnt;
    int      _SeatPosn_Abs_P_AR_SpontanFlag;
    int      _SeatPosn_Abs_P_AR_DelayCnt;

    byte     _SeatPosn_Abs_P_AR_E2E_Armed;
    byte     _SeatPosn_Abs_P_AR_CRC_ErrorCnt;
    byte     _SeatPosn_Abs_P_AR_SQC_TriggPos;
    int      _SeatPosn_Abs_P_AR_SQC_WrongSeqJump;
    byte     _SeatPosn_Abs_P_AR_SQC_RepeatedCnt;
    byte     _SeatPosn_Abs_P_AR_MSG_DropCnt;
    byte     _SeatPosn_Abs_P_AR_CRC_Offset[16] = {  47, 134, 221,  57, 144, 231,  67, 154, 241,  77, 164, 251,  87, 174,  10,  97 };
    msTimer _tSeatPosn_Abs_P_AR;

//  message   SND_GEN_Stat_AR ID: 1210 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   SND_GEN_Stat_AR _mSND_GEN_Stat_AR;
    int      _SND_GEN_Stat_AR_Timebase;
    int      _SND_GEN_Stat_AR_CycleCount;
    int      _SND_GEN_Stat_AR_StartDelay;
    int      _SND_GEN_Stat_AR_MinDelay;
    int      _SND_GEN_Stat_AR_Cnt;
    int      _SND_GEN_Stat_AR_SpontanFlag;
    int      _SND_GEN_Stat_AR_DelayCnt;
    msTimer _tSND_GEN_Stat_AR;
	
	//  message   SONAR_A1_AR2_DAI: 2429288448  --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   SONAR_A1_AR2_DAI _mSONAR_A1_AR2_DAI;
    int      _SONAR_A1_AR2_DAI_Timebase;
    int      _SONAR_A1_AR2_DAI_CycleCount;
    int      _SONAR_A1_AR2_DAI_StartDelay;
    int      _SONAR_A1_AR2_DAI_MinDelay;
    int      _SONAR_A1_AR2_DAI_Cnt;
    int      _SONAR_A1_AR2_DAI_SpontanFlag;
    int      _SONAR_A1_AR2_DAI_DelayCnt;
    msTimer  _tSONAR_A1_AR2_DAI;
	
	//  message   SONAR_A3_AR2_DAI: 2429550592  --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   SONAR_A3_AR2_DAI _mSONAR_A3_AR2_DAI;
    int      _SONAR_A3_AR2_DAI_Timebase;
    int      _SONAR_A3_AR2_DAI_CycleCount;
    int      _SONAR_A3_AR2_DAI_StartDelay;
    int      _SONAR_A3_AR2_DAI_MinDelay;
    int      _SONAR_A3_AR2_DAI_Cnt;
    int      _SONAR_A3_AR2_DAI_SpontanFlag;
    int      _SONAR_A3_AR2_DAI_DelayCnt;
    msTimer _tSONAR_A3_AR2_DAI;

	//  message   SONAR_A4_AR2_DAI: 2429812736  --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   SONAR_A4_AR2_DAI _mSONAR_A4_AR2_DAI;
    int      _SONAR_A4_AR2_DAI_Timebase;
    int      _SONAR_A4_AR2_DAI_CycleCount;
    int      _SONAR_A4_AR2_DAI_StartDelay;
    int      _SONAR_A4_AR2_DAI_MinDelay;
    int      _SONAR_A4_AR2_DAI_Cnt;
    int      _SONAR_A4_AR2_DAI_SpontanFlag;
    int      _SONAR_A4_AR2_DAI_DelayCnt;
    msTimer _tSONAR_A4_AR2_DAI;

//  message   SPC_Disp_Rq_AR ID: 635 --- Sendeart 0 cyclicX --- 
    message   SPC_Disp_Rq_AR _mSPC_Disp_Rq_AR;
    int      _SPC_Disp_Rq_AR_Timebase;
    int      _SPC_Disp_Rq_AR_CycleCount;
    int      _SPC_Disp_Rq_AR_Cnt;
    int      _SPC_Disp_Rq_AR_StartDelay;
    msTimer _tSPC_Disp_Rq_AR;

//  message   SPC_SwLED_Msg_Rq_AR --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   SPC_SwLED_Msg_Rq_AR _mSPC_SwLED_Msg_Rq_AR;
    int      _SPC_SwLED_Msg_Rq_AR_Timebase;
    int      _SPC_SwLED_Msg_Rq_AR_CycleCount;
    int      _SPC_SwLED_Msg_Rq_AR_StartDelay;
    int      _SPC_SwLED_Msg_Rq_AR_Cnt;
    int      _SPC_SwLED_Msg_Rq_AR_SpontanFlag;

    byte     _SPC_SwLED_Msg_Rq_AR_E2E_Armed;
    byte     _SPC_SwLED_Msg_Rq_AR_CRC_ErrorCnt;
    byte     _SPC_SwLED_Msg_Rq_AR_SQC_TriggPos;
    int      _SPC_SwLED_Msg_Rq_AR_SQC_WrongSeqJump;
    byte     _SPC_SwLED_Msg_Rq_AR_SQC_RepeatedCnt;
    byte     _SPC_SwLED_Msg_Rq_AR_MSG_DropCnt;
    byte     _SPC_SwLED_Msg_Rq_AR_CRC_Offset[16] = {  94, 113, 132, 151, 170, 189, 208, 227, 246,  14,  33,  52,  71,  90, 109, 128 };
    msTimer _tSPC_SwLED_Msg_Rq_AR;

//  Botschaft SPV_Disp_Rq_VAN_AR ID: 791 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   SPV_Disp_Rq_VAN_AR _mSPV_Disp_Rq_VAN_AR;
    int      _SPV_Disp_Rq_VAN_AR_Timebase;
    int      _SPV_Disp_Rq_VAN_AR_CycleCount;
    int      _SPV_Disp_Rq_VAN_AR_StartDelay;
    int      _SPV_Disp_Rq_VAN_AR_MinDelay;
    int      _SPV_Disp_Rq_VAN_AR_Cnt;
    int      _SPV_Disp_Rq_VAN_AR_SpontanFlag;
    int      _SPV_Disp_Rq_VAN_AR_DelayCnt;
    msTimer _tSPV_Disp_Rq_VAN_AR;

//  Botschaft SPV_Disp_Rq2_VAN_AR ID: 2351169536 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   SPV_Disp_Rq2_VAN_AR _mSPV_Disp_Rq2_VAN_AR;
    int      _SPV_Disp_Rq2_VAN_AR_Timebase;
    int      _SPV_Disp_Rq2_VAN_AR_CycleCount;
    int      _SPV_Disp_Rq2_VAN_AR_StartDelay;
    int      _SPV_Disp_Rq2_VAN_AR_MinDelay;
    int      _SPV_Disp_Rq2_VAN_AR_Cnt;
    int      _SPV_Disp_Rq2_VAN_AR_SpontanFlag;
    int      _SPV_Disp_Rq2_VAN_AR_DelayCnt;
    msTimer _tSPV_Disp_Rq2_VAN_AR;
    
//  message   SPV_Ret_Stat_VAN_AR ID: 628 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   SPV_Ret_Stat_VAN_AR _mSPV_Ret_Stat_VAN_AR;
    int      _SPV_Ret_Stat_VAN_AR_Timebase;
    int      _SPV_Ret_Stat_VAN_AR_CycleCount;
    int      _SPV_Ret_Stat_VAN_AR_StartDelay;
    int      _SPV_Ret_Stat_VAN_AR_MinDelay;
    int      _SPV_Ret_Stat_VAN_AR_Cnt;
    int      _SPV_Ret_Stat_VAN_AR_SpontanFlag;
    int      _SPV_Ret_Stat_VAN_AR_DelayCnt;

    byte     _SPV_Ret_Stat_VAN_AR_E2E_Armed;
    byte     _SPV_Ret_Stat_VAN_AR_CRC_ErrorCnt;
    byte     _SPV_Ret_Stat_VAN_AR_SQC_TriggPos;
    int      _SPV_Ret_Stat_VAN_AR_SQC_WrongSeqJump;
    byte     _SPV_Ret_Stat_VAN_AR_SQC_RepeatedCnt;
    byte     _SPV_Ret_Stat_VAN_AR_MSG_DropCnt;
    byte     _SPV_Ret_Stat_VAN_AR_CRC_Offset[16] = { 71, 105, 139, 173, 207, 241, 24, 58, 92, 126, 160, 194, 228, 11, 45, 79 };
    msTimer _tSPV_Ret_Stat_VAN_AR;        
  
//  message   SPV_Rq_AR ID: 789 --- Sendeart 8 cyclicIfActiveFast --- 
    message   SPV_Rq_AR _mSPV_Rq_AR;
    int      _SPV_Rq_AR_Timebase;
    int      _SPV_Rq_AR_CycleCountSlow;
    int      _SPV_Rq_AR_CycleCountFast;
    int      _SPV_Rq_AR_StartDelay;
    int      _SPV_Rq_AR_Cnt;
    int      _SPV_Rq_AR_SigActivity;

    int      _SPV_Rq_AR_AcustWarn_Rq_MPM_LastState = 0;
    int      _SPV_Rq_AR_AudioMute_1_Rq_LastState = 0;
    int      _SPV_Rq_AR_AudioMute_2_Rq_LastState = 0;
    int      _SPV_Rq_AR_AuthRadio_Actv_LastState = 0;
    int      _SPV_Rq_AR_FBAS_VideoIn_Rq_LastState = 0;
    int      _SPV_Rq_AR_Gas_Dr_Unlk_Rq_MPM_LastState = 0;
    int      _SPV_Rq_AR_RadioHdFree_Actv_LastState = 0;
    int      _SPV_Rq_AR_Radio_NumPad_Rq_LastState = 0;
    int      _SPV_Rq_AR_SPV_Rem_UI_Rq_LastState = 0;
    msTimer _tSPV_Rq_AR;

//  message   SPV_Stat_AR ID: 791 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   SPV_Stat_AR _mSPV_Stat_AR;
    int      _SPV_Stat_AR_Timebase;
    int      _SPV_Stat_AR_CycleCount;
    int      _SPV_Stat_AR_StartDelay;
    int      _SPV_Stat_AR_MinDelay;
    int      _SPV_Stat_AR_Cnt;
    int      _SPV_Stat_AR_SpontanFlag;
    int      _SPV_Stat_AR_DelayCnt;
    msTimer _tSPV_Stat_AR;
	
//  message   SPV_Stat_VAN_AR  ID: 630 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   SPV_Stat_VAN_AR _mSPV_Stat_VAN_AR;
    int      _SPV_Stat_VAN_AR_Timebase;
    int      _SPV_Stat_VAN_AR_CycleCount;
    int      _SPV_Stat_VAN_AR_StartDelay;
    int      _SPV_Stat_VAN_AR_MinDelay;
    int      _SPV_Stat_VAN_AR_Cnt;
    int      _SPV_Stat_VAN_AR_SpontanFlag;
    int      _SPV_Stat_VAN_AR_DelayCnt;

    byte     _SPV_Stat_VAN_AR_E2E_Armed;
    byte     _SPV_Stat_VAN_AR_CRC_ErrorCnt;
    byte     _SPV_Stat_VAN_AR_SQC_TriggPos;
    int      _SPV_Stat_VAN_AR_SQC_WrongSeqJump;
    byte     _SPV_Stat_VAN_AR_SQC_RepeatedCnt;
    byte     _SPV_Stat_VAN_AR_MSG_DropCnt;
    byte     _SPV_Stat_VAN_AR_CRC_Offset[16] = { 213, 197, 181, 165, 149, 133, 117, 101, 85, 69, 53, 37, 21, 5, 240, 224 };
    msTimer _tSPV_Stat_VAN_AR;


//  message   StWhl_Angl_Stat_AR ID: 47 --- Sendeart 0 cyclicX --- 
    message   StWhl_Angl_Stat_AR _mStWhl_Angl_Stat_AR;
    int      _StWhl_Angl_Stat_AR_Timebase;
    int      _StWhl_Angl_Stat_AR_CycleCount;
    int      _StWhl_Angl_Stat_AR_StartDelay;
    int      _StWhl_Angl_Stat_AR_Cnt;

    byte     _StWhl_Angl_Stat_AR_E2E_Armed;
    byte     _StWhl_Angl_Stat_AR_CRC_ErrorCnt;
    byte     _StWhl_Angl_Stat_AR_SQC_TriggPos;
    int      _StWhl_Angl_Stat_AR_SQC_WrongSeqJump;
    byte     _StWhl_Angl_Stat_AR_SQC_RepeatedCnt;
    byte     _StWhl_Angl_Stat_AR_MSG_DropCnt;
    byte     _StWhl_Angl_Stat_AR_CRC_Offset[16] = {  39,   7, 226, 194, 162, 130,  98,  66,  34, 253, 221, 189, 157, 125,  93,  61 };
    msTimer _tStWhl_Angl_Stat_AR;

//  message   StWhl_OFN_Stat_AR --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   StWhl_OFN_Stat_AR _mStWhl_OFN_Stat_AR;
    int      _StWhl_OFN_Stat_AR_Timebase;
    int      _StWhl_OFN_Stat_AR_CycleCount;
    int      _StWhl_OFN_Stat_AR_StartDelay;
    int      _StWhl_OFN_Stat_AR_MinDelay;
    int      _StWhl_OFN_Stat_AR_Cnt;
    int      _StWhl_OFN_Stat_AR_SpontanFlag;
    int      _StWhl_OFN_Stat_AR_DelayCnt;
    msTimer _tStWhl_OFN_Stat_AR;

//  message   StWhl_Sw_Stat_AR ID: 1025 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   StWhl_Sw_Stat_AR _mStWhl_Sw_Stat_AR;
    int      _StWhl_Sw_Stat_AR_Timebase;
    int      _StWhl_Sw_Stat_AR_CycleCount;
    int      _StWhl_Sw_Stat_AR_StartDelay;
    int      _StWhl_Sw_Stat_AR_Cnt;
    int      _StWhl_Sw_Stat_AR_SpontanFlag;

    byte     _StWhl_Sw_Stat_AR_E2E_Armed;
    byte     _StWhl_Sw_Stat_AR_CRC_ErrorCnt;
    byte     _StWhl_Sw_Stat_AR_SQC_TriggPos;
    int      _StWhl_Sw_Stat_AR_SQC_WrongSeqJump;
    byte     _StWhl_Sw_Stat_AR_SQC_RepeatedCnt;
    byte     _StWhl_Sw_Stat_AR_MSG_DropCnt;
    byte     _StWhl_Sw_Stat_AR_CRC_Offset[16] = { 189, 144, 99,  54,   9, 215, 170, 125,  80,  35, 241, 196, 151, 106,  61,  16 };
    msTimer _tStWhl_Sw_Stat_AR;

//  message   TC_Disp_Rq_ECM_AR ID: 331 --- Sendeart 0 cyclicX --- 
    message   TC_Disp_Rq_ECM_AR _mTC_Disp_Rq_ECM_AR;
    int      _TC_Disp_Rq_ECM_AR_Timebase;
    int      _TC_Disp_Rq_ECM_AR_CycleCount;
    int      _TC_Disp_Rq_ECM_AR_StartDelay;
    int      _TC_Disp_Rq_ECM_AR_Cnt;
    int      _TC_Disp_Rq_ECM_AR_SigActivity;

    int      _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState = 0;
    msTimer _tTC_Disp_Rq_ECM_AR;
	
    // Botschaft TC_Disp_Rq2_AR2 ID: 1210 --- Sendeart 0 cyclicX ---  
    message TC_Disp_Rq2_AR2 _mTC_Disp_Rq2_AR2;
    int _TC_Disp_Rq2_AR2_Timebase;
    int _TC_Disp_Rq2_AR2_CycleCount;
    int _TC_Disp_Rq2_AR2_StartDelay;
    int _TC_Disp_Rq2_AR2_MinDelay;
    int _TC_Disp_Rq2_AR2_Cnt;
    int _TC_Disp_Rq2_AR2_SpontanFlag;
    int _TC_Disp_Rq2_AR2_DelayCnt;
    msTimer _tTC_Disp_Rq2_AR2;

//  message   TC_EBBC_Disp_Rq_ECM_AR ID: 333 --- Sendeart 0 cyclicX --- 
    message   TC_EBBC_Disp_Rq_ECM_AR _mTC_EBBC_Disp_Rq_ECM_AR;
    int      _TC_EBBC_Disp_Rq_ECM_AR_Timebase;
    int      _TC_EBBC_Disp_Rq_ECM_AR_CycleCount;
    int      _TC_EBBC_Disp_Rq_ECM_AR_StartDelay;
    int      _TC_EBBC_Disp_Rq_ECM_AR_Cnt;
    msTimer _tTC_EBBC_Disp_Rq_ECM_AR;

//  message   TC_EEBBC_Disp_Rq_AR ID: 647 --- Sendeart 0 cyclicX --- 
    message   TC_EEBBC_Disp_Rq_AR _mTC_EEBBC_Disp_Rq_AR;
    int      _TC_EEBBC_Disp_Rq_AR_Timebase;
    int      _TC_EEBBC_Disp_Rq_AR_CycleCount;
    int      _TC_EEBBC_Disp_Rq_AR_StartDelay;
    int      _TC_EEBBC_Disp_Rq_AR_Cnt;
    msTimer _tTC_EEBBC_Disp_Rq_AR;

//	message	 TC_EEBBC_Energy_Cons_AR ID: 2344615936 --- Sendeart 0 cyclicX ---
	message	 TC_EEBBC_Energy_Cons_AR _mTC_EEBBC_Energy_Cons_AR;
	int		_TC_EEBBC_Energy_Cons_AR_Timebase;
	int		_TC_EEBBC_Energy_Cons_AR_CycleCount;
	int		_TC_EEBBC_Energy_Cons_AR_StartDelay;
	int		_TC_EEBBC_Energy_Cons_AR_Cnt;
  int   _TC_EEBBC_Energy_Cons_AR_SpontanFlag;
	msTimer	_tTC_EEBBC_Energy_Cons_AR;

//  message   TC_EU6_Cons_Disp_Rq_AR ID: 848 --- Sendeart 0 cyclicX --- 
    message   TC_EU6_Cons_Disp_Rq_AR _mTC_EU6_Cons_Disp_Rq_AR;
    int      _TC_EU6_Cons_Disp_Rq_AR_Timebase;
    int      _TC_EU6_Cons_Disp_Rq_AR_CycleCount;
    int      _TC_EU6_Cons_Disp_Rq_AR_StartDelay;
    int      _TC_EU6_Cons_Disp_Rq_AR_MinDelay;
    int      _TC_EU6_Cons_Disp_Rq_AR_Cnt;
    int      _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag;
    int      _TC_EU6_Cons_Disp_Rq_AR_DelayCnt;
    int      _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState = 0;
    msTimer _tTC_EU6_Cons_Disp_Rq_AR;    
    
//  message   TCM_Disp_Rq_AMG_AR ID: 653 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   TCM_Disp_Rq_AMG_AR _mTCM_Disp_Rq_AMG_AR;
    int      _TCM_Disp_Rq_AMG_AR_Timebase;
    int      _TCM_Disp_Rq_AMG_AR_CycleCount;
    int      _TCM_Disp_Rq_AMG_AR_StartDelay;
    int      _TCM_Disp_Rq_AMG_AR_MinDelay;
    int      _TCM_Disp_Rq_AMG_AR_Cnt;
    int      _TCM_Disp_Rq_AMG_AR_SpontanFlag;
    int      _TCM_Disp_Rq_AMG_AR_DelayCnt;
    msTimer _tTCM_Disp_Rq_AMG_AR;

//  message   Teleaid_WRN_AR ID: 1199 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Teleaid_WRN_AR _mTeleaid_WRN_AR;
    int      _Teleaid_WRN_AR_Timebase;
    int      _Teleaid_WRN_AR_CycleCount;
    int      _Teleaid_WRN_AR_StartDelay;
    int      _Teleaid_WRN_AR_Cnt;
    int      _Teleaid_WRN_AR_SpontanFlag;
    msTimer _tTeleaid_WRN_AR;

//  message   TP_EIS_IC_SecOdo --- Sendeart 0 cyclicX --- 
    message   TP_EIS_IC_SecOdo _mTP_EIS_IC_SecOdo;
    int      _TP_EIS_IC_SecOdo_Timebase;
    int      _TP_EIS_IC_SecOdo_SpontanFlag;
    msTimer _tTP_EIS_IC_SecOdo;

////  message   TP_COM_TGW_Adapt --- Sendeart 0 cyclicX --- 
//    message   TP_COM_TGW_Adapt _mTP_COM_TGW_Adapt;
//    int      _TP_COM_TGW_Adapt_Timebase;
//    int      _TP_COM_TGW_Adapt_SpontanFlag;
//    msTimer _tTP_COM_TGW_Adapt;

//  message   TP_MPM_TGW_Nav ID: 745 --- Sendeart 0 cyclicX --- 
    message   TP_MPM_TGW_Nav _mTP_MPM_TGW_Nav;
    int      _TP_MPM_TGW_Nav_Timebase;
    int      _TP_MPM_TGW_Nav_SpontanFlag;
    msTimer _tTP_MPM_TGW_Nav;

//  message   TP_PARK_TGW --- Sendeart 0 cyclicX --- 
    message   TP_PARK_TGW _mTP_PARK_TGW;
    int      _TP_PARK_TGW_Timebase;
    int      _TP_PARK_TGW_SpontanFlag;
    msTimer _tTP_PARK_TGW;

//  message   TP_TELEAID_TGW ID: 739 --- Sendeart 0 cyclicX --- 
    message   TP_TELEAID_TGW _mTP_TELEAID_TGW;
    int      _TP_TELEAID_TGW_Timebase;
    int      _TP_TELEAID_TGW_SpontanFlag;
    msTimer _tTP_TELEAID_TGW;

//  message   TP_WPT_IC ID: 1230 --- Sendeart 0 cyclicX --- 
    message   TP_WPT_IC _mTP_WPT_IC;
    int      _TP_WPT_IC_Timebase;
    int      _TP_WPT_IC_SpontanFlag;
    msTimer _tTP_WPT_IC;

//  message   TP_WPT_TGW ID: 643 --- Sendeart 0 cyclicX --- 
    message   TP_WPT_TGW _mTP_WPT_TGW;
    int      _TP_WPT_TGW_Timebase;
    int      _TP_WPT_TGW_SpontanFlag;
    msTimer _tTP_WPT_TGW;

//  message   Trailer_Stat_AR ID: 865 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Trailer_Stat_AR _mTrailer_Stat_AR;
    int      _Trailer_Stat_AR_Timebase;
    int      _Trailer_Stat_AR_CycleCount;
    int      _Trailer_Stat_AR_StartDelay;
    int      _Trailer_Stat_AR_Cnt;
    int      _Trailer_Stat_AR_SpontanFlag;

    byte     _Trailer_Stat_AR_E2E_Armed;
    byte     _Trailer_Stat_AR_CRC_ErrorCnt;
    byte     _Trailer_Stat_AR_SQC_TriggPos;
    int      _Trailer_Stat_AR_SQC_WrongSeqJump;
    byte     _Trailer_Stat_AR_SQC_RepeatedCnt;
    byte     _Trailer_Stat_AR_MSG_DropCnt;
    byte     _Trailer_Stat_AR_CRC_Offset[16] = { 164, 239,  63, 138, 213,  37, 112, 187,  11,  86, 161, 236,  60, 135, 210,  34 };
    msTimer _tTrailer_Stat_AR;

//  message   TSA_Disp_Rq1_AR ID: 213 --- Sendeart 0 cyclicX --- 
    message   TSA_Disp_Rq1_AR _mTSA_Disp_Rq1_AR;
    int      _TSA_Disp_Rq1_AR_Timebase;
    int      _TSA_Disp_Rq1_AR_CycleCount;
    int      _TSA_Disp_Rq1_AR_StartDelay;
    int      _TSA_Disp_Rq1_AR_MinDelay;
    int      _TSA_Disp_Rq1_AR_Cnt;
    int      _TSA_Disp_Rq1_AR_DelayCnt;
    int      _TSA_Disp_Rq1_AR_SpontanFlag;
    msTimer _tTSA_Disp_Rq1_AR;

//  message   TSA_Disp_Rq2_AR ID: 1051 --- Sendeart 0 cyclicX --- 
    message   TSA_Disp_Rq2_AR _mTSA_Disp_Rq2_AR;
    int      _TSA_Disp_Rq2_AR_Timebase;
    int      _TSA_Disp_Rq2_AR_CycleCount;
    int      _TSA_Disp_Rq2_AR_StartDelay;
    int      _TSA_Disp_Rq2_AR_Cnt;
    byte     _TSA_Disp_Rq2_AR_framecount;
    msTimer _tTSA_Disp_Rq2_AR;

//  message   TSA_Disp_Rq3_AR ID: 1052 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   TSA_Disp_Rq3_AR _mTSA_Disp_Rq3_AR;
    int      _TSA_Disp_Rq3_AR_Timebase;
    int      _TSA_Disp_Rq3_AR_CycleCount;
    int      _TSA_Disp_Rq3_AR_StartDelay;
    int      _TSA_Disp_Rq3_AR_MinDelay;
    int      _TSA_Disp_Rq3_AR_Cnt;
    int      _TSA_Disp_Rq3_AR_SpontanFlag;
    int      _TSA_Disp_Rq3_AR_DelayCnt;
    msTimer _tTSA_Disp_Rq3_AR;
    
//  message   Veh_Susp_Adj_AR  ID: 864 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Veh_Susp_Adj_AR _mVeh_Susp_Adj_AR;
    int      _Veh_Susp_Adj_AR_Timebase;
    int      _Veh_Susp_Adj_AR_CycleCount;
    int      _Veh_Susp_Adj_AR_StartDelay;
    int      _Veh_Susp_Adj_AR_MinDelay;
    int      _Veh_Susp_Adj_AR_Cnt;
    int      _Veh_Susp_Adj_AR_SpontanFlag;
    int      _Veh_Susp_Adj_AR_DelayCnt;

    byte     _Veh_Susp_Adj_AR_E2E_Armed;
    byte     _Veh_Susp_Adj_AR_CRC_ErrorCnt;
    byte     _Veh_Susp_Adj_AR_SQC_TriggPos;
    int      _Veh_Susp_Adj_AR_SQC_WrongSeqJump;
    byte     _Veh_Susp_Adj_AR_SQC_RepeatedCnt;
    byte     _Veh_Susp_Adj_AR_MSG_DropCnt;
    byte     _Veh_Susp_Adj_AR_CRC_Offset[16] = { 10, 173, 85, 248, 160, 72, 235, 147, 59, 222, 134, 46, 209, 121, 33, 196 };
    msTimer _tVeh_Susp_Adj_AR;    
	
//  message   VehCarv_Stat_AR ID: 1064 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   VehCarv_Stat_AR _mVehCarv_Stat_AR;
    int      _VehCarv_Stat_AR_Timebase;
    int      _VehCarv_Stat_AR_CycleCount;
    int      _VehCarv_Stat_AR_StartDelay;
    int      _VehCarv_Stat_AR_MinDelay;
    int      _VehCarv_Stat_AR_Cnt;
    int      _VehCarv_Stat_AR_SpontanFlag;
    int      _VehCarv_Stat_AR_DelayCnt;
    msTimer _tVehCarv_Stat_AR;
	
	
//  message   VehDyn_Stat1_AR --- Sendeart 0 cyclicX --- 
    message   VehDyn_Stat1_AR _mVehDyn_Stat1_AR;
    int      _VehDyn_Stat1_AR_Timebase;
    int      _VehDyn_Stat1_AR_CycleCount;
    int      _VehDyn_Stat1_AR_StartDelay;
    int      _VehDyn_Stat1_AR_Cnt;

    byte     _VehDyn_Stat1_AR_E2E_Armed;
    byte     _VehDyn_Stat1_AR_CRC_ErrorCnt;
    byte     _VehDyn_Stat1_AR_SQC_TriggPos;
    int      _VehDyn_Stat1_AR_SQC_WrongSeqJump;
    byte     _VehDyn_Stat1_AR_SQC_RepeatedCnt;
    byte     _VehDyn_Stat1_AR_MSG_DropCnt;
    byte     _VehDyn_Stat1_AR_CRC_Offset[16] = { 124, 120, 116, 112, 108, 104, 100,  96,  92,  88,  84,  80,  76,  72,  68,  64 };
    msTimer _tVehDyn_Stat1_AR;

//  message   VehDyn_Stat2_AR --- Sendeart 0 cyclicX --- 
    message   VehDyn_Stat2_AR _mVehDyn_Stat2_AR;
    int      _VehDyn_Stat2_AR_Timebase;
    int      _VehDyn_Stat2_AR_CycleCount;
    int      _VehDyn_Stat2_AR_StartDelay;
    int      _VehDyn_Stat2_AR_Cnt;

    byte     _VehDyn_Stat2_AR_E2E_Armed;
    byte     _VehDyn_Stat2_AR_CRC_ErrorCnt;
    byte     _VehDyn_Stat2_AR_SQC_TriggPos;
    int      _VehDyn_Stat2_AR_SQC_WrongSeqJump;
    byte     _VehDyn_Stat2_AR_SQC_RepeatedCnt;
    byte     _VehDyn_Stat2_AR_MSG_DropCnt;
    byte     _VehDyn_Stat2_AR_CRC_Offset[16] = { 163,  16, 120, 224,  77, 181,  34, 138, 242,  95, 199,  52, 156,   9, 113, 217 };
    msTimer _tVehDyn_Stat2_AR;

//  message   VehLvl_Stat_AR ID: 172 --- Sendeart 0 cyclicX --- 
    message   VehLvl_Stat_AR _mVehLvl_Stat_AR;
    int      _VehLvl_Stat_AR_Timebase;
    int      _VehLvl_Stat_AR_CycleCount;
    int      _VehLvl_Stat_AR_StartDelay;
    int      _VehLvl_Stat_AR_Cnt;

    byte     _VehLvl_Stat_AR_E2E_Armed;
    byte     _VehLvl_Stat_AR_CRC_ErrorCnt;
    byte     _VehLvl_Stat_AR_SQC_TriggPos;
    int      _VehLvl_Stat_AR_SQC_WrongSeqJump;
    byte     _VehLvl_Stat_AR_SQC_RepeatedCnt;
    byte     _VehLvl_Stat_AR_MSG_DropCnt;
    byte     _VehLvl_Stat_AR_CRC_Offset[16] = { 114,  51, 239, 176, 113,  50, 238, 175, 112,  49, 237, 174, 111,  48, 236, 173 };
    msTimer _tVehLvl_Stat_AR;

//  message   VehPwrMngmnt_EMM_Stat2_AR ID: 1185 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   VehPwrMngmnt_EMM_Stat2_AR _mVehPwrMngmnt_EMM_Stat2_AR;
    int      _VehPwrMngmnt_EMM_Stat2_AR_Timebase;
    int      _VehPwrMngmnt_EMM_Stat2_AR_CycleCount;
    int      _VehPwrMngmnt_EMM_Stat2_AR_StartDelay;
    int      _VehPwrMngmnt_EMM_Stat2_AR_MinDelay;
    int      _VehPwrMngmnt_EMM_Stat2_AR_Cnt;
    int      _VehPwrMngmnt_EMM_Stat2_AR_SpontanFlag;
    int      _VehPwrMngmnt_EMM_Stat2_AR_DelayCnt;

    byte     _VehPwrMngmnt_EMM_Stat2_AR_E2E_Armed;
    byte     _VehPwrMngmnt_EMM_Stat2_AR_CRC_ErrorCnt;
    byte     _VehPwrMngmnt_EMM_Stat2_AR_SQC_TriggPos;
    int      _VehPwrMngmnt_EMM_Stat2_AR_SQC_WrongSeqJump;
    byte     _VehPwrMngmnt_EMM_Stat2_AR_SQC_RepeatedCnt;
    byte     _VehPwrMngmnt_EMM_Stat2_AR_MSG_DropCnt;
    byte     _VehPwrMngmnt_EMM_Stat2_AR_CRC_Offset[16] = {  18,  90, 162, 234,  55, 127, 199,  20,  92, 164, 236,  57, 129, 201,  22,  94 };
    msTimer _tVehPwrMngmnt_EMM_Stat2_AR;

//  message   VehSpd_X_AR --- Sendeart 0 cyclicX --- 
    message   VehSpd_X_AR _mVehSpd_X_AR;
    int      _VehSpd_X_AR_Timebase;
    int      _VehSpd_X_AR_CycleCount;
    int      _VehSpd_X_AR_StartDelay;
    int      _VehSpd_X_AR_Cnt;

    byte     _VehSpd_X_AR_E2E_Armed;
    byte     _VehSpd_X_AR_CRC_ErrorCnt;
    byte     _VehSpd_X_AR_SQC_TriggPos;
    int      _VehSpd_X_AR_SQC_WrongSeqJump;
    byte     _VehSpd_X_AR_SQC_RepeatedCnt;
    byte     _VehSpd_X_AR_MSG_DropCnt;
    byte     _VehSpd_X_AR_CRC_Offset[16] = { 59, 75, 91, 107, 123, 139, 155, 171, 187, 203, 219, 235, 251, 16, 32, 48 };
    msTimer _tVehSpd_X_AR;

//  message   VIN_AR ID: 113 --- Sendeart 1 spontanX --- 
    message   VIN_AR _mVIN_AR;
    int      _VIN_AR_Timebase;
    int      _VIN_AR_SpontanFlag;
    msTimer _tVIN_AR;

//  message   VTA_Event_Disp_AR ID: 1194 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   VTA_Event_Disp_AR _mVTA_Event_Disp_AR;
    int      _VTA_Event_Disp_AR_Timebase;
    int      _VTA_Event_Disp_AR_CycleCount;
    int      _VTA_Event_Disp_AR_StartDelay;
    int      _VTA_Event_Disp_AR_MinDelay;
    int      _VTA_Event_Disp_AR_Cnt;
    int      _VTA_Event_Disp_AR_SpontanFlag;
    int      _VTA_Event_Disp_AR_DelayCnt;
    msTimer _tVTA_Event_Disp_AR;

//  message   DLM_Stat_AR ID: 996 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   DLM_Stat_AR _mDLM_Stat_AR;
    int      _DLM_Stat_AR_Timebase;
    int      _DLM_Stat_AR_CycleCount;
    int      _DLM_Stat_AR_StartDelay;
    int      _DLM_Stat_AR_MinDelay;
    int      _DLM_Stat_AR_Cnt;
    int      _DLM_Stat_AR_SpontanFlag;
    int      _DLM_Stat_AR_DelayCnt;

    byte     _DLM_Stat_AR_E2E_Armed;
    byte     _DLM_Stat_AR_CRC_ErrorCnt;
    byte     _DLM_Stat_AR_SQC_TriggPos;
    int      _DLM_Stat_AR_SQC_WrongSeqJump;
    byte     _DLM_Stat_AR_SQC_RepeatedCnt;
    byte     _DLM_Stat_AR_MSG_DropCnt;
    byte     _DLM_Stat_AR_CRC_Offset[16] = {126,26,177,77,228,128,28,179,79,230,130,30,181,81,232,132};
    msTimer _tDLM_Stat_AR;
	
//  message   Whl_Lt_Stat_AR ID: 161 --- Sendeart 0 cyclicX --- 
    message   Whl_Lt_Stat_AR _mWhl_Lt_Stat_AR;
    int      _Whl_Lt_Stat_AR_Timebase;
    int      _Whl_Lt_Stat_AR_CycleCount;
    int      _Whl_Lt_Stat_AR_StartDelay;
    int      _Whl_Lt_Stat_AR_Cnt;

    byte     _Whl_Lt_Stat_AR_E2E_Armed;
    byte     _Whl_Lt_Stat_AR_CRC_ErrorCnt;
    byte     _Whl_Lt_Stat_AR_SQC_TriggPos;
    int      _Whl_Lt_Stat_AR_SQC_WrongSeqJump;
    byte     _Whl_Lt_Stat_AR_SQC_RepeatedCnt;
    byte     _Whl_Lt_Stat_AR_MSG_DropCnt;
    byte     _Whl_Lt_Stat_AR_CRC_Offset[16] = { 135, 212,  38, 115, 192,  18,  95, 172, 249,  75, 152, 229,  55, 132, 209,  35 };
    msTimer _tWhl_Lt_Stat_AR;

//  message   Whl_Rt_Stat_AR ID: 163 --- Sendeart 0 cyclicX --- 
    message   Whl_Rt_Stat_AR _mWhl_Rt_Stat_AR;
    int      _Whl_Rt_Stat_AR_Timebase;
    int      _Whl_Rt_Stat_AR_CycleCount;
    int      _Whl_Rt_Stat_AR_StartDelay;
    int      _Whl_Rt_Stat_AR_Cnt;

    byte     _Whl_Rt_Stat_AR_E2E_Armed;
    byte     _Whl_Rt_Stat_AR_CRC_ErrorCnt;
    byte     _Whl_Rt_Stat_AR_SQC_TriggPos;
    int      _Whl_Rt_Stat_AR_SQC_WrongSeqJump;
    byte     _Whl_Rt_Stat_AR_SQC_RepeatedCnt;
    byte     _Whl_Rt_Stat_AR_MSG_DropCnt;
    byte     _Whl_Rt_Stat_AR_CRC_Offset[16] = {  39, 128, 217,  55, 144, 233,  71, 160, 249,  87, 176,  14, 103, 192,  30, 119 };
    msTimer _tWhl_Rt_Stat_AR;

//  message   WhlPlsCnt_TPM_AR --- Sendeart 0 cyclicX --- 
    message   WhlPlsCnt_TPM_AR _mWhlPlsCnt_TPM_AR;
    int      _WhlPlsCnt_TPM_AR_Timebase;
    int      _WhlPlsCnt_TPM_AR_CycleCount;
    int      _WhlPlsCnt_TPM_AR_StartDelay;
    int      _WhlPlsCnt_TPM_AR_Cnt;

    byte     _WhlPlsCnt_TPM_AR_E2E_Armed;
    byte     _WhlPlsCnt_TPM_AR_CRC_ErrorCnt;
    byte     _WhlPlsCnt_TPM_AR_SQC_TriggPos;
    int      _WhlPlsCnt_TPM_AR_SQC_WrongSeqJump;
    byte     _WhlPlsCnt_TPM_AR_SQC_RepeatedCnt;
    byte     _WhlPlsCnt_TPM_AR_MSG_DropCnt;
    byte     _WhlPlsCnt_TPM_AR_CRC_Offset[16] = { 136, 194, 252,  59, 117, 175, 233,  40,  98, 156, 214,  21,  79, 137, 195, 253 };
    msTimer _tWhlPlsCnt_TPM_AR;

//  message   WIA_EngTrq_AR ID: 1149 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   WIA_EngTrq_AR _mWIA_EngTrq_AR;
    int      _WIA_EngTrq_AR_Timebase;
    int      _WIA_EngTrq_AR_CycleCount;
    int      _WIA_EngTrq_AR_StartDelay;
    int      _WIA_EngTrq_AR_Cnt;
    int      _WIA_EngTrq_AR_SpontanFlag;
    msTimer _tWIA_EngTrq_AR;
	
		//  message   WMI_Stat_AR: 1225  --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   WMI_Stat_AR _mWMI_Stat_AR;
    int      _WMI_Stat_AR_Timebase;
    int      _WMI_Stat_AR_CycleCount;
    int      _WMI_Stat_AR_StartDelay;
    int      _WMI_Stat_AR_MinDelay;
    int      _WMI_Stat_AR_Cnt;
    int      _WMI_Stat_AR_SpontanFlag;
    int      _WMI_Stat_AR_DelayCnt;
    msTimer  _tWMI_Stat_AR;

//  message   Wpr_Stat_AR ID: 845 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   Wpr_Stat_AR _mWpr_Stat_AR;
    int      _Wpr_Stat_AR_Timebase;
    int      _Wpr_Stat_AR_CycleCount;
    int      _Wpr_Stat_AR_StartDelay;
    int      _Wpr_Stat_AR_Cnt;
    int      _Wpr_Stat_AR_SpontanFlag;
    msTimer _tWpr_Stat_AR;

//  message   WPT_Stat2_AR ID: 634 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
    message   WPT_Stat2_AR _mWPT_Stat2_AR;
    int      _WPT_Stat2_AR_Timebase;
    int      _WPT_Stat2_AR_CycleCount;
    int      _WPT_Stat2_AR_StartDelay;
    int      _WPT_Stat2_AR_Cnt;
    int      _WPT_Stat2_AR_SpontanFlag;
    msTimer _tWPT_Stat2_AR;

////  message   XCP_Rq_RBTM_FL --- Sendeart 5 cyclicAndSpontanWithDelay --- 
//    message   XCP_Rq_RBTM_FL _mXCP_Rq_RBTM_FL;
//    int      _XCP_Rq_RBTM_FL_Timebase;
//    int      _XCP_Rq_RBTM_FL_CycleCount = 50;
//    int      _XCP_Rq_RBTM_FL_StartDelay;
//    int      _XCP_Rq_RBTM_FL_MinDelay = 5;
//    int      _XCP_Rq_RBTM_FL_Cnt;
//    int      _XCP_Rq_RBTM_FL_SpontanFlag = 0;
//    int      _XCP_Rq_RBTM_FL_DelayCnt;
//
////  message   XCP_Rq_RBTM_FR --- Sendeart 5 cyclicAndSpontanWithDelay --- 
//    message   XCP_Rq_RBTM_FR _mXCP_Rq_RBTM_FR;
//    int      _XCP_Rq_RBTM_FR_Timebase;
//    int      _XCP_Rq_RBTM_FR_CycleCount = 50;
//    int      _XCP_Rq_RBTM_FR_StartDelay;
//    int      _XCP_Rq_RBTM_FR_MinDelay = 5;
//    int      _XCP_Rq_RBTM_FR_Cnt;
//    int      _XCP_Rq_RBTM_FR_SpontanFlag = 0;
//    int      _XCP_Rq_RBTM_FR_DelayCnt;

// #VAR_DEF_END#
    Timer t_DoorNMCancelTimer;
    Timer t_KeyInLockNMCancelTimer;
    Timer t_StWhlButtonNMCancelTimer;
    Timer t_PnhvIcDispNmCancelTimer;
    Timer t_WakeWarningNMCancelTimer;
    Timer t_CarClosureNMCancelTimer;
    Timer t_EPKBWarningNMCancelTimer;
    Timer t_IlluNMCancelTimer;
    Timer t_GearIndNMCancelTimer;
	Timer t_LowBeamNMCancelTimer;
    const byte c_NMCancelTimer_05sec = 5;
    const byte c_NMCancelTimer_30sec = 30;
    const byte c_NMCancelTimer_120sec = 120;
    

    char buffer[1024], stringbuffer[512];
    int bActiveHelper;    // Hilfsvariable f�r "Aktive Signale"

//--------------------------------------- AUTOSAR NM ------------------------------------------------

    const byte cAUTO =   0;
    const byte cMANUAL = 1;

    msTimer t_NM_Transmit;
    long  NM_Transmit_Cycle;
    msTimer t_NM_Wait_Bus_Sleep_Time;
    const c_NM_Wait_Bus_Sleep_Time = 1500;
//    msTimer t_NM_Remote_Sleep_Ind_Time;
    const c_NM_Remote_Sleep_Ind_Time = 5000;
    msTimer t_NM_Repeat_Message_Time;
    const c_NM_Repeat_Message_Time = 6000;
    msTimer t_NM_Timeout_Time;
    const c_NM_Timeout_Time = 5000;

    byte NM_Mode = 0;
    const byte cNM_Mode_Init = 0;
    const byte cNM_Mode_Sleep = 1;
    const byte cNM_Mode_Prepare_Bus_Sleep = 2;
    const byte cNM_Mode_Ready_Sleep = 3;
    const byte cNM_Mode_Normal_Operation_State = 4;
    const byte cNM_Mode_RepeatMsg = 5;

    byte boCanNM_Rx_Indication = 0;
    byte boCanNM_Tx_Confirmation = 0;
    byte boCanNM_WaitBusSleep_Timer_Expired = 0;
    byte boCanNM_RepeatMessage_Timer_Expired = 0;
    byte boCanNM_NM_Timeout_Timer_Expired = 0;
    byte boCanNM_RepeatMessage_Requested = 0;

    const word cFLDoorNMRequest =       0x0001;
    const word cFRDoorNMRequest =       0x0002;
    const word cRLDoorNMRequest =       0x0004;
    const word cRRDoorNMRequest =       0x0008;
    const word cAllDoorNMRequest =      0x000F;
    const word cIgnitionNMRequest =     0x0010;
    const word cStWhlButtonNMRequest =  0x0020;
    const word cWakeWarningNMRequest =  0x0040;
    const word cEPKBWarningNMRequest =  0x0080;
    const word cIlluNMRequest =         0x0100;
    const word cCarClosureNMRequest =   0x0200;
    const word cGearIndNMRequest =      0x0400;
    const word cLowBeamNMRequest =      0x0800;
	const word cPnhvIcDispNmRequest =   0x1000;

    const word cManualNMRequest =       0x8000;
    const word cAllNMRequest =          0xFFFF;

    const CanNmNodeId_Base =       1280; // =   07h
    const CanNmNodeId_APM =          76; // =   4Ch
    const CanNmNodeId_DRVU =         77; // =   4Dh
    const CanNmNodeId_EIS =           7; // =   07h
    const CanNmNodeId_HGW =          27; // =   07h
    const CanNmNodeId_TGW =          56; // =   38h
    const CanNmNodeId_RBTM_FR =      64; // =   40h
    const CanNmNodeId_IC =           65; // =   41h
    const CanNmNodeId_HUD =          66; // =   42h
    const CanNmNodeId_NV =           67; // =   43h
    const CanNmNodeId_RVC_SVS =      68; // =   44h
    const CanNmNodeId_ORC =          69; // =   45h
    const CanNmNodeId_RBTM_FL =      71; // =   47h
    const CanNmNodeId_TPM =          82; // =   52h

    const CanNmNodeDetectionEnabled =          0; //false
    const CanNmNodeIdEnabled =                 1; //true
    const CanNmUserDataEnabled =               1; //true;
    const CanNmUserDataLentgh =                7;
    const CanNmRepeatMsgIndEnabled =           1; //true;
    const CanNmDevErrorDetect =                0; //false
//    const CanNmUserDataEnabled =             1; //true
    const CanNmRemoteSleepIndEnabled =         0; //false
    const CanNmMsgReducedtime =                80; //ms
    const CanNmPduRxIndicationEnabled =        0; //false
    const CanNmStateChangeIndEnabled =         0; //false
    const CanNmImmediateTxconfEnabled =        0;// false
    const CanNmMsgTimeoutTime =                5000; //ms
    const CanNmPduNidPosition =                0; //CANNM_PDU_BYTE_0;
    const CanNmPduCbvPosition =                0xFF; //ANNM_PDU_OFF;
    const CanNmPduLength =                     8;
    const cCanNmPassiveModeEnabled =           0; //false
    const CanNmBusSynchronizationEnabled =     0; //false
    const CanNmBusLoadReductionEnabled =       1; //true
//    const CanNmRemoteSleepIndEnabled =       0; //false
//    const CanNmNodeDetectionEnabled =        0; //false
    const CanNmComControlEnabled =             1; //true    

    const NmAsrCanMsgStandardCycle =          2000;
    const NmAsrCanMsgCycleOffset_APM =          40;
    const NmAsrCanMsgReducedTime_APM =        1760;
    const NmAsrCanMsgCycleOffset_DRVU =         50;
    const NmAsrCanMsgReducedTime_DRVU =       1770;
    const NmAsrCanMsgCycleOffset_EIS =          70;
    const NmAsrCanMsgReducedTime_EIS =        1070;
    const NmAsrCanMsgCycleOffset_HGW =          30;
    const NmAsrCanMsgReducedTime_HGW =        1270;
    const NmAsrCanMsgCycleOffset_HUD =          20;
    const NmAsrCanMsgReducedTime_HUD =        1660;
    const NmAsrCanMsgCycleOffset_IC =           10;
    const NmAsrCanMsgReducedTime_IC =         1650;
    const NmAsrCanMsgCycleOffset_NV =           30;
    const NmAsrCanMsgReducedTime_NV =         1670;
    const NmAsrCanMsgCycleOffset_ORC =          50;
    const NmAsrCanMsgReducedTime_ORC =        1690;
    const NmAsrCanMsgCycleOffset_RBTM_FL =       0;
    const NmAsrCanMsgReducedTime_RBTM_FL =    1640;
    const NmAsrCanMsgCycleOffset_RBTM_FR =      70;
    const NmAsrCanMsgReducedTime_RBTM_FR =    1710;
    const NmAsrCanMsgCycleOffset_RVC =          40;
    const NmAsrCanMsgReducedTime_RVC =        1680;
    const NmAsrCanMsgCycleOffset_SVS =          40;
    const NmAsrCanMsgReducedTime_SVS =        1680;
    const NmAsrCanMsgCycleOffset_TGW =           0;
    const NmAsrCanMsgReducedTime_TGW =        1560;
    const NmAsrCanMsgCycleOffset_TPM =          20;
    const NmAsrCanMsgReducedTime_TPM =        1820;

    char gECU[12] = "HMI_EIS";

    byte CanNmNodeId =            CanNmNodeId_EIS;
    word NmNodeIdentifier =       CanNmNodeId_Base + CanNmNodeId_EIS;
    word NmAsrCanMsgCycleOffset = NmAsrCanMsgCycleOffset_EIS;
    word NmAsrCanMsgReducedTime = NmAsrCanMsgReducedTime_EIS;
    word NmAsrCanMsgCycleTime =   2000;
    byte NM_Repeat_Message_State_Active = 0;
    byte NM_AutomaticModeActive = 0;

//  message   NM_xxx_AR --- Sendeart cyclicX --- 
    message NM_EIS_AR _mNM_xxx_AR;
    byte _mNM_xxx_Transmit_Allowed = 1;

//--------------------------------------- AUTOSAR NM ------------------------------------------------

    byte  crctable[256] = {
        0x00, 0x1D, 0x3A, 0x27, 0x74, 0x69, 0x4E, 0x53, 0xE8, 0xF5, 0xD2, 0xCF, 0x9C, 0x81, 0xA6, 0xBB,
        0xCD, 0xD0, 0xF7, 0xEA, 0xB9, 0xA4, 0x83, 0x9E, 0x25, 0x38, 0x1F, 0x02, 0x51, 0x4C, 0x6B, 0x76,
        0x87, 0x9A, 0xBD, 0xA0, 0xF3, 0xEE, 0xC9, 0xD4, 0x6F, 0x72, 0x55, 0x48, 0x1B, 0x06, 0x21, 0x3C,
        0x4A, 0x57, 0x70, 0x6D, 0x3E, 0x23, 0x04, 0x19, 0xA2, 0xBF, 0x98, 0x85, 0xD6, 0xCB, 0xEC, 0xF1,
        0x13, 0x0E, 0x29, 0x34, 0x67, 0x7A, 0x5D, 0x40, 0xFB, 0xE6, 0xC1, 0xDC, 0x8F, 0x92, 0xB5, 0xA8,
        0xDE, 0xC3, 0xE4, 0xF9, 0xAA, 0xB7, 0x90, 0x8D, 0x36, 0x2B, 0x0C, 0x11, 0x42, 0x5F, 0x78, 0x65,
        0x94, 0x89, 0xAE, 0xB3, 0xE0, 0xFD, 0xDA, 0xC7, 0x7C, 0x61, 0x46, 0x5B, 0x08, 0x15, 0x32, 0x2F,
        0x59, 0x44, 0x63, 0x7E, 0x2D, 0x30, 0x17, 0x0A, 0xB1, 0xAC, 0x8B, 0x96, 0xC5, 0xD8, 0xFF, 0xE2,
        0x26, 0x3B, 0x1C, 0x01, 0x52, 0x4F, 0x68, 0x75, 0xCE, 0xD3, 0xF4, 0xE9, 0xBA, 0xA7, 0x80, 0x9D,
        0xEB, 0xF6, 0xD1, 0xCC, 0x9F, 0x82, 0xA5, 0xB8, 0x03, 0x1E, 0x39, 0x24, 0x77, 0x6A, 0x4D, 0x50,
        0xA1, 0xBC, 0x9B, 0x86, 0xD5, 0xC8, 0xEF, 0xF2, 0x49, 0x54, 0x73, 0x6E, 0x3D, 0x20, 0x07, 0x1A,
        0x6C, 0x71, 0x56, 0x4B, 0x18, 0x05, 0x22, 0x3F, 0x84, 0x99, 0xBE, 0xA3, 0xF0, 0xED, 0xCA, 0xD7,
        0x35, 0x28, 0x0F, 0x12, 0x41, 0x5C, 0x7B, 0x66, 0xDD, 0xC0, 0xE7, 0xFA, 0xA9, 0xB4, 0x93, 0x8E,
        0xF8, 0xE5, 0xC2, 0xDF, 0x8C, 0x91, 0xB6, 0xAB, 0x10, 0x0D, 0x2A, 0x37, 0x64, 0x79, 0x5E, 0x43,
        0xB2, 0xAF, 0x88, 0x95, 0xC6, 0xDB, 0xFC, 0xE1, 0x5A, 0x47, 0x60, 0x7D, 0x2E, 0x33, 0x14, 0x09,
        0x7F, 0x62, 0x45, 0x58, 0x0B, 0x16, 0x31, 0x2C, 0x97, 0x8A, 0xAD, 0xB0, 0xE3, 0xFE, 0xD9, 0xC4
    };

    byte  crctable_profile02[256] = {
        0x00, 0x2F, 0x5E, 0x71, 0xBC, 0x93, 0xE2, 0xCD, 0x57, 0x78, 0x09, 0x26, 0xEB, 0xC4, 0xB5, 0x9A,
        0xAE, 0x81, 0xF0, 0xDF, 0x12, 0x3D, 0x4C, 0x63, 0xF9, 0xD6, 0xA7, 0x88, 0x45, 0x6A, 0x1B, 0x34,
        0x73, 0x5C, 0x2D, 0x02, 0xCF, 0xE0, 0x91, 0xBE, 0x24, 0x0B, 0x7A, 0x55, 0x98, 0xB7, 0xC6, 0xE9,
        0xDD, 0xF2, 0x83, 0xAC, 0x61, 0x4E, 0x3F, 0x10, 0x8A, 0xA5, 0xD4, 0xFB, 0x36, 0x19, 0x68, 0x47,
        0xE6, 0xC9, 0xB8, 0x97, 0x5A, 0x75, 0x04, 0x2B, 0xB1, 0x9E, 0xEF, 0xC0, 0x0D, 0x22, 0x53, 0x7C,
        0x48, 0x67, 0x16, 0x39, 0xF4, 0xDB, 0xAA, 0x85, 0x1F, 0x30, 0x41, 0x6E, 0xA3, 0x8C, 0xFD, 0xD2,
        0x95, 0xBA, 0xCB, 0xE4, 0x29, 0x06, 0x77, 0x58, 0xC2, 0xED, 0x9C, 0xB3, 0x7E, 0x51, 0x20, 0x0F,
        0x3B, 0x14, 0x65, 0x4A, 0x87, 0xA8, 0xD9, 0xF6, 0x6C, 0x43, 0x32, 0x1D, 0xD0, 0xFF, 0x8E, 0xA1,
        0xE3, 0xCC, 0xBD, 0x92, 0x5F, 0x70, 0x01, 0x2E, 0xB4, 0x9B, 0xEA, 0xC5, 0x08, 0x27, 0x56, 0x79,
        0x4D, 0x62, 0x13, 0x3C, 0xF1, 0xDE, 0xAF, 0x80, 0x1A, 0x35, 0x44, 0x6B, 0xA6, 0x89, 0xF8, 0xD7,
        0x90, 0xBF, 0xCE, 0xE1, 0x2C, 0x03, 0x72, 0x5D, 0xC7, 0xE8, 0x99, 0xB6, 0x7B, 0x54, 0x25, 0x0A,
        0x3E, 0x11, 0x60, 0x4F, 0x82, 0xAD, 0xDC, 0xF3, 0x69, 0x46, 0x37, 0x18, 0xD5, 0xFA, 0x8B, 0xA4,
        0x05, 0x2A, 0x5B, 0x74, 0xB9, 0x96, 0xE7, 0xC8, 0x52, 0x7D, 0x0C, 0x23, 0xEE, 0xC1, 0xB0, 0x9F,
        0xAB, 0x84, 0xF5, 0xDA, 0x17, 0x38, 0x49, 0x66, 0xFC, 0xD3, 0xA2, 0x8D, 0x40, 0x6F, 0x1E, 0x31,
        0x76, 0x59, 0x28, 0x07, 0xCA, 0xE5, 0x94, 0xBB, 0x21, 0x0E, 0x7F, 0x50, 0x9D, 0xB2, 0xC3, 0xEC,
        0xD8, 0xF7, 0x86, 0xA9, 0x64, 0x4B, 0x3A, 0x15, 0x8F, 0xA0, 0xD1, 0xFE, 0x33, 0x1C, 0x6D, 0x42
    };
}

on start
{
    putValue( HMI__NM_EIS_NM_Request, 0 );  // reset all requests
    _NM_Switch_NM_Mode();
    
    __Init_Msg();
    __Startup_Delay();
    __Reset_E2E_SQC();
   
    putValue( HMI__NM_EIS_AutomaticModeActive, 0 );
    putValue( HMI__NM_EIS_AutomaticModeActive, 1 );

    putValue( Env_ODO_Takeover_For_TCO, 1 );   // used in EIS_VDO to synchronize ODO's
    putValue( HMI_EVC_CfgVAN_Stat,1 );

    /*Date and time settings requested as default by Mr. Weiss on 22/11/2017 -> Date:01.03.2018 Hour:12:34:15 */
    putValue(HMI_DateTmHour,    0x0C);    //h:   12
    putValue(HMI_DateTmMinute,  0x22);    //min: 34
    putValue(HMI_DateTmSecond,  0x0F);    //sec: 15
    putValue(HMI_DateTmDay,     0x01);    //day: 01
    putValue(HMI_DateTmMonth,   0x03);    //mon: 03
    putValue(HMI_DateTmYear,    0x7E2);  //year: 2018
    
}

__Init_Msg()
{
// #START_INIT#
    AB_R_Stat_AR_init();
    //Adapt_Seat_D_Stat_AR_init();
    Adblue_Disp_Rq_AR_init();
    Adblue_Disp_Warn_Rq_AR_init();
    ARB_Stat_AR_init();
    Assyst_Stat_AR_init();
    Assyst_Stat2_AR_init();
    Assyst_Stat3_AR_init();
    AWD_TCASE_Disp_Rq_AR_init();
	BC_Stat1_VAN_AR_init();
    BC_F_Disp_Rq_AR_init();
    BC_F_Stat1_AR_init();
    BC_F_Stat2_AR_init();
    BC_R_Stat1_AR_init();
    BC_R_Stat2_AR_init();
    BODY_HMI_R0_AR_init();
    BODY_HMI_R1_AR_init();
    BODY_HMI_R2_AR_init();
    BSM_Disp_Warn_Rq_AR_init();
	BSM_M_Lat_FreeSp_AR_init();
	BSM_S_Lat_FreeSp_AR_init();
    CamLane_Disp_Warn_Rq_AR_init();
	CamLane_LaneAttr7_AR_init();
	CamLane_LaneAttr2_AR_init();
	LDP_Disp_Rq_AR_init();
	CamLane_LaneAttr6_AR_init();
//	  CHASS_PERIPH_HMI_Camlane_R1_AR_init();
//	  CHASS_PERIPH_HMI_Camlane_R2_AR_init();
//	  CHASS_PERIPH_HMI_Camlane_R3_AR_init();
	  CHASSIS_HMI_Radar_R1_AR_init();
	  CHASSIS_HMI_Radar_R2_AR_init();
	  CHASSIS_HMI_Radar_R3_AR_init();
	  CHASSIS_HMI_Radar_R4_AR_init();
	  CHASSIS_HMI_Radar_R5_AR_init();
	CHASSIS_HMI_DTR_R2_AR_init();
    CHASSIS_HMI_R0_AR_init();
    CHASSIS_HMI_R1_AR_init();
    CHASSIS_HMI_R2_AR_init();
    CHASSIS_HMI_R3_AR_init();
    CHASSIS_HMI_R4_AR_init();
//	CHASSIS_HMI_R5_AR_init();
    CHASSISPERIPHERY_HMI_R1_AR_init();
	  CHASSISPERIPHERY_HMI_R2_AR_init();
    CLkS_Rq_AR_init();
    CLkS_State_AR_init();
    ClockSync_Stat_AR_init();
    CMS_PI_Sd_Stat_MMR_F1_AR_init();
    CMS_PI_Sd_Stat_MMR_F4_AR_init();
    CMS_PI_Stat_AR_init();
    CNG_Disp_Rq_AR_init();
    COM_Call_Stat_AR_init();
	  COMM_EIS_TGW_AR_init();
    COMM_EIS_WMI_AR_init();
    CRCM_Disp_Rq_AR_init();
    CU_GNSS_Data1_AR_init();
	  CU_Pos1_AR_init();
	  CU_Pos2_AR_init();
	  CU_UTC_AR2_init();
    CU_RemFunc_Rq3_AR_init();
    D_RQ_GLOBAL_UDS_init();
    D_RQ_IC_init();
    D_RQ_TCO_init();
    DidA_MBContact_State_AR_init();
    Door_FL_Stat_AR_init();
    Door_FR_Stat_AR_init();
    Door_RL_Stat_AR_init();
    Door_RR_Stat_AR_init();
    DPC_Disp_Rq_AR_init();
    DPC_IndMd_Stat_AR_init();
    DPC_IndMd_Style_AR_init();
    DPC_IndMd_Style2_AR_init();
    DPC_Master_Rq_AR_init();
	DPC_MdSel_Rs_AMG_AR_init();
	  DTQ_Traj_AR_init();
	  DTR_Obj_Attr1_AR_init();
	  DTR_Obj_Attr2_AR_init();
	  DTR_Obj_Attr3_AR_init();
	ECO_Score_Disp_Rq_AR_init();
    EL_Ft_Disp_Rq_AR_init();
    EL_R_Disp_Rq_AR_init();
    EL_Stat_AR_init();
    EL_TurnInd_Rq_AR_init();
    Eng_Data_VAN_AR_init();
    Eng_Rs_EngCtrl_AR_init();
    Eng_Rs2_AR_init();
    EngCtrl_Disp_Rq_AR_init();
    EngCtrl_Stat_AR_init();
    EPKB_Disp_IndLmp_Rq_2_AR_init();
    EPS_Stat_Disp_Rq_AR_init();
    ESP_ATC_Stat_AMG_AR_init();  
    ESP_Disp_Rq_AR_init();
    ESP_Disp_Rq2_AR_init();
    ESP_Disp_Rq3_AR_init();
    ESP_Disp_Rq_AMG_AR_init();
    ESP_Stat1_VAN_AR_init();
    EVC_CfgBit_01_32_AR_init();
    EVC_CfgBit_33_64_AR_init();
    EVC_CfgBit_65_96_AR_init();
    EVC_CfgBit_97_C8_AR_init();
    EVC_CfgList_01_0C_AR_init();
    EVC_CfgVAN_AR_init();
	  ExitWarn_Disp_Rq_AR_init();
    FBL_CFG_Star2_AR_init();
    FCW_Disp_Rq_AR_init();
    FDC_Disp_Rq_AR_init();
    FlashOverTheAir_Stat_AR_init();
    Fuel_Stat2_AR_init();
    FuelLvl_Stat_AR_init();
    FWLP_D_AR_init();
    FWLP_P_AR_init();
	HAD_MDC_CamLane_MapLrn_Attr1_AR_init();
	HAD_MDC_CamObj_MapLrn_Attr1_AR_init();
	HAD_MDC_MapData2_AR_init();
	HAD_MDC_MapLrn_Attr1_AR_init();
	HAD_MDC_TSR_Sign_Attr1_AR_init();
	HAD_MDC_TSR_Sign_Attr2_AR_init();
	HFP_R5_AR2_DAI_init();
	HMIG_Stat_AR_init();
    HumanMachineIfc_AR_init();
	  HumanMachineIfc2_AR_init();
    HumanMachineIfc_Rq_AR_init();
    HVAC_Disp_Stat1_AR_init();
    HVAC_Disp_Stat2_AR_init();
    HVAC_Disp_Stat3_AR_init();
	  HVAC_Disp_Stat4_AR_init();
    HVAC_State1_AR_init();
    ICH_PreTime_Stat_AR_init();
    ICH_Stat_AR_init();
    Ign_Veh_Stat_AR_init();
    IL_AmbLgt_Disp_AR_init();
    IL_AmbLgtCfg_Stat_AR_init();
    IL_AmbLgtCfg_Stat2_AR_init();
    IL_Stat2_AR_init();
    Immobilizer_Disp_Rq_AR_init();
    Immobilizer_IC_AR_init();
    Immobilizer_KeyID_AR_init();
    KEP_MODE_DISP_RQ_init();
    KG_Msg_Disp_Rq_AR_init();
    KG_State_AR_init();
    LDC_Disp_Rq_ESP_AR_init();
	  LDC_Disp_Rq2_ESP_AR_init();
    LDC_Disp_Rq_RDU_AR_init();
	  LDC_Disp_Rq2_RDU_AR_init();
    LDP_Warn_Rq_AR_init();
    LgtSens_State_AR_init();
    MCMS_FL_AR_init();
    MCMS_FL_Stat_AR_init();
    MCMS_FR_AR_init();
    MCMS_FR_Stat_AR_init();
    MCMS_RL_AR_init();
    MCMS_RL_Stat_AR_init();
    MCMS_RR_AR_init();
    MCMS_RR_Stat_AR_init();
    OffRoad_Disp_Rq_AR_init();
    Park_Disp_Rq_AR_init();
    Park_Set_Stat_AR_init();
    Park_Stat_AR_init();	
	  ParkSpace_Posn_AR_init();
    ParkSpaceMeas_Stat_AR_init();
    ParkWarn_AR_init();
    PERIPHERY_HMI_R1_AR_init();
    PN14_Disp_Rq_AR_init();
    PN14_Disp_Rq2_AR_init();
    PN14_Stat_AR_init();
	  PN14_Stat_VAN_AR_init();
    PN48_Bat_Stat_AR_init();
    PN48_Disp_Rq_AR_init();
    PnHt_Stat_AR_init();
    PNHV_Disp_Rq1_AR_init();
    PNHV_Disp_Rq2_AR_init();
    PNHV_Energy_Rq_AR_init();
    PNHV_EnergyMngmnt_Disp_Rq_AR_init();
    PNHV_EnergyMngmnt_Stat2_AR_init();
    PNHV_EnergyMngmntSet_Rs1_AR_init();
    PNHV_EnergyMngmntSet_Rs2_AR_init();
    PNHV_EnergyMngmntSet_Rs3_AR_init();
    PNHV_WeekDepTmTbl_Stat_AR_init();
    PreCond_CfgStat_AR_init();
    PresfCtrl_Rq_ESP_AR_init();
    PSL_L_Stat_AR_init();
	PNHV_Bat_Warn_Rq_V2_AR2_init();
    PNHV_Bat_Warn_Rq_AR_init();
    PNHV_Stat_VAN_AR_init();
    OBWlight_Message_VAN_AR_init();
    Tire_temp_VAN_AR_init();
    PSL_R_Stat_AR_init();          
    PT_Data_VAN_AR_init();
    PT_DataContain_Rq_AR_init();          
    PT_Disp_Rq2_AR_init();                
    PtHyb_Mngmnt_Rq_AR_init();            
    PtMngmnt_Disp_Rq_AR_init();
	Radar_EGO1_Obj_Attr1_AR_init();
    RDS_Data_HU_AR_init();
    RDU_Disp_Rq_AR_init(); 
    RTC_Date_Time_AR_init();                
    RTC_Stat1_AR_init();                
    RTC_Stat2_AR_init();                
    RVC_SVS_Park_Stat_AR_init();          
    SBW_DrvPosn_Disp_Rq_ISM_AR_init();    
    SBW_DrvPosn_Disp_Rq_TCM_AR_init(); 
    Seat_3L_Stat_AR_init(); 
    Seat_3R_Stat_AR_init();  
    Seat_D_Stat_AR_init();                
    Seat_P_Stat_AR_init();                
    Seat_RL_Stat_AR_init();               
    Seat_RR_Stat_AR_init();
	  SeatCM_D_Stat_HU_AR_init();
	  SeatCM_P_Stat_HU_AR_init();
    SeatHtVn_Stat_AR_init();
    SeatHtVn_Stat2_AR_init();
	SeatMat_Stat_AR_init();
    SeatMem_D_Rq_AR_init();
    SeatPosn_Abs_D_AR_init();
    SeatPosn_Abs_P_AR_init();
    SND_GEN_Stat_AR_init();
	SONAR_A1_AR2_DAI_init();
    SONAR_A3_AR2_DAI_init();
	SONAR_A4_AR2_DAI_init();
    SPC_Disp_Rq_AR_init();
    SPC_SwLED_Msg_Rq_AR_init();
    SPV_Ret_Stat_VAN_AR_init();
    SPV_Rq_AR_init();
    SPV_Stat_AR_init();
	  SPV_Stat_VAN_AR_init();
    SPV_Disp_Rq_VAN_AR_init();
    SPV_Disp_Rq2_VAN_AR_init();
    StWhl_Angl_Stat_AR_init();
    StWhl_OFN_Stat_AR_init();
    StWhl_Sw_Stat_AR_init();
    TC_Disp_Rq_ECM_AR_init();
    TC_Disp_Rq2_AR2_init();
    TC_EBBC_Disp_Rq_ECM_AR_init();
    TC_EEBBC_Disp_Rq_AR_init();
	TC_EEBBC_Energy_Cons_AR_init();
    TC_EU6_Cons_Disp_Rq_AR_init();  
    TCM_Disp_Rq_AMG_AR_init();
    Teleaid_WRN_AR_init();
//    TP_COM_TGW_Adapt_init();
//    TP_EIS_IC_SecOdo_init();
//    TP_MPM_TGW_Nav_init();
//    TP_PARK_TGW_init();
//    TP_TELEAID_TGW_init();
//    TP_WPT_IC_init();
//    TP_WPT_TGW_init();
    Trailer_Stat_AR_init();
    TSA_Disp_Rq1_AR_init();
    TSA_Disp_Rq2_AR_init();
	  TSA_Disp_Rq3_AR_init();
    Veh_Susp_Adj_AR_init();	
	  VehCarv_Stat_AR_init();
    VehDyn_Stat1_AR_init();
    VehDyn_Stat2_AR_init();
    VehLvl_Stat_AR_init();
    VehPwrMngmnt_EMM_Stat2_AR_init();
    VehSpd_X_AR_init();
    VIN_AR_init();
    VTA_Event_Disp_AR_init();
    Whl_Lt_Stat_AR_init();
    DLM_Stat_AR_init();
    Whl_Rt_Stat_AR_init();
    WhlPlsCnt_TPM_AR_init();
    WIA_EngTrq_AR_init();
	WMI_Stat_AR_init();
    Wpr_Stat_AR_init();
    WPT_Stat2_AR_init();
// #START_INIT_END#
//    APPL_ECU_APM_1_init();
//    APPL_ECU_APM_2_init();
//    APPL_ECU_DRVU_1_init();
//    APPL_ECU_DRVU_2_init();
    APPL_ECU_HIL_TO_IC1_init();
//    APPL_ECU_ORC1_init();
//    APPL_ECU_RVC_SVS1_init();
//    APPL_ECU_TGW1_init();
//    NM_APPL_AR_init();
    NM_xxx_AR_init();
//    XCP_Rq_DRVU_1_init();
//    XCP_Rq_DRVU_2_init();
//    XCP_Rq_RBTM_FL_init();
//    XCP_Rq_RBTM_FR_init();
//    XCP_Rq_RVC_SVS_init();
//    XCP_Rq_TPM_init();
}

on envVar HMI__STOP_All_MESSAGES_DEFAULT_STARTDELAY
{
    if( getValue( this ) )
    {
        __Init_Msg();
        __Startup_Delay();
    }
}

on envVar HMI__STOP_All_MESSAGES_SET_STARTDELAY
{
    if( getValue( this ) )
    {
        __Startup_Delay();
    }
}

__Startup_Delay()
{
//    write(" Delay setzen :__EIS_Startup_Delay");
// #START_DELAY#
    _AB_R_Stat_AR_Cnt =                 getValue( HMI__STMSGSD_AB_R_Stat_AR                 ) / _AB_R_Stat_AR_Timebase;
    //_Adapt_Seat_D_Stat_AR_Cnt =         getValue( HMI__STMSGSD_Adapt_Seat_D_Stat_AR         ) / _Adapt_Seat_D_Stat_AR_Timebase;
    _Adblue_Disp_Rq_AR_Cnt =            getValue( HMI__STMSGSD_Adblue_Disp_Rq_AR            ) / _Adblue_Disp_Rq_AR_Timebase;
    _Adblue_Disp_Warn_Rq_AR_Cnt =       getValue( HMI__STMSGSD_Adblue_Disp_Warn_Rq_AR       ) / _Adblue_Disp_Warn_Rq_AR_Timebase;
    _AQS_Data_HU_AR_Cnt =               getValue( HMI__STMSGSD_AQS_Data_HU_AR               ) / _ARB_Stat_AR_Timebase;
    _ARB_Stat_AR_Cnt =                  getValue( HMI__STMSGSD_ARB_Stat_AR                  ) / _ARB_Stat_AR_Timebase;
    _Assyst_Stat_AR_Cnt =               getValue( HMI__STMSGSD_Assyst_Stat_AR               ) / _Assyst_Stat_AR_Timebase;
    _Assyst_Stat2_AR_Cnt =              getValue( HMI__STMSGSD_Assyst_Stat2_AR              ) / _Assyst_Stat2_AR_Timebase;
    _Assyst_Stat3_AR_Cnt =              getValue( HMI__STMSGSD_Assyst_Stat3_AR              ) / _Assyst_Stat3_AR_Timebase;
    _AWD_TCASE_Disp_Rq_AR_Cnt =         getValue( HMI__STMSGSD_AWD_TCASE_Disp_Rq_AR         ) / _AWD_TCASE_Disp_Rq_AR_Timebase;
    _BC_Stat1_VAN_AR_Cnt = 				getValue( HMI__STMSGSD_BC_Stat1_VAN_AR				) / _BC_Stat1_VAN_AR_Timebase;
	_BC_F_Disp_Rq_AR_Cnt =              getValue( HMI__STMSGSD_BC_F_Disp_Rq_AR              ) / _BC_F_Disp_Rq_AR_Timebase;
    _BC_F_Stat1_AR_Cnt =                getValue( HMI__STMSGSD_BC_F_Stat1_AR                ) / _BC_F_Stat1_AR_Timebase;
    _BC_F_Stat2_AR_Cnt =                getValue( HMI__STMSGSD_BC_F_Stat2_AR                ) / _BC_F_Stat2_AR_Timebase;
    _BC_R_Stat1_AR_Cnt =                getValue( HMI__STMSGSD_BC_R_Stat1_AR                ) / _BC_R_Stat1_AR_Timebase;
    _BC_R_Stat2_AR_Cnt =                getValue( HMI__STMSGSD_BC_R_Stat2_AR                ) / _BC_R_Stat2_AR_Timebase;
    _BODY_HMI_R0_AR_Cnt =               getValue( HMI__STMSGSD_BODY_HMI_R0_AR               ) / _BODY_HMI_R0_AR_Timebase;
    _BODY_HMI_R1_AR_Cnt =               getValue( HMI__STMSGSD_BODY_HMI_R1_AR               ) / _BODY_HMI_R1_AR_Timebase;
    _BODY_HMI_R2_AR_Cnt =               getValue( HMI__STMSGSD_BODY_HMI_R2_AR               ) / _BODY_HMI_R2_AR_Timebase;
    _BSM_Disp_Warn_Rq_AR_Cnt =          getValue( HMI__STMSGSD_BSM_Disp_Warn_Rq_AR          ) / _BSM_Disp_Warn_Rq_AR_Timebase;
    _BSM_M_Lat_FreeSp_AR_Cnt =			getValue( HMI__STMSGSD_BSM_M_Lat_FreeSp_AR 			) / _BSM_M_Lat_FreeSp_AR_Timebase;
	_BSM_S_Lat_FreeSp_AR_Cnt =			getValue( HMI__STMSGSD_BSM_S_Lat_FreeSp_AR 			) / _BSM_S_Lat_FreeSp_AR_Timebase;
	_CamLane_Disp_Warn_Rq_AR_Cnt =      getValue( HMI__STMSGSD_CamLane_Disp_Warn_Rq_AR      ) / _CamLane_Disp_Warn_Rq_AR_Timebase;
	  _CamLane_LaneAttr7_AR_Cnt =      	  getValue( HMI__STMSGSD_CamLane_LaneAttr7_AR      	  ) / _CamLane_LaneAttr7_AR_Timebase;
	_CamLane_LaneAttr6_AR_Cnt =			getValue( HMI__STMSGSD_CamLane_LaneAttr6_AR			) / _CamLane_LaneAttr6_AR_Timebase;
	_CamLane_LaneAttr2_AR_Cnt =			getValue( HMI__STMSGSD_CamLane_LaneAttr2_AR			) / _CamLane_LaneAttr2_AR_Timebase;
	_LDP_Disp_Rq_AR_Cnt =			getValue( HMI__STMSGSD_LDP_Disp_Rq_AR			) / _LDP_Disp_Rq_AR_Timebase;
//	_CHASS_PERIPH_HMI_Camlane_R1_AR_Cnt =         getValue( HMI__STMSGSD_CHASS_PERIPH_HMI_Camlane_R1_AR         ) / _CHASS_PERIPH_HMI_Camlane_R1_AR_Timebase;
//	_CHASS_PERIPH_HMI_Camlane_R2_AR_Cnt =         getValue( HMI__STMSGSD_CHASS_PERIPH_HMI_Camlane_R2_AR         ) / _CHASS_PERIPH_HMI_Camlane_R2_AR_Timebase;
//	  _CHASS_PERIPH_HMI_Camlane_R3_AR_Cnt = getValue( HMI__STMSGSD_CHASS_PERIPH_HMI_Camlane_R3_AR         ) / _CHASS_PERIPH_HMI_Camlane_R3_AR_Timebase;
	  _CHASSIS_HMI_Radar_R1_AR_Cnt =      getValue( HMI__STMSGSD_CHASSIS_HMI_Radar_R1_AR      ) / _CHASSIS_HMI_Radar_R1_AR_Timebase;
	  _CHASSIS_HMI_Radar_R2_AR_Cnt =      getValue( HMI__STMSGSD_CHASSIS_HMI_Radar_R2_AR      ) / _CHASSIS_HMI_Radar_R2_AR_Timebase;
	  _CHASSIS_HMI_Radar_R3_AR_Cnt =      getValue( HMI__STMSGSD_CHASSIS_HMI_Radar_R3_AR      ) / _CHASSIS_HMI_Radar_R3_AR_Timebase;
	  _CHASSIS_HMI_Radar_R4_AR_Cnt =      getValue( HMI__STMSGSD_CHASSIS_HMI_Radar_R4_AR      ) / _CHASSIS_HMI_Radar_R4_AR_Timebase;
	  _CHASSIS_HMI_Radar_R5_AR_Cnt =      getValue( HMI__STMSGSD_CHASSIS_HMI_Radar_R5_AR      ) / _CHASSIS_HMI_Radar_R5_AR_Timebase;
    _CHASSIS_HMI_R0_AR_Cnt =            getValue( HMI__STMSGSD_CHASSIS_HMI_R0_AR            ) / _CHASSIS_HMI_R0_AR_Timebase;
    _CHASSIS_HMI_R1_AR_Cnt =            getValue( HMI__STMSGSD_CHASSIS_HMI_R1_AR            ) / _CHASSIS_HMI_R1_AR_Timebase;
    _CHASSIS_HMI_R2_AR_Cnt =            getValue( HMI__STMSGSD_CHASSIS_HMI_R2_AR            ) / _CHASSIS_HMI_R2_AR_Timebase;
    _CHASSIS_HMI_R3_AR_Cnt =            getValue( HMI__STMSGSD_CHASSIS_HMI_R3_AR            ) / _CHASSIS_HMI_R3_AR_Timebase;
    _CHASSIS_HMI_R4_AR_Cnt =            getValue( HMI__STMSGSD_CHASSIS_HMI_R4_AR            ) / _CHASSIS_HMI_R4_AR_Timebase;
//	_CHASSIS_HMI_R5_AR_Cnt =            getValue( HMI__STMSGSD_CHASSIS_HMI_R5_AR            ) / _CHASSIS_HMI_R5_AR_Timebase;
    _CHASSIS_HMI_DTR_R2_AR_Cnt =		getValue( HMI__STMSGSD_CHASSIS_HMI_DTR_R2_AR 		) / _CHASSIS_HMI_DTR_R2_AR_Timebase;
	_CHASSISPERIPHERY_HMI_R1_AR_Cnt =   getValue( HMI__STMSGSD_CHASSISPERIPHERY_HMI_R1_AR   ) / _CHASSISPERIPHERY_HMI_R1_AR_Timebase;
	  _CHASSISPERIPHERY_HMI_R2_AR_Cnt =   getValue( HMI__STMSGSD_CHASSISPERIPHERY_HMI_R2_AR   ) / _CHASSISPERIPHERY_HMI_R2_AR_Timebase;
    _CLkS_Rq_AR_Cnt =                   getValue( HMI__STMSGSD_CLkS_Rq_AR                   ) / _CLkS_Rq_AR_Timebase;
    _CLkS_State_AR_Cnt =                getValue( HMI__STMSGSD_CLkS_State_AR                ) / _CLkS_State_AR_Timebase;
    _ClockSync_Stat_AR_Cnt =            getValue( HMI__STMSGSD_ClockSync_Stat_AR            ) / _ClockSync_Stat_AR_Timebase;
    _CMS_PI_Sd_Stat_MMR_F1_AR_Cnt =     getValue( HMI__STMSGSD_CMS_PI_Sd_Stat_MMR_F1_AR     ) / _CMS_PI_Sd_Stat_MMR_F1_AR_Timebase;
    _CMS_PI_Sd_Stat_MMR_F4_AR_Cnt =     getValue( HMI__STMSGSD_CMS_PI_Sd_Stat_MMR_F4_AR     ) / _CMS_PI_Sd_Stat_MMR_F4_AR_Timebase;
    _CMS_PI_Stat_AR_Cnt =               getValue( HMI__STMSGSD_CMS_PI_Stat_AR               ) / _CMS_PI_Stat_AR_Timebase;
    _CNG_Disp_Rq_AR_Cnt =               getValue( HMI__STMSGSD_CNG_Disp_Rq_AR               ) / _CNG_Disp_Rq_AR_Timebase;
    _COM_Call_Stat_AR_Cnt =             getValue( HMI__STMSGSD_COM_Call_Stat_AR             ) / _COM_Call_Stat_AR_Timebase;
//  _COMM_EIS_WMI_AR_Cnt =              getValue( HMI__STMSGSD_COMM_EIS_WMI_AR              ) / _COMM_EIS_WMI_AR_Timebase;
//  _COMM_EIS_TGW_AR_Cnt =              getValue( HMI__STMSGSD_COMM_EIS_TGW_AR              ) / _COMM_EIS_TGW_AR_Timebase;
    _CRCM_Disp_Rq_AR_Cnt =              getValue( HMI__STMSGSD_CRCM_Disp_Rq_AR              ) / _CRCM_Disp_Rq_AR_Timebase;
	  _CU_GNSS_Data1_AR_Cnt =         		getValue( HMI__STMSGSD_CU_GNSS_Data1_AR         		) / _CU_GNSS_Data1_AR_Timebase;
    _CU_Pos1_AR_Cnt =         			    getValue( HMI__STMSGSD_CU_Pos1_AR         			    ) / _CU_Pos1_AR_Timebase;
	  _CU_Pos2_AR_Cnt =         			    getValue( HMI__STMSGSD_CU_Pos2_AR         			    ) / _CU_Pos2_AR_Timebase;
    _CU_RemFunc_Rq3_AR_Cnt =            getValue( HMI__STMSGSD_CU_RemFunc_Rq3_AR            ) / _CU_RemFunc_Rq3_AR_Timebase;
    _CU_UTC_AR2_Cnt =            getValue( HMI__STMSGSD_CU_UTC_AR2            ) / _CU_UTC_AR2_Timebase;
    _D_RQ_GLOBAL_UDS_Cnt =              getValue( HMI__STMSGSD_D_RQ_GLOBAL_UDS              ) / _D_RQ_GLOBAL_UDS_Timebase;
    _D_RQ_IC_Cnt =                      getValue( HMI__STMSGSD_D_RQ_IC                      ) / _D_RQ_IC_Timebase;
    _D_RQ_TCO_Cnt =                     getValue( HMI__STMSGSD_D_RQ_TCO                     ) / _D_RQ_TCO_Timebase;
    _DidA_MBContact_State_AR_Cnt =      getValue( HMI__STMSGSD_DidA_MBContact_State_AR      ) / _DidA_MBContact_State_AR_Timebase;
    _Door_FL_Stat_AR_Cnt =              getValue( HMI__STMSGSD_Door_FL_Stat_AR              ) / _Door_FL_Stat_AR_Timebase;
    _Door_FR_Stat_AR_Cnt =              getValue( HMI__STMSGSD_Door_FR_Stat_AR              ) / _Door_FR_Stat_AR_Timebase;
    _Door_RL_Stat_AR_Cnt =              getValue( HMI__STMSGSD_Door_RL_Stat_AR              ) / _Door_RL_Stat_AR_Timebase;
    _Door_RR_Stat_AR_Cnt =              getValue( HMI__STMSGSD_Door_RR_Stat_AR              ) / _Door_RR_Stat_AR_Timebase;
    _DPC_Disp_Rq_AR_Cnt =               getValue( HMI__STMSGSD_DPC_Disp_Rq_AR               ) / _DPC_Disp_Rq_AR_Timebase;
    _DPC_IndMd_Stat_AR_Cnt =            getValue( HMI__STMSGSD_DPC_IndMd_Stat_AR            ) / _DPC_IndMd_Stat_AR_Timebase;
    _DPC_IndMd_Style_AR_Cnt =           getValue( HMI__STMSGSD_DPC_IndMd_Style_AR           ) / _DPC_IndMd_Style_AR_Timebase;
    _DPC_IndMd_Style2_AR_Cnt =          getValue( HMI__STMSGSD_DPC_IndMd_Style2_AR          ) / _DPC_IndMd_Style2_AR_Timebase;
    _DPC_Master_Rq_AR_Cnt =             getValue( HMI__STMSGSD_DPC_Master_Rq_AR             ) / _DPC_Master_Rq_AR_Timebase;
	_DPC_MdSel_Rs_AMG_AR_Cnt =			getValue( HMI__STMSGSD_DPC_MdSel_Rs_AMG_AR			) / _DPC_MdSel_Rs_AMG_AR_Timebase;
	_DTQ_Traj_AR_Cnt =         			    getValue( HMI__STMSGSD_DTQ_Traj_AR         			    ) / _DTQ_Traj_AR_Timebase;
	  _DTR_Obj_Attr1_AR_Cnt =         	  getValue( HMI__STMSGSD_DTR_Obj_Attr1_AR         	  ) / _DTR_Obj_Attr1_AR_Timebase;
	  _DTR_Obj_Attr2_AR_Cnt =         	  getValue( HMI__STMSGSD_DTR_Obj_Attr2_AR         	  ) / _DTR_Obj_Attr2_AR_Timebase;
	  _DTR_Obj_Attr3_AR_Cnt =         	  getValue( HMI__STMSGSD_DTR_Obj_Attr3_AR         	  ) / _DTR_Obj_Attr3_AR_Timebase;
    _ECO_Score_Disp_Rq_AR_Cnt =         getValue( HMI__STMSGSD_ECO_Score_Disp_Rq_AR         ) / _ECO_Score_Disp_Rq_AR_Timebase;
    _EL_Ft_Disp_Rq_AR_Cnt =             getValue( HMI__STMSGSD_EL_Ft_Disp_Rq_AR             ) / _EL_Ft_Disp_Rq_AR_Timebase;
    _EL_R_Disp_Rq_AR_Cnt =              getValue( HMI__STMSGSD_EL_R_Disp_Rq_AR              ) / _EL_R_Disp_Rq_AR_Timebase;
    _EL_Stat_AR_Cnt =                   getValue( HMI__STMSGSD_EL_Stat_AR                   ) / _EL_Stat_AR_Timebase;
    //_EL_TurnInd_Rq_AR_Cnt =             getValue( HMI__STMSGSD_EL_TurnInd_Rq_AR             ) / _EL_TurnInd_Rq_AR_Timebase;
    _Eng_Data_VAN_AR_Cnt =              getValue( HMI__STMSGSD_Eng_Data_VAN_AR              ) / _Eng_Data_VAN_AR_Timebase;
    _Eng_Rs_EngCtrl_AR_Cnt =            getValue( HMI__STMSGSD_Eng_Rs_EngCtrl_AR            ) / _Eng_Rs_EngCtrl_AR_Timebase;
    _Eng_Rs2_AR_Cnt =                   getValue( HMI__STMSGSD_Eng_Rs2_AR                   ) / _Eng_Rs2_AR_Timebase;
    _EngCtrl_Disp_Rq_AR_Cnt =           getValue( HMI__STMSGSD_EngCtrl_Disp_Rq_AR           ) / _EngCtrl_Disp_Rq_AR_Timebase;
    _EngCtrl_Stat_AR_Cnt =              getValue( HMI__STMSGSD_EngCtrl_Stat_AR              ) / _EngCtrl_Stat_AR_Timebase;
    _EPKB_Disp_IndLmp_Rq_2_AR_Cnt =     getValue( HMI__STMSGSD_EPKB_Disp_IndLmp_Rq_2_AR     ) / _EPKB_Disp_IndLmp_Rq_2_AR_Timebase;
    _EPS_Stat_Disp_Rq_AR_Cnt =          getValue( HMI__STMSGSD_EPS_Stat_Disp_Rq_AR          ) / _EPS_Stat_Disp_Rq_AR_Timebase;
    _ESP_ATC_Stat_AMG_AR_Cnt =          getValue( HMI__STMSGSD_ESP_ATC_Stat_AMG_AR          ) / _ESP_ATC_Stat_AMG_AR_Timebase;  
    _ESP_Disp_Rq_AR_Cnt =               getValue( HMI__STMSGSD_ESP_Disp_Rq_AR               ) / _ESP_Disp_Rq_AR_Timebase;
    _ESP_Disp_Rq2_AR_Cnt =              getValue( HMI__STMSGSD_ESP_Disp_Rq2_AR              ) / _ESP_Disp_Rq2_AR_Timebase;
    _ESP_Disp_Rq3_AR_Cnt =              getValue( HMI__STMSGSD_ESP_Disp_Rq3_AR              ) / _ESP_Disp_Rq3_AR_Timebase;
    _ESP_Disp_Rq_AMG_AR_Cnt =           getValue( HMI__STMSGSD_ESP_Disp_Rq_AMG_AR           ) / _ESP_Disp_Rq_AMG_AR_Timebase;  
    _ESP_Stat1_VAN_AR_Cnt =             getValue( HMI__STMSGSD_ESP_Stat1_VAN_AR             ) / _ESP_Stat1_VAN_AR_Timebase;
    _EVC_CfgBit_01_32_AR_Cnt =          getValue( HMI__STMSGSD_EVC_CfgBit_01_32_AR          ) / _EVC_CfgBit_01_32_AR_Timebase;
    _EVC_CfgBit_33_64_AR_Cnt =          getValue( HMI__STMSGSD_EVC_CfgBit_33_64_AR          ) / _EVC_CfgBit_33_64_AR_Timebase;
    _EVC_CfgBit_65_96_AR_Cnt =          getValue( HMI__STMSGSD_EVC_CfgBit_65_96_AR          ) / _EVC_CfgBit_65_96_AR_Timebase;
    _EVC_CfgBit_97_C8_AR_Cnt =          getValue( HMI__STMSGSD_EVC_CfgBit_97_C8_AR          ) / _EVC_CfgBit_97_C8_AR_Timebase;
    _EVC_CfgList_01_0C_AR_Cnt =         getValue( HMI__STMSGSD_EVC_CfgList_01_0C_AR         ) / _EVC_CfgList_01_0C_AR_Timebase;
    _EVC_CfgVAN_AR_Cnt =                getValue( HMI__STMSGSD_EVC_CfgVAN_AR                ) / _EVC_CfgVAN_AR_Timebase;
	  _ExitWarn_Disp_Rq_AR_Cnt =          getValue( HMI__STMSGSD_ExitWarn_Disp_Rq_AR          ) / _ExitWarn_Disp_Rq_AR_Timebase;
    _FBL_CFG_Star2_AR_Cnt =             getValue( HMI__STMSGSD_FBL_CFG_Star2_AR             ) / _FBL_CFG_Star2_AR_Timebase;
    _FCW_Disp_Rq_AR_Cnt =               getValue( HMI__STMSGSD_FCW_Disp_Rq_AR               ) / _FCW_Disp_Rq_AR_Timebase;
    _FDC_Disp_Rq_AR_Cnt =               getValue( HMI__STMSGSD_FDC_Disp_Rq_AR               ) / _FDC_Disp_Rq_AR_Timebase;
    _FlashOverTheAir_Stat_AR_Cnt =      getValue( HMI__STMSGSD_FlashOverTheAir_Stat_AR      ) / _FlashOverTheAir_Stat_AR_Timebase;
    _FuelLvl_Stat_AR_Cnt =              getValue( HMI__STMSGSD_FuelLvl_Stat_AR              ) / _FuelLvl_Stat_AR_Timebase;
    _Fuel_Stat2_AR_Cnt =                getValue( HMI__STMSGSD_Fuel_Stat2_AR                ) / _Fuel_Stat2_AR_Timebase;
    _FWLP_D_AR_Cnt =                    getValue( HMI__STMSGSD_FWLP_D_AR                    ) / _FWLP_D_AR_Timebase;
    _FWLP_P_AR_Cnt =                    getValue( HMI__STMSGSD_FWLP_P_AR                    ) / _FWLP_P_AR_Timebase;
    _HAD_MDC_CamLane_MapLrn_Attr1_AR_Cnt =	getValue( HMI__STMSGSD_HAD_MDC_CamLane_MapLrn_Attr1_AR ) / _HAD_MDC_CamLane_MapLrn_Attr1_AR_Timebase;
	_HAD_MDC_CamObj_MapLrn_Attr1_AR_Cnt =	getValue( HMI__STMSGSD_HAD_MDC_CamObj_MapLrn_Attr1_AR  ) / _HAD_MDC_CamObj_MapLrn_Attr1_AR_Timebase;
	_HAD_MDC_MapData2_AR_Cnt =			getValue( HMI__STMSGSD_HAD_MDC_MapData2_AR			) /	_HAD_MDC_MapData2_AR_Timebase;
	_HAD_MDC_MapLrn_Attr1_AR_Cnt =		getValue( HMI__STMSGSD_HAD_MDC_MapLrn_Attr1_AR 		) / _HAD_MDC_MapLrn_Attr1_AR_Timebase;
	_HAD_MDC_TSR_Sign_Attr1_AR_Cnt	=	getValue( HMI__STMSGSD_HAD_MDC_TSR_Sign_Attr1_AR 	) / _HAD_MDC_TSR_Sign_Attr1_AR_Timebase;
	_HAD_MDC_TSR_Sign_Attr2_AR_Cnt	=	getValue( HMI__STMSGSD_HAD_MDC_TSR_Sign_Attr2_AR 	) / _HAD_MDC_TSR_Sign_Attr2_AR_Timebase;
	_HMIG_Stat_AR_Cnt =                 getValue( HMI__STMSGSD_HMIG_Stat_AR                    ) /_HMIG_Stat_AR_Timebase;
	_HFP_R5_AR2_DAI_Cnt =               getValue( HMI__STMSGSD_HFP_R5_AR2_DAI               ) / _FWLP_P_AR_Timebase;
    _HumanMachineIfc_AR_Cnt =           getValue( HMI__STMSGSD_HumanMachineIfc_AR           ) / _HumanMachineIfc_AR_Timebase;
	  _HumanMachineIfc2_AR_Cnt =          getValue( HMI__STMSGSD_HumanMachineIfc2_AR          ) / _HumanMachineIfc2_AR_Timebase;
    _HumanMachineIfc_Rq_AR_Cnt =        getValue( HMI__STMSGSD_HumanMachineIfc_Rq_AR        ) / _HumanMachineIfc_Rq_AR_Timebase;
    _HVAC_Disp_Stat1_AR_Cnt =           getValue( HMI__STMSGSD_HVAC_Disp_Stat1_AR           ) / _HVAC_Disp_Stat1_AR_Timebase;
    _HVAC_Disp_Stat2_AR_Cnt =           getValue( HMI__STMSGSD_HVAC_Disp_Stat2_AR           ) / _HVAC_Disp_Stat2_AR_Timebase;
    _HVAC_Disp_Stat3_AR_Cnt =           getValue( HMI__STMSGSD_HVAC_Disp_Stat3_AR           ) / _HVAC_Disp_Stat3_AR_Timebase;
	  _HVAC_Disp_Stat4_AR_Cnt =           getValue( HMI__STMSGSD_HVAC_Disp_Stat4_AR           ) / _HVAC_Disp_Stat4_AR_Timebase;
    _HVAC_State1_AR_Cnt =               getValue( HMI__STMSGSD_HVAC_State1_AR               ) / _HVAC_State1_AR_Timebase;
    _ICH_PreTime_Stat_AR_Cnt =          getValue( HMI__STMSGSD_ICH_PreTime_Stat_AR          ) / _ICH_PreTime_Stat_AR_Timebase;
    _ICH_Stat_AR_Cnt =                  getValue( HMI__STMSGSD_ICH_Stat_AR                  ) / _ICH_Stat_AR_Timebase;
    _Ign_Veh_Stat_AR_Cnt =              getValue( HMI__STMSGSD_Ign_Veh_Stat_AR              ) / _Ign_Veh_Stat_AR_Timebase;
    _IL_AmbLgt_Disp_AR_Cnt =            getValue( HMI__STMSGSD_IL_AmbLgt_Disp_AR            ) / _IL_AmbLgt_Disp_AR_Timebase;
    _IL_AmbLgtCfg_Stat_AR_Cnt =         getValue( HMI__STMSGSD_IL_AmbLgtCfg_Stat_AR         ) / _IL_AmbLgtCfg_Stat_AR_Timebase;
    _IL_AmbLgtCfg_Stat2_AR_Cnt =         getValue( HMI__STMSGSD_IL_AmbLgtCfg_Stat2_AR         ) / _IL_AmbLgtCfg_Stat2_AR_Timebase;
    _IL_Stat2_AR_Cnt =                  getValue( HMI__STMSGSD_IL_Stat2_AR                  ) / _IL_Stat2_AR_Timebase;
    _Immobilizer_Disp_Rq_AR_Cnt =       getValue( HMI__STMSGSD_Immobilizer_Disp_Rq_AR       ) / _Immobilizer_Disp_Rq_AR_Timebase;
    _Immobilizer_IC_AR_Cnt =            getValue( HMI__STMSGSD_Immobilizer_IC_AR            ) / _Immobilizer_IC_AR_Timebase;
    _Immobilizer_KeyID_AR_Cnt =         getValue( HMI__STMSGSD_Immobilizer_KeyID_AR         ) / _Immobilizer_KeyID_AR_Timebase;
    _KG_Msg_Disp_Rq_AR_Cnt =            getValue( HMI__STMSGSD_KG_Msg_Disp_Rq_AR            ) / _KG_Msg_Disp_Rq_AR_Timebase;
    _KEP_MODE_DISP_RQ_Cnt =                  getValue( HMI__STMSGSD_KEP_MODE_DISP_RQ                  ) / _KEP_MODE_DISP_RQ_Timebase;
    _KG_State_AR_Cnt =                  getValue( HMI__STMSGSD_KG_State_AR                  ) / _KG_State_AR_Timebase;
    _LDC_Disp_Rq_ESP_AR_Cnt =           getValue( HMI__STMSGSD_LDC_Disp_Rq_ESP_AR           ) / _LDC_Disp_Rq_ESP_AR_Timebase;
	  _LDC_Disp_Rq2_ESP_AR_Cnt =          getValue( HMI__STMSGSD_LDC_Disp_Rq2_ESP_AR          ) / _LDC_Disp_Rq2_ESP_AR_Timebase;
    _LDC_Disp_Rq_RDU_AR_Cnt =           getValue( HMI__STMSGSD_LDC_Disp_Rq_RDU_AR           ) / _LDC_Disp_Rq_RDU_AR_Timebase;
	  _LDC_Disp_Rq2_RDU_AR_Cnt =          getValue( HMI__STMSGSD_LDC_Disp_Rq2_RDU_AR          ) / _LDC_Disp_Rq2_RDU_AR_Timebase;
    _LDP_Warn_Rq_AR_Cnt =               getValue( HMI__STMSGSD_LDP_Warn_Rq_AR               ) / _LDP_Warn_Rq_AR_Timebase;
    _LgtSens_State_AR_Cnt =             getValue( HMI__STMSGSD_LgtSens_State_AR             ) / _LgtSens_State_AR_Timebase;
    _MCMS_FL_AR_Cnt =                   getValue( HMI__STMSGSD_MCMS_FL_AR                   ) / _MCMS_FL_AR_Timebase;
    _MCMS_FL_Stat_AR_Cnt =              getValue( HMI__STMSGSD_MCMS_FL_Stat_AR              ) / _MCMS_FL_Stat_AR_Timebase;
    _MCMS_FR_AR_Cnt =                   getValue( HMI__STMSGSD_MCMS_FR_AR                   ) / _MCMS_FR_AR_Timebase;
    _MCMS_FR_Stat_AR_Cnt =              getValue( HMI__STMSGSD_MCMS_FR_Stat_AR              ) / _MCMS_FR_Stat_AR_Timebase;
    _MCMS_RL_AR_Cnt =                   getValue( HMI__STMSGSD_MCMS_RL_AR                   ) / _MCMS_RL_AR_Timebase;
    _MCMS_RL_Stat_AR_Cnt =              getValue( HMI__STMSGSD_MCMS_RL_Stat_AR              ) / _MCMS_RL_Stat_AR_Timebase;
    _MCMS_RR_AR_Cnt =                   getValue( HMI__STMSGSD_MCMS_RR_AR                   ) / _MCMS_RR_AR_Timebase;
    _MCMS_RR_Stat_AR_Cnt =              getValue( HMI__STMSGSD_MCMS_RR_Stat_AR              ) / _MCMS_RR_Stat_AR_Timebase;
    _OffRoad_Disp_Rq_AR_Cnt =           getValue( HMI__STMSGSD_OffRoad_Disp_Rq_AR           ) / _OffRoad_Disp_Rq_AR_Timebase;
    _Park_Disp_Rq_AR_Cnt =              getValue( HMI__STMSGSD_Park_Disp_Rq_AR              ) / _Park_Disp_Rq_AR_Timebase;
    _Park_Set_Stat_AR_Cnt =             getValue( HMI__STMSGSD_Park_Set_Stat_AR             ) / _Park_Set_Stat_AR_Timebase;
    _ParkSpaceMeas_Stat_AR_Cnt =        getValue( HMI__STMSGSD_ParkSpaceMeas_Stat_AR        ) / _ParkSpaceMeas_Stat_AR_Timebase;
    _Park_Stat_AR_Cnt =                 getValue( HMI__STMSGSD_Park_Stat_AR                 ) / _Park_Stat_AR_Timebase;
	  _ParkSpace_Posn_AR_Cnt =        	  getValue( HMI__STMSGSD_ParkSpace_Posn_AR        	  ) / _ParkSpace_Posn_AR_Timebase;
    _ParkWarn_AR_Cnt =                  getValue( HMI__STMSGSD_ParkWarn_AR                  ) / _ParkWarn_AR_Timebase;
    _PERIPHERY_HMI_R1_AR_Cnt =          getValue( HMI__STMSGSD_PERIPHERY_HMI_R1_AR          ) / _PERIPHERY_HMI_R1_AR_Timebase;
    _PN14_Disp_Rq_AR_Cnt =              getValue( HMI__STMSGSD_PN14_Disp_Rq_AR              ) / _PN14_Disp_Rq_AR_Timebase;
    _PN14_Disp_Rq2_AR_Cnt =             getValue( HMI__STMSGSD_PN14_Disp_Rq2_AR             ) / _PN14_Disp_Rq2_AR_Timebase;
    _PN14_Stat_AR_Cnt =                 getValue( HMI__STMSGSD_PN14_Stat_AR                 ) / _PN14_Stat_AR_Timebase;
	  _PN14_Stat_VAN_AR_Cnt =             getValue( HMI__STMSGSD_PN14_Stat_VAN_AR             ) / _PN14_Stat_VAN_AR_Timebase;
    _PN48_Bat_Stat_AR_Cnt =             getValue( HMI__STMSGSD_PN48_Bat_Stat_AR             ) / _PN48_Bat_Stat_AR_Timebase;
    _PN48_Disp_Rq_AR_Cnt =              getValue( HMI__STMSGSD_PN48_Disp_Rq_AR              ) / _PN48_Disp_Rq_AR_Timebase;
    _PnHt_Stat_AR_Cnt =                 getValue( HMI__STMSGSD_PnHt_Stat_AR                 ) / _PnHt_Stat_AR_Timebase;
    _PNHV_Disp_Rq1_AR_Cnt =             getValue( HMI__STMSGSD_PNHV_Disp_Rq1_AR             ) / _PNHV_Disp_Rq1_AR_Timebase;
    _PNHV_Energy_Rq_AR_Cnt =            getValue( HMI__STMSGSD_PNHV_Energy_Rq_AR            ) / _PNHV_Energy_Rq_AR_Timebase;
    _PNHV_EnergyMngmnt_Disp_Rq_AR_Cnt = getValue( HMI__STMSGSD_PNHV_EnergyMngmnt_Disp_Rq_AR ) / _PNHV_EnergyMngmnt_Disp_Rq_AR_Timebase;
    _PNHV_EnergyMngmnt_Stat2_AR_Cnt =   getValue( HMI__STMSGSD_PNHV_EnergyMngmnt_Stat2_AR   ) / _PNHV_EnergyMngmnt_Stat2_AR_Timebase;
    _PNHV_EnergyMngmntSet_Rs1_AR_Cnt =  getValue( HMI__STMSGSD_PNHV_EnergyMngmntSet_Rs1_AR  ) / _PNHV_EnergyMngmntSet_Rs1_AR_Timebase;
    _PNHV_EnergyMngmntSet_Rs2_AR_Cnt =  getValue( HMI__STMSGSD_PNHV_EnergyMngmntSet_Rs2_AR  ) / _PNHV_EnergyMngmntSet_Rs2_AR_Timebase;
    _PNHV_EnergyMngmntSet_Rs3_AR_Cnt =  getValue( HMI__STMSGSD_PNHV_EnergyMngmntSet_Rs3_AR  ) / _PNHV_EnergyMngmntSet_Rs3_AR_Timebase;
    _PNHV_Stat_VAN_AR_Cnt     =         getValue( HMI__STMSGSD_PNHV_Stat_VAN_AR             ) / _PNHV_Stat_VAN_AR_Timebase; 
    _OBWlight_Message_VAN_AR_Cnt     =         getValue( HMI__STMSGSD_OBWlight_Message_VAN_AR             ) / _OBWlight_Message_VAN_AR_Timebase; 
    _Tire_temp_VAN_AR_Cnt     =         getValue( HMI__STMSGSD_Tire_temp_VAN_AR             ) / _Tire_temp_VAN_AR_Timebase; 
  //    _PNHV_WeekDepTmTbl_Stat_AR_Cnt =    getValue( HMI__STMSGSD_PNHV_WeekDepTmTbl_Stat_AR    ) / _PNHV_WeekDepTmTbl_Stat_AR_Timebase;
    _PreCond_CfgStat_AR_Cnt =           getValue( HMI__STMSGSD_PreCond_CfgStat_AR           ) / _PreCond_CfgStat_AR_Timebase;
    _PresfCtrl_Rq_ESP_AR_Cnt =          getValue( HMI__STMSGSD_PresfCtrl_Rq_ESP_AR          ) / _PresfCtrl_Rq_ESP_AR_Timebase;
    _PSL_L_Stat_AR_Cnt =                getValue( HMI__STMSGSD_PSL_L_Stat_AR                ) / _PSL_L_Stat_AR_Timebase;
	_PNHV_Bat_Warn_Rq_V2_AR2_Cnt =          getValue( HMI__STMSGSD_PNHV_Bat_Warn_Rq_V2_AR2          ) / _PNHV_Bat_Warn_Rq_V2_AR2_Timebase;
    _PNHV_Bat_Warn_Rq_AR_Cnt =          getValue( HMI__STMSGSD_PNHV_Bat_Warn_Rq_AR          ) / _PNHV_Bat_Warn_Rq_AR_Timebase;
    _PSL_R_Stat_AR_Cnt =                getValue( HMI__STMSGSD_PSL_R_Stat_AR                ) / _PSL_R_Stat_AR_Timebase;
    _PT_Data_VAN_AR_Cnt =				        getValue( HMI__STMSGSD_PT_Data_VAN_AR               ) / _PT_Data_VAN_AR_Timebase;
    _PT_DataContain_Rq_AR_Cnt =         getValue( HMI__STMSGSD_PT_DataContain_Rq_AR         ) / _PT_DataContain_Rq_AR_Timebase;
    _PT_Disp_Rq2_AR_Cnt =               getValue( HMI__STMSGSD_PT_Disp_Rq2_AR               ) / _PT_Disp_Rq2_AR_Timebase;
    _PtHyb_Mngmnt_Rq_AR_Cnt =           getValue( HMI__STMSGSD_PtHyb_Mngmnt_Rq_AR           ) / _PtHyb_Mngmnt_Rq_AR_Timebase;
    _PtMngmnt_Disp_Rq_AR_Cnt =          getValue( HMI__STMSGSD_PtMngmnt_Disp_Rq_AR          ) / _PtMngmnt_Disp_Rq_AR_Timebase;
	_Radar_EGO1_Obj_Attr1_AR_Cnt =      getValue( HMI__STMSGSD_Radar_EGO1_Obj_Attr1_AR      ) / _Radar_EGO1_Obj_Attr1_AR_Timebase;
    _RDS_Data_HU_AR_Cnt =               getValue( HMI__STMSGSD_RDS_Data_HU_AR             ) / _RDS_Data_HU_AR_Timebase;
    _RDU_Disp_Rq_AR_Cnt =               getValue( HMI__STMSGSD_RDU_Disp_Rq_AR               ) / _RDU_Disp_Rq_AR_Timebase;
    _RTC_Date_Time_AR_Cnt =             getValue( HMI__STMSGSD_RTC_Date_Time_AR             ) / _RTC_Date_Time_AR_Timebase;
    _RTC_Stat1_AR_Cnt =                 getValue( HMI__STMSGSD_RTC_Stat1_AR                 ) / _RTC_Stat1_AR_Timebase;
    _RTC_Stat2_AR_Cnt =                 getValue( HMI__STMSGSD_RTC_Stat2_AR                 ) / _RTC_Stat2_AR_Timebase;
    _RVC_SVS_Park_Stat_AR_Cnt =         getValue( HMI__STMSGSD_RVC_SVS_Park_Stat_AR         ) / _RVC_SVS_Park_Stat_AR_Timebase;
    _SBW_DrvPosn_Disp_Rq_ISM_AR_Cnt =   getValue( HMI__STMSGSD_SBW_DrvPosn_Disp_Rq_ISM_AR   ) / _SBW_DrvPosn_Disp_Rq_ISM_AR_Timebase;
    _SBW_DrvPosn_Disp_Rq_TCM_AR_Cnt =   getValue( HMI__STMSGSD_SBW_DrvPosn_Disp_Rq_TCM_AR   ) / _SBW_DrvPosn_Disp_Rq_TCM_AR_Timebase;
    _Seat_D_Stat_AR_Cnt =               getValue( HMI__STMSGSD_Seat_D_Stat_AR               ) / _Seat_D_Stat_AR_Timebase;
     _Seat_3L_Stat_AR_Cnt =               getValue( HMI__STMSGSD_Seat_3L_Stat_AR               ) / _Seat_3L_Stat_AR_Timebase;
    _Seat_3R_Stat_AR_Cnt =               getValue( HMI__STMSGSD_Seat_3R_Stat_AR               ) / _Seat_3R_Stat_AR_Timebase;
    _Seat_P_Stat_AR_Cnt =               getValue( HMI__STMSGSD_Seat_P_Stat_AR               ) / _Seat_P_Stat_AR_Timebase;
    _Seat_RL_Stat_AR_Cnt =              getValue( HMI__STMSGSD_Seat_RL_Stat_AR              ) / _Seat_RL_Stat_AR_Timebase;
    _Seat_RR_Stat_AR_Cnt =              getValue( HMI__STMSGSD_Seat_RR_Stat_AR              ) / _Seat_RR_Stat_AR_Timebase;
	  _SeatCM_D_Stat_HU_AR_Cnt =          getValue( HMI__STMSGSD_SeatCM_D_Stat_HU_AR          ) / _SeatCM_D_Stat_HU_AR_Timebase;
	  _SeatCM_P_Stat_HU_AR_Cnt =          getValue( HMI__STMSGSD_SeatCM_P_Stat_HU_AR          ) / _SeatCM_P_Stat_HU_AR_Timebase;
    _SeatHtVn_Stat_AR_Cnt =             getValue( HMI__STMSGSD_SeatHtVn_Stat_AR             ) / _SeatHtVn_Stat_AR_Timebase;
    _SeatHtVn_Stat2_AR_Cnt =            getValue( HMI__STMSGSD_SeatHtVn_Stat2_AR            ) / _SeatHtVn_Stat2_AR_Timebase;
    _SeatMem_D_Rq_AR_Cnt =              getValue( HMI__STMSGSD_SeatMem_D_Rq_AR              ) / _SeatMem_D_Rq_AR_Timebase;
	_SeatMem_D_Rq_AR_Cnt =              getValue( HMI__STMSGSD_SeatMem_D_Rq_AR              ) / _SeatMem_D_Rq_AR_Timebase;
    _SeatPosn_Abs_D_AR_Cnt =            getValue( HMI__STMSGSD_SeatPosn_Abs_D_AR            ) / _SeatPosn_Abs_D_AR_Timebase;
    _SeatPosn_Abs_P_AR_Cnt =            getValue( HMI__STMSGSD_SeatPosn_Abs_P_AR            ) / _SeatPosn_Abs_P_AR_Timebase;
    _SND_GEN_Stat_AR_Cnt =              getValue( HMI__STMSGSD_SND_GEN_Stat_AR              ) / _SND_GEN_Stat_AR_Timebase;
	_SONAR_A1_AR2_DAI_Cnt =            getValue( HMI__STMSGSD_SONAR_A1_AR2_DAI             ) / _SONAR_A1_AR2_DAI_Timebase;
	_SONAR_A3_AR2_DAI_Cnt =            getValue( HMI__STMSGSD_SONAR_A3_AR2_DAI             ) / _SONAR_A3_AR2_DAI_Timebase;
	_SONAR_A4_AR2_DAI_Cnt =            getValue( HMI__STMSGSD_SONAR_A4_AR2_DAI             ) / _SONAR_A4_AR2_DAI_Timebase;
//    _SPC_Disp_Rq_AR_Cnt =               getValue( HMI__STMSGSD_SPC_Disp_Rq_AR               ) / _SPC_Disp_Rq_AR_Timebase;
    _SPC_SwLED_Msg_Rq_AR_Cnt =          getValue( HMI__STMSGSD_SPC_SwLED_Msg_Rq_AR          ) / _SPC_SwLED_Msg_Rq_AR_Timebase;
    _SPV_Ret_Stat_VAN_AR_Cnt =          getValue( HMI__STMSGSD_SPV_Ret_Stat_VAN_AR          ) / _SPV_Ret_Stat_VAN_AR_Timebase;
    _SPV_Disp_Rq_VAN_AR_Cnt =           getValue( HMI__STMSGSD_SPV_Disp_Rq_VAN_AR           ) / _SPV_Disp_Rq_VAN_AR_Timebase;
    _SPV_Disp_Rq2_VAN_AR_Cnt =          getValue( HMI__STMSGSD_SPV_Disp_Rq2_VAN_AR          ) / _SPV_Disp_Rq2_VAN_AR_Timebase;
    _SPV_Rq_AR_Cnt =                    getValue( HMI__STMSGSD_SPV_Rq_AR                    ) / _SPV_Rq_AR_Timebase;
    _SPV_Stat_AR_Cnt =                  getValue( HMI__STMSGSD_SPV_Stat_AR                  ) / _SPV_Stat_AR_Timebase;
	  _SPV_Stat_VAN_AR_Cnt =              getValue( HMI__STMSGSD_SPV_Stat_VAN_AR              ) / _SPV_Stat_VAN_AR_Timebase;
    _StWhl_Angl_Stat_AR_Cnt =           getValue( HMI__STMSGSD_StWhl_Angl_Stat_AR           ) / _StWhl_Angl_Stat_AR_Timebase;
    _StWhl_OFN_Stat_AR_Cnt =            getValue( HMI__STMSGSD_StWhl_OFN_Stat_AR            ) / _StWhl_OFN_Stat_AR_Timebase;
    _StWhl_Sw_Stat_AR_Cnt =             getValue( HMI__STMSGSD_StWhl_Sw_Stat_AR             ) / _StWhl_Sw_Stat_AR_Timebase;
    _TC_Disp_Rq_ECM_AR_Cnt =            getValue( HMI__STMSGSD_TC_Disp_Rq_ECM_AR            ) / _TC_Disp_Rq_ECM_AR_Timebase;
    _TC_Disp_Rq2_AR2_Cnt =            getValue( HMI__STMSGSD_TC_Disp_Rq2_AR2            ) / _TC_Disp_Rq2_AR2_Timebase;
    _TC_EBBC_Disp_Rq_ECM_AR_Cnt =       getValue( HMI__STMSGSD_TC_EBBC_Disp_Rq_ECM_AR       ) / _TC_EBBC_Disp_Rq_ECM_AR_Timebase;
    _TC_EEBBC_Disp_Rq_AR_Cnt =          getValue( HMI__STMSGSD_TC_EEBBC_Disp_Rq_AR          ) / _TC_EEBBC_Disp_Rq_AR_Timebase;
	_TC_EEBBC_Energy_Cons_AR_Cnt =		getValue( HMI__STMSGSD_TC_EEBBC_Energy_Cons_AR 		) / _TC_EEBBC_Energy_Cons_AR_Timebase;
    _TC_EU6_Cons_Disp_Rq_AR_Cnt       = getValue( HMI__STMSGSD_TC_EU6_Cons_Disp_Rq_AR       ) / _TC_EU6_Cons_Disp_Rq_AR_Timebase;
    _TCM_Disp_Rq_AMG_AR_Cnt =           getValue( HMI__STMSGSD_TCM_Disp_Rq_AMG_AR           ) / _TCM_Disp_Rq_AMG_AR_Timebase;
    _Teleaid_WRN_AR_Cnt =               getValue( HMI__STMSGSD_Teleaid_WRN_AR               ) / _Teleaid_WRN_AR_Timebase;
//    _TP_COM_TGW_Adapt_Cnt =             getValue( HMI__STMSGSD_TP_COM_TGW_Adapt             ) / _TP_COM_TGW_Adapt_Timebase;
//    _TP_EIS_IC_SecOdo_Cnt =             getValue( HMI__STMSGSD_TP_EIS_IC_SecOdo             ) / _TP_EIS_IC_SecOdo_Timebase;
//    _TP_MPM_TGW_Nav_Cnt =               getValue( HMI__STMSGSD_TP_MPM_TGW_Nav               ) / _TP_MPM_TGW_Nav_Timebase;
//    _TP_PARK_TGW_Cnt =                  getValue( HMI__STMSGSD_TP_PARK_TGW                  ) / _TP_PARK_TGW_Timebase;
//    _TP_TELEAID_TGW_Cnt =               getValue( HMI__STMSGSD_TP_TELEAID_TGW               ) / _TP_TELEAID_TGW_Timebase;
//    _TP_WPT_IC_Cnt =                    getValue( HMI__STMSGSD_TP_WPT_IC                    ) / _TP_WPT_IC_Timebase;
//    _TP_WPT_TGW_Cnt =                   getValue( HMI__STMSGSD_TP_WPT_TGW                   ) / _TP_WPT_TGW_Timebase;
    _Trailer_Stat_AR_Cnt =              getValue( HMI__STMSGSD_Trailer_Stat_AR              ) / _Trailer_Stat_AR_Timebase;
    _TSA_Disp_Rq1_AR_Cnt =              getValue( HMI__STMSGSD_TSA_Disp_Rq1_AR              ) / _TSA_Disp_Rq1_AR_Timebase;
    _TSA_Disp_Rq2_AR_Cnt =              getValue( HMI__STMSGSD_TSA_Disp_Rq2_AR              ) / _TSA_Disp_Rq2_AR_Timebase;
	  _TSA_Disp_Rq3_AR_Cnt =              getValue( HMI__STMSGSD_TSA_Disp_Rq3_AR              ) / _TSA_Disp_Rq3_AR_Timebase;
    _Veh_Susp_Adj_AR_Cnt =      getValue( HMI__STMSGSD_Veh_Susp_Adj_AR      ) / _Veh_Susp_Adj_AR_Timebase;
    _VehCarv_Stat_AR_Cnt =              getValue( HMI__STMSGSD_VehCarv_Stat_AR              ) / _VehCarv_Stat_AR_Timebase;
    _VehDyn_Stat1_AR_Cnt =              getValue( HMI__STMSGSD_VehDyn_Stat1_AR              ) / _VehDyn_Stat1_AR_Timebase;
    _VehDyn_Stat2_AR_Cnt =              getValue( HMI__STMSGSD_VehDyn_Stat2_AR              ) / _VehDyn_Stat2_AR_Timebase;
    _VehLvl_Stat_AR_Cnt =               getValue( HMI__STMSGSD_VehLvl_Stat_AR               ) / _VehLvl_Stat_AR_Timebase;
    _VehPwrMngmnt_EMM_Stat2_AR_Cnt =    getValue( HMI__STMSGSD_VehPwrMngmnt_EMM_Stat2_AR    ) / _VehPwrMngmnt_EMM_Stat2_AR_Timebase;
    _VehSpd_X_AR_Cnt =                  getValue( HMI__STMSGSD_VehSpd_X_AR                  ) / _VehSpd_X_AR_Timebase;
//  _VIN_AR_Cnt =                       getValue( HMI__STMSGSD_VIN_AR                       ) / _VIN_AR_Timebase;
    _VTA_Event_Disp_AR_Cnt =            getValue( HMI__STMSGSD_VTA_Event_Disp_AR            ) / _VTA_Event_Disp_AR_Timebase;
    _Whl_Lt_Stat_AR_Cnt =               getValue( HMI__STMSGSD_Whl_Lt_Stat_AR               ) / _Whl_Lt_Stat_AR_Timebase;
    _DLM_Stat_AR_Cnt =               getValue( HMI__STMSGSD_DLM_Stat_AR               ) / _DLM_Stat_AR_Timebase;
    _Whl_Rt_Stat_AR_Cnt =               getValue( HMI__STMSGSD_Whl_Rt_Stat_AR               ) / _Whl_Rt_Stat_AR_Timebase;
    _WhlPlsCnt_TPM_AR_Cnt =             getValue( HMI__STMSGSD_WhlPlsCnt_TPM_AR             ) / _WhlPlsCnt_TPM_AR_Timebase;
    _WIA_EngTrq_AR_Cnt =                getValue( HMI__STMSGSD_WIA_EngTrq_AR                ) / _WIA_EngTrq_AR_Timebase;
	_WMI_Stat_AR_Cnt =            getValue( HMI__STMSGSD_WMI_Stat_AR             ) / _WMI_Stat_AR_Timebase;
    _Wpr_Stat_AR_Cnt =                  getValue( HMI__STMSGSD_Wpr_Stat_AR                  ) / _Wpr_Stat_AR_Timebase;
    _WPT_Stat2_AR_Cnt =                 getValue( HMI__STMSGSD_WPT_Stat2_AR                 ) / _WPT_Stat2_AR_Timebase;
// #START_DELAY_END#
}

__Reset_E2E_SQC()
{
    putValue( HMI_SQC_Airbag_LED_Stat_ASBM, 15 );
    putValue( HMI_SQC_CamLane_Disp_Warn_Rq, 15 );
    putValue( HMI_SQC_PT_Stat, 15 );
    putValue( HMI_SQC_ClockSync_Stat1, 15 );
    putValue( HMI_SQC_ClockSync_Stat2, 15 );
    putValue( HMI_SQC_CMS_PI_Sd_Lt_Stat, 15 );
    putValue( HMI_SQC_CMS_PI_Sd_Rt_Stat, 15 );
    putValue( HMI_SQC_CMS_PI_Stat, 15 );
    putValue( HMI_SQC_Airbag_LED_Stat, 15 );
    putValue( HMI_SQC_CTRL_L_Stat, 15 );
    putValue( HMI_SQC_CTRL_L2_Stat, 15 );
    putValue( HMI_SQC_Door_FL_Stat, 15 );
    putValue( HMI_SQC_Door_FR_Stat, 15 );
    putValue( HMI_SQC_Door_RL_Stat, 15 );
    putValue( HMI_SQC_Door_RR_Stat, 15 );
    putValue( HMI_SQC_DPC_Disp_Rq, 15 );
    putValue( HMI_SQC_DPC_IndMd_Stat, 15 );
    putValue( HMI_SQC_DPC_IndMd_Style, 15 );
    putValue( HMI_SQC_DPC_IndMd_Style2, 15 );
	putValue( HMI_SQC_DPC_Swstat_DRVU, 15 );
    putValue( HMI_SQC_DPC_Master_Rq, 15 );
    putValue( HMI_SQC_EL_Ft_FltDisp_Rq, 15 );
    putValue( HMI_SQC_EL_R_FltDisp_Rq, 15 );
    putValue( HMI_SQC_ExtLgt_Lmp_On_Rq, 15 );
    putValue( HMI_SQC_EL_TurnInd_On_Rq, 15 );
    putValue( HMI_SQC_Eng_Rs_EngCtrl, 15 );
    putValue( HMI_SQC_Eng_Rs2, 15 );
    putValue( HMI_SQC_EPKB_Disp_IndLmp_Rq, 15 );                _mEPKB_Disp_IndLmp_Rq_2_AR.SQC_EPKB_Disp_IndLmp_Rq = 15;
    putValue( HMI_SQC_EPS_CtrlLmp_Disp_Rq, 15 );
    putValue( HMI_SQC_ESP_ATC_Stat_AMG, 15 );                   _mESP_ATC_Stat_AMG_AR.SQC_ESP_ATC_Stat_AMG =15;
    putValue( HMI_SQC_ESP_Disp_Rq, 15 );                        _mESP_Disp_Rq_AR.SQC_ESP_Disp_Rq =15;
    putValue( HMI_SQC_ESP_Stat1_VAN, 15 );                      _mESP_Stat1_VAN_AR.SQC_ESP_Stat1_VAN =15;
    putValue( HMI_SQC_DSR_Disp_Rq, 15 );
    putValue( HMI_SQC_EVC_CfgBit_01_32, 15 );
    putValue( HMI_SQC_EVC_CfgBit_33_64, 15 );
    putValue( HMI_SQC_EVC_CfgBit_65_96, 15 );
    putValue( HMI_SQC_EVC_CfgBit_97_C8, 15 );
    putValue( HMI_SQC_EVC_CfgList_01_0C, 15 );
    putValue( HMI_SQC_EVC_CfgVAN, 15 );
    putValue( HMI_SQC_FDC_Disp_Rq, 15 );
    putValue( HMI_SQC_Ign_Stat, 15 );
    putValue( HMI_SQC_IHC_Lgt_Stat_MPC, 15 );
    putValue( HMI_SQC_Immobilizer_KeyID, 15 );
    putValue( HMI_SQC_RemPark_Stat_KG, 15 );
    putValue( HMI_SQC_NVP_Stat1, 15 );
    putValue( HMI_SQC_Bckl_Sw_Ft_Stat, 15 );
    putValue( HMI_SQC_Impact, 15 );
    putValue( HMI_SQC_Park_Disp_Rq, 15 );
    putValue( HMI_SQC_PN14_Disp_Rq2, 15 );
    putValue( HMI_SQC_PresfCtrl_Rq_ESP, 15 );
    putValue( HMI_SQC_PT_Data_VAN, 15 );
    putValue( HMI_SQC_ISM_TxDrvPosn_Disp_Rq, 15 );
    putValue( HMI_SQC_SBW_Drv_Pk_Posn_TCM, 15 );
    putValue( HMI_SQC_SeatPosn_Abs_D, 15 );
    putValue( HMI_SQC_SeatPosn_Abs_P, 15 );
    putValue( HMI_SQC_SPC_Msg_Rq, 15 );
    putValue( HMI_SQC_SPL_Obj1_Obj2_NV, 15 );
    putValue( HMI_SQC_StWhl_Angl_Stat, 15 );
    putValue( HMI_SQC_StWhl_Sw_Ok1_Ok2_Psd, 15 );
    putValue( HMI_SQC_TPM_Lmp_On_Rq, 15 );
    putValue( HMI_SQC_ElecTrlrHtch_Stat, 15 );
    putValue( HMI_SQC_HMIG_Stat, 15 );
    putValue( HMI_SQC_VehDyn_Stat1, 15 );
    putValue( HMI_SQC_VehDyn_Stat2, 15 );
    putValue( HMI_SQC_VehLvl_Stat, 15 );
    putValue( HMI_SQC_EMM_Disp_Rq, 15 );
    putValue( HMI_SQC_VehSpd_X, 15 );
    putValue( HMI_SQC_Whl_Lt_Stat, 15 );
    putValue( HMI_SQC_Whl_Rt_Stat, 15 );
    putValue( HMI_SQC_WhlPlsCnt_TPM, 15 );
//    write(" E2E-simu: Reset SQC to 15 ");
}

on Timer t_DBKomTimer_5ms
{
// *** DBKom-Sendefunktion ***
    // timer aufziehen f�r n�chsten Zyklus
    if( getValue( HMI__NM_EIS_CommActive ) )
    {
        setTimer( t_DBKomTimer_5ms, c_tDBKomTimer_5ms );
    }
// #CYC_TIMER_5_MS_START#
    BC_F_Stat1_AR_check_output();
    CLkS_Rq_AR_check_output();
    EL_TurnInd_Rq_AR_check_output();
    Eng_Rs_EngCtrl_AR_check_output();
    PN48_Disp_Rq_AR_check_output();
    RDU_Disp_Rq_AR_check_output();
    SeatMem_D_Rq_AR_check_output();
    SPC_Disp_Rq_AR_check_output();
    SPV_Rq_AR_check_output();
    SPV_Stat_AR_check_output();
	  SPV_Stat_VAN_AR_check_output();
    StWhl_Angl_Stat_AR_check_output();
    StWhl_OFN_Stat_AR_check_output();
    TSA_Disp_Rq1_AR_check_output();
    PNHV_Stat_VAN_AR_check_output();
// #CYC_TIMER_5_MS_END#
}

on Timer t_DBKomTimer_20ms
{
// *** DBKom-Sendefunktion ***
    // timer aufziehen f�r n�chsten Zyklus
    if( getValue( HMI__NM_EIS_CommActive    ) )
    {
        setTimer( t_DBKomTimer_20ms, c_tDBKomTimer_20ms );
    }
// #CYC_TIMER_20_MS#
	
	SBW_DrvPosn_Disp_Rq_TCM_AR_check_output();
    AB_R_Stat_AR_check_output();
    //Adapt_Seat_D_Stat_AR_check_output();
    Adblue_Disp_Rq_AR_check_output();
    Adblue_Disp_Warn_Rq_AR_check_output();
    AQS_Data_HU_AR_check_output();
    ARB_Stat_AR_check_output();
    Assyst_Stat_AR_check_output();
    Assyst_Stat2_AR_check_output();
    Assyst_Stat3_AR_check_output();
    AWD_TCASE_Disp_Rq_AR_check_output();
    BC_Stat1_VAN_AR_check_output();
	BC_F_Disp_Rq_AR_check_output();
// 5ms    BC_F_Stat1_AR_check_output();
    BC_F_Stat2_AR_check_output();
    BC_R_Stat1_AR_check_output();
    BC_R_Stat2_AR_check_output();
    BODY_HMI_R0_AR_check_output();
    BODY_HMI_R1_AR_check_output();
    BODY_HMI_R2_AR_check_output();
    BSM_Disp_Warn_Rq_AR_check_output();
	BSM_M_Lat_FreeSp_AR_check_output();
	BSM_S_Lat_FreeSp_AR_check_output();
    CamLane_Disp_Warn_Rq_AR_check_output();
	CamLane_LaneAttr2_AR_check_output();
	LDP_Disp_Rq_AR_check_output();
	Tire_temp_VAN_AR_check_output();
	OBWlight_Message_VAN_AR_check_output();
	CamLane_LaneAttr6_AR_check_output();
	  CamLane_LaneAttr7_AR_check_output();
//	CHASS_PERIPH_HMI_Camlane_R1_AR_check_output();
//	CHASS_PERIPH_HMI_Camlane_R2_AR_check_output();
//	  CHASS_PERIPH_HMI_Camlane_R3_AR_check_output();
	  CHASSIS_HMI_Radar_R1_AR_check_output();
	  CHASSIS_HMI_Radar_R2_AR_check_output();
	  CHASSIS_HMI_Radar_R3_AR_check_output();
	  CHASSIS_HMI_Radar_R4_AR_check_output();
	  CHASSIS_HMI_Radar_R5_AR_check_output();
    CHASSIS_HMI_R0_AR_check_output();
    CHASSIS_HMI_R1_AR_check_output();
    CHASSIS_HMI_R2_AR_check_output();
    CHASSIS_HMI_R3_AR_check_output();
    CHASSIS_HMI_R4_AR_check_output();
//	CHASSIS_HMI_R5_AR_check_output();
	CHASSIS_HMI_DTR_R2_AR_check_output();
    CHASSISPERIPHERY_HMI_R1_AR_check_output();
	  CHASSISPERIPHERY_HMI_R2_AR_check_output();
// 5ms    CLkS_Rq_AR_check_output();
    CLkS_State_AR_check_output();
    ClockSync_Stat_AR_check_output();
    CMS_PI_Sd_Stat_MMR_F1_AR_check_output();
    CMS_PI_Sd_Stat_MMR_F4_AR_check_output();
    CMS_PI_Stat_AR_check_output();
    CNG_Disp_Rq_AR_check_output();
    COM_Call_Stat_AR_check_output();
//    COMM_EIS_WMI_AR_check_output();
//    COMM_EIS_TGW_AR_check_output();
    CRCM_Disp_Rq_AR_check_output();
    CU_GNSS_Data1_AR_check_output();
    CU_Pos1_AR_check_output();
  	CU_Pos2_AR_check_output();
  	CU_UTC_AR2_check_output();
    CU_RemFunc_Rq3_AR_check_output();
    D_RQ_GLOBAL_UDS_check_output();
    D_RQ_IC_check_output();
    D_RQ_TCO_check_output();
    DidA_MBContact_State_AR_check_output();
    Door_FL_Stat_AR_check_output();
    Door_FR_Stat_AR_check_output();
    Door_RL_Stat_AR_check_output();
    Door_RR_Stat_AR_check_output();
    DPC_Disp_Rq_AR_check_output();
    DPC_IndMd_Stat_AR_check_output();
    DPC_IndMd_Style_AR_check_output();
    DPC_IndMd_Style2_AR_check_output();
    DPC_Master_Rq_AR_check_output();
	DPC_MdSel_Rs_AMG_AR_check_output();
	  DTQ_Traj_AR_check_output();
	  DTR_Obj_Attr1_AR_check_output();
	  DTR_Obj_Attr2_AR_check_output();
	  DTR_Obj_Attr3_AR_check_output();
    ECO_Score_Disp_Rq_AR_check_output();
    EL_Ft_Disp_Rq_AR_check_output();
    EL_R_Disp_Rq_AR_check_output();
    EL_Stat_AR_check_output();
// 5ms    EL_TurnInd_Rq_AR_check_output();
    Eng_Data_VAN_AR_check_output();
// 5ms    Eng_Rs_EngCtrl_AR_check_output();
    Eng_Rs2_AR_check_output();
    EngCtrl_Disp_Rq_AR_check_output();
    EngCtrl_Stat_AR_check_output();
    EPKB_Disp_IndLmp_Rq_2_AR_check_output();
    EPS_Stat_Disp_Rq_AR_check_output();
    ESP_ATC_Stat_AMG_AR_check_output();
    ESP_Disp_Rq_AR_check_output();
    ESP_Disp_Rq2_AR_check_output();
    ESP_Disp_Rq3_AR_check_output();
    ESP_Disp_Rq_AMG_AR_check_output();
    ESP_Stat1_VAN_AR_check_output();
    EVC_CfgBit_01_32_AR_check_output();
    EVC_CfgBit_33_64_AR_check_output();
    EVC_CfgBit_65_96_AR_check_output();
    EVC_CfgBit_97_C8_AR_check_output();
    EVC_CfgList_01_0C_AR_check_output();
    EVC_CfgVAN_AR_check_output();
	  ExitWarn_Disp_Rq_AR_check_output();
    FBL_CFG_Star2_AR_check_output();
    FCW_Disp_Rq_AR_check_output();
    Fuel_Stat2_AR_check_output();
    FDC_Disp_Rq_AR_check_output();
    FlashOverTheAir_Stat_AR_check_output();
    FuelLvl_Stat_AR_check_output();
    FWLP_D_AR_check_output();
    FWLP_P_AR_check_output();
	HAD_MDC_CamLane_MapLrn_Attr1_AR_check_output();
	HAD_MDC_CamObj_MapLrn_Attr1_AR_check_output();
	HAD_MDC_MapData2_AR_check_output();
	HAD_MDC_MapLrn_Attr1_AR_check_output();
	HAD_MDC_TSR_Sign_Attr1_AR_check_output();
	HAD_MDC_TSR_Sign_Attr2_AR_check_output();
	HFP_R5_AR2_DAI_check_output();
	HMIG_Stat_AR_check_output();
    HumanMachineIfc_AR_check_output();
	  HumanMachineIfc2_AR_check_output();
    HumanMachineIfc_Rq_AR_check_output();
    HVAC_Disp_Stat1_AR_check_output();
    HVAC_Disp_Stat2_AR_check_output();
    HVAC_Disp_Stat3_AR_check_output();
	  HVAC_Disp_Stat4_AR_check_output();
    HVAC_State1_AR_check_output();
    ICH_PreTime_Stat_AR_check_output();
    ICH_Stat_AR_check_output();
    Ign_Veh_Stat_AR_check_output();
    IL_AmbLgt_Disp_AR_check_output();
    IL_AmbLgtCfg_Stat_AR_check_output();
    IL_AmbLgtCfg_Stat2_AR_check_output();
    IL_Stat2_AR_check_output();
    Immobilizer_Disp_Rq_AR_check_output();
    Immobilizer_IC_AR_check_output();
    Immobilizer_KeyID_AR_check_output();
    KEP_MODE_DISP_RQ_check_output();
    KG_Msg_Disp_Rq_AR_check_output();
    KG_State_AR_check_output();
    LDC_Disp_Rq_ESP_AR_check_output();
	  LDC_Disp_Rq2_ESP_AR_check_output();
    LDC_Disp_Rq_RDU_AR_check_output();
	  LDC_Disp_Rq2_RDU_AR_check_output();
    LDP_Warn_Rq_AR_check_output();
    LgtSens_State_AR_check_output();
    MCMS_FL_AR_check_output();
    MCMS_FL_Stat_AR_check_output();
    MCMS_FR_AR_check_output();
    MCMS_FR_Stat_AR_check_output();
    MCMS_RL_AR_check_output();
    MCMS_RL_Stat_AR_check_output();
    MCMS_RR_AR_check_output();
    MCMS_RR_Stat_AR_check_output();
    OffRoad_Disp_Rq_AR_check_output();
    Park_Disp_Rq_AR_check_output();
    Park_Set_Stat_AR_check_output();
    ParkSpaceMeas_Stat_AR_check_output();
    Park_Stat_AR_check_output();
	  ParkSpace_Posn_AR_check_output();
    ParkWarn_AR_check_output();
    PERIPHERY_HMI_R1_AR_check_output();
    PN14_Disp_Rq_AR_check_output();
    PN14_Disp_Rq2_AR_check_output();
    PN14_Stat_AR_check_output();
	  PN14_Stat_VAN_AR_check_output();
    PN48_Bat_Stat_AR_check_output();
// 5ms    PN48_Disp_Rq_AR_check_output();
    PnHt_Stat_AR_check_output();
    PNHV_Disp_Rq1_AR_check_output();
    PNHV_Disp_Rq2_AR_check_output();
    PNHV_Energy_Rq_AR_check_output();
    PNHV_EnergyMngmnt_Disp_Rq_AR_check_output();
    PNHV_EnergyMngmnt_Stat2_AR_check_output();
    PNHV_EnergyMngmntSet_Rs1_AR_check_output();
    PNHV_EnergyMngmntSet_Rs2_AR_check_output();
    PNHV_EnergyMngmntSet_Rs3_AR_check_output();
    PNHV_WeekDepTmTbl_Stat_AR_check_output();
    PreCond_CfgStat_AR_check_output();
    PresfCtrl_Rq_ESP_AR_check_output();
    PSL_L_Stat_AR_check_output(); 
    //PNHV_Bat_Warn_Rq_AR_output(); 
    PSL_R_Stat_AR_check_output();          
    PT_Data_VAN_AR_check_output();
    PT_DataContain_Rq_AR_check_output();
    PT_Disp_Rq2_AR_check_output();
    PtHyb_Mngmnt_Rq_AR_check_output();
    PtMngmnt_Disp_Rq_AR_check_output();
	Radar_EGO1_Obj_Attr1_AR_check_output();
	RDS_Data_HU_AR_check_output();
// 5ms    RDU_Disp_Rq_AR_check_output();
    RTC_Date_Time_AR_check_output();
    RTC_Stat1_AR_check_output();
    RTC_Stat2_AR_check_output();
    RVC_SVS_Park_Stat_AR_check_output();
    SBW_DrvPosn_Disp_Rq_ISM_AR_check_output();
    Seat_3L_Stat_AR_check_output();
    Seat_3R_Stat_AR_check_output();
    Seat_D_Stat_AR_check_output();
    Seat_P_Stat_AR_check_output();
    Seat_RL_Stat_AR_check_output();
    Seat_RR_Stat_AR_check_output();
	SeatCM_D_Stat_HU_AR_check_output();
	SeatCM_P_Stat_HU_AR_check_output();
    SeatHtVn_Stat_AR_check_output();
    SeatHtVn_Stat2_AR_check_output();
	SeatMat_Stat_AR_check_output();
// 5ms    SeatMem_D_Rq_AR_check_output();
    SeatPosn_Abs_D_AR_check_output();
    SeatPosn_Abs_P_AR_check_output();
    SND_GEN_Stat_AR_check_output();
	SONAR_A1_AR2_DAI_check_output();
	SONAR_A3_AR2_DAI_check_output();
	SONAR_A4_AR2_DAI_check_output();
// 5ms    SPC_Disp_Rq_AR_check_output();
    SPC_SwLED_Msg_Rq_AR_check_output();
    SPV_Ret_Stat_VAN_AR_check_output();
    SPV_Disp_Rq_VAN_AR_check_output();
    SPV_Disp_Rq2_VAN_AR_check_output();
// 5ms    SPV_Rq_AR_check_output();
// 5ms    SPV_Stat_AR_check_output();
// 5ms    StWhl_Angl_Stat_AR_check_output();
// 5ms    StWhl_OFN_Stat_AR_check_output();
    StWhl_Sw_Stat_AR_check_output();
    TC_Disp_Rq_ECM_AR_check_output();
    TC_Disp_Rq2_AR2_check_output();
    TC_EBBC_Disp_Rq_ECM_AR_check_output();
    TC_EEBBC_Disp_Rq_AR_check_output();
	TC_EEBBC_Energy_Cons_AR_check_output();
    TC_EU6_Cons_Disp_Rq_AR_check_output();
    TCM_Disp_Rq_AMG_AR_check_output();
    Teleaid_WRN_AR_check_output();
//    TP_COM_TGW_Adapt_check_output();
//    TP_EIS_IC_SecOdo_check_output();
    TP_MPM_TGW_Nav_check_output();
    TP_PARK_TGW_check_output();
    TP_TELEAID_TGW_check_output();
    TP_WPT_IC_check_output();
    TP_WPT_TGW_check_output();
    Trailer_Stat_AR_check_output();
// 5ms    TSA_Disp_Rq1_AR_check_output();
    TSA_Disp_Rq2_AR_check_output();
	  TSA_Disp_Rq3_AR_check_output();
    Veh_Susp_Adj_AR_check_output();
	  VehCarv_Stat_AR_check_output();
    VehDyn_Stat1_AR_check_output();
    VehDyn_Stat2_AR_check_output();
    VehLvl_Stat_AR_check_output();
    VehPwrMngmnt_EMM_Stat2_AR_check_output();
    VehSpd_X_AR_check_output();
    VIN_AR_check_output();
    VTA_Event_Disp_AR_check_output();
    DLM_Stat_AR_check_output();
    Whl_Lt_Stat_AR_check_output();
    Whl_Rt_Stat_AR_check_output();
    WhlPlsCnt_TPM_AR_check_output();
    WIA_EngTrq_AR_check_output();
	WMI_Stat_AR_check_output();
    Wpr_Stat_AR_check_output();
    WPT_Stat2_AR_check_output();
	PNHV_Bat_Warn_Rq_V2_AR2_check_output();
    PNHV_Bat_Warn_Rq_AR_check_output();
// #CYC_TIMER_20_MS_END#
//    APPL_ECU_APM_1_check_output();
//    APPL_ECU_APM_2_check_output();
//    APPL_ECU_DRVU_1_check_output();
//    APPL_ECU_DRVU_2_check_output();
    APPL_ECU_HIL_TO_IC1_check_output();
//    APPL_ECU_ORC1_check_output();
//    APPL_ECU_RVC_SVS1_check_output();
//    APPL_ECU_TGW1_check_output();
//    NM_APPL_AR_check_output();
//    NM_EIS_AR_check_output();
//    XCP_Rq_DRVU_1_check_output();
//    XCP_Rq_DRVU_2_check_output();
//    XCP_Rq_RBTM_FL_check_output();
//    XCP_Rq_RBTM_FR_check_output();
//    XCP_Rq_RVC_SVS_check_output();
//    XCP_Rq_TPM_check_output();
}

on EnvVar HMI__SAVE_PANEL_CONFIG_EIS
{
    dword hFile;

    if( getValue(this) )
    {
        write("Saving HMI Panel Variables ...");

        hFile = openFileWrite( "CONFIG\\HMI_PRESETS.ASC", 0 );
        filePutString( "base hex timestamps absolute\n", 31, hFile );

// #MSG_SAVEENVVAR#
        AB_R_Stat_AR_saveEnvVars( hFile );
        //Adapt_Seat_D_Stat_AR_saveEnvVars( hFile );
        Adblue_Disp_Rq_AR_saveEnvVars( hFile );
        Adblue_Disp_Warn_Rq_AR_saveEnvVars( hFile );
        AQS_Data_HU_AR_saveEnvVars( hFile );
        ARB_Stat_AR_saveEnvVars( hFile );
        Assyst_Stat_AR_saveEnvVars( hFile );
        Assyst_Stat2_AR_saveEnvVars( hFile );
        Assyst_Stat3_AR_saveEnvVars( hFile );
        AWD_TCASE_Disp_Rq_AR_saveEnvVars( hFile );
        BC_Stat1_VAN_AR_saveEnvVars( hFile );
		BC_F_Disp_Rq_AR_saveEnvVars( hFile );
        BC_F_Stat1_AR_saveEnvVars( hFile );
        BC_F_Stat2_AR_saveEnvVars( hFile );
        BC_R_Stat1_AR_saveEnvVars( hFile );
        BC_R_Stat2_AR_saveEnvVars( hFile );
        BODY_HMI_R0_AR_saveEnvVars( hFile );
        BODY_HMI_R1_AR_saveEnvVars( hFile );
        BODY_HMI_R2_AR_saveEnvVars( hFile );
        BSM_Disp_Warn_Rq_AR_saveEnvVars( hFile );
		BSM_M_Lat_FreeSp_AR_saveEnvVars( hFile );
		BSM_S_Lat_FreeSp_AR_saveEnvVars( hFile );
        CamLane_Disp_Warn_Rq_AR_saveEnvVars( hFile );
		CamLane_LaneAttr7_AR_saveEnvVars( hFile );
		CamLane_LaneAttr2_AR_saveEnvVars( hFile );
		CamLane_LaneAttr6_AR_saveEnvVars( hFile );
//		CHASS_PERIPH_HMI_Camlane_R1_AR_saveEnvVars( hFile );
//		CHASS_PERIPH_HMI_Camlane_R2_AR_saveEnvVars( hFile );
//		CHASS_PERIPH_HMI_Camlane_R3_AR_saveEnvVars( hFile );
		CHASSIS_HMI_Radar_R1_AR_saveEnvVars( hFile );
		CHASSIS_HMI_Radar_R2_AR_saveEnvVars( hFile );
		CHASSIS_HMI_Radar_R3_AR_saveEnvVars( hFile );
		CHASSIS_HMI_Radar_R4_AR_saveEnvVars( hFile );
		CHASSIS_HMI_Radar_R5_AR_saveEnvVars( hFile );
        CHASSIS_HMI_R0_AR_saveEnvVars( hFile );
        CHASSIS_HMI_R1_AR_saveEnvVars( hFile );
        CHASSIS_HMI_R2_AR_saveEnvVars( hFile );
        CHASSIS_HMI_R3_AR_saveEnvVars( hFile );
        CHASSIS_HMI_R4_AR_saveEnvVars( hFile );
//		CHASSIS_HMI_R5_AR_saveEnvVars( hFile );
		CHASSIS_HMI_DTR_R2_AR_saveEnvVars( hFile );
        CHASSISPERIPHERY_HMI_R1_AR_saveEnvVars( hFile );
		CHASSISPERIPHERY_HMI_R2_AR_saveEnvVars( hFile );
        CLkS_Rq_AR_saveEnvVars( hFile );
        CLkS_State_AR_saveEnvVars( hFile );
        ClockSync_Stat_AR_saveEnvVars( hFile );
        CMS_PI_Sd_Stat_MMR_F1_AR_saveEnvVars( hFile );
        CMS_PI_Sd_Stat_MMR_F4_AR_saveEnvVars( hFile );
        CMS_PI_Stat_AR_saveEnvVars( hFile );
        CNG_Disp_Rq_AR_saveEnvVars( hFile );
        COM_Call_Stat_AR_saveEnvVars( hFile );
        COMM_EIS_WMI_AR_saveEnvVars( hFile );
		    COMM_EIS_TGW_AR_saveEnvVars( hFile );
        CRCM_Disp_Rq_AR_saveEnvVars( hFile );
        CU_GNSS_Data1_AR_saveEnvVars( hFile );
        CU_UTC_AR2_saveEnvVars( hFile );
        CU_Pos1_AR_saveEnvVars( hFile );
		    CU_Pos2_AR_saveEnvVars( hFile );
        DidA_MBContact_State_AR_saveEnvVars( hFile );
        Door_FL_Stat_AR_saveEnvVars( hFile );
        Door_FR_Stat_AR_saveEnvVars( hFile );
        Door_RL_Stat_AR_saveEnvVars( hFile );
        Door_RR_Stat_AR_saveEnvVars( hFile );
        DPC_Disp_Rq_AR_saveEnvVars( hFile );
        DPC_IndMd_Stat_AR_saveEnvVars( hFile );
        DPC_IndMd_Style_AR_saveEnvVars( hFile );
        DPC_IndMd_Style2_AR_saveEnvVars( hFile );
        DPC_Master_Rq_AR_saveEnvVars( hFile );
		DPC_MdSel_Rs_AMG_AR_saveEnvVars( hFile );
		    DTQ_Traj_AR_saveEnvVars( hFile );
		    DTR_Obj_Attr1_AR_saveEnvVars( hFile );
		    DTR_Obj_Attr2_AR_saveEnvVars( hFile );
		    DTR_Obj_Attr3_AR_saveEnvVars( hFile );
        ECO_Score_Disp_Rq_AR_saveEnvVars( hFile );
        EL_Ft_Disp_Rq_AR_saveEnvVars( hFile );
        EL_R_Disp_Rq_AR_saveEnvVars( hFile );
        EL_Stat_AR_saveEnvVars( hFile );
        EL_TurnInd_Rq_AR_saveEnvVars( hFile );
        Eng_Data_VAN_AR_saveEnvVars( hFile );
        Eng_Rs_EngCtrl_AR_saveEnvVars( hFile );
        Eng_Rs2_AR_saveEnvVars( hFile );
        EngCtrl_Disp_Rq_AR_saveEnvVars( hFile );
        EngCtrl_Stat_AR_saveEnvVars( hFile );
        EPKB_Disp_IndLmp_Rq_2_AR_saveEnvVars( hFile );
        EPS_Stat_Disp_Rq_AR_saveEnvVars( hFile );
        ESP_ATC_Stat_AMG_AR_saveEnvVars( hFile );
        ESP_Disp_Rq_AR_saveEnvVars( hFile );
        ESP_Disp_Rq2_AR_saveEnvVars( hFile );
        ESP_Disp_Rq3_AR_saveEnvVars( hFile );
        ESP_Disp_Rq_AMG_AR_saveEnvVars( hFile );
        ESP_Stat1_VAN_AR_saveEnvVars( hFile );
        EVC_CfgBit_01_32_AR_saveEnvVars( hFile );
        EVC_CfgBit_33_64_AR_saveEnvVars( hFile );
        EVC_CfgBit_65_96_AR_saveEnvVars( hFile );
        EVC_CfgBit_97_C8_AR_saveEnvVars( hFile );
        EVC_CfgList_01_0C_AR_saveEnvVars( hFile );
        EVC_CfgVAN_AR_saveEnvVars( hFile );
		    ExitWarn_Disp_Rq_AR_saveEnvVars( hFile );
        FBL_CFG_Star2_AR_saveEnvVars( hFile );
        FCW_Disp_Rq_AR_saveEnvVars( hFile );
        FDC_Disp_Rq_AR_saveEnvVars( hFile );
        FlashOverTheAir_Stat_AR_saveEnvVars( hFile );
        Fuel_Stat2_AR_saveEnvVars( hFile );
        FuelLvl_Stat_AR_saveEnvVars( hFile );
        FWLP_D_AR_saveEnvVars( hFile );
        FWLP_P_AR_saveEnvVars( hFile );
		HAD_MDC_CamLane_MapLrn_Attr1_AR_saveEnvVars( hFile );
		HAD_MDC_CamObj_MapLrn_Attr1_AR_saveEnvVars( hFile );
		HAD_MDC_MapData2_AR_saveEnvVars( hFile );
		HAD_MDC_MapLrn_Attr1_AR_saveEnvVars( hFile );
		HAD_MDC_TSR_Sign_Attr1_AR_saveEnvVars( hFile );
		HAD_MDC_TSR_Sign_Attr2_AR_saveEnvVars( hFile );
		HMIG_Stat_AR_saveEnvVars( hFile );
        HumanMachineIfc_AR_saveEnvVars( hFile );
		    HumanMachineIfc2_AR_saveEnvVars( hFile );
        HumanMachineIfc_Rq_AR_saveEnvVars( hFile );
        HVAC_Disp_Stat1_AR_saveEnvVars( hFile );
        HVAC_Disp_Stat2_AR_saveEnvVars( hFile );
        HVAC_Disp_Stat3_AR_saveEnvVars( hFile );
		    HVAC_Disp_Stat4_AR_saveEnvVars( hFile );
        HVAC_State1_AR_saveEnvVars( hFile );
        ICH_PreTime_Stat_AR_saveEnvVars( hFile );
        ICH_Stat_AR_saveEnvVars( hFile );
        Ign_Veh_Stat_AR_saveEnvVars( hFile );
        IL_AmbLgt_Disp_AR_saveEnvVars( hFile );
        IL_AmbLgtCfg_Stat_AR_saveEnvVars( hFile );
        IL_AmbLgtCfg_Stat2_AR_saveEnvVars( hFile );
        IL_Stat2_AR_saveEnvVars( hFile );
        Immobilizer_Disp_Rq_AR_saveEnvVars( hFile );
        Immobilizer_IC_AR_saveEnvVars( hFile );
        Immobilizer_KeyID_AR_saveEnvVars( hFile );
        KEP_MODE_DISP_RQ_saveEnvVars( hFile );
        KG_Msg_Disp_Rq_AR_saveEnvVars( hFile );
        KG_State_AR_saveEnvVars( hFile );
        LDC_Disp_Rq_ESP_AR_saveEnvVars( hFile );
		    LDC_Disp_Rq2_ESP_AR_saveEnvVars( hFile );
        LDC_Disp_Rq_RDU_AR_saveEnvVars( hFile );
		    LDC_Disp_Rq2_RDU_AR_saveEnvVars( hFile );
        LDP_Warn_Rq_AR_saveEnvVars( hFile );
        LgtSens_State_AR_saveEnvVars( hFile );
        MCMS_FL_AR_saveEnvVars( hFile );
        MCMS_FL_Stat_AR_saveEnvVars( hFile );
        MCMS_FR_AR_saveEnvVars( hFile );
        MCMS_FR_Stat_AR_saveEnvVars( hFile );
        MCMS_RL_AR_saveEnvVars( hFile );
        MCMS_RL_Stat_AR_saveEnvVars( hFile );
        MCMS_RR_AR_saveEnvVars( hFile );
        MCMS_RR_Stat_AR_saveEnvVars( hFile );
        OffRoad_Disp_Rq_AR_saveEnvVars( hFile );
        Park_Disp_Rq_AR_saveEnvVars( hFile );
        Park_Set_Stat_AR_saveEnvVars( hFile );
        ParkSpaceMeas_Stat_AR_saveEnvVars( hFile );
        Park_Stat_AR_saveEnvVars( hFile );
		    ParkSpace_Posn_AR_saveEnvVars( hFile );
        ParkWarn_AR_saveEnvVars( hFile );
        PERIPHERY_HMI_R1_AR_saveEnvVars( hFile );
        PN14_Disp_Rq_AR_saveEnvVars( hFile );
        PN14_Disp_Rq2_AR_saveEnvVars( hFile );
        PN14_Stat_AR_saveEnvVars( hFile );
		    PN14_Stat_VAN_AR_saveEnvVars( hFile );
        PN48_Bat_Stat_AR_saveEnvVars( hFile );
        PN48_Disp_Rq_AR_saveEnvVars( hFile );
        PnHt_Stat_AR_saveEnvVars( hFile );
        PNHV_Disp_Rq1_AR_saveEnvVars( hFile );
        PNHV_Disp_Rq2_AR_saveEnvVars( hFile );
        PNHV_Energy_Rq_AR_saveEnvVars( hFile );
        PNHV_EnergyMngmnt_Disp_Rq_AR_saveEnvVars( hFile );
        PNHV_EnergyMngmnt_Stat2_AR_saveEnvVars( hFile );
        PNHV_EnergyMngmntSet_Rs1_AR_saveEnvVars( hFile );
        PNHV_EnergyMngmntSet_Rs2_AR_saveEnvVars( hFile );
        PNHV_EnergyMngmntSet_Rs3_AR_saveEnvVars( hFile );
//        PNHV_WeekDepTmTbl_Stat_AR_saveEnvVars( hFile );
        PreCond_CfgStat_AR_saveEnvVars( hFile );
        PresfCtrl_Rq_ESP_AR_saveEnvVars( hFile );
        PSL_L_Stat_AR_saveEnvVars( hFile );  
		PNHV_Bat_Warn_Rq_V2_AR2_saveEnvVars( hFile );
        PNHV_Bat_Warn_Rq_AR_saveEnvVars( hFile );
        PSL_R_Stat_AR_saveEnvVars( hFile );        
        PT_Data_VAN_AR_saveEnvVars( hFile );
        PT_DataContain_Rq_AR_saveEnvVars( hFile );
        PT_Disp_Rq2_AR_saveEnvVars( hFile );
        PtHyb_Mngmnt_Rq_AR_saveEnvVars( hFile );
        PtMngmnt_Disp_Rq_AR_saveEnvVars( hFile );
		Radar_EGO1_Obj_Attr1_AR_saveEnvVars( hFile );
	    RDS_Data_HU_AR_saveEnvVars( hFile );
        RDU_Disp_Rq_AR_saveEnvVars( hFile );
        RTC_Date_Time_AR_saveEnvVars( hFile );
        RTC_Stat1_AR_saveEnvVars( hFile );
        RTC_Stat2_AR_saveEnvVars( hFile );
        RVC_SVS_Park_Stat_AR_saveEnvVars( hFile );
        SBW_DrvPosn_Disp_Rq_ISM_AR_saveEnvVars( hFile );
        SBW_DrvPosn_Disp_Rq_TCM_AR_saveEnvVars( hFile );
	Seat_3L_Stat_AR_saveEnvVars( hFile );
	Seat_3R_Stat_AR_saveEnvVars( hFile );
        Seat_D_Stat_AR_saveEnvVars( hFile );
        Seat_P_Stat_AR_saveEnvVars( hFile );
        Seat_RL_Stat_AR_saveEnvVars( hFile );
        Seat_RR_Stat_AR_saveEnvVars( hFile );
		    SeatCM_D_Stat_HU_AR_saveEnvVars( hFile );
		    SeatCM_P_Stat_HU_AR_saveEnvVars( hFile );
        SeatHtVn_Stat_AR_saveEnvVars( hFile );
        SeatHtVn_Stat2_AR_saveEnvVars( hFile );
		SeatMat_Stat_AR_saveEnvVars( hFile );
        SeatMem_D_Rq_AR_saveEnvVars( hFile );
        SeatPosn_Abs_D_AR_saveEnvVars( hFile );
        SeatPosn_Abs_P_AR_saveEnvVars( hFile );
        SND_GEN_Stat_AR_saveEnvVars( hFile );
		SONAR_A1_AR2_DAI_saveEnvVars( hFile );
		SONAR_A3_AR2_DAI_saveEnvVars( hFile );
		SONAR_A4_AR2_DAI_saveEnvVars( hFile );
        SPC_Disp_Rq_AR_saveEnvVars( hFile );
        SPC_SwLED_Msg_Rq_AR_saveEnvVars( hFile );
        SPV_Ret_Stat_VAN_AR_saveEnvVars( hFile );
        SPV_Disp_Rq_VAN_AR_saveEnvVars( hFile );
        SPV_Disp_Rq2_VAN_AR_saveEnvVars( hFile );
        SPV_Rq_AR_saveEnvVars( hFile );
        SPV_Stat_AR_saveEnvVars( hFile );
		    SPV_Stat_VAN_AR_saveEnvVars( hFile );
        StWhl_Angl_Stat_AR_saveEnvVars( hFile );
        StWhl_OFN_Stat_AR_saveEnvVars( hFile );
        StWhl_Sw_Stat_AR_saveEnvVars( hFile );
        TC_Disp_Rq_ECM_AR_saveEnvVars( hFile );
        TC_Disp_Rq2_AR2_saveEnvVars( hFile );
        TC_EBBC_Disp_Rq_ECM_AR_saveEnvVars( hFile );
        TC_EEBBC_Disp_Rq_AR_saveEnvVars( hFile );
		TC_EEBBC_Energy_Cons_AR_saveEnvVars( hFile );
        TC_EU6_Cons_Disp_Rq_AR_saveEnvVars( hFile );      
        TCM_Disp_Rq_AMG_AR_saveEnvVars( hFile );
        Teleaid_WRN_AR_saveEnvVars( hFile );
//        TP_COM_TGW_Adapt_saveEnvVars( hFile );
//        TP_EIS_IC_SecOdo_saveEnvVars( hFile );
        TP_MPM_TGW_Nav_saveEnvVars( hFile );
        TP_PARK_TGW_saveEnvVars( hFile );
        TP_TELEAID_TGW_saveEnvVars( hFile );
        TP_WPT_IC_saveEnvVars( hFile );
        TP_WPT_TGW_saveEnvVars( hFile );
        Trailer_Stat_AR_saveEnvVars( hFile );
        TSA_Disp_Rq1_AR_saveEnvVars( hFile );
        TSA_Disp_Rq2_AR_saveEnvVars( hFile );
		    TSA_Disp_Rq3_AR_saveEnvVars( hFile );
        Veh_Susp_Adj_AR_saveEnvVars( hFile );
		    VehCarv_Stat_AR_saveEnvVars( hFile );
        VehDyn_Stat1_AR_saveEnvVars( hFile );
        VehDyn_Stat2_AR_saveEnvVars( hFile );
        VehLvl_Stat_AR_saveEnvVars( hFile );
        VehPwrMngmnt_EMM_Stat2_AR_saveEnvVars( hFile );
        DLM_Stat_AR_saveEnvVars( hFile );
        VehSpd_X_AR_saveEnvVars( hFile );
        VIN_AR_saveEnvVars( hFile );
        VTA_Event_Disp_AR_saveEnvVars( hFile );
        Whl_Lt_Stat_AR_saveEnvVars( hFile );
        Whl_Rt_Stat_AR_saveEnvVars( hFile );
        WhlPlsCnt_TPM_AR_saveEnvVars( hFile );
        WIA_EngTrq_AR_saveEnvVars( hFile );
		WMI_Stat_AR_saveEnvVars( hFile );
        Wpr_Stat_AR_saveEnvVars( hFile );
        WPT_Stat2_AR_saveEnvVars( hFile );
// #MSG_SAVEENVVAR_END#

//        APPL_ECU_APM_1_saveEnvVars( hFile );
//        APPL_ECU_APM_2_saveEnvVars( hFile );
//        APPL_ECU_DRVU_1_saveEnvVars( hFile );
//        APPL_ECU_DRVU_2_saveEnvVars( hFile );
        APPL_ECU_HIL_TO_IC1_saveEnvVars( hFile );
//        APPL_ECU_ORC1_saveEnvVars( hFile );
//        APPL_ECU_RVC_SVS1_saveEnvVars( hFile );
//        APPL_ECU_TGW1_saveEnvVars( hFile );
//        NM_APPL_AR_saveEnvVars( hFile );
        NM_xxx_AR_saveEnvVars( hFile );
//        XCP_Rq_DRVU_1_saveEnvVars( hFile );
//        XCP_Rq_DRVU_2_saveEnvVars( hFile );
//        XCP_Rq_RBTM_FL_saveEnvVars( hFile );
//        XCP_Rq_RBTM_FR_saveEnvVars( hFile );
//        XCP_Rq_RVC_SVS_saveEnvVars( hFile );
//        XCP_Rq_TPM_saveEnvVars( hFile );

        fileClose(hFile );
    }
}

on EnvVar HMI__STOP_EIS_MESSAGES_OFF
{
    if( getValue(this) )
    {
// #MSG_OFF#
        putValue( HMI__STMSG_AB_R_Stat_AR, 1 );
        //putValue( HMI__STMSG_Adapt_Seat_D_Stat_AR, 1 );
        putValue( HMI__STMSG_Adblue_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_Adblue_Disp_Warn_Rq_AR, 1 );
        putValue( HMI__STMSG_AQS_Data_HU_AR, 1 );
        putValue( HMI__STMSG_ARB_Stat_AR, 1 );
        putValue( HMI__STMSG_Assyst_Stat_AR, 1 );
        putValue( HMI__STMSG_Assyst_Stat2_AR, 1 );
        putValue( HMI__STMSG_Assyst_Stat3_AR, 1 );
        putValue( HMI__STMSG_AWD_TCASE_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_BC_Stat1_VAN_AR, 1);
		putValue( HMI__STMSG_BC_F_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_BC_F_Stat1_AR, 1 );
        putValue( HMI__STMSG_BC_F_Stat2_AR, 1 );
        putValue( HMI__STMSG_BC_F_Stat4_AR, 1 );
        putValue( HMI__STMSG_BC_R_Stat1_AR, 1 );
        putValue( HMI__STMSG_BC_R_Stat2_AR, 1 );
        putValue( HMI__STMSG_BODY_HMI_R0_AR, 1 );
        putValue( HMI__STMSG_BODY_HMI_R1_AR, 1 );
        putValue( HMI__STMSG_BODY_HMI_R2_AR, 1 );
        putValue( HMI__STMSG_BSM_Disp_Warn_Rq_AR, 1 );
		putValue( HMI__STMSG_BSM_M_Lat_FreeSp_AR, 1 );
		putValue( HMI__STMSG_BSM_S_Lat_FreeSp_AR, 1 );
        putValue( HMI__STMSG_CamLane_Disp_Warn_Rq_AR, 1 );
		putValue( HMI__STMSG_CamLane_LaneAttr2_AR, 1 );
		putValue( HMI__STMSG_LDP_Disp_Rq_AR, 1 );
		putValue( HMI__STMSG_CamLane_LaneAttr6_AR, 1 );
		putValue( HMI__STMSG_CamLane_LaneAttr7_AR, 1 );
//		putValue( HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R1_AR, 1 );
//		putValue( HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R2_AR, 1 );
		putValue( HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R3_AR, 1 );
		putValue( HMI__STMSG_CHASSIS_HMI_Radar_R1_AR, 1 );
		putValue( HMI__STMSG_CHASSIS_HMI_Radar_R2_AR, 1 );
		putValue( HMI__STMSG_CHASSIS_HMI_Radar_R3_AR, 1 );
		putValue( HMI__STMSG_CHASSIS_HMI_Radar_R4_AR, 1 );
		putValue( HMI__STMSG_CHASSIS_HMI_Radar_R5_AR, 1 );
        putValue( HMI__STMSG_CHASSIS_HMI_R0_AR, 1 );
        putValue( HMI__STMSG_CHASSIS_HMI_R1_AR, 1 );
        putValue( HMI__STMSG_CHASSIS_HMI_R2_AR, 1 );
        putValue( HMI__STMSG_CHASSIS_HMI_R3_AR, 1 );
        putValue( HMI__STMSG_CHASSIS_HMI_R4_AR, 1 );
//		putValue( HMI__STMSG_CHASSIS_HMI_R5_AR, 1 );
		putValue( HMI__STMSG_CHASSIS_HMI_DTR_R2_AR, 1 );
        putValue( HMI__STMSG_CHASSISPERIPHERY_HMI_R1_AR, 1 );
		putValue( HMI__STMSG_CHASSISPERIPHERY_HMI_R2_AR, 1 );
        putValue( HMI__STMSG_CLkS_Rq_AR, 1 );
        putValue( HMI__STMSG_CLkS_State_AR, 1 );
        putValue( HMI__STMSG_ClockSync_Stat_AR, 1 );
        putValue( HMI__STMSG_CMS_PI_Sd_Stat_MMR_F1_AR, 1 );
        putValue( HMI__STMSG_CMS_PI_Sd_Stat_MMR_F4_AR, 1 );
        putValue( HMI__STMSG_CMS_PI_Stat_AR, 1 );
        putValue( HMI__STMSG_CNG_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_COM_Call_Stat_AR, 1 );
        putValue( HMI__STMSG_COMM_EIS_WMI_AR, 1 );
		    putValue( HMI__STMSG_COMM_EIS_TGW_AR, 1 );
        putValue( HMI__STMSG_CRCM_Disp_Rq_AR, 1 );
		    putValue( HMI__STMSG_CU_GNSS_Data1_AR, 1 );
        putValue( HMI__STMSG_CU_Pos1_AR, 1 );
        putValue( HMI__STMSG_CU_UTC_AR2, 1 );
		    putValue( HMI__STMSG_CU_Pos2_AR, 1 );
        putValue( HMI__STMSG_CU_RemFunc_Rq3_AR, 1 );
        putValue( HMI__STMSG_D_RQ_GLOBAL_UDS, 1 );
        putValue( HMI__STMSG_D_RQ_IC, 1 );
        putValue( HMI__STMSG_D_RQ_TCO, 1 );
        putValue( HMI__STMSG_DidA_MBContact_State_AR, 1 );
        putValue( HMI__STMSG_Door_FL_Stat_AR, 1 );
        putValue( HMI__STMSG_Door_FR_Stat_AR, 1 );
        putValue( HMI__STMSG_Door_RL_Stat_AR, 1 );
        putValue( HMI__STMSG_Door_RR_Stat_AR, 1 );
        putValue( HMI__STMSG_DPC_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_DPC_IndMd_Stat_AR, 1 );
        putValue( HMI__STMSG_DPC_IndMd_Style_AR, 1 );
        putValue( HMI__STMSG_DPC_IndMd_Style2_AR, 1 );
        putValue( HMI__STMSG_DPC_Master_Rq_AR, 1 );
		putValue( HMI__STMSG_DPC_MdSel_Rs_AMG_AR, 1);
		    putValue( HMI__STMSG_DTQ_Traj_AR, 1 );
		    putValue( HMI__STMSG_DTR_Obj_Attr1_AR, 1 );
		    putValue( HMI__STMSG_DTR_Obj_Attr2_AR, 1 );
		    putValue( HMI__STMSG_DTR_Obj_Attr3_AR, 1 );
        putValue( HMI__STMSG_ECO_Score_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_EL_Ft_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_EL_R_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_EL_Stat_AR, 1 );
        putValue( HMI__STMSG_EL_TurnInd_Rq_AR, 1 );
        putValue( HMI__STMSG_Eng_Data_VAN_AR, 1 );
        putValue( HMI__STMSG_Eng_Rs_EngCtrl_AR, 1 );
        putValue( HMI__STMSG_Eng_Rs2_AR, 1 );
        putValue( HMI__STMSG_EngCtrl_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_EngCtrl_Stat_AR, 1 );
        putValue( HMI__STMSG_EPKB_Disp_IndLmp_Rq_2_AR, 1 );
        putValue( HMI__STMSG_EPS_Stat_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_ESP_ATC_Stat_AMG_AR, 1 );
        putValue( HMI__STMSG_ESP_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_ESP_Disp_Rq2_AR, 1 );
        putValue( HMI__STMSG_ESP_Disp_Rq3_AR, 1 );
        putValue( HMI__STMSG_ESP_Disp_Rq_AMG_AR, 1 );
        putValue( HMI__STMSG_ESP_Stat1_VAN_AR, 1 );
        putValue( HMI__STMSG_EVC_CfgBit_01_32_AR, 1 );
        putValue( HMI__STMSG_EVC_CfgBit_33_64_AR, 1 );
        putValue( HMI__STMSG_EVC_CfgBit_65_96_AR, 1 );
        putValue( HMI__STMSG_EVC_CfgBit_97_C8_AR, 1 );
        putValue( HMI__STMSG_EVC_CfgList_01_0C_AR, 1 );
        putVAlue( HMI__STMSG_EVC_CfgVAN_AR, 1 );
		    putValue( HMI__STMSG_ExitWarn_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_FBL_CFG_Star2_AR, 1 );
        putValue( HMI__STMSG_FCW_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_FDC_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_FlashOverTheAir_Stat_AR, 1 );
        putValue( HMI__STMSG_Fuel_Stat2_AR, 1 );
        putValue( HMI__STMSG_FuelLvl_Stat_AR, 1 );
        putValue( HMI__STMSG_FWLP_D_AR, 1 );
        putValue( HMI__STMSG_FWLP_P_AR, 1 );
		putValue( HMI__STMSG_HAD_MDC_CamLane_MapLrn_Attr1_AR, 1 );
		putValue( HMI__STMSG_HAD_MDC_CamObj_MapLrn_Attr1_AR, 1 );
		putValue( HMI__STMSG_HAD_MDC_MapData2_AR, 1 );
		putValue( HMI__STMSG_HAD_MDC_MapLrn_Attr1_AR, 1 );
		putValue( HMI__STMSG_HAD_MDC_TSR_Sign_Attr1_AR, 1 );
		putValue( HMI__STMSG_HAD_MDC_TSR_Sign_Attr2_AR, 1 );
		putValue( HMI__STMSG_HMIG_Stat_AR, 1 );
        putValue( HMI__STMSG_HumanMachineIfc_AR, 1 );
		    putValue( HMI__STMSG_HumanMachineIfc2_AR, 1 );
        putValue( HMI__STMSG_HumanMachineIfc_Rq_AR, 1 );
        putValue( HMI__STMSG_HVAC_Disp_Stat1_AR, 1 );
        putValue( HMI__STMSG_HVAC_Disp_Stat2_AR, 1 );
        putValue( HMI__STMSG_HVAC_Disp_Stat3_AR, 1 );
		    putValue( HMI__STMSG_HVAC_Disp_Stat4_AR, 1 );
        putValue( HMI__STMSG_HVAC_State1_AR, 1 );
        putValue( HMI__STMSG_ICH_PreTime_Stat_AR, 1 );
        putValue( HMI__STMSG_ICH_Stat_AR, 1 );
        putValue( HMI__STMSG_Ign_Veh_Stat_AR, 1 );
        putValue( HMI__STMSG_IHC_Lgt_Stat_MPC_AR, 1 );
        putValue( HMI__STMSG_IL_AmbLgt_Disp_AR, 1 );
        putValue( HMI__STMSG_IL_AmbLgtCfg_Stat_AR, 1 );
        putValue( HMI__STMSG_IL_AmbLgtCfg_Stat2_AR, 1 );
        putValue( HMI__STMSG_IL_Stat2_AR,1 );
        putValue( HMI__STMSG_Immobilizer_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_Immobilizer_IC_AR, 1 );
        putValue( HMI__STMSG_Immobilizer_KeyID_AR, 1 );
        putValue( HMI__STMSG_KEP_MODE_DISP_RQ, 1 );
        putValue( HMI__STMSG_KG_Msg_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_KG_State_AR, 1 );
        putValue( HMI__STMSG_LDC_Disp_Rq_ESP_AR, 1 );
        putValue( HMI__STMSG_LDC_Disp_Rq_RDU_AR, 1 );
		    putValue( HMI__STMSG_LDC_Disp_Rq2_RDU_AR, 1 );
        putValue( HMI__STMSG_LDP_Warn_Rq_AR, 1 );
        putValue( HMI__STMSG_LgtSens_State_AR, 1 );
        putValue( HMI__STMSG_MCMS_FL_AR, 1 );
        putValue( HMI__STMSG_MCMS_FL_Stat_AR, 1 );
        putValue( HMI__STMSG_MCMS_FR_AR, 1 );
        putValue( HMI__STMSG_MCMS_FR_Stat_AR, 1 );
        putValue( HMI__STMSG_MCMS_RL_AR, 1 );
        putValue( HMI__STMSG_MCMS_RL_Stat_AR, 1 );
        putValue( HMI__STMSG_MCMS_RR_AR, 1 );
        putValue( HMI__STMSG_MCMS_RR_Stat_AR, 1 );
        putValue( HMI__STMSG_OffRoad_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_Park_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_Park_Set_Stat_AR, 1 );
        putValue( HMI__STMSG_ParkSpaceMeas_Stat_AR, 1 );
        putValue( HMI__STMSG_Park_Stat_AR, 1 );
		    putValue( HMI__STMSG_ParkSpace_Posn_AR, 1 );
        putValue( HMI__STMSG_ParkWarn_AR, 1 );
        putValue( HMI__STMSG_PERIPHERY_HMI_R1_AR, 1 );
        putValue( HMI__STMSG_PN14_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_PN14_Disp_Rq2_AR, 1 );
        putValue( HMI__STMSG_PN14_Stat_AR, 1 );
		    putValue( HMI__STMSG_PN14_Stat_VAN_AR, 1 );
        putValue( HMI__STMSG_PN48_Bat_Stat_AR, 1 );
        putValue( HMI__STMSG_PN48_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_PnHt_Stat_AR, 1 );
        putValue( HMI__STMSG_PNHV_Disp_Rq1_AR, 1 );
        putValue( HMI__STMSG_PNHV_Disp_Rq2_AR, 1 );
        putValue( HMI__STMSG_PNHV_EnergyMngmnt_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_PNHV_EnergyMngmnt_Stat2_AR, 1 );
        putValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs1_AR, 1 );
        putValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs2_AR, 1 );
        putValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs3_AR, 1 );
        putValue( HMI__STMSG_PNHV_WeekDepTmTbl_Stat_AR, 1 );
        putValue( HMI__STMSG_PNHV_Stat_VAN_AR, 1 );
        putValue( HMI__STMSG_OBWlight_Message_VAN_AR, 1 );
        putValue( HMI__STMSG_Tire_temp_VAN_AR, 1 );
        putValue( HMI__STMSG_PreCond_CfgStat_AR, 1 );
        putValue( HMI__STMSG_PresfCtrl_Rq_ESP_AR, 1 );
        putValue( HMI__STMSG_PSL_L_Stat_AR, 1 );
		putValue( HMI__STMSG_PNHV_Bat_Warn_Rq_V2_AR2, 1 );
        putValue( HMI__STMSG_PNHV_Bat_Warn_Rq_AR, 1 );
        putValue( HMI__STMSG_PSL_R_Stat_AR, 1 );
        putValue( HMI__STMSG_PT_Data_VAN_AR, 1 );
        putValue( HMI__STMSG_PT_DataContain_Rq_AR, 1 );
        putValue( HMI__STMSG_PT_Disp_Rq2_AR, 1 );
        putValue( HMI__STMSG_PtHyb_Mngmnt_Rq_AR, 1 );
        putValue( HMI__STMSG_PtMngmnt_Disp_Rq_AR, 1 );
		putValue( HMI__STMSG_Radar_EGO1_Obj_Attr1_AR, 1 );
        putValue( HMI__STMSG_RDS_Data_HU_AR, 1 );
        putValue( HMI__STMSG_RDU_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_RTC_Date_Time_AR, 1 );
        putValue( HMI__STMSG_RTC_Stat1_AR, 1 );
        putValue( HMI__STMSG_RTC_Stat2_AR, 1 );
        putValue( HMI__STMSG_RVC_SVS_Park_Stat_AR, 1 );
        putValue( HMI__STMSG_SBW_DrvPosn_Disp_Rq_ISM_AR, 1 );
        putValue( HMI__STMSG_SBW_DrvPosn_Disp_Rq_TCM_AR, 1 );
	putValue( HMI__STMSG_Seat_3L_Stat_AR, 1 );
	putValue( HMI__STMSG_Seat_3R_Stat_AR, 1 );
        putValue( HMI__STMSG_Seat_D_Stat_AR, 1 );
        putValue( HMI__STMSG_Seat_P_Stat_AR, 1 );
        putValue( HMI__STMSG_Seat_RL_Stat_AR, 1 );
        putValue( HMI__STMSG_Seat_RR_Stat_AR, 1 );
		    putValue( HMI__STMSG_SeatCM_D_Stat_HU_AR, 1 );
		    putValue( HMI__STMSG_SeatCM_P_Stat_HU_AR, 1 );
        putValue( HMI__STMSG_SeatHtVn_Stat_AR, 1 );
        putValue( HMI__STMSG_SeatHtVn_Stat2_AR, 1 );
		putValue( HMI__STMSG_SeatMat_Stat_AR, 1 );
        putValue( HMI__STMSG_SeatMem_D_Rq_AR, 1 );
        putValue( HMI__STMSG_SeatPosn_Abs_D_AR, 1 );
        putValue( HMI__STMSG_SeatPosn_Abs_P_AR, 1 );
        putValue( HMI__STMSG_SND_GEN_Stat_AR, 1 );
		putValue( HMI__STMSG_SONAR_A1_AR2_DAI, 1 );
		putValue( HMI__STMSG_SONAR_A3_AR2_DAI, 1 );
		putValue( HMI__STMSG_SONAR_A4_AR2_DAI, 1 );
        putValue( HMI__STMSG_SPC_Disp_Rq_AR, 1 );
        putValue( HMI__STMSG_SPC_SwLED_Msg_Rq_AR, 1 );
        putValue( HMI__STMSG_SPV_Ret_Stat_VAN_AR, 1 );
        putValue( HMI__STMSG_SPV_Disp_Rq_VAN_AR, 1 );
        putValue( HMI__STMSG_SPV_Disp_Rq2_VAN_AR, 1 );
        putValue( HMI__STMSG_SPV_Rq_AR, 1 );
        putValue( HMI__STMSG_SPV_Stat_AR, 1 );
		    putValue( HMI__STMSG_SPV_Stat_VAN_AR, 1 );
        putValue( HMI__STMSG_StWhl_Angl_Stat_AR, 1 );
        putValue( HMI__STMSG_StWhl_OFN_Stat_AR, 1 );
        putValue( HMI__STMSG_StWhl_Sw_Stat_AR, 1 );
        putValue( HMI__STMSG_TC_Disp_Rq_ECM_AR, 1 );
        putValue( HMI__STMSG_TC_Disp_Rq2_AR2, 1 );
        putValue( HMI__STMSG_TC_EBBC_Disp_Rq_ECM_AR, 1 );
        putValue( HMI__STMSG_TC_EEBBC_Disp_Rq_AR, 1 );
		putValue( HMI__STMSG_TC_EEBBC_Energy_Cons_AR, 1 );
        putValue( HMI__STMSG_TC_EU6_Cons_Disp_Rq_AR, 1 );      
        putValue( HMI__STMSG_TCM_Disp_Rq_AMG_AR, 1 );
        putValue( HMI__STMSG_Teleaid_WRN_AR, 1 );
//        putValue( HMI__STMSG_TP_COM_TGW_Adapt, 1 );
        putValue( HMI__STMSG_TP_EIS_IC_SecOdo, 1 );
        putValue( HMI__STMSG_TP_MPM_TGW_Nav, 1 );
        putValue( HMI__STMSG_TP_PARK_TGW, 1 );
        putValue( HMI__STMSG_TP_TELEAID_TGW, 1 );
        putValue( HMI__STMSG_TP_WPT_IC, 1 );
        putValue( HMI__STMSG_TP_WPT_TGW, 1 );
        putValue( HMI__STMSG_Trailer_Stat_AR, 1 );
        putValue( HMI__STMSG_TSA_Disp_Rq1_AR, 1 );
        putValue( HMI__STMSG_TSA_Disp_Rq2_AR, 1 );
		    putValue( HMI__STMSG_TSA_Disp_Rq3_AR, 1 );
        putValue( HMI__STMSG_Veh_Susp_Adj_AR, 1 );
		    putValue( HMI__STMSG_VehCarv_Stat_AR, 1 );
        putValue( HMI__STMSG_VehDyn_Stat1_AR, 1 );
        putValue( HMI__STMSG_VehDyn_Stat2_AR, 1 );
        putValue( HMI__STMSG_VehLvl_Stat_AR, 1 );
        putValue( HMI__STMSG_VehPwrMngmnt_EMM_Stat2_AR, 1 );
        putValue( HMI__STMSG_DLM_Stat_AR, 1 );
        putValue( HMI__STMSG_VehSpd_X_AR, 1 );
        putValue( HMI__STMSG_VIN_AR, 1 );
        putValue( HMI__STMSG_VTA_Event_Disp_AR, 1 );
        putValue( HMI__STMSG_Whl_Lt_Stat_AR, 1 );
        putValue( HMI__STMSG_Whl_Rt_Stat_AR, 1 );
        putValue( HMI__STMSG_WhlPlsCnt_TPM_AR, 1 );
        putValue( HMI__STMSG_WIA_EngTrq_AR, 1 );
		putValue( HMI__STMSG_WMI_Stat_AR, 1 );
        putValue( HMI__STMSG_Wpr_Stat_AR, 1 );
        putValue( HMI__STMSG_WPT_Stat2_AR, 1 );
// #MSG_OFF_END#

//        putValue( HMI__STMSG_APPL_ECU_APM_1, 1 );
//        putValue( HMI__STMSG_APPL_ECU_APM_2, 1 );
//        putValue( HMI__STMSG_APPL_ECU_DRVU_1, 1 );
//        putValue( HMI__STMSG_APPL_ECU_DRVU_2, 1 );
//        putValue( HMI__STMSG_APPL_ECU_HIL_TO_IC1, 1 );   only on event
//        putValue( HMI__STMSG_APPL_ECU_ORC1, 1 );
//        putValue( HMI__STMSG_APPL_ECU_RVC_SVS1, 1 );
//        putValue( HMI__STMSG_APPL_ECU_TGW1, 1 );
//        putValue( HMI__STMSG_NM_APPL_AR, 1 );
        putValue( HMI__STMSG_NM_EIS_AR, 1 );
//        putValue( HMI__STMSG_XCP_Rq_DRVU_1, 1 );
//        putValue( HMI__STMSG_XCP_Rq_DRVU_2, 1 );
//        putValue( HMI__STMSG_XCP_Rq_RBTM_FL, 1 );
//        putValue( HMI__STMSG_XCP_Rq_RBTM_FR, 1 );
//        putValue( HMI__STMSG_XCP_Rq_RVC_SVS, 1 );
//        putValue( HMI__STMSG_XCP_Rq_TPM, 1 );
    }
}

on envVar HMI__STOP_EIS_MESSAGES_ON
{
    if( getValue(this) )
    {
// #MSG_ON#
        putValue( HMI__STMSG_AB_R_Stat_AR, 0 );
        //putValue( HMI__STMSG_Adapt_Seat_D_Stat_AR, 0 );
        putValue( HMI__STMSG_Adblue_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_Adblue_Disp_Warn_Rq_AR, 0 );
        putValue( HMI__STMSG_AQS_Data_HU_AR, 0 );
        putValue( HMI__STMSG_ARB_Stat_AR, 0 );
        putValue( HMI__STMSG_Assyst_Stat_AR, 0 );
        putValue( HMI__STMSG_Assyst_Stat2_AR, 0 );
        putValue( HMI__STMSG_Assyst_Stat3_AR, 0 );
        putValue( HMI__STMSG_AWD_TCASE_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_BC_Stat1_VAN_AR, 0);
		putValue( HMI__STMSG_BC_F_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_BC_F_Stat1_AR, 0 );
        putValue( HMI__STMSG_BC_F_Stat2_AR, 0 );
        putValue( HMI__STMSG_BC_F_Stat4_AR, 0 );
        putValue( HMI__STMSG_BC_R_Stat1_AR, 0 );
        putValue( HMI__STMSG_BC_R_Stat2_AR, 0 );
        putValue( HMI__STMSG_BODY_HMI_R0_AR, 0 );
        putValue( HMI__STMSG_BODY_HMI_R1_AR, 0 );
        putValue( HMI__STMSG_BODY_HMI_R2_AR, 0 );
        putValue( HMI__STMSG_BSM_Disp_Warn_Rq_AR, 0 );
		putValue( HMI__STMSG_BSM_M_Lat_FreeSp_AR, 0 );
		putValue( HMI__STMSG_BSM_S_Lat_FreeSp_AR, 0 );
        putValue( HMI__STMSG_CamLane_Disp_Warn_Rq_AR, 0 );
		putValue( HMI__STMSG_CamLane_LaneAttr2_AR, 0 );
		putValue( HMI__STMSG_LDP_Disp_Rq_AR, 0 );
		putValue( HMI__STMSG_CamLane_LaneAttr6_AR, 0 );
		putValue( HMI__STMSG_CamLane_LaneAttr7_AR, 0 );
//		    putValue( HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R1_AR, 0 );
//		    putValue( HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R2_AR, 0 );
		    putValue( HMI__STMSG_CHASS_PERIPH_HMI_Camlane_R3_AR, 0 );
		    putValue( HMI__STMSG_CHASSIS_HMI_Radar_R1_AR, 0 );
		    putValue( HMI__STMSG_CHASSIS_HMI_Radar_R2_AR, 0 );
		    putValue( HMI__STMSG_CHASSIS_HMI_Radar_R3_AR, 0 );
		    putValue( HMI__STMSG_CHASSIS_HMI_Radar_R4_AR, 0 );
		    putValue( HMI__STMSG_CHASSIS_HMI_Radar_R5_AR, 0 );
        putValue( HMI__STMSG_CHASSIS_HMI_R0_AR, 0 );
        putValue( HMI__STMSG_CHASSIS_HMI_R1_AR, 0 );
        putValue( HMI__STMSG_CHASSIS_HMI_R2_AR, 0 );
        putValue( HMI__STMSG_CHASSIS_HMI_R3_AR, 0 );
        putValue( HMI__STMSG_CHASSIS_HMI_R4_AR, 0 );
//		putValue( HMI__STMSG_CHASSIS_HMI_R5_AR, 0 );
		putValue( HMI__STMSG_CHASSIS_HMI_DTR_R2_AR, 0 );
        putValue( HMI__STMSG_CHASSISPERIPHERY_HMI_R1_AR, 0 );
		    putValue( HMI__STMSG_CHASSISPERIPHERY_HMI_R2_AR, 0 );
        putValue( HMI__STMSG_CLkS_Rq_AR, 0 );
        putValue( HMI__STMSG_CLkS_State_AR, 0 );
        putValue( HMI__STMSG_ClockSync_Stat_AR, 0 );
        putValue( HMI__STMSG_CMS_PI_Sd_Stat_MMR_F1_AR, 0 );
        putValue( HMI__STMSG_CMS_PI_Sd_Stat_MMR_F4_AR, 0 );
        putValue( HMI__STMSG_CMS_PI_Stat_AR, 0 );
        putValue( HMI__STMSG_CNG_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_COM_Call_Stat_AR, 0 );
        putValue( HMI__STMSG_COMM_EIS_WMI_AR, 0 );
		    putValue( HMI__STMSG_COMM_EIS_TGW_AR, 0 );
        putValue( HMI__STMSG_CRCM_Disp_Rq_AR, 0 );
		    putValue( HMI__STMSG_CU_GNSS_Data1_AR, 0 );  
        putValue( HMI__STMSG_CU_Pos1_AR, 0 );
        putValue( HMI__STMSG_CU_UTC_AR2, 0 );
		    putValue( HMI__STMSG_CU_Pos2_AR, 0 );
        putValue( HMI__STMSG_CU_RemFunc_Rq3_AR, 0 );
        putValue( HMI__STMSG_D_RQ_GLOBAL_UDS, 0 );
        putValue( HMI__STMSG_D_RQ_IC, 0 );
        putValue( HMI__STMSG_D_RQ_TCO, 0 );
        putValue( HMI__STMSG_DidA_MBContact_State_AR, 0 );
        putValue( HMI__STMSG_Door_FL_Stat_AR, 0 );
        putValue( HMI__STMSG_Door_FR_Stat_AR, 0 );
        putValue( HMI__STMSG_Door_RL_Stat_AR, 0 );
        putValue( HMI__STMSG_Door_RR_Stat_AR, 0 );
        putValue( HMI__STMSG_DPC_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_DPC_IndMd_Stat_AR, 0 );
        putValue( HMI__STMSG_DPC_IndMd_Style_AR, 0 );
        putValue( HMI__STMSG_DPC_IndMd_Style2_AR, 0 );
        putValue( HMI__STMSG_DPC_Master_Rq_AR, 0 );
		putValue( HMI__STMSG_DPC_MdSel_Rs_AMG_AR, 0 );
		    putValue( HMI__STMSG_DTQ_Traj_AR, 0 );
		    putValue( HMI__STMSG_DTR_Obj_Attr1_AR, 0 );
		    putValue( HMI__STMSG_DTR_Obj_Attr2_AR, 0 );
		    putValue( HMI__STMSG_DTR_Obj_Attr3_AR, 0 );
        putValue( HMI__STMSG_ECO_Score_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_EL_Ft_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_EL_R_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_EL_Stat_AR, 0 );
        putValue( HMI__STMSG_EL_TurnInd_Rq_AR, 0 );
        putValue( HMI__STMSG_Eng_Data_VAN_AR, 0 );
        putValue( HMI__STMSG_Eng_Rs_EngCtrl_AR, 0 );
        putValue( HMI__STMSG_Eng_Rs2_AR, 0 );
        putValue( HMI__STMSG_EngCtrl_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_EngCtrl_Stat_AR, 0 );
        putValue( HMI__STMSG_EPKB_Disp_IndLmp_Rq_2_AR, 0 );
        putValue( HMI__STMSG_EPS_Stat_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_ESP_ATC_Stat_AMG_AR, 0 );
        putValue( HMI__STMSG_ESP_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_ESP_Disp_Rq2_AR, 0 );
        putValue( HMI__STMSG_ESP_Disp_Rq3_AR, 0 );
        putValue( HMI__STMSG_ESP_Disp_Rq_AMG_AR, 0 );
        putValue( HMI__STMSG_ESP_Stat1_VAN_AR, 0 );
        putValue( HMI__STMSG_EVC_CfgBit_01_32_AR, 0 );
        putValue( HMI__STMSG_EVC_CfgBit_33_64_AR, 0 );
        putValue( HMI__STMSG_EVC_CfgBit_65_96_AR, 0 );
        putValue( HMI__STMSG_EVC_CfgBit_97_C8_AR, 0 );
        putValue( HMI__STMSG_EVC_CfgList_01_0C_AR, 0 );
        putValue( HMI__STMSG_EVC_CfgVAN_AR, 0 );
		    putValue( HMI__STMSG_ExitWarn_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_FBL_CFG_Star2_AR, 0 );
        putValue( HMI__STMSG_FCW_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_FDC_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_FlashOverTheAir_Stat_AR, 0 );
        putValue( HMI__STMSG_Fuel_Stat2_AR, 0 );
        putValue( HMI__STMSG_FuelLvl_Stat_AR, 0 );
        putValue( HMI__STMSG_FWLP_D_AR, 0 );
        putValue( HMI__STMSG_FWLP_P_AR, 0 );
		putValue( HMI__STMSG_HAD_MDC_CamLane_MapLrn_Attr1_AR, 0 );
		putValue( HMI__STMSG_HAD_MDC_CamObj_MapLrn_Attr1_AR, 0 );
		putValue( HMI__STMSG_HAD_MDC_MapData2_AR, 0 );
		putValue( HMI__STMSG_HAD_MDC_MapLrn_Attr1_AR, 0 );
		putValue( HMI__STMSG_HAD_MDC_TSR_Sign_Attr1_AR, 0 );
		putValue( HMI__STMSG_HAD_MDC_TSR_Sign_Attr2_AR, 0 );
		putValue( HMI__STMSG_HMIG_Stat_AR, 0 );
        putValue( HMI__STMSG_HumanMachineIfc_AR, 0 );
		    putValue( HMI__STMSG_HumanMachineIfc2_AR, 0 );
        putValue( HMI__STMSG_HumanMachineIfc_Rq_AR, 0 );
        putValue( HMI__STMSG_HVAC_Disp_Stat1_AR, 0 );
        putValue( HMI__STMSG_HVAC_Disp_Stat2_AR, 0 );
        putValue( HMI__STMSG_HVAC_Disp_Stat3_AR, 0 );
		    putValue( HMI__STMSG_HVAC_Disp_Stat4_AR, 0 );
        putValue( HMI__STMSG_HVAC_State1_AR, 0 );
        putValue( HMI__STMSG_ICH_PreTime_Stat_AR, 0 );
        putValue( HMI__STMSG_ICH_Stat_AR, 0 );
        putValue( HMI__STMSG_Ign_Veh_Stat_AR, 0 );
        putValue( HMI__STMSG_IHC_Lgt_Stat_MPC_AR, 0 );
        putValue( HMI__STMSG_IL_AmbLgt_Disp_AR, 0 );
        putValue( HMI__STMSG_IL_AmbLgtCfg_Stat_AR, 0 );
        putValue( HMI__STMSG_IL_AmbLgtCfg_Stat2_AR, 0 );
        putValue( HMI__STMSG_IL_Stat2_AR, 0 );
        putValue( HMI__STMSG_Immobilizer_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_Immobilizer_IC_AR, 0 );
        putValue( HMI__STMSG_Immobilizer_KeyID_AR, 0 );
        putValue( HMI__STMSG_KEP_MODE_DISP_RQ, 0 );
        putValue( HMI__STMSG_KG_Msg_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_KG_State_AR, 0 );
        putValue( HMI__STMSG_LDC_Disp_Rq_ESP_AR, 0 );
		    putValue( HMI__STMSG_LDC_Disp_Rq2_ESP_AR, 0 );
        putValue( HMI__STMSG_LDC_Disp_Rq_RDU_AR, 0 );
		    putValue( HMI__STMSG_LDC_Disp_Rq2_RDU_AR, 0 );
        putValue( HMI__STMSG_LDP_Warn_Rq_AR, 0 );
        putValue( HMI__STMSG_LgtSens_State_AR, 0 );
        putValue( HMI__STMSG_MCMS_FL_AR, 0 );
        putValue( HMI__STMSG_MCMS_FL_Stat_AR, 0 );
        putValue( HMI__STMSG_MCMS_FR_AR, 0 );
        putValue( HMI__STMSG_MCMS_FR_Stat_AR, 0 );
        putValue( HMI__STMSG_MCMS_RL_AR, 0 );
        putValue( HMI__STMSG_MCMS_RL_Stat_AR, 0 );
        putValue( HMI__STMSG_MCMS_RR_AR, 0 );
        putValue( HMI__STMSG_MCMS_RR_Stat_AR, 0 );
        putValue( HMI__STMSG_OffRoad_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_Park_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_Park_Set_Stat_AR, 0 );
        putValue( HMI__STMSG_ParkSpaceMeas_Stat_AR, 0 );
        putValue( HMI__STMSG_Park_Stat_AR, 0 );
		    putValue( HMI__STMSG_ParkSpace_Posn_AR, 0 );
        putValue( HMI__STMSG_ParkWarn_AR, 0 );
        putValue( HMI__STMSG_PERIPHERY_HMI_R1_AR, 0 );
        putValue( HMI__STMSG_PN14_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_PN14_Disp_Rq2_AR, 0 );
        putValue( HMI__STMSG_PN14_Stat_AR, 0 );
		    putValue( HMI__STMSG_PN14_Stat_VAN_AR, 0 );
        putValue( HMI__STMSG_PN48_Bat_Stat_AR, 0 );
        putValue( HMI__STMSG_PN48_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_PnHt_Stat_AR, 0 );
        putValue( HMI__STMSG_PNHV_Disp_Rq1_AR, 0 );
        putValue( HMI__STMSG_PNHV_Disp_Rq2_AR, 0 );
        putValue( HMI__STMSG_PNHV_EnergyMngmnt_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_PNHV_EnergyMngmnt_Stat2_AR, 0 );
        putValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs1_AR, 0 );
        putValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs2_AR, 0 );
        putValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs3_AR, 0 );
        putValue( HMI__STMSG_PNHV_WeekDepTmTbl_Stat_AR, 0 );
        putValue( HMI__STMSG_PNHV_Stat_VAN_AR, 0 );
        putValue( HMI__STMSG_OBWlight_Message_VAN_AR, 0 );
        putValue( HMI__STMSG_Tire_temp_VAN_AR, 0 );
        putValue( HMI__STMSG_PreCond_CfgStat_AR, 0 );
        putValue( HMI__STMSG_PresfCtrl_Rq_ESP_AR, 0 );
        putValue( HMI__STMSG_PSL_L_Stat_AR, 0 );
		putValue( HMI__STMSG_PNHV_Bat_Warn_Rq_V2_AR2, 0 );
        putValue( HMI__STMSG_PNHV_Bat_Warn_Rq_AR, 0 );
        putValue( HMI__STMSG_PSL_R_Stat_AR, 0 );
        putValue( HMI__STMSG_PT_Data_VAN_AR, 0  );
        putValue( HMI__STMSG_PT_DataContain_Rq_AR, 0 );
        putValue( HMI__STMSG_PT_Disp_Rq2_AR, 0 );
        putValue( HMI__STMSG_PtHyb_Mngmnt_Rq_AR, 0 );
        putValue( HMI__STMSG_PtMngmnt_Disp_Rq_AR, 0 );
		putValue( HMI__STMSG_Radar_EGO1_Obj_Attr1_AR, 0 );
        putValue( HMI__STMSG_RDS_Data_HU_AR, 0 );
		putValue( HMI__STMSG_RDU_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_RTC_Date_Time_AR, 0 );
        putValue( HMI__STMSG_RTC_Stat1_AR, 0 );
        putValue( HMI__STMSG_RTC_Stat2_AR, 0 );
        putValue( HMI__STMSG_RVC_SVS_Park_Stat_AR, 0 );
        putValue( HMI__STMSG_SBW_DrvPosn_Disp_Rq_ISM_AR, 0 );
        putValue( HMI__STMSG_SBW_DrvPosn_Disp_Rq_TCM_AR, 0 );
	putValue( HMI__STMSG_Seat_3L_Stat_AR, 0 );
	putValue( HMI__STMSG_Seat_3R_Stat_AR, 0 );
        putValue( HMI__STMSG_Seat_D_Stat_AR, 0 );
        putValue( HMI__STMSG_Seat_P_Stat_AR, 0 );
        putValue( HMI__STMSG_Seat_RL_Stat_AR, 0 );
        putValue( HMI__STMSG_Seat_RR_Stat_AR, 0 );
		    putValue( HMI__STMSG_SeatCM_D_Stat_HU_AR, 0 );
		    putValue( HMI__STMSG_SeatCM_P_Stat_HU_AR, 0 );
        putValue( HMI__STMSG_SeatHtVn_Stat_AR, 0 );
        putValue( HMI__STMSG_SeatHtVn_Stat2_AR, 0 );
		putValue( HMI__STMSG_SeatMat_Stat_AR, 0 );
        putValue( HMI__STMSG_SeatMem_D_Rq_AR, 0 );
        putValue( HMI__STMSG_SeatPosn_Abs_D_AR, 0 );
        putValue( HMI__STMSG_SeatPosn_Abs_P_AR, 0 );
        putValue( HMI__STMSG_SND_GEN_Stat_AR, 0 );
		putValue( HMI__STMSG_SONAR_A1_AR2_DAI, 0 );
		putValue( HMI__STMSG_SONAR_A3_AR2_DAI, 0 );
		putValue( HMI__STMSG_SONAR_A4_AR2_DAI, 0 );
        putValue( HMI__STMSG_SPC_Disp_Rq_AR, 0 );
        putValue( HMI__STMSG_SPC_SwLED_Msg_Rq_AR, 0 );
        putValue( HMI__STMSG_SPV_Ret_Stat_VAN_AR, 0 );
        putValue( HMI__STMSG_SPV_Disp_Rq_VAN_AR, 0 );
        putValue( HMI__STMSG_SPV_Disp_Rq2_VAN_AR, 0 );
        putValue( HMI__STMSG_SPV_Rq_AR, 0 );
        putValue( HMI__STMSG_SPV_Stat_AR, 0 );
		    putValue( HMI__STMSG_SPV_Stat_VAN_AR, 0 );
        putValue( HMI__STMSG_StWhl_Angl_Stat_AR, 0 );
        putValue( HMI__STMSG_StWhl_OFN_Stat_AR, 0 );
        putValue( HMI__STMSG_StWhl_Sw_Stat_AR, 0 );
        putValue( HMI__STMSG_TC_Disp_Rq_ECM_AR, 0 );
        putValue( HMI__STMSG_TC_Disp_Rq2_AR2, 0 );
        putValue( HMI__STMSG_TC_EBBC_Disp_Rq_ECM_AR, 0 );
        putValue( HMI__STMSG_TC_EEBBC_Disp_Rq_AR, 0 );
		putValue( HMI__STMSG_TC_EEBBC_Energy_Cons_AR, 0 );
        putValue( HMI__STMSG_TC_EU6_Cons_Disp_Rq_AR, 0 );      
        putValue( HMI__STMSG_TCM_Disp_Rq_AMG_AR, 0 );
        putValue( HMI__STMSG_Teleaid_WRN_AR, 0 );
//        putValue( HMI__STMSG_TP_COM_TGW_Adapt, 0 );
        putValue( HMI__STMSG_TP_EIS_IC_SecOdo, 0 );
        putValue( HMI__STMSG_TP_MPM_TGW_Nav, 0 );
        putValue( HMI__STMSG_TP_PARK_TGW, 0 );
        putValue( HMI__STMSG_TP_TELEAID_TGW, 0 );
        putValue( HMI__STMSG_TP_WPT_IC, 1 );
        putValue( HMI__STMSG_TP_WPT_TGW, 1 );
        putValue( HMI__STMSG_Trailer_Stat_AR, 0 );
        putValue( HMI__STMSG_TSA_Disp_Rq1_AR, 0 );
        putValue( HMI__STMSG_TSA_Disp_Rq2_AR, 0 );
		    putValue( HMI__STMSG_TSA_Disp_Rq3_AR, 0 );
        putValue( HMI__STMSG_Veh_Susp_Adj_AR, 0 );
        putValue( HMI__STMSG_VehDyn_Stat1_AR, 0 );
        putValue( HMI__STMSG_VehDyn_Stat2_AR, 0 );
        putValue( HMI__STMSG_VehLvl_Stat_AR, 0 );
        putValue( HMI__STMSG_DLM_Stat_AR, 0 );
        putValue( HMI__STMSG_VehPwrMngmnt_EMM_Stat2_AR, 0 );
        putValue( HMI__STMSG_VehSpd_X_AR, 0 );
        putValue( HMI__STMSG_VIN_AR, 0 );
        putValue( HMI__STMSG_VTA_Event_Disp_AR, 0 );
        putValue( HMI__STMSG_Whl_Lt_Stat_AR, 0 );
        putValue( HMI__STMSG_Whl_Rt_Stat_AR, 0 );
        putValue( HMI__STMSG_WhlPlsCnt_TPM_AR, 0 );
        putValue( HMI__STMSG_WIA_EngTrq_AR, 0 );
		putValue( HMI__STMSG_WMI_Stat_AR, 0 );
        putValue( HMI__STMSG_Wpr_Stat_AR, 0 );
        putValue( HMI__STMSG_WPT_Stat2_AR, 0 );
        putValue( HMI__STMSG_PNHV_Energy_Rq_AR, 0 );
        putValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs3_AR, 0 );
// #MSG_ON_END#

//        putValue( HMI__STMSG_APPL_ECU_APM_1, 0 );
//        putValue( HMI__STMSG_APPL_ECU_APM_2, 0 );
//        putValue( HMI__STMSG_APPL_ECU_DRVU_1, 0 );
//        putValue( HMI__STMSG_APPL_ECU_DRVU_2, 0 );
        putValue( HMI__STMSG_APPL_ECU_HIL_TO_IC1, 0 );
//        putValue( HMI__STMSG_APPL_ECU_ORC1, 0 );
//        putValue( HMI__STMSG_APPL_ECU_RVC_SVS1, 0 );
//        putValue( HMI__STMSG_APPL_ECU_TGW1, 0 );
//        putValue( HMI__STMSG_NM_APPL_AR, 0 );
        putValue( HMI__STMSG_NM_EIS_AR, 0 );
//        putValue( HMI__STMSG_XCP_Rq_DRVU_1, 0 );
//        putValue( HMI__STMSG_XCP_Rq_DRVU_2, 0 );
//        putValue( HMI__STMSG_XCP_Rq_RBTM_FL, 0 );
//        putValue( HMI__STMSG_XCP_Rq_RBTM_FR, 0 );
//        putValue( HMI__STMSG_XCP_Rq_RVC_SVS, 0 );
//        putValue( HMI__STMSG_XCP_Rq_TPM, 0 );
    }
}

on EnvVar HMI__STOP_All_MESSAGES_OFF
{
    if( getValue(this) )
    {
        putValue( HMI__STOP_DRVU_MESSAGES_OFF, 1 );
        putValue( HMI__STOP_EIS_MESSAGES_OFF, 1 );
        putValue( HMI__STOP_HUD_MESSAGES_OFF, 1 );
        putValue( HMI__STOP_IC_MESSAGES_OFF, 1 );
        putValue( HMI__STOP_NV_MESSAGES_OFF, 1 );
        putValue( HMI__STOP_ORC_MESSAGES_OFF, 1 );
        putValue( HMI__STOP_RBTM_FL_MESSAGES_OFF, 1 );
        putValue( HMI__STOP_RBTM_FR_MESSAGES_OFF, 1 );
        putValue( HMI__STOP_SVS_MESSAGES_OFF, 1 );
        putValue( HMI__STOP_TGW_MESSAGES_OFF, 1 );
        putValue( HMI__STOP_TPM_MESSAGES_OFF, 1 );
    }
    else
    {
        putValue( HMI__STOP_DRVU_MESSAGES_OFF, 0 );
        putValue( HMI__STOP_EIS_MESSAGES_OFF, 0 );
        putValue( HMI__STOP_HUD_MESSAGES_OFF, 0 );
        putValue( HMI__STOP_IC_MESSAGES_OFF, 0 );
        putValue( HMI__STOP_NV_MESSAGES_OFF, 0 );
        putValue( HMI__STOP_ORC_MESSAGES_OFF, 0 );
        putValue( HMI__STOP_RBTM_FL_MESSAGES_OFF, 0 );
        putValue( HMI__STOP_RBTM_FR_MESSAGES_OFF, 0 );
        putValue( HMI__STOP_SVS_MESSAGES_OFF, 0 );
        putValue( HMI__STOP_TGW_MESSAGES_OFF, 0 );
        putValue( HMI__STOP_TPM_MESSAGES_OFF, 0 );
    }
}

on EnvVar HMI__STOP_All_MESSAGES_ON
{
    if( getValue(this) )
    {
        putValue( HMI__STOP_DRVU_MESSAGES_ON, 1 );
        putValue( HMI__STOP_EIS_MESSAGES_ON, 1 );
        putValue( HMI__STOP_HUD_MESSAGES_ON, 1 );
        putValue( HMI__STOP_IC_MESSAGES_ON, 1 );
        putValue( HMI__STOP_NV_MESSAGES_ON, 1 );
        putValue( HMI__STOP_ORC_MESSAGES_ON, 1 );
        putValue( HMI__STOP_RBTM_FL_MESSAGES_ON, 1 );
        putValue( HMI__STOP_RBTM_FR_MESSAGES_ON, 1 );
        putValue( HMI__STOP_SVS_MESSAGES_ON, 1 );
        putValue( HMI__STOP_TGW_MESSAGES_ON, 1 );
        putValue( HMI__STOP_TPM_MESSAGES_ON, 1 );
    }
    else
    {
        putValue( HMI__STOP_DRVU_MESSAGES_ON, 0 );
        putValue( HMI__STOP_EIS_MESSAGES_ON, 0 );
        putValue( HMI__STOP_HUD_MESSAGES_ON, 0 );
        putValue( HMI__STOP_IC_MESSAGES_ON, 0 );
        putValue( HMI__STOP_NV_MESSAGES_ON, 0 );
        putValue( HMI__STOP_ORC_MESSAGES_ON, 0 );
        putValue( HMI__STOP_RBTM_FL_MESSAGES_ON, 0 );
        putValue( HMI__STOP_RBTM_FR_MESSAGES_ON, 0 );
        putValue( HMI__STOP_SVS_MESSAGES_ON, 0 );
        putValue( HMI__STOP_TGW_MESSAGES_ON, 0 );
        putValue( HMI__STOP_TPM_MESSAGES_ON, 0 );
    }
}

on busOff
{
    resetCan();
    write("CAN has been resetted due to BUSOFF    ( coded version )");
}

on message 0x500-0x57F
{
    byte Identifier;

    Identifier = this.byte( 1 );

    if( this.byte( 1 ) == CanNmNodeId )    // check, wether the received NM-Frame is an own one
    {
        boCanNM_Tx_Confirmation = TRUE;    // so it is a TX-confirmation
    }
    else
    {
        boCanNM_Rx_Indication = TRUE;     // else it is a NM-Frame from another ECU
    }
    _NM_Switch_NM_Mode();     // inform the state-mashine
}

on timer t_DoorNMCancelTimer
{
    if( getValue( HMI__NM_EIS_AutomaticModeActive ) == 1 )
    {
        _ReleaseCommRequest( 15 );  // all doors reset their requests
    }
}

on timer t_KeyInLockNMCancelTimer
{
    if( getValue( HMI__NM_EIS_AutomaticModeActive ) == 1 )
    {
        _ReleaseCommRequest( cIgnitionNMRequest );
    }
}

on timer t_StWhlButtonNMCancelTimer
{
    if( getValue( HMI__NM_EIS_AutomaticModeActive ) == 1 )
    {
        _ReleaseCommRequest( cStWhlButtonNMRequest );  // all keys reset their requests
    }
}

on timer t_PnhvIcDispNmCancelTimer
{
    if( getValue( HMI__NM_EIS_AutomaticModeActive ) == 1 )
    {
        _ReleaseCommRequest( cPnhvIcDispNmRequest );  // all keys reset their requests
    }
}

on timer t_WakeWarningNMCancelTimer
{
    if( getValue( HMI__NM_EIS_AutomaticModeActive ) == 1 )
    {
        _ReleaseCommRequest( cWakeWarningNMRequest );  // all keys reset their requests
    }
}

on timer t_EPKBWarningNMCancelTimer
{
    if( getValue( HMI__NM_EIS_AutomaticModeActive ) == 1 )
    {
        _ReleaseCommRequest( cEPKBWarningNMRequest );  // all keys reset their requests
    }
}

on timer t_IlluNMCancelTimer
{
    if( getValue( HMI__NM_EIS_AutomaticModeActive ) == 1 )
    {
        _ReleaseCommRequest( cIlluNMRequest );  // all keys reset their requests
    }
}

on timer t_LowBeamNMCancelTimer
{
    if( getValue( HMI__NM_EIS_AutomaticModeActive ) == 1 )
    {
        _ReleaseCommRequest( cLowBeamNMRequest );  // all keys reset their requests
    }
}

on timer t_CarClosureNMCancelTimer
{
    if( getValue( HMI__NM_EIS_AutomaticModeActive ) == 1 )
    {
        _ReleaseCommRequest( cCarClosureNMRequest );  // all keys reset their requests
    }
}

on timer t_GearIndNMCancelTimer
{
    if( getValue( HMI__NM_EIS_AutomaticModeActive ) == 1 )
    {
        _ReleaseCommRequest( cGearIndNMRequest );  // all keys reset their requests
    }
}

on timer t_NM_Repeat_Message_Time
{
    boCanNM_RepeatMessage_Timer_Expired = TRUE;
    _NM_Switch_NM_Mode();     // inform the state-mashine
}

on timer t_NM_Timeout_Time
{
    boCanNM_NM_Timeout_Timer_Expired = TRUE;
    _NM_Switch_NM_Mode();     // inform the state-mashine
}

on timer t_NM_Transmit
{
    setTimer( t_NM_Transmit, NM_Transmit_Cycle );
    _mNM_xxx_AR.byte( 1 ) = CanNmNodeId;
    if( _mNM_xxx_Transmit_Allowed )
        output( _mNM_xxx_AR );
}

on timer t_NM_Wait_Bus_Sleep_Time
{
    boCanNM_WaitBusSleep_Timer_Expired = TRUE;
    _NM_Switch_NM_Mode();     // inform the state-mashine
}

NM_xxx_AR_init()
{
    _mNM_xxx_AR.Awake_Diag_Actv.phys = getValue( HMI_Awake_Diag_Actv_EIS );
    _mNM_xxx_AR.Awake_Ignition_On.phys = getValue( HMI_Awake_Ignition_On_EIS );
    _mNM_xxx_AR.Awake_IgnitionAccessory_On.phys = getValue( HMI_Awake_IgnitionAccessory_On_EIS );
    _mNM_xxx_AR.Awake_ISw_Stat_Chg.phys = getValue( HMI_Awake_ISw_Stat_Chg_EIS );
    _mNM_xxx_AR.Awake_TXPkPosn_Rq.phys = getValue( HMI_Awake_TXPkPosn_Rq_EIS );
    _mNM_xxx_AR.WakeupRsn_EIS.phys = getValue( HMI_WakeupRsn_EIS );
}

NM_xxx_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten NM_EIS_AR\n", 33, hFile );
    snprintf(buffer, elcount(buffer), "0.0000 HMI__STMSG_NM_EIS_AR := %X\n", getValue(HMI__STMSG_NM_EIS_AR ));        filePutString (buffer, elcount(buffer), hFile);
    snprintf(buffer, elcount(buffer), "0.0000 HMI__STMSGT_NM_EIS_AR := %X\n", getValue(HMI__STMSGT_NM_EIS_AR ));        filePutString (buffer, elcount(buffer), hFile);
    snprintf(buffer, elcount(buffer), "0.0000 HMI_Awake_Diag_Actv := %X\n", getValue( HMI_Awake_Diag_Actv_EIS ) );        filePutString (buffer, elcount(buffer), hFile);
    snprintf(buffer, elcount(buffer), "0.0000 HMI_Awake_Ignition_On := %X\n", getValue( HMI_Awake_Ignition_On_EIS ) );        filePutString (buffer, elcount(buffer), hFile);
    snprintf(buffer, elcount(buffer), "0.0000 HMI_Awake_IgnitionAccessory_On := %X\n", getValue( HMI_Awake_IgnitionAccessory_On_EIS ) );        filePutString (buffer, elcount(buffer), hFile);
    snprintf(buffer, elcount(buffer), "0.0000 HMI_Awake_ISw_Stat_Chg := %X\n", getValue( HMI_Awake_ISw_Stat_Chg_EIS ) );        filePutString (buffer, elcount(buffer), hFile);
    snprintf(buffer, elcount(buffer), "0.0000 HMI_Awake_TXPkPosn_Rq := %X\n", getValue( HMI_Awake_TXPkPosn_Rq_EIS ) );        filePutString (buffer, elcount(buffer), hFile);
    snprintf(buffer, elcount(buffer), "0.0000 HMI_WakeupRsn_EIS := %X\n", getValue( HMI_WakeupRsn_EIS ) );        filePutString (buffer, elcount(buffer), hFile);
}

on envVar HMI__STMSG_NM_EIS_AR
{
    if( getValue( this ) == 0 )
        _mNM_xxx_Transmit_Allowed = 1;
    else
        _mNM_xxx_Transmit_Allowed = 0;    
}

on EnvVar HMI_Awake_Diag_Actv_EIS
{
    _mNM_xxx_AR.Awake_Diag_Actv.phys = getValue(this);
}

on EnvVar HMI_Awake_Ignition_On_EIS
{
    _mNM_xxx_AR.Awake_Ignition_On.phys = getValue(this);
}

on EnvVar HMI_Awake_IgnitionAccessory_On_EIS
{
    _mNM_xxx_AR.Awake_IgnitionAccessory_On.phys = getValue(this);
}

on EnvVar HMI_Awake_ISw_Stat_Chg_EIS
{
    _mNM_xxx_AR.Awake_ISw_Stat_Chg.phys = getValue(this);
}

on EnvVar HMI_Awake_TXPkPosn_Rq_EIS
{
    _mNM_xxx_AR.Awake_TXPkPosn_Rq.phys = getValue(this);
}

on EnvVar HMI_WakeupRsn_EIS
{
    _mNM_xxx_AR.WakeupRsn_EIS.phys = getValue(this);
}

on envVar HMI__NM_EIS_AutomaticModeActive
{
    byte temp; // actual NM request status

    if( getValue( this ) )
    {
        EnableControl( "Hauptpanel", "EnvVar:HMI__NM_EIS_Manually_Request_NM", 0 );

        temp = getValue( HMI_ISw_Stat );
//        write( "HMI_ISw_Stat is %d", temp );
        if( temp > 1 ) // IGN not Lock
        {
            putValue( HMI__NM_EIS_Manually_Request_NM, 1 );
            putValue( HMI__NM_EIS_NM_Request, cIgnitionNMRequest );
            _NM_Switch_NM_Mode();
        }
        else
        {
            putValue( HMI__NM_EIS_Manually_Request_NM, 0 );
            _ReleaseCommRequest( cAllNMRequest );  // release all requests
            _NM_Switch_NM_Mode();
        }
    }
    else
    {
        EnableControl( "Hauptpanel", "EnvVar:HMI__NM_EIS_Manually_Request_NM", 1 );
        if( getValue( HMI_ISw_Stat ) > 1 )
        {
            _SetCommRequest( cIgnitionNMRequest );
            _NM_Switch_NM_Mode();
            putValue( HMI__NM_EIS_Manually_Request_NM, 1 );
        }
    }
    NM_AutomaticModeActive = getValue( this );
}

on envVar HMI__NM_EIS_Manually_Request_NM
{
    if( getValue ( HMI__NM_EIS_AutomaticModeActive ) == 0 )
    {
        if( getValue( this ) )
        {
            _SetCommRequest( cManualNMRequest );
        }
        else
        {
            _ReleaseCommRequest( cAllNMRequest );// all
        }
    }
}

_NM_Switch_NM_Mode()
{
    byte bOld_NM_Mode;
    word NM_Request_State;

    bOld_NM_Mode = NM_Mode;
    NM_Request_State = getValue( HMI__NM_EIS_NM_Request );
    switch( NM_Mode )
    {
        case cNM_Mode_Init:                   _NM_Init();
                                              NM_Mode = cNM_Mode_Sleep;
                                              break;
        case cNM_Mode_Sleep:                  if( boCanNM_Rx_Indication == TRUE )
                                              {
                                                  // _NM_NetworkStartIndication();   nothing to do
                                                  // _NM_PassiveStartUp();    is content of _NM_NetworkMode();
                                                  setTimer( t_NM_Transmit, NmAsrCanMsgCycleOffset );    // send NM-Frame delayed
                                                  boCanNM_Rx_Indication = FALSE;
                                                  cancelTimer( t_NM_Timeout_Time );
                                                  setTimer( t_NM_Timeout_Time, c_NM_Timeout_Time );
                                                  setTimer( t_NM_Repeat_Message_Time, c_NM_Repeat_Message_Time );
                                                  NM_Transmit_Cycle = NmAsrCanMsgStandardCycle;
                                                  _NM_NetworkMode();
                                                  NM_Mode = cNM_Mode_RepeatMsg;
                                              }
                                              if( NM_Request_State )
                                              {
                                                  setTimer( t_NM_Transmit, 1 );    //send NM-Franme immediately
                                                  NM_Transmit_Cycle = NmAsrCanMsgStandardCycle;
                                                  cancelTimer( t_NM_Timeout_Time );
                                                  setTimer( t_NM_Timeout_Time, c_NM_Timeout_Time );
                                                  setTimer( t_NM_Repeat_Message_Time, c_NM_Repeat_Message_Time );
                                                  NM_Transmit_Cycle = NmAsrCanMsgStandardCycle;
                                                  _NM_NetworkMode();
                                                  NM_Mode = cNM_Mode_RepeatMsg;
                                              }
                                              break;
        case cNM_Mode_Prepare_Bus_Sleep:      if( boCanNM_WaitBusSleep_Timer_Expired == TRUE )
                                              {
                                                  _NM_BusSleepModeInd();   // set message startup delay
                                                  NM_Mode = cNM_Mode_Sleep;
                                                  boCanNM_WaitBusSleep_Timer_Expired = FALSE;
                                              }
                                              if( boCanNM_NM_Timeout_Timer_Expired == TRUE )
                                                  boCanNM_NM_Timeout_Timer_Expired = FALSE;
                                              if( ( boCanNM_Rx_Indication == TRUE ) ||  NM_Request_State )
                                              {
                                                  boCanNM_Rx_Indication = FALSE;
                                                  if( NM_Request_State )
                                                  {
                                                      setTimer( t_NM_Transmit, 1 );    //send NM-Franme immediately
                                                  }
                                                  cancelTimer( t_NM_Timeout_Time );
                                                  setTimer( t_NM_Timeout_Time, c_NM_Timeout_Time );
                                                  setTimer( t_NM_Repeat_Message_Time, c_NM_Repeat_Message_Time );
                                                  _NM_NetworkMode();
                                                  NM_Transmit_Cycle = NmAsrCanMsgStandardCycle;
                                                  NM_Mode = cNM_Mode_RepeatMsg;
                                              }
                                              break;
        case cNM_Mode_Ready_Sleep:            if( boCanNM_Rx_Indication == TRUE )
                                              {
                                                  cancelTimer( t_NM_Timeout_Time );
                                                  setTimer( t_NM_Timeout_Time, c_NM_Timeout_Time );
                                                  boCanNM_Rx_Indication = FALSE;
                                              }
                                              if( boCanNM_Tx_Confirmation == TRUE )
                                              {
                                                  cancelTimer( t_NM_Timeout_Time );
                                                  setTimer( t_NM_Timeout_Time, c_NM_Timeout_Time );
                                                  boCanNM_Tx_Confirmation = FALSE;
                                              }
                                              if( NM_Request_State )
                                              {
                                                  setTimer( t_NM_Transmit, 1 );    //send NM-Franme immediately
                                                  cancelTimer( t_NM_Timeout_Time );
                                                  setTimer( t_NM_Timeout_Time, c_NM_Timeout_Time );
                                                  NM_Transmit_Cycle = NmAsrCanMsgReducedTime;
                                                  NM_Mode = cNM_Mode_Normal_Operation_State;
                                              }
                                              if( boCanNM_RepeatMessage_Requested == TRUE )
                                              {
                                                  setTimer( t_NM_Transmit, NmAsrCanMsgCycleOffset );    // send NM-Frame delayed
                                                  cancelTimer( t_NM_Timeout_Time );
                                                  setTimer( t_NM_Timeout_Time, c_NM_Timeout_Time );
                                                  setTimer( t_NM_Repeat_Message_Time, c_NM_Repeat_Message_Time );
                                                  NM_Transmit_Cycle = NmAsrCanMsgStandardCycle;
                                                  boCanNM_RepeatMessage_Requested = FALSE;
                                                  NM_Mode = cNM_Mode_RepeatMsg;
                                              }
                                              if( boCanNM_NM_Timeout_Timer_Expired == TRUE )
                                              {
                                                  setTimer( t_NM_Wait_Bus_Sleep_Time, c_NM_Wait_Bus_Sleep_Time );
                                                  _NM_PrepareBusSleepModeInd();    // here t_DBKonTimer is stopped
                                                  NM_Mode = cNM_Mode_Prepare_Bus_Sleep;
                                                  boCanNM_NM_Timeout_Timer_Expired = FALSE;
                                              }
                                              break;
        case cNM_Mode_Normal_Operation_State: if( boCanNM_NM_Timeout_Timer_Expired == TRUE )
                                              {
                                                  setTimer( t_NM_Timeout_Time, c_NM_Timeout_Time );
                                                  // _NM_TimeoutExeption();    // no action to be done
                                                  boCanNM_NM_Timeout_Timer_Expired = FALSE;
                                              }
                                              if( boCanNM_Rx_Indication == TRUE )
                                              {
                                                  cancelTimer( t_NM_Timeout_Time );
                                                  setTimer( t_NM_Timeout_Time, c_NM_Timeout_Time );
                                                  cancelTimer( t_NM_Transmit );
                                                  setTimer( t_NM_Transmit, NmAsrCanMsgReducedTime );
                                                  boCanNM_Rx_Indication = FALSE;
                                              }
                                              if( boCanNM_Tx_Confirmation == TRUE )
                                              {
                                                  cancelTimer( t_NM_Timeout_Time );
                                                  setTimer( t_NM_Timeout_Time, c_NM_Timeout_Time );
                                                  cancelTimer( t_NM_Transmit );
                                                  setTimer( t_NM_Transmit, NmAsrCanMsgStandardCycle );
                                                  boCanNM_Tx_Confirmation = FALSE;
                                              }
                                              if( NM_Request_State == 0 )    //no network requested
                                              {
                                                  cancelTimer( t_NM_Transmit );    // stop NM-Franme immediately
                                                  NM_Mode = cNM_Mode_Ready_Sleep;
                                              }
                                              if( boCanNM_RepeatMessage_Requested == TRUE )
                                              {
                                                  setTimer( t_NM_Transmit, NmAsrCanMsgCycleOffset );    // send NM-Frame delayed
                                                  cancelTimer( t_NM_Timeout_Time );
                                                  setTimer( t_NM_Timeout_Time, c_NM_Timeout_Time );
                                                  setTimer( t_NM_Repeat_Message_Time, c_NM_Repeat_Message_Time );
                                                  boCanNM_RepeatMessage_Requested = FALSE;
                                                  NM_Transmit_Cycle = NmAsrCanMsgStandardCycle;
                                                  NM_Mode = cNM_Mode_RepeatMsg;
                                              }
                                              break;
        case cNM_Mode_RepeatMsg:              if( boCanNM_NM_Timeout_Timer_Expired == TRUE )
                                              {
                                                  setTimer( t_NM_Timeout_Time, c_NM_Timeout_Time );
                                                  boCanNM_NM_Timeout_Timer_Expired = FALSE;
                                              }
                                              if( boCanNM_Rx_Indication == TRUE )
                                              {
                                                  cancelTimer( t_NM_Timeout_Time );
                                                  setTimer( t_NM_Timeout_Time, c_NM_Timeout_Time );
                                                  boCanNM_Rx_Indication = FALSE;
                                              }
                                              if( boCanNM_Tx_Confirmation == TRUE )
                                              {
                                                  cancelTimer( t_NM_Timeout_Time );
                                                  setTimer( t_NM_Timeout_Time, c_NM_Timeout_Time );
                                                  boCanNM_Tx_Confirmation = FALSE;
                                              }
                                              if( boCanNM_RepeatMessage_Timer_Expired == TRUE )
                                              {
                                                  boCanNM_RepeatMessage_Timer_Expired = FALSE;
                                                  if( NM_Request_State )
                                                  {
                                                      NM_Mode = cNM_Mode_Normal_Operation_State;
                                                      NM_Transmit_Cycle = NmAsrCanMsgReducedTime;
                                                  }
                                                  else
                                                  {
                                                      cancelTimer( t_NM_Transmit );    // stop NM-Franme immediately
                                                      NM_Mode = cNM_Mode_Ready_Sleep;
                                                  }
                                              }
                                              break;
    }
    if( bOld_NM_Mode != NM_Mode )
    {
        _Nm_StateChangeNotification( bOld_NM_Mode, NM_Mode );    // does the Trace
        putValue( HMI__NM_EIS_ActualState, NM_Mode );
    }
}

_NM_Init()
{
    NM_Transmit_Cycle = NmAsrCanMsgStandardCycle;
}

_NM_NetworkMode()
{
    setTimer( t_DBKomTimer_5ms, 1 ); //  ms     start CAN-communication immediately
    setTimer( t_DBKomTimer_20ms, 2 ); //  ms     start CAN-communication immediately
    putValue( HMI__NM_EIS_CommActive, 1 );
}

_Nm_BusSleepModeInd()
{
    putValue( Env_ODO_Takeover_For_TCO, 1 );   // used in EIS_VDO to synchronize ODO's
//    write( "_Nm_BusSleepModeInd: Sleep Mode active");
    __Startup_Delay();
    __Reset_E2E_SQC();
}

void _Nm_PrepareBusSleepModeInd()
{
//    _Trace( "Nm_PrepareBusSleepModeInd", "Prepare Sleep Mode active");
    putValue( HMI__NM_EIS_CommActive, 0 );
    cancelTimer( t_DBKomTimer_5ms );
    cancelTimer( t_DBKomTimer_20ms );
}

_Nm_StateChangeNotification( byte previousState, byte currentState )
{
/*
    char line[50];

    snprintf( line, elcount(line ), "Transition from %d to %d", previousState, currentState );
    _Trace( "Nm_StateChangeNotification", "", line );
*/
}

_ReleaseCommRequest( word RequestID )
{
    word temp; // actual NM request status

    temp = getValue( HMI__NM_EIS_NM_Request );
    temp &= ~RequestID; // reset NM request 
    putValue( HMI__NM_EIS_NM_Request, temp );
    _NM_Switch_NM_Mode();
}

_SetCommRequest( word RequestID )
{
    word temp; // actual NM request status

    temp = getValue( HMI__NM_EIS_NM_Request );
    temp |= RequestID; // set NM request 
    putValue( HMI__NM_EIS_NM_Request, temp );
    _NM_Switch_NM_Mode();
}

void _TraceCall( char functionName[], long callResult )
{
    char line[100];

    if( callResult == 1 )
        snprintf( line, elcount(line ), "calling %s", functionName );
    else
        snprintf( line, elcount(line ), "call to %s failed - wrong state?", functionName );
    _Trace( "", "", line );
}

void _Trace( char functionName[], char info[])
{
    _Trace( functionName, info, "");
}

void _Trace( char functionName[], char info[], char verbose[], long argument )
{
    char line[100];

    snprintf( line, elcount(line ), verbose, argument );
    _Trace( functionName, info, line );
}

void _Trace( char functionName[], char info[], char verbose[])
{
  char sep[2] = "/";
  sep[0] = functionName[0] ? '/' : 0;
  if( verbose[0])
  {
    write( "[%.3f]%s%s%s: %s", timeNow()/100000.0, gECU
           , sep
           , functionName
           , verbose
           );
  } else
  {
    write( "[%.3f]%s%s%s: %s", timeNow()/100000.0, gECU
           , sep
           , functionName
           , info
           );
  }
}

___Template_Header()
{
// #FUNCTIONS#
// #FUNCTIONS_END#
// #TIMERS#
// #TIMERS_END#
// #ENVVARS#
// #ENVVARS_END#
}

AB_R_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_AB_R_Stat_AR ) )
    {
    //  message   AB_R_Stat_AR ID: 819 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _AB_R_Stat_AR_DelayCnt > 0) _AB_R_Stat_AR_DelayCnt--; // Mindestsendeabstand
        _AB_R_Stat_AR_Cnt--;
        if( _AB_R_Stat_AR_Cnt < 1 )
        {
            if( _AB_R_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                AB_R_Stat_AR_output();
                 _AB_R_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _AB_R_Stat_AR_DelayCnt = _AB_R_Stat_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _AB_R_Stat_AR_SpontanFlag = 1;
            }
            _AB_R_Stat_AR_Cnt = ( getValue( HMI__MSGCyc_AB_R_Stat_AR ) / _AB_R_Stat_AR_Timebase ); //_AB_R_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _AB_R_Stat_AR_SpontanFlag)
        {
            if( _AB_R_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                AB_R_Stat_AR_output();
                _AB_R_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _AB_R_Stat_AR_DelayCnt = _AB_R_Stat_AR_MinDelay;
            }
        }
    }
}

AB_R_Stat_AR_init()
{   /* Botschaft AB_R_Stat_AR ID: 819 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 819 0;
BA_ "NmAsrMessage" BO_ 819 0;
BA_ "GenMsgMinAcceptLength" BO_ 819 2;
BA_ "GenMsgILSupport" BO_ 819 1;
BA_ "DiagState" BO_ 819 0;
BA_ "DiagRequest" BO_ 819 0;
BA_ "DiagResponse" BO_ 819 0;
BA_ "GenMsgStartValue" BO_ 819 "0";
BA_ "GenMsgStartDelayTime" BO_ 819 0;
BA_ "GenMsgDelayTime" BO_ 819 5;
BA_ "GenMsgNrOfRepetitions" BO_ 819 0;
BA_ "GenMsgCycleTime" BO_ 819 500;
BA_ "GenMsgSendType" BO_ 819 5;
    */
    _AB_R_Stat_AR_Timebase =             c_tDBKomTimer_20ms;
    _AB_R_Stat_AR_CycleCount =          500 / _AB_R_Stat_AR_Timebase;
    _AB_R_Stat_AR_StartDelay =            0 / _AB_R_Stat_AR_Timebase;
    _AB_R_Stat_AR_MinDelay =              5 / _AB_R_Stat_AR_Timebase;
    _AB_R_Stat_AR_Cnt = _AB_R_Stat_AR_StartDelay;
    _AB_R_Stat_AR_SpontanFlag = 0;
    _AB_R_Stat_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_AB_R_Stat_AR, _AB_R_Stat_AR_StartDelay * _AB_R_Stat_AR_Timebase );
    
    _mAB_R_Stat_AR.AB_R_Alive.phys = getValue( HMI_AB_R_Alive );
    _mAB_R_Stat_AR.AB_R_Presf_Disp_Rq.phys = getValue( HMI_AB_R_Presf_Disp_Rq );
    _mAB_R_Stat_AR.AB_RL_Movm.phys = getValue( HMI_AB_RL_Movm);
    _mAB_R_Stat_AR.AB_RL_Posn.phys = getValue( HMI_AB_RL_Posn);
    _mAB_R_Stat_AR.AB_RL_SRS_Disp_Rq_1.phys = getValue( HMI_AB_RL_SRS_Disp_Rq_1 );
    _mAB_R_Stat_AR.AB_RL_SRS_Disp_Rq_2.phys = getValue( HMI_AB_RL_SRS_Disp_Rq_2);
    _mAB_R_Stat_AR.AB_RR_Movm.phys = getValue( HMI_AB_RR_Movm);
    _mAB_R_Stat_AR.AB_RR_Posn.phys = getValue( HMI_AB_RR_Posn);
    _mAB_R_Stat_AR.AB_RR_SRS_Disp_Rq_1.phys = getValue( HMI_AB_RR_SRS_Disp_Rq_1 );
    _mAB_R_Stat_AR.AB_RR_SRS_Disp_Rq_2.phys = getValue( HMI_AB_RR_SRS_Disp_Rq_2);
}

void AB_R_Stat_AR_output(void)
{
   byte crc;

    if( getValue( HMI_AB_R_Presf_Disp_Rq_Toggle_Rq ) )
    {
        if( getValue( HMI_AB_R_Presf_Disp_Rq ) )
            putValue( HMI_AB_R_Presf_Disp_Rq, 0 );
        else
            putValue( HMI_AB_R_Presf_Disp_Rq, 1 );

           _AB_R_Stat_AR_SpontanFlag = 0;
    }
    output( _mAB_R_Stat_AR );
}

AB_R_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: AB_R_Stat_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_AB_R_Stat_AR := %X\n", getValue( HMI__STMSG_AB_R_Stat_AR ) );            filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_AB_R_Stat_AR := %X\n", getValue( HMI__STMSGT_AB_R_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AB_R_Alive := %X\n", getValue( HMI_AB_R_Alive ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AB_R_Presf_Disp_Rq := %X\n", getValue( HMI_AB_R_Presf_Disp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AB_RL_Movm := %X\n", getValue( HMI_AB_RL_Movm ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AB_RL_Posn := %X\n", getValue( HMI_AB_RL_Posn ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AB_RL_SRS_Disp_Rq_1 := %X\n", getValue( HMI_AB_RL_SRS_Disp_Rq_1 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AB_RL_SRS_Disp_Rq_2 := %X\n", getValue( HMI_AB_RL_SRS_Disp_Rq_2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AB_RR_Movm := %X\n", getValue( HMI_AB_RR_Movm ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AB_RR_Posn := %X\n", getValue( HMI_AB_RR_Posn ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AB_RR_SRS_Disp_Rq_1 := %X\n", getValue( HMI_AB_RR_SRS_Disp_Rq_1 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AB_RR_SRS_Disp_Rq_2 := %X\n", getValue( HMI_AB_RR_SRS_Disp_Rq_2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
}

on envVar HMI__MSGCyc_AB_R_Stat_AR
{
       _AB_R_Stat_AR_SpontanFlag = 1;
}

on timer _tAB_R_Stat_AR
{
    putValue( HMI__STMSG_AB_R_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_AB_R_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_AB_R_Stat_AR );
        if( tDelay > 0 )
            setTimer( _tAB_R_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_AB_R_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_AB_R_Stat_AR
{
    if( getValue( this ) )
        openPanel("AB_R_Stat_AR");
}

on EnvVar HMI_AB_R_Alive
{

   _mAB_R_Stat_AR.AB_R_Alive.phys = getValue(this);
    _AB_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_AB_R_Presf_Disp_Rq
{
    _mAB_R_Stat_AR.AB_R_Presf_Disp_Rq.phys = getValue(this);
    if( getValue( HMI_AB_R_Presf_Disp_Rq_Toggle_Rq ) == 0 )
        _AB_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_AB_RL_Movm
{
    _mAB_R_Stat_AR.AB_RL_Movm.phys = getValue(this);
    _AB_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_AB_RL_Posn
{
    _mAB_R_Stat_AR.AB_RL_Posn.phys = getValue(this);
    _AB_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_AB_RL_SRS_Disp_Rq_1
{
    _mAB_R_Stat_AR.AB_RL_SRS_Disp_Rq_1.phys = getValue(this);
    _AB_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_AB_RL_SRS_Disp_Rq_2
{
    _mAB_R_Stat_AR.AB_RL_SRS_Disp_Rq_2.phys = getValue(this);
    _AB_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_AB_RR_Movm
{
    _mAB_R_Stat_AR.AB_RR_Movm.phys = getValue(this);
    _AB_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_AB_RR_Posn
{
    _mAB_R_Stat_AR.AB_RR_Posn.phys = getValue(this);
    _AB_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_AB_RR_SRS_Disp_Rq_1
{
    _mAB_R_Stat_AR.AB_RR_SRS_Disp_Rq_1.phys = getValue(this);
    _AB_R_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_AB_RR_SRS_Disp_Rq_2
{
    _mAB_R_Stat_AR.AB_RR_SRS_Disp_Rq_2.phys = getValue(this);
    _AB_R_Stat_AR_SpontanFlag = 1;
}

//Adapt_Seat_D_Stat_AR_check_output()
//{
//    if( !getValue( HMI__STMSG_Adapt_Seat_D_Stat_AR ) )
//        {
//        //  message   Adapt_Seat_D_Stat_AR ID: 1206 --- Sendeart 0 cyclicX --- 
//            _Adapt_Seat_D_Stat_AR_Cnt--;
//            if( _Adapt_Seat_D_Stat_AR_Cnt < 1 )
//            {
//                // Nachricht wg. abgelaufenem Zyklus ausgeben
//                Adapt_Seat_D_Stat_AR_output();
//                // Zyklus-Z�hler zur�cksetzen
//                _Adapt_Seat_D_Stat_AR_Cnt = _Adapt_Seat_D_Stat_AR_CycleCount;
//            }
//        }
//}
//
//Adapt_Seat_D_Stat_AR_init()
//{   /* Botschaft Adapt_Seat_D_Stat_AR ID: 1206 --- Sendeart 0 cyclicX --- 
//BA_ "ApplMessage" BO_ 1206 0;
//BA_ "NmAsrMessage" BO_ 1206 0;
//BA_ "GenMsgMinAcceptLength" BO_ 1206 4;
//BA_ "GenMsgILSupport" BO_ 1206 1;
//BA_ "DiagState" BO_ 1206 0;
//BA_ "DiagRequest" BO_ 1206 0;
//BA_ "DiagResponse" BO_ 1206 0;
//BA_ "GenMsgStartValue" BO_ 1206 "0";
//BA_ "GenMsgCycleTime" BO_ 1206 1000;
//BA_ "GenMsgSendType" BO_ 1206 0;
//    */
//    _Adapt_Seat_D_Stat_AR_Timebase =      c_tDBKomTimer_20ms;
//    _Adapt_Seat_D_Stat_AR_CycleCount =   1000 / _Adapt_Seat_D_Stat_AR_Timebase;
//    _Adapt_Seat_D_Stat_AR_StartDelay =      0 / _Adapt_Seat_D_Stat_AR_Timebase;
//    _Adapt_Seat_D_Stat_AR_Cnt = _Adapt_Seat_D_Stat_AR_StartDelay;
//    _Adapt_Seat_D_Stat_AR_SpontanFlag = 0;
//
//    putValue( HMI__STMSGSD_Adapt_Seat_D_Stat_AR, _Adapt_Seat_D_Stat_AR_StartDelay * _Adapt_Seat_D_Stat_AR_Timebase );
//
//    _mAdapt_Seat_D_Stat_AR.Adapt_Seat_D_ID_MemPos1.phys = getValue( HMI_Adapt_Seat_D_ID_MemPos1 );
//    _mAdapt_Seat_D_Stat_AR.Adapt_Seat_D_ID_MemPos2.phys = getValue( HMI_Adapt_Seat_D_ID_MemPos2 );
//    _mAdapt_Seat_D_Stat_AR.Adapt_Seat_D_ID_MemPos3.phys = getValue( HMI_Adapt_Seat_D_ID_MemPos3 );
//}
//
//Adapt_Seat_D_Stat_AR_output(void)
//{
//    output( _mAdapt_Seat_D_Stat_AR );
//}
//
//Adapt_Seat_D_Stat_AR_saveEnvVars( dword hFile )
//{
//    filePutString("\n// Knoten EIS: Adapt_Seat_D_Stat_AR\n", 36, hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Adapt_Seat_D_Stat_AR := %X\n", getValue( HMI__STMSG_Adapt_Seat_D_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Adapt_Seat_D_Stat_AR := %X\n", getValue( HMI__STMSGT_Adapt_Seat_D_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Adapt_Seat_D_ID_MemPos1  := %X\n", getValue( HMI_Adapt_Seat_D_ID_MemPos1 ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Adapt_Seat_D_ID_MemPos2  := %X\n", getValue( HMI_Adapt_Seat_D_ID_MemPos2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Adapt_Seat_D_ID_MemPos3  := %X\n", getValue( HMI_Adapt_Seat_D_ID_MemPos3 ) );        filePutString ( buffer, elcount( buffer ), hFile );
//}
//
//on timer _tAdapt_Seat_D_Stat_AR
//{
//    putValue( HMI__STMSG_Adapt_Seat_D_Stat_AR, 0 );
//}
//
//on EnvVar HMI__STMSG_Adapt_Seat_D_Stat_AR
//{
//    long tDelay;
//    if( getValue( this ) == 2 )
//    {
//        tDelay = getValue( HMI__STMSGT_Adapt_Seat_D_Stat_AR );
//        if( tDelay > 0)    
//            setTimer( _tAdapt_Seat_D_Stat_AR, tDelay );
//        else
//            putValue( HMI__STMSG_Adapt_Seat_D_Stat_AR, 0 );
//    }
//}
//
//on envVar HMI__STMSG_PO_Adapt_Seat_D_Stat_AR
//{
//    if( getValue( this ) )
//        openPanel("Adapt_Seat_D_Stat_AR");
//}
//
//on EnvVar HMI_Adapt_Seat_D_ID_MemPos1
//{
//    _mAdapt_Seat_D_Stat_AR.Adapt_Seat_D_ID_MemPos1.phys = getValue(this);
//}
//
//on EnvVar HMI_Adapt_Seat_D_ID_MemPos2
//{
//    _mAdapt_Seat_D_Stat_AR.Adapt_Seat_D_ID_MemPos2.phys = getValue(this);
//}
//
//on EnvVar HMI_Adapt_Seat_D_ID_MemPos3
//{
//    _mAdapt_Seat_D_Stat_AR.Adapt_Seat_D_ID_MemPos3.phys = getValue(this);
//}

Adblue_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_Adblue_Disp_Rq_AR ) )
    {
    //  message   Adblue_Disp_Rq_AR ID: 734 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _Adblue_Disp_Rq_AR_DelayCnt > 0) _Adblue_Disp_Rq_AR_DelayCnt--; // Mindestsendeabstand
        _Adblue_Disp_Rq_AR_Cnt--;
        if( _Adblue_Disp_Rq_AR_Cnt < 1 )
        {
            if( _Adblue_Disp_Rq_AR_DelayCnt < 1 )
            {
                Adblue_Disp_Rq_AR_output();  // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                 _Adblue_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Adblue_Disp_Rq_AR_DelayCnt = _Adblue_Disp_Rq_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _Adblue_Disp_Rq_AR_SpontanFlag = 1;
            }
            _Adblue_Disp_Rq_AR_Cnt = _Adblue_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _Adblue_Disp_Rq_AR_SpontanFlag )
        {
            if( _Adblue_Disp_Rq_AR_DelayCnt < 1 )
            {
                Adblue_Disp_Rq_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _Adblue_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Adblue_Disp_Rq_AR_DelayCnt = _Adblue_Disp_Rq_AR_MinDelay;
            }
        }
    }
}

Adblue_Disp_Rq_AR_init()
{   /* Botschaft Adblue_Disp_Rq_AR ID: 734 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 734 0;
BA_ "NmAsrMessage" BO_ 734 0;
BA_ "GenMsgMinAcceptLength" BO_ 734 8;
BA_ "GenMsgILSupport" BO_ 734 1;
BA_ "DiagState" BO_ 734 0;
BA_ "DiagRequest" BO_ 734 0;
BA_ "DiagResponse" BO_ 734 0;
BA_ "GenMsgStartValue" BO_ 734 "0";
BA_ "GenMsgStartDelayTime" BO_ 734 0;
BA_ "GenMsgDelayTime" BO_ 734 500;
BA_ "GenMsgNrOfRepetitions" BO_ 734 0;
BA_ "GenMsgCycleTime" BO_ 734 5000;
BA_ "GenMsgSendType" BO_ 734 5;
    */
    _Adblue_Disp_Rq_AR_Timebase =          c_tDBKomTimer_20ms;
    _Adblue_Disp_Rq_AR_CycleCount =      5000 / _Adblue_Disp_Rq_AR_Timebase;
    _Adblue_Disp_Rq_AR_StartDelay =       500 / _Adblue_Disp_Rq_AR_Timebase;
    _Adblue_Disp_Rq_AR_MinDelay =           0 / _Adblue_Disp_Rq_AR_Timebase;
    _Adblue_Disp_Rq_AR_Cnt = _Adblue_Disp_Rq_AR_StartDelay;
    _Adblue_Disp_Rq_AR_SpontanFlag = 0;
    _Adblue_Disp_Rq_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_Adblue_Disp_Rq_AR, _Adblue_Disp_Rq_AR_StartDelay * _Adblue_Disp_Rq_AR_Timebase );

    _mAdblue_Disp_Rq_AR.AdBlue_Md_Disp_Rq.phys =           getValue( HMI_AdBlue_Md_Disp_Rq );
    _mAdblue_Disp_Rq_AR.Adblue_RemDistServ_Disp_Rq.phys =  getValue( HMI_Adblue_RemDistServ_Disp_Rq );
    _mAdblue_Disp_Rq_AR.AdBlue_SCRCM_Flt_Disp_Rq.phys =    getValue( HMI_AdBlue_SCRCM_Flt_Disp_Rq );
    _mAdblue_Disp_Rq_AR.AdBlue_TankLvl_Disp_Rq.phys =      getValue( HMI_AdBlue_TankLvl_Disp_Rq );
    _mAdblue_Disp_Rq_AR.AdBlue_TankRes_Disp_Rq.phys =      getValue( HMI_AdBlue_TankRes_Disp_Rq );
    _mAdblue_Disp_Rq_AR.AdBlue_TankVol.phys =              getValue( HMI_AdBlue_TankVol );
    _mAdblue_Disp_Rq_AR.AdBlue_TankVol_UB.phys =           getValue( HMI_AdBlue_TankVol_UB );  
    _mAdblue_Disp_Rq_AR.AdblueEU6_RefillChkMsg_Md.phys =   getValue( HMI_AdblueEU6_RefillChkMsg_Md );
    _mAdblue_Disp_Rq_AR.AdBlueMinRefillVol.phys          = getValue( HMI_AdBlueMinRefillVol );
	_mAdblue_Disp_Rq_AR.WrtInj_Avl.phys =      getValue( HMI_WrtInj_Avl );
    _mAdblue_Disp_Rq_AR.WtrInj_Err_Warn_Rq.phys =      getValue( HMI_WtrInj_Err_Warn_Rq );
    _mAdblue_Disp_Rq_AR.WtrInj_Menu_Disp_Rq.phys =              getValue( HMI_WtrInj_Menu_Disp_Rq );
    _mAdblue_Disp_Rq_AR.WtrInj_Res_Disp_Rq.phys =           getValue( HMI_WtrInj_Res_Disp_Rq );  
    _mAdblue_Disp_Rq_AR.WtrInj_Res_Icon_Rq.phys =   getValue( HMI_WtrInj_Res_Icon_Rq );
    _mAdblue_Disp_Rq_AR.WtrInj_Res_Warn_Rq.phys          = getValue( HMI_WtrInj_Res_Warn_Rq );
	
}

Adblue_Disp_Rq_AR_output(void)
{
    output( _mAdblue_Disp_Rq_AR );
}

Adblue_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Adblue_Disp_Rq_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Adblue_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_Adblue_Disp_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Adblue_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_Adblue_Disp_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AdBlue_Md_Disp_Rq := %X\n", getValue( HMI_AdBlue_Md_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Adblue_RemDistServ_Disp_Rq := %X\n", getValue( HMI_Adblue_RemDistServ_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AdBlue_SCRCM_Flt_Disp_Rq := %X\n", getValue( HMI_AdBlue_SCRCM_Flt_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AdBlue_TankLvl_Disp_Rq := %X\n", getValue( HMI_AdBlue_TankLvl_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AdBlue_TankRes_Disp_Rq := %X\n", getValue( HMI_AdBlue_TankRes_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AdBlue_TankVol := %X\n", getValue( HMI_AdBlue_TankVol ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AdBlue_TankVol_UB := %X\n", getValue( HMI_AdBlue_TankVol_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );  
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AdblueEU6_RefillChkMsg_Md := %X\n", getValue( HMI_AdblueEU6_RefillChkMsg_Md ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AdBlueMinRefillVol := %X\n", getValue( HMI_AdBlueMinRefillVol ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_WrtInj_Avl := %X\n", getValue( HMI_WrtInj_Avl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WtrInj_Err_Warn_Rq := %X\n", getValue( HMI_WtrInj_Err_Warn_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WtrInj_Menu_Disp_Rq := %X\n", getValue( HMI_WtrInj_Menu_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WtrInj_Res_Disp_Rq := %X\n", getValue( HMI_WtrInj_Res_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );  
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WtrInj_Res_Icon_Rq := %X\n", getValue( HMI_WtrInj_Res_Icon_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WtrInj_Res_Warn_Rq := %X\n", getValue( HMI_WtrInj_Res_Warn_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tAdblue_Disp_Rq_AR
{
    putValue( HMI__STMSG_Adblue_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_Adblue_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Adblue_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tAdblue_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_Adblue_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Adblue_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("Adblue_Disp_Warn_Rq_AR");
}

on EnvVar HMI_AdBlue_Md_Disp_Rq
{
    _mAdblue_Disp_Rq_AR.AdBlue_Md_Disp_Rq.phys = getValue(this);
    _Adblue_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Adblue_RemDistServ_Disp_Rq
{
    _mAdblue_Disp_Rq_AR.Adblue_RemDistServ_Disp_Rq.phys = getValue(this);
    _Adblue_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_AdBlue_SCRCM_Flt_Disp_Rq
{
    _mAdblue_Disp_Rq_AR.AdBlue_SCRCM_Flt_Disp_Rq.phys = getValue(this);
    _Adblue_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_AdBlue_TankLvl_Disp_Rq
{
    _mAdblue_Disp_Rq_AR.AdBlue_TankLvl_Disp_Rq.phys = getValue(this);
    _Adblue_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_AdBlue_TankRes_Disp_Rq
{
    _mAdblue_Disp_Rq_AR.AdBlue_TankRes_Disp_Rq.phys = getValue(this);
    _Adblue_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_AdBlue_TankVol
{
    _mAdblue_Disp_Rq_AR.AdBlue_TankVol.phys = getValue(this);
    _Adblue_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_AdBlue_TankVol_UB
{
    _mAdblue_Disp_Rq_AR.AdBlue_TankVol_UB.phys = getValue(this);
    _Adblue_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_AdblueEU6_RefillChkMsg_Md
{
    _mAdblue_Disp_Rq_AR.AdblueEU6_RefillChkMsg_Md.phys = getValue(this);
    _Adblue_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_AdBlueMinRefillVol
{
    _mAdblue_Disp_Rq_AR.AdBlueMinRefillVol.phys = getValue(this);
    _Adblue_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_WrtInj_Avl
{
    _mAdblue_Disp_Rq_AR.WrtInj_Avl.phys = getValue(this);
    _Adblue_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_WtrInj_Err_Warn_Rq
{
    _mAdblue_Disp_Rq_AR.WtrInj_Err_Warn_Rq.phys = getValue(this);
    _Adblue_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_WtrInj_Menu_Disp_Rq
{
    _mAdblue_Disp_Rq_AR.WtrInj_Menu_Disp_Rq.phys = getValue(this);
    _Adblue_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_WtrInj_Res_Disp_Rq
{
    _mAdblue_Disp_Rq_AR.WtrInj_Res_Disp_Rq.phys = getValue(this);
    _Adblue_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_WtrInj_Res_Icon_Rq
{
    _mAdblue_Disp_Rq_AR.WtrInj_Res_Icon_Rq.phys = getValue(this);
    _Adblue_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_WtrInj_Res_Warn_Rq
{
    _mAdblue_Disp_Rq_AR.WtrInj_Res_Warn_Rq.phys = getValue(this);
    _Adblue_Disp_Rq_AR_SpontanFlag = 1;
}

Adblue_Disp_Warn_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_Adblue_Disp_Warn_Rq_AR ) )
        {
        //  message   Adblue_Disp_Warn_Rq_AR ID: 1209 --- Sendeart 0 cyclicX --- 
            _Adblue_Disp_Warn_Rq_AR_Cnt--;
            if( _Adblue_Disp_Warn_Rq_AR_Cnt < 1 )
            {
                Adblue_Disp_Warn_Rq_AR_output();  // Nachricht wg. abgelaufenem Zyklus ausgeben
                _Adblue_Disp_Warn_Rq_AR_Cnt = _Adblue_Disp_Warn_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            }
        }
}

Adblue_Disp_Warn_Rq_AR_init()
{   /* Botschaft Adblue_Disp_Warn_Rq_AR ID: 1209 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 1209 0;
BA_ "NmAsrMessage" BO_ 1209 0;
BA_ "GenMsgMinAcceptLength" BO_ 1209 8;
BA_ "GenMsgILSupport" BO_ 1209 1;
BA_ "DiagState" BO_ 1209 0;
BA_ "DiagRequest" BO_ 1209 0;
BA_ "DiagResponse" BO_ 1209 0;
BA_ "GenMsgStartValue" BO_ 1209 "0";
BA_ "GenMsgStartDelayTime" BO_ 1209 0;
BA_ "GenMsgCycleTime" BO_ 1209 1000;
BA_ "GenMsgSendType" BO_ 1209 0;
    */
    _Adblue_Disp_Warn_Rq_AR_Timebase =          c_tDBKomTimer_20ms;
    _Adblue_Disp_Warn_Rq_AR_CycleCount = 1000 / _Adblue_Disp_Warn_Rq_AR_Timebase;
    _Adblue_Disp_Warn_Rq_AR_StartDelay =    0 / _Adblue_Disp_Warn_Rq_AR_Timebase;
    _Adblue_Disp_Warn_Rq_AR_Cnt = _Adblue_Disp_Warn_Rq_AR_StartDelay;

    putValue( HMI__STMSGSD_Adblue_Disp_Warn_Rq_AR, _Adblue_Disp_Warn_Rq_AR_StartDelay * _Adblue_Disp_Warn_Rq_AR_Timebase );

    _mAdblue_Disp_Warn_Rq_AR.Adblue_RemainDist.phys = getValue( HMI_Adblue_RemainDist );
    _mAdblue_Disp_Warn_Rq_AR.AdBlue_TankChk_Warn1_Disp_Rq.phys = getValue( HMI_AdBlue_TankChk_Warn1_Disp_Rq );
    _mAdblue_Disp_Warn_Rq_AR.AdBlue_TankChk_Warn2_Disp_Rq.phys = getValue( HMI_AdBlue_TankChk_Warn2_Disp_Rq );
    _mAdblue_Disp_Warn_Rq_AR.Adblue_WarnLvl1.phys = getValue( HMI_Adblue_WarnLvl1 );
    _mAdblue_Disp_Warn_Rq_AR.Adblue_WarnLvl2.phys = getValue( HMI_Adblue_WarnLvl2 );
    _mAdblue_Disp_Warn_Rq_AR.Adblue_WarnLvl3.phys = getValue( HMI_Adblue_WarnLvl3 );
    _mAdblue_Disp_Warn_Rq_AR.AdblueEU6_ChkMsg_Disp_Rq.phys = getValue( HMI_AdblueEU6_ChkMsg_Disp_Rq );
    _mAdblue_Disp_Warn_Rq_AR.AdblueEU6_Msg_Disp_TrgrRq.phys = getValue( HMI_AdblueEU6_Msg_Disp_TrgrRq );
    _mAdblue_Disp_Warn_Rq_AR.AdblueEU6_RefillMsg_Disp_Rq.phys = getValue( HMI_AdblueEU6_RefillMsg_Disp_Rq );
    _mAdblue_Disp_Warn_Rq_AR.AdblueEU6_RemainDist.phys = getValue( HMI_AdblueEU6_RemainDist );
    _mAdblue_Disp_Warn_Rq_AR.EngSt_Remain.phys = getValue( HMI_EngSt_Remain );
}

Adblue_Disp_Warn_Rq_AR_output(void)
{
    output( _mAdblue_Disp_Warn_Rq_AR );
}

Adblue_Disp_Warn_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Adblue_Disp_Warn_Rq_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_EIAdblue_Disp_Warn_Rq_AR := %X\n", getValue( HMI__STMSG_Adblue_Disp_Warn_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_EAdblue_Disp_Warn_Rq_AR := %X\n", getValue( HMI__STMSGT_Adblue_Disp_Warn_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Adblue_RemainDist  := %X\n", getValue( HMI_Adblue_RemainDist ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AdBlue_TankChk_Warn1_Disp_Rq  := %X\n", getValue( HMI_AdBlue_TankChk_Warn1_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AdBlue_TankChk_Warn2_Disp_Rq  := %X\n", getValue( HMI_AdBlue_TankChk_Warn2_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Adblue_WarnLvl1  := %X\n", getValue( HMI_Adblue_WarnLvl1 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Adblue_WarnLvl2  := %X\n", getValue( HMI_Adblue_WarnLvl2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Adblue_WarnLvl3  := %X\n", getValue( HMI_Adblue_WarnLvl3 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AdblueEU6_ChkMsg_Disp_Rq  := %X\n", getValue( HMI_AdblueEU6_ChkMsg_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AdblueEU6_Msg_Disp_TrgrRq  := %X\n", getValue( HMI_AdblueEU6_Msg_Disp_TrgrRq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AdblueEU6_RefillMsg_Disp_Rq  := %X\n", getValue( HMI_AdblueEU6_RefillMsg_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AdblueEU6_RemainDist  := %X\n", getValue( HMI_AdblueEU6_RemainDist ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngSt_Remain  := %X\n", getValue( HMI_EngSt_Remain ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tAdblue_Disp_Warn_Rq_AR
{
    putValue( HMI__STMSG_Adblue_Disp_Warn_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_Adblue_Disp_Warn_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Adblue_Disp_Warn_Rq_AR );
        if( tDelay > 0 )
            setTimer( _tAdblue_Disp_Warn_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_Adblue_Disp_Warn_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Adblue_Disp_Warn_Rq_AR
{
    if( getValue( this ) )
        openPanel("Adblue_Disp_Warn_Rq_AR");
}

on EnvVar HMI_Adblue_RemainDist
{
    _mAdblue_Disp_Warn_Rq_AR.Adblue_RemainDist.phys = getValue(this);
    putValue( HMI_Adblue_RemainDist_Hex, getValue(this) + 32767 );
}

on EnvVar HMI_AdBlue_TankChk_Warn1_Disp_Rq
{
    _mAdblue_Disp_Warn_Rq_AR.AdBlue_TankChk_Warn1_Disp_Rq.phys = getValue(this);
    putValue( HMI_AdBlue_TankChk_Warn1_Disp_Rq_Hex, getValue(this) + 32767 );
}

on EnvVar HMI_AdBlue_TankChk_Warn2_Disp_Rq
{
    _mAdblue_Disp_Warn_Rq_AR.AdBlue_TankChk_Warn2_Disp_Rq.phys = getValue(this);
    putValue( HMI_AdBlue_TankChk_Warn2_Disp_Rq_Hex, getValue(this) + 32767 );
}

on EnvVar HMI_Adblue_WarnLvl1
{
    _mAdblue_Disp_Warn_Rq_AR.Adblue_WarnLvl1.phys = getValue(this);
}

on EnvVar HMI_Adblue_WarnLvl2
{
    _mAdblue_Disp_Warn_Rq_AR.Adblue_WarnLvl2.phys = getValue(this);
}

on EnvVar HMI_Adblue_WarnLvl3
{
    _mAdblue_Disp_Warn_Rq_AR.Adblue_WarnLvl3.phys = getValue(this);
}

on EnvVar HMI_AdblueEU6_ChkMsg_Disp_Rq
{
    _mAdblue_Disp_Warn_Rq_AR.AdblueEU6_ChkMsg_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_AdblueEU6_Msg_Disp_TrgrRq
{
    _mAdblue_Disp_Warn_Rq_AR.AdblueEU6_Msg_Disp_TrgrRq.phys = getValue(this);
}

on EnvVar HMI_AdblueEU6_RefillMsg_Disp_Rq
{
    _mAdblue_Disp_Warn_Rq_AR.AdblueEU6_RefillMsg_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_AdblueEU6_RemainDist
{
    _mAdblue_Disp_Warn_Rq_AR.AdblueEU6_RemainDist.phys = getValue(this);
}

on EnvVar HMI_EngSt_Remain
{
    _mAdblue_Disp_Warn_Rq_AR.EngSt_Remain.phys = getValue(this);
}

on EnvVar HMI_Adblue_RemainDist_Hex
{
    _mAdblue_Disp_Warn_Rq_AR.Adblue_RemainDist.phys = getValue(this)-32767;
    putValue( HMI_Adblue_RemainDist, getValue(this) - 32767 );
}

APPL_ECU_HIL_TO_IC1_check_output()
{
//    if( !getValue( HMI__STMSG_APPL_ECU_HIL_TO_IC1 ) )  must not timeouted, is on event only
    {
    //  message   APPL_ECU_HIL_TO_IC1 --- Sendeart 1 spontanX
        if( _APPL_ECU_HIL_TO_IC1_SpontanFlag )
        {
            // Nachricht wg. spontaner �nderung ausgeben
            APPL_ECU_HIL_TO_IC1_output();
            // Spontan-Flag zur�cksetzen
            _APPL_ECU_HIL_TO_IC1_SpontanFlag = 0;
        }
    }
}

void APPL_ECU_HIL_TO_IC1_getValue(void)
{
    _mAPPL_ECU_HIL_TO_IC1.byte( 0 ) = getValue( HMI_APPL_ECU_HIL_TO_IC1A );
    _mAPPL_ECU_HIL_TO_IC1.byte( 1 ) = getValue( HMI_APPL_ECU_HIL_TO_IC1B );
    _mAPPL_ECU_HIL_TO_IC1.byte( 2 ) = getValue( HMI_APPL_ECU_HIL_TO_IC1C );
    _mAPPL_ECU_HIL_TO_IC1.byte( 3 ) = getValue( HMI_APPL_ECU_HIL_TO_IC1D );
    _mAPPL_ECU_HIL_TO_IC1.byte( 4 ) = getValue( HMI_APPL_ECU_HIL_TO_IC1E );
    _mAPPL_ECU_HIL_TO_IC1.byte( 5 ) = getValue( HMI_APPL_ECU_HIL_TO_IC1F );
    _mAPPL_ECU_HIL_TO_IC1.byte( 6 ) = getValue( HMI_APPL_ECU_HIL_TO_IC1G );
    _mAPPL_ECU_HIL_TO_IC1.byte( 7 ) = getValue( HMI_APPL_ECU_HIL_TO_IC1H );
}

APPL_ECU_HIL_TO_IC1_init()
{
//  message   APPL_ECU_HIL_TO_IC1 --- Sendeart 1 spontanX --- 
    _APPL_ECU_HIL_TO_IC1_Timebase =      c_tDBKomTimer_20ms;
    _APPL_ECU_HIL_TO_IC1_SpontanFlag = 0;

    _mAPPL_ECU_HIL_TO_IC1.APPL_ECU_HIL_TO_IC1A.phys = getValue( HMI_APPL_ECU_HIL_TO_IC1A);
    _mAPPL_ECU_HIL_TO_IC1.APPL_ECU_HIL_TO_IC1B.phys = getValue( HMI_APPL_ECU_HIL_TO_IC1B);
    _mAPPL_ECU_HIL_TO_IC1.APPL_ECU_HIL_TO_IC1C.phys = getValue( HMI_APPL_ECU_HIL_TO_IC1C);
    _mAPPL_ECU_HIL_TO_IC1.APPL_ECU_HIL_TO_IC1D.phys = getValue( HMI_APPL_ECU_HIL_TO_IC1D);
    _mAPPL_ECU_HIL_TO_IC1.APPL_ECU_HIL_TO_IC1E.phys = getValue( HMI_APPL_ECU_HIL_TO_IC1E);
    _mAPPL_ECU_HIL_TO_IC1.APPL_ECU_HIL_TO_IC1F.phys = getValue( HMI_APPL_ECU_HIL_TO_IC1F);
    _mAPPL_ECU_HIL_TO_IC1.APPL_ECU_HIL_TO_IC1G.phys = getValue( HMI_APPL_ECU_HIL_TO_IC1G);
    _mAPPL_ECU_HIL_TO_IC1.APPL_ECU_HIL_TO_IC1H.phys = getValue( HMI_APPL_ECU_HIL_TO_IC1H);
}

APPL_ECU_HIL_TO_IC1_output(void)
{
    output( _mAPPL_ECU_HIL_TO_IC1 );
}

APPL_ECU_HIL_TO_IC1_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: APPL_ECU_HIL_TO_IC1\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_APPL_ECU_HIL_TO_IC1 := %X\n", getValue( HMI__STMSG_APPL_ECU_HIL_TO_IC1 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_APPL_ECU_HIL_TO_IC1 := %X\n", getValue( HMI__STMSGT_APPL_ECU_HIL_TO_IC1 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_APPL_ECU_HIL_TO_IC1A := %X\n", getValue( HMI_APPL_ECU_HIL_TO_IC1A ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_APPL_ECU_HIL_TO_IC1B := %X\n", getValue( HMI_APPL_ECU_HIL_TO_IC1B ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_APPL_ECU_HIL_TO_IC1C := %X\n", getValue( HMI_APPL_ECU_HIL_TO_IC1C ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_APPL_ECU_HIL_TO_IC1D := %X\n", getValue( HMI_APPL_ECU_HIL_TO_IC1D ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_APPL_ECU_HIL_TO_IC1E := %X\n", getValue( HMI_APPL_ECU_HIL_TO_IC1E ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_APPL_ECU_HIL_TO_IC1F := %X\n", getValue( HMI_APPL_ECU_HIL_TO_IC1F ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_APPL_ECU_HIL_TO_IC1G := %X\n", getValue( HMI_APPL_ECU_HIL_TO_IC1G ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_APPL_ECU_HIL_TO_IC1H := %X\n", getValue( HMI_APPL_ECU_HIL_TO_IC1H ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on EnvVar HMI__STMSP_APPL_ECU_HIL_TO_IC1
{
/* HJH inserted VDO */
    _APPL_ECU_HIL_TO_IC1_SpontanFlag = 1;
    if( getValue( this ) )
        putValue( this, 0 );
}

on envVar Env_Send_APPL_ECU_HIL_TO_IC1
{
  if( getValue(this) )
  {
    output( _mAPPL_ECU_HIL_TO_IC1 );
  }
}

on envVar HMI__STMSG_PO_APPL_ECU_HIL_TO_IC1
{
    if( getValue( this ) )
        openPanel("APPL_ECU_HIL_TO_IC1");
}

on EnvVar HMI_APPL_ECU_HIL_TO_IC1A
{
    _mAPPL_ECU_HIL_TO_IC1.APPL_ECU_HIL_TO_IC1A = getValue(this);
}

on EnvVar HMI_APPL_ECU_HIL_TO_IC1B
{
    _mAPPL_ECU_HIL_TO_IC1.APPL_ECU_HIL_TO_IC1B = getValue(this);
}

on EnvVar HMI_APPL_ECU_HIL_TO_IC1C
{
    _mAPPL_ECU_HIL_TO_IC1.APPL_ECU_HIL_TO_IC1C = getValue(this);
}

on EnvVar HMI_APPL_ECU_HIL_TO_IC1D
{
    _mAPPL_ECU_HIL_TO_IC1.APPL_ECU_HIL_TO_IC1D = getValue(this);
}

on EnvVar HMI_APPL_ECU_HIL_TO_IC1E
{
    _mAPPL_ECU_HIL_TO_IC1.APPL_ECU_HIL_TO_IC1E = getValue(this);
}

on EnvVar HMI_APPL_ECU_HIL_TO_IC1F
{
    _mAPPL_ECU_HIL_TO_IC1.APPL_ECU_HIL_TO_IC1F = getValue(this);
}

on EnvVar HMI_APPL_ECU_HIL_TO_IC1G
{
    _mAPPL_ECU_HIL_TO_IC1.APPL_ECU_HIL_TO_IC1G = getValue(this);
}

on EnvVar HMI_APPL_ECU_HIL_TO_IC1H
{
    _mAPPL_ECU_HIL_TO_IC1.APPL_ECU_HIL_TO_IC1H = getValue(this);
}

AQS_Data_HU_AR_check_output()
{
    if( !getValue( HMI__STMSG_AQS_Data_HU_AR ) )
    {
    //  message   AQS_Data_HU_AR ID: 2457862144 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _AQS_Data_HU_AR_DelayCnt > 0) _AQS_Data_HU_AR_DelayCnt--; // Mindestsendeabstand
        _AQS_Data_HU_AR_Cnt--;
        if( _AQS_Data_HU_AR_Cnt < 1 )
        {
            if( _AQS_Data_HU_AR_DelayCnt < 1 )
            {
                AQS_Data_HU_AR_output();  // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                 _AQS_Data_HU_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _AQS_Data_HU_AR_DelayCnt = _AQS_Data_HU_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _AQS_Data_HU_AR_SpontanFlag = 1;
            }
            _AQS_Data_HU_AR_Cnt = _AQS_Data_HU_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _AQS_Data_HU_AR_SpontanFlag )
        {
            if( _AQS_Data_HU_AR_DelayCnt < 1 )
            {
                AQS_Data_HU_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _AQS_Data_HU_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _AQS_Data_HU_AR_DelayCnt = _AQS_Data_HU_AR_MinDelay;
            }
        }
    }
}

AQS_Data_HU_AR_init()
{   /* Botschaft AQS_Data_HU_AR ID: 2457862144 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 2457862144 0;
BA_ "NmAsrMessage" BO_ 2457862144 0;
BA_ "GenMsgMinAcceptLength" BO_ 2457862144 8;
BA_ "GenMsgILSupport" BO_ 2457862144 1;
BA_ "DiagState" BO_ 2457862144 0;
BA_ "DiagRequest" BO_ 2457862144 0;
BA_ "DiagResponse" BO_ 2457862144 0;
BA_ "GenMsgStartValue" BO_ 2457862144 "0";
BA_ "GenMsgDelayTime" BO_ 2457862144 50;
BA_ "GenMsgNrOfRepetition" BO_ 2457862144 0;
BA_ "GenMsgCycleTime" BO_ 2457862144 1000;
BA_ "GenMsgSendType" BO_ 2457862144 5;
    */
    _AQS_Data_HU_AR_Timebase =          c_tDBKomTimer_20ms;
    _AQS_Data_HU_AR_CycleCount =      1000 / _AQS_Data_HU_AR_Timebase;
    _AQS_Data_HU_AR_StartDelay =        50 / _AQS_Data_HU_AR_Timebase;
    _AQS_Data_HU_AR_MinDelay =           0 / _AQS_Data_HU_AR_Timebase;
    _AQS_Data_HU_AR_Cnt = _AQS_Data_HU_AR_StartDelay;
    _AQS_Data_HU_AR_SpontanFlag = 0;
    _AQS_Data_HU_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_AQS_Data_HU_AR, _AQS_Data_HU_AR_StartDelay * _AQS_Data_HU_AR_Timebase );

    _mAQS_Data_HU_AR.AirQual.phys =           	getValue( HMI_AirQual );
    _mAQS_Data_HU_AR.AQS_CO.phys =  			getValue( HMI_AQS_CO );
    _mAQS_Data_HU_AR.AQS_NOX.phys =    			getValue( HMI_AQS_NOX );
    _mAQS_Data_HU_AR.AQS_Par.phys =      		getValue( HMI_AQS_Par );
    
}

AQS_Data_HU_AR_output(void)
{
    output( _mAQS_Data_HU_AR );
}

AQS_Data_HU_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: AQS_Data_HU_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_AQS_Data_HU_AR := %X\n", getValue( HMI__STMSG_AQS_Data_HU_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_AQS_Data_HU_AR := %X\n", getValue( HMI__STMSGT_AQS_Data_HU_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_AirQual := %X\n", getValue( HMI_AirQual ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AQS_CO := %X\n", getValue( HMI_AQS_CO ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AQS_NOX := %X\n", getValue( HMI_AQS_NOX ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AQS_Par := %X\n", getValue( HMI_AQS_Par ) );        filePutString ( buffer, elcount( buffer ), hFile );
    
	}

on timer _tAQS_Data_HU_AR
{
    putValue( HMI__STMSG_AQS_Data_HU_AR, 0 );
}

on EnvVar HMI__STMSG_AQS_Data_HU_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_AQS_Data_HU_AR );
        if( tDelay > 0)    
            setTimer( _tAQS_Data_HU_AR, tDelay );
        else
            putValue( HMI__STMSG_AQS_Data_HU_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_AQS_Data_HU_AR
{
    if( getValue( this ) )
        openPanel("AQS_Data_HU_AR");
}

on EnvVar HMI_AirQual
{
    _mAQS_Data_HU_AR.AirQual.phys = getValue(this);
    _AQS_Data_HU_AR_SpontanFlag = 1;
}

on EnvVar HMI_AQS_CO
{
    _mAQS_Data_HU_AR.AQS_CO.phys = getValue(this);
    _AQS_Data_HU_AR_SpontanFlag = 1;
}

on EnvVar HMI_AQS_NOX
{
    _mAQS_Data_HU_AR.AQS_NOX.phys = getValue(this);
    _AQS_Data_HU_AR_SpontanFlag = 1;
}

on EnvVar HMI_AQS_Par
{
    _mAQS_Data_HU_AR.AQS_Par.phys = getValue(this);
    _AQS_Data_HU_AR_SpontanFlag = 1;
}


ARB_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_ARB_Stat_AR ) )
    {
    //  message   ARB_Stat_AR ID: 2440036352 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _ARB_Stat_AR_DelayCnt > 0) _ARB_Stat_AR_DelayCnt--; // Mindestsendeabstand
        _ARB_Stat_AR_Cnt--;
        if( _ARB_Stat_AR_Cnt < 1 )
        {
            if( _ARB_Stat_AR_DelayCnt < 1 )
            {
                ARB_Stat_AR_output();  // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                 _ARB_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _ARB_Stat_AR_DelayCnt = _ARB_Stat_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _ARB_Stat_AR_SpontanFlag = 1;
            }
            _ARB_Stat_AR_Cnt = _ARB_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _ARB_Stat_AR_SpontanFlag )
        {
            if( _ARB_Stat_AR_DelayCnt < 1 )
            {
                ARB_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _ARB_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _ARB_Stat_AR_DelayCnt = _ARB_Stat_AR_MinDelay;
            }
        }
    }
}

ARB_Stat_AR_init()
{   /* Botschaft ARB_Stat_AR ID: 2440036352 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 2440036352 0;
BA_ "NmAsrMessage" BO_ 2440036352 0;
BA_ "GenMsgMinAcceptLength" BO_ 2440036352 8;
BA_ "GenMsgILSupport" BO_ 2440036352 1;
BA_ "DiagState" BO_ 2440036352 0;
BA_ "DiagRequest" BO_ 2440036352 0;
BA_ "DiagResponse" BO_ 2440036352 0;
BA_ "GenMsgStartValue" BO_ 2440036352 "0";
BA_ "GenMsgDelayTime" BO_ 2440036352 50;
BA_ "GenMsgNrOfRepetition" BO_ 2440036352 0;
BA_ "GenMsgCycleTime" BO_ 2440036352 1000;
BA_ "GenMsgSendType" BO_ 2440036352 5;
    */
    _ARB_Stat_AR_Timebase =          c_tDBKomTimer_20ms;
    _ARB_Stat_AR_CycleCount =      1000 / _ARB_Stat_AR_Timebase;
    _ARB_Stat_AR_StartDelay =        50 / _ARB_Stat_AR_Timebase;
    _ARB_Stat_AR_MinDelay =           0 / _ARB_Stat_AR_Timebase;
    _ARB_Stat_AR_Cnt = _ARB_Stat_AR_StartDelay;
    _ARB_Stat_AR_SpontanFlag = 0;
    _ARB_Stat_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_ARB_Stat_AR, _ARB_Stat_AR_StartDelay * _ARB_Stat_AR_Timebase );

    _mARB_Stat_AR.ARB_AutoFct_Avl.phys =           	getValue( HMI_ARB_AutoFct_Avl );
    _mARB_Stat_AR.ARB_AutoFct_Stat.phys =  			getValue( HMI_ARB_AutoFct_Stat );
    _mARB_Stat_AR.ARB_Lt_Stat.phys =    			getValue( HMI_ARB_Lt_Stat );
    _mARB_Stat_AR.ARB_ManFct_Avl.phys =      		getValue( HMI_ARB_ManFct_Avl );
    _mARB_Stat_AR.ARB_Rt_Stat.phys =      			getValue( HMI_ARB_Rt_Stat );
    _mARB_Stat_AR.ARB_Warn_MsgDisp_Rq.phys =        getValue( HMI_ARB_Warn_MsgDisp_Rq );
    _mARB_Stat_AR.ARB_Stat_MsgDisp_Rq.phys =        getValue( HMI_ARB_Stat_MsgDisp_Rq );
}

ARB_Stat_AR_output(void)
{
    output( _mARB_Stat_AR );
}

ARB_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: ARB_Stat_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_ARB_Stat_AR := %X\n", getValue( HMI__STMSG_ARB_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_ARB_Stat_AR := %X\n", getValue( HMI__STMSGT_ARB_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ARB_AutoFct_Avl := %X\n", getValue( HMI_ARB_AutoFct_Avl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ARB_AutoFct_Stat := %X\n", getValue( HMI_ARB_AutoFct_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ARB_Lt_Stat := %X\n", getValue( HMI_ARB_Lt_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ARB_ManFct_Avl := %X\n", getValue( HMI_ARB_ManFct_Avl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ARB_Rt_Stat := %X\n", getValue( HMI_ARB_Rt_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ARB_Warn_MsgDisp_Rq := %X\n", getValue( HMI_ARB_Warn_MsgDisp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ARB_Stat_MsgDisp_Rq := %X\n", getValue( HMI_ARB_Warn_MsgDisp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tARB_Stat_AR
{
    putValue( HMI__STMSG_ARB_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_ARB_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_ARB_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tARB_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_ARB_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_ARB_Stat_AR
{
    if( getValue( this ) )
        openPanel("ARB_Stat_AR");
}

on EnvVar HMI_ARB_AutoFct_Avl
{
    _mARB_Stat_AR.ARB_AutoFct_Avl.phys = getValue(this);
    _ARB_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ARB_AutoFct_Stat
{
    _mARB_Stat_AR.ARB_AutoFct_Stat.phys = getValue(this);
    _ARB_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ARB_Lt_Stat
{
    _mARB_Stat_AR.ARB_Lt_Stat.phys = getValue(this);
    _ARB_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ARB_ManFct_Avl
{
    _mARB_Stat_AR.ARB_ManFct_Avl.phys = getValue(this);
    _ARB_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ARB_Rt_Stat
{
    _mARB_Stat_AR.ARB_Rt_Stat.phys = getValue(this);
    _ARB_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ARB_Warn_MsgDisp_Rq
{
    _mARB_Stat_AR.ARB_Warn_MsgDisp_Rq.phys = getValue(this);
    _ARB_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ARB_Stat_MsgDisp_Rq
{
   _mARB_Stat_AR.ARB_Stat_MsgDisp_Rq.phys = getValue(this);
    _ARB_Stat_AR_SpontanFlag = 1;
}

Assyst_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_Assyst_Stat_AR ) )
    {
    //  message   Assyst_Stat_AR ID: 487 --- Sendeart 0 cyclicX --- 
        _Assyst_Stat_AR_Cnt--;
        if( _Assyst_Stat_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            Assyst_Stat_AR_output();
            // Zyklus-Z�hler zur�cksetzen
            _Assyst_Stat_AR_Cnt = _Assyst_Stat_AR_CycleCount;
        }
    }
}

Assyst_Stat_AR_init()
{   /* Botschaft Assyst_Stat_AR ID: 487 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 487 0;
BA_ "NmAsrMessage" BO_ 487 0;
BA_ "GenMsgMinAcceptLength" BO_ 487 8;
BA_ "GenMsgILSupport" BO_ 487 1;
BA_ "DiagState" BO_ 487 0;
BA_ "DiagRequest" BO_ 487 0;
BA_ "DiagResponse" BO_ 487 0;
BA_ "GenMsgStartValue" BO_ 487 "0";
BA_ "GenMsgStartDelayTime" BO_ 487 0;
BA_ "GenMsgCycleTime" BO_ 487 1000;
BA_ "GenMsgSendType" BO_ 487 0;
    */
    _Assyst_Stat_AR_Timebase =          c_tDBKomTimer_20ms;
    _Assyst_Stat_AR_CycleCount =      1000 / _Assyst_Stat_AR_Timebase;
    _Assyst_Stat_AR_StartDelay =         0 / _Assyst_Stat_AR_Timebase;
    _Assyst_Stat_AR_Cnt = _Assyst_Stat_AR_StartDelay;

    putValue( HMI__STMSGSD_Assyst_Stat_AR, _Assyst_Stat_AR_StartDelay * _Assyst_Stat_AR_Timebase );

    _mAssyst_Stat_AR.Assyst_OilQuant.phys =            getValue( HMI_Assyst_OilQuant );
    _mAssyst_Stat_AR.Assyst_RelOilQual_Para.phys =     getValue( HMI_Assyst_RelOilQual_Para );
    _mAssyst_Stat_AR.Assyst_RemDist.phys =             getValue( HMI_Assyst_RemDist );
    _mAssyst_Stat_AR.Assyst_RemDist_Rdc.phys =         getValue( HMI_Assyst_RemDist_Rdc );
    _mAssyst_Stat_AR.Assyst_RemTm.phys =               getValue( HMI_Assyst_RemTm );
}

Assyst_Stat_AR_output(void)
{
    output( _mAssyst_Stat_AR );
}

Assyst_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Assyst_Stat_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Assyst_Stat_AR := %X\n", getValue( HMI__STMSG_Assyst_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Assyst_Stat_AR := %X\n", getValue( HMI__STMSGT_Assyst_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Assyst_OilQuant := %X\n", getValue( HMI_Assyst_OilQuant ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Assyst_RelOilQual_Para := %X\n", getValue( HMI_Assyst_RelOilQual_Para ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Assyst_RemDist := %X\n", getValue( HMI_Assyst_RemDist ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Assyst_RemDist_Rdc := %X\n", getValue( HMI_Assyst_RemDist_Rdc ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Assyst_RemTm := %X\n", getValue( HMI_Assyst_RemTm ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tAssyst_Stat_AR
{
    putValue( HMI__STMSG_Assyst_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_Assyst_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Assyst_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tAssyst_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_Assyst_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Assyst_Stat_AR
{
    if( getValue( this ) )
        openPanel("Assyst_Stat_AR");
}

on EnvVar HMI_Assyst_OilQuant
{
    _mAssyst_Stat_AR.Assyst_OilQuant.phys = getValue(this);
}

on EnvVar HMI_Assyst_RelOilQual_Para
{
    putValue( HMI_Assyst_RelOilQual_Para_0x01, getValue( this ) & 0x01 );
    putValue( HMI_Assyst_RelOilQual_Para_0x02, ( getValue( this ) & 0x02 ) >> 1 );
    putValue( HMI_Assyst_RelOilQual_Para_0x04, ( getValue( this ) & 0x04 ) >> 2 );
    putValue( HMI_Assyst_RelOilQual_Para_0x08, ( getValue( this ) & 0x08 ) >> 3 );
    putValue( HMI_Assyst_RelOilQual_Para_0x10, ( getValue( this ) & 0x10 ) >> 4 );
    putValue( HMI_Assyst_RelOilQual_Para_0x20, ( getValue( this ) & 0x20 ) >> 5 );
    putValue( HMI_Assyst_RelOilQual_Para_0x40, ( getValue( this ) & 0x40 ) >> 6 );
    putValue( HMI_Assyst_RelOilQual_Para_0x80, ( getValue( this ) & 0x80 ) >> 7 );
   _mAssyst_Stat_AR.Assyst_RelOilQual_Para.phys = getValue(this);
}

on EnvVar HMI_Assyst_RelOilQual_Para_0x01
{
    byte temp;

    temp = getValue( HMI_Assyst_RelOilQual_Para );
    if( ( temp & 0x01 ) == getValue( this ) )
    {
        return;
    }
    else
    {
        temp = ( temp & 0xFE ) + getValue( this );
    }
    putValue( HMI_Assyst_RelOilQual_Para, temp );
    _mAssyst_Stat_AR.Assyst_RelOilQual_Para.phys = temp;
}

on EnvVar HMI_Assyst_RelOilQual_Para_0x02
{
    byte temp;

    temp = getValue( HMI_Assyst_RelOilQual_Para );
    if( ( ( temp & 0x02 ) >> 1 ) == getValue( this ) )
    {
        return;
    }
    else
    {
        temp = (temp & 0xFD) + ( getValue( this ) << 1 );
    }
    putValue( HMI_Assyst_RelOilQual_Para, temp );
    _mAssyst_Stat_AR.Assyst_RelOilQual_Para.phys = temp;
}

on EnvVar HMI_Assyst_RelOilQual_Para_0x04
{
    byte temp;

    temp = getValue( HMI_Assyst_RelOilQual_Para );
    if( ( ( temp & 0x04 ) >> 2 ) == getValue( this ) )
    {
        return;
    }
    else
    {
        temp = (temp & 0xFB) + ( getValue( this ) << 2 );
    }
    putValue( HMI_Assyst_RelOilQual_Para, temp );
    _mAssyst_Stat_AR.Assyst_RelOilQual_Para.phys = temp;
}

on EnvVar HMI_Assyst_RelOilQual_Para_0x08
{
    byte temp;

    temp = getValue( HMI_Assyst_RelOilQual_Para );
    if( ( ( temp & 0x08 ) >> 3 ) == getValue( this ) )
    {
        return;
    }
    else
    {
        temp = (temp & 0xF7) + ( getValue( this ) << 3 );
    }
    putValue( HMI_Assyst_RelOilQual_Para, temp );
    _mAssyst_Stat_AR.Assyst_RelOilQual_Para.phys = temp;
}

on EnvVar HMI_Assyst_RelOilQual_Para_0x10
{
    byte temp;

    temp = getValue( HMI_Assyst_RelOilQual_Para );
    if( ( ( temp & 0x10 ) >> 4 ) == getValue( this ) )
    {
        return;
    }
    else
    {
        temp = (temp & 0xEF) + ( getValue( this ) << 4 );
    }
    putValue( HMI_Assyst_RelOilQual_Para, temp );
    _mAssyst_Stat_AR.Assyst_RelOilQual_Para.phys = temp;
}

on EnvVar HMI_Assyst_RelOilQual_Para_0x20
{
    byte temp;

    temp = getValue( HMI_Assyst_RelOilQual_Para );
    if( ( ( temp & 0x20 ) >> 5 ) == getValue( this ) )
    {
        return;
    }
    else
    {
        temp = (temp & 0xDF) + ( getValue( this ) << 5 );
    }
    putValue( HMI_Assyst_RelOilQual_Para, temp );
    _mAssyst_Stat_AR.Assyst_RelOilQual_Para.phys = temp;
}

on EnvVar HMI_Assyst_RelOilQual_Para_0x40
{
    byte temp;

    temp = getValue( HMI_Assyst_RelOilQual_Para );
    if( ( ( temp & 0x40 ) >> 6 ) == getValue( this ) )
    {
        return;
    }
    else
    {
        temp = (temp & 0xBF) + ( getValue( this ) << 6 );
    }
    putValue( HMI_Assyst_RelOilQual_Para, temp );
    _mAssyst_Stat_AR.Assyst_RelOilQual_Para.phys = temp;
}

on EnvVar HMI_Assyst_RelOilQual_Para_0x80
{
    byte temp;

    temp = getValue( HMI_Assyst_RelOilQual_Para );
    if( ( ( temp & 0x80 ) >> 7 ) == getValue( this ) )
    {
        return;
    }
    else
    {
        temp = (temp & 0x7F) + ( getValue( this ) << 7 );
    }
    putValue( HMI_Assyst_RelOilQual_Para, temp );
    _mAssyst_Stat_AR.Assyst_RelOilQual_Para.phys = temp;
}

on EnvVar HMI_Assyst_RemDist
{
    _mAssyst_Stat_AR.Assyst_RemDist.phys = getValue(this);
}

on EnvVar HMI_Assyst_RemDist_Rdc
{
    _mAssyst_Stat_AR.Assyst_RemDist_Rdc.phys = getValue(this);
}

on EnvVar HMI_Assyst_RemTm
{
    _mAssyst_Stat_AR.Assyst_RemTm.phys = getValue(this);
}

Assyst_Stat2_AR_check_output()
{
    if( !getValue( HMI__STMSG_Assyst_Stat2_AR ) )
    {
    //  message   Assyst_Stat2_AR ID: 485 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _Assyst_Stat2_AR_DelayCnt > 0) _Assyst_Stat2_AR_DelayCnt--; // Mindestsendeabstand
        _Assyst_Stat2_AR_Cnt--;
        if( _Assyst_Stat2_AR_Cnt < 1 )
        {
            if( _Assyst_Stat2_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                Assyst_Stat2_AR_output();
                _Assyst_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Assyst_Stat2_AR_DelayCnt = _Assyst_Stat2_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _Assyst_Stat2_AR_SpontanFlag = 1;
            }
            _Assyst_Stat2_AR_Cnt = _Assyst_Stat2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _Assyst_Stat2_AR_SpontanFlag )
        {
            if( _Assyst_Stat2_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                Assyst_Stat2_AR_output();
                _Assyst_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Assyst_Stat2_AR_DelayCnt = _Assyst_Stat2_AR_MinDelay;
            }
        }
    }
}

Assyst_Stat2_AR_init()
{   /* Botschaft Assyst_Stat2_AR ID: 485 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 485 0;
BA_ "NmAsrMessage" BO_ 485 0;
BA_ "GenMsgMinAcceptLength" BO_ 485 8;
BA_ "GenMsgILSupport" BO_ 485 1;
BA_ "DiagState" BO_ 485 0;
BA_ "DiagRequest" BO_ 485 0;
BA_ "DiagResponse" BO_ 485 0;
BA_ "GenMsgStartValue" BO_ 485 "0";
BA_ "GenMsgStartDelayTime" BO_ 485 0;
BA_ "GenMsgDelayTime" BO_ 485 100;
BA_ "GenMsgNrOfRepetitions" BO_ 485 0;
BA_ "GenMsgCycleTime" BO_ 485 1000;
BA_ "GenMsgSendType" BO_ 485 5;
    */
    _Assyst_Stat2_AR_Timebase =         c_tDBKomTimer_20ms;
    _Assyst_Stat2_AR_CycleCount =     1000 / _Assyst_Stat2_AR_Timebase;
    _Assyst_Stat2_AR_StartDelay =        0 / _Assyst_Stat2_AR_Timebase;
    _Assyst_Stat2_AR_MinDelay =        100 / _Assyst_Stat2_AR_Timebase;
    _Assyst_Stat2_AR_Cnt = _Assyst_Stat2_AR_StartDelay;
    _Assyst_Stat2_AR_SpontanFlag = 0;
    _Assyst_Stat2_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_Assyst_Stat2_AR, _Assyst_Stat2_AR_StartDelay * _Assyst_Stat2_AR_Timebase );

    _mAssyst_Stat2_AR.Assyst_HndOvr_Stat.phys = getValue( HMI_Assyst_HndOvr_Stat );
    _mAssyst_Stat2_AR.Assyst_OilQuant_Disp_Rq.phys = getValue( HMI_Assyst_OilQuant_Disp_Rq );
    _mAssyst_Stat2_AR.Assyst_OilQuant_Miss.phys = getValue( HMI_Assyst_OilQuant_Miss );
    _mAssyst_Stat2_AR.Assyst_OilQuant_Rel.phys = getValue( HMI_Assyst_OilQuant_Rel );
    _mAssyst_Stat2_AR.Assyst_OilWarn_Disp_Rq.phys = getValue( HMI_Assyst_OilWarn_Disp_Rq );
    _mAssyst_Stat2_AR.Assyst_RelOilQual_Para2.phys = getValue( HMI_Assyst_RelOilQual_Para2 );
    _mAssyst_Stat2_AR.Assyst_ServConf_Stat.phys = getValue( HMI_Assyst_ServConf_Stat );
    _mAssyst_Stat2_AR.Assyst_ServRst_Stat.phys = getValue( HMI_Assyst_ServRst_Stat );
    _mAssyst_Stat2_AR.Assyst_SpServConf_Succ.phys = getValue( HMI_Assyst_SpServConf_Succ );
}

Assyst_Stat2_AR_output()
{
    output( _mAssyst_Stat2_AR );
}

Assyst_Stat2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Assyst_Stat2_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Assyst_Stat2_AR := %X\n", getValue( HMI__STMSG_Assyst_Stat2_AR) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Assyst_Stat2_AR := %X\n", getValue( HMI__STMSGT_Assyst_Stat2_AR) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Assyst_HndOvr_Stat := %X\n", getValue( HMI_Assyst_HndOvr_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Assyst_OilQuant_Disp_Rq := %X\n", getValue( HMI_Assyst_OilQuant_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Assyst_OilQuant_Miss := %X\n", getValue( HMI_Assyst_OilQuant_Miss ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Assyst_OilQuant_Rel := %X\n", getValue( HMI_Assyst_OilQuant_Rel ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Assyst_OilWarn_Disp_Rq := %X\n", getValue( HMI_Assyst_OilWarn_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Assyst_RelOilQual_Para2 := %X\n", getValue( HMI_Assyst_RelOilQual_Para2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Assyst_ServConf_Stat := %X\n", getValue( HMI_Assyst_ServConf_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Assyst_ServRst_Stat := %X\n", getValue( HMI_Assyst_ServRst_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Assyst_SpServConf_Succ := %X\n", getValue( HMI_Assyst_SpServConf_Succ ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tAssyst_Stat2_AR
{
    putValue( HMI__STMSG_Assyst_Stat2_AR, 0 );
}

on EnvVar HMI__STMSG_Assyst_Stat2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Assyst_Stat2_AR );
        if( tDelay > 0)    
            setTimer( _tAssyst_Stat2_AR, tDelay );
        else
            putValue( HMI__STMSG_Assyst_Stat2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Assyst_Stat2_AR
{
    if( getValue( this ) )
        openPanel("Assyst_Stat2_AR");
}

on EnvVar HMI_Assyst_RelOilQual_Para2
{
    putValue( HMI_Assyst_RelOilQual_Para2_0x01, getValue( this ) & 0x01 );
    putValue( HMI_Assyst_RelOilQual_Para2_0x02, ( getValue( this ) & 0x02 ) >> 1 );
    putValue( HMI_Assyst_RelOilQual_Para2_0x04, ( getValue( this ) & 0x04 ) >> 2 );
    putValue( HMI_Assyst_RelOilQual_Para2_0x08, ( getValue( this ) & 0x08 ) >> 3 );
    putValue( HMI_Assyst_RelOilQual_Para2_0x10, ( getValue( this ) & 0x10 ) >> 4 );
    putValue( HMI_Assyst_RelOilQual_Para2_0x20, ( getValue( this ) & 0x20 ) >> 5 );
    putValue( HMI_Assyst_RelOilQual_Para2_0x40, ( getValue( this ) & 0x40 ) >> 6 );
    putValue( HMI_Assyst_RelOilQual_Para2_0x80, ( getValue( this ) & 0x80 ) >> 7 );
   _mAssyst_Stat2_AR.Assyst_RelOilQual_Para2.phys = getValue(this);
}

on EnvVar HMI_Assyst_RelOilQual_Para2_0x01
{
    byte temp;

    temp = getValue( HMI_Assyst_RelOilQual_Para2 );
    if( ( temp & 0x01 ) == getValue( this ) )
    {
        return;
    }
    else
    {
        temp = ( temp & 0xFE ) + getValue( this );
    }
    putValue( HMI_Assyst_RelOilQual_Para2, temp );
    _mAssyst_Stat2_AR.Assyst_RelOilQual_Para2.phys = temp;
}

on EnvVar HMI_Assyst_RelOilQual_Para2_0x02
{
    byte temp;

    temp = getValue( HMI_Assyst_RelOilQual_Para2 );
    if( ( ( temp & 0x02 ) >> 1 ) == getValue( this ) )
    {
        return;
    }
    else
    {
        temp = (temp & 0xFD) + ( getValue( this ) << 1 );
    }
    putValue( HMI_Assyst_RelOilQual_Para2, temp );
    _mAssyst_Stat2_AR.Assyst_RelOilQual_Para2.phys = temp;
}

on EnvVar HMI_Assyst_RelOilQual_Para2_0x04
{
    byte temp;

    temp = getValue( HMI_Assyst_RelOilQual_Para2 );
    if( ( ( temp & 0x04 ) >> 2 ) == getValue( this ) )
    {
        return;
    }
    else
    {
        temp = (temp & 0xFB) + ( getValue( this ) << 2 );
    }
    putValue( HMI_Assyst_RelOilQual_Para2, temp );
    _mAssyst_Stat2_AR.Assyst_RelOilQual_Para2.phys = temp;
}

on EnvVar HMI_Assyst_RelOilQual_Para2_0x08
{
    byte temp;

    temp = getValue( HMI_Assyst_RelOilQual_Para2 );
    if( ( ( temp & 0x08 ) >> 3 ) == getValue( this ) )
    {
        return;
    }
    else
    {
        temp = (temp & 0xF7) + ( getValue( this ) << 3 );
    }
    putValue( HMI_Assyst_RelOilQual_Para2, temp );
    _mAssyst_Stat2_AR.Assyst_RelOilQual_Para2.phys = temp;
}

on EnvVar HMI_Assyst_RelOilQual_Para2_0x10
{
    byte temp;

    temp = getValue( HMI_Assyst_RelOilQual_Para2 );
    if( ( ( temp & 0x10 ) >> 4 ) == getValue( this ) )
    {
        return;
    }
    else
    {
        temp = (temp & 0xEF) + ( getValue( this ) << 4 );
    }
    putValue( HMI_Assyst_RelOilQual_Para2, temp );
    _mAssyst_Stat2_AR.Assyst_RelOilQual_Para2.phys = temp;
}

on EnvVar HMI_Assyst_RelOilQual_Para2_0x20
{
    byte temp;

    temp = getValue( HMI_Assyst_RelOilQual_Para2 );
    if( ( ( temp & 0x20 ) >> 5 ) == getValue( this ) )
    {
        return;
    }
    else
    {
        temp = (temp & 0xDF) + ( getValue( this ) << 5 );
    }
    putValue( HMI_Assyst_RelOilQual_Para2, temp );
    _mAssyst_Stat2_AR.Assyst_RelOilQual_Para2.phys = temp;
}

on EnvVar HMI_Assyst_RelOilQual_Para2_0x40
{
    byte temp;

    temp = getValue( HMI_Assyst_RelOilQual_Para2 );
    if( ( ( temp & 0x40 ) >> 6 ) == getValue( this ) )
    {
        return;
    }
    else
    {
        temp = (temp & 0xBF) + ( getValue( this ) << 6 );
    }
    putValue( HMI_Assyst_RelOilQual_Para2, temp );
    _mAssyst_Stat2_AR.Assyst_RelOilQual_Para2.phys = temp;
}

on EnvVar HMI_Assyst_RelOilQual_Para2_0x80
{
    byte temp;

    temp = getValue( HMI_Assyst_RelOilQual_Para2 );
    if( ( ( temp & 0x80 ) >> 7 ) == getValue( this ) )
    {
        return;
    }
    else
    {
        temp = (temp & 0x7F) + ( getValue( this ) << 7 );
    }
    putValue( HMI_Assyst_RelOilQual_Para2, temp );
    _mAssyst_Stat2_AR.Assyst_RelOilQual_Para2.phys = temp;
}

on EnvVar HMI_Assyst_SpServConf_Succ
{
    _mAssyst_Stat2_AR.Assyst_SpServConf_Succ.phys = getValue(this);
    _Assyst_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Assyst_HndOvr_Stat
{
    _mAssyst_Stat2_AR.Assyst_HndOvr_Stat.phys = getValue(this);
    _Assyst_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Assyst_OilQuant_Disp_Rq
{
    _mAssyst_Stat2_AR.Assyst_OilQuant_Disp_Rq.phys = getValue(this);
    _Assyst_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Assyst_OilQuant_Miss
{
    _mAssyst_Stat2_AR.Assyst_OilQuant_Miss.phys = getValue(this);
    _Assyst_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Assyst_OilQuant_Rel
{
    _mAssyst_Stat2_AR.Assyst_OilQuant_Rel.phys = getValue(this);
    _Assyst_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Assyst_OilWarn_Disp_Rq
{
    _mAssyst_Stat2_AR.Assyst_OilWarn_Disp_Rq.phys = getValue(this);
    _Assyst_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Assyst_ServConf_Stat
{
    _mAssyst_Stat2_AR.Assyst_ServConf_Stat.phys = getValue(this);
    _Assyst_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Assyst_ServRst_Stat
{
    _mAssyst_Stat2_AR.Assyst_ServRst_Stat.phys = getValue(this);
    _Assyst_Stat2_AR_SpontanFlag = 1;
}

Assyst_Stat3_AR_check_output()
{
    if( !getValue( HMI__STMSG_Assyst_Stat3_AR ) )
    {
    //  message   Assyst_Stat3_AR ID: 1065 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _Assyst_Stat3_AR_DelayCnt > 0) _Assyst_Stat3_AR_DelayCnt--; // Mindestsendeabstand
        _Assyst_Stat3_AR_Cnt--;
        if( _Assyst_Stat3_AR_Cnt < 1 )
        {
            if( _Assyst_Stat3_AR_DelayCnt < 1 )
            {
                Assyst_Stat3_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                _Assyst_Stat3_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Assyst_Stat3_AR_DelayCnt = _Assyst_Stat3_AR_MinDelay;
            }
            else
            {
                 _Assyst_Stat3_AR_SpontanFlag = 1; // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
            }
            _Assyst_Stat3_AR_Cnt = _Assyst_Stat3_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _Assyst_Stat3_AR_SpontanFlag )
        {
            if( _Assyst_Stat3_AR_DelayCnt < 1 )
            {
                Assyst_Stat3_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _Assyst_Stat3_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Assyst_Stat3_AR_DelayCnt = _Assyst_Stat3_AR_MinDelay;
            }
        }
    }
}

Assyst_Stat3_AR_init()
{   /* Botschaft Assyst_Stat3_AR ID: 1065 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1065 0;
BA_ "NmAsrMessage" BO_ 1065 0;
BA_ "GenMsgMinAcceptLength" BO_ 1065 8;
BA_ "GenMsgILSupport" BO_ 1065 1;
BA_ "DiagState" BO_ 1065 0;
BA_ "DiagRequest" BO_ 1065 0;
BA_ "DiagResponse" BO_ 1065 0;
BA_ "GenMsgStartValue" BO_ 1065 "0";
BA_ "GenMsgCycleTime" BO_ 1065 1000;
BA_ "GenMsgSendType" BO_ 1065 0;
    */
    _Assyst_Stat3_AR_Timebase =         c_tDBKomTimer_20ms;
    _Assyst_Stat3_AR_CycleCount =     1000 / _Assyst_Stat3_AR_Timebase;
    _Assyst_Stat3_AR_StartDelay =        0 / _Assyst_Stat3_AR_Timebase;
    _Assyst_Stat3_AR_MinDelay =          0 / _Assyst_Stat3_AR_Timebase;
    _Assyst_Stat3_AR_Cnt = _Assyst_Stat3_AR_StartDelay;
    _Assyst_Stat3_AR_SpontanFlag = 0;
    _Assyst_Stat3_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_Assyst_Stat2_AR, _Assyst_Stat2_AR_StartDelay * _Assyst_Stat2_AR_Timebase );

    _mAssyst_Stat3_AR.Assyst_OprtnTm.phys = getValue( HMI_Assyst_OprtnTm );
    _mAssyst_Stat3_AR.Assyst_RemainOprtnTm.phys = getValue( HMI_Assyst_RemainOprtnTm );
}

Assyst_Stat3_AR_output()
{
    output( _mAssyst_Stat3_AR );
}

Assyst_Stat3_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Assyst_Stat3_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Assyst_Stat3_AR := %X\n", getValue( HMI__STMSG_Assyst_Stat3_AR) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Assyst_Stat3_AR := %X\n", getValue( HMI__STMSGT_Assyst_Stat3_AR) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Assyst_OprtnTm := %X\n", getValue( HMI_Assyst_OprtnTm ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Assyst_RemainOprtnTm := %X\n", getValue( HMI_Assyst_RemainOprtnTm ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tAssyst_Stat3_AR
{
    putValue( HMI__STMSG_Assyst_Stat3_AR, 0 );
}

on EnvVar HMI__STMSG_Assyst_Stat3_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Assyst_Stat3_AR );
        if( tDelay > 0)    
            setTimer( _tAssyst_Stat3_AR, tDelay );
        else
            putValue( HMI__STMSG_Assyst_Stat3_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Assyst_Stat3_AR
{
    if( getValue( this ) )
        openPanel("Assyst_Stat3_AR");
}

on EnvVar HMI_Assyst_OprtnTm
{
    _mAssyst_Stat3_AR.Assyst_OprtnTm.phys = getValue(this);
    _Assyst_Stat3_AR_SpontanFlag = 1;
}

on EnvVar HMI_Assyst_RemainOprtnTm
{
    _mAssyst_Stat3_AR.Assyst_RemainOprtnTm.phys = getValue(this);
    _Assyst_Stat3_AR_SpontanFlag = 1;
}

AWD_TCASE_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_AWD_TCASE_Disp_Rq_AR ) )
    {
    //  message   AWD_TCASE_Disp_Rq_AR ID: 1184 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _AWD_TCASE_Disp_Rq_AR_DelayCnt > 0) _AWD_TCASE_Disp_Rq_AR_DelayCnt--; // Mindestsendeabstand
        _AWD_TCASE_Disp_Rq_AR_Cnt--;
        if( _AWD_TCASE_Disp_Rq_AR_Cnt < 1 )
        {
            if( _AWD_TCASE_Disp_Rq_AR_DelayCnt < 1 )
            {
                AWD_TCASE_Disp_Rq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _AWD_TCASE_Disp_Rq_AR_DelayCnt = _AWD_TCASE_Disp_Rq_AR_MinDelay;
            }
            else
            {
                 _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1; // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
            }
            _AWD_TCASE_Disp_Rq_AR_Cnt = _AWD_TCASE_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _AWD_TCASE_Disp_Rq_AR_SpontanFlag )
        {
            if( _AWD_TCASE_Disp_Rq_AR_DelayCnt < 1 )
            {
                AWD_TCASE_Disp_Rq_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _AWD_TCASE_Disp_Rq_AR_DelayCnt = _AWD_TCASE_Disp_Rq_AR_MinDelay;
            }
        }
    }
}

AWD_TCASE_Disp_Rq_AR_init()
{   /* Botschaft AWD_TCASE_Disp_Rq_AR ID: 1184 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1184 0;
BA_ "NmAsrMessage" BO_ 1184 0;
BA_ "GenMsgMinAcceptLength" BO_ 1184 6;
BA_ "GenMsgILSupport" BO_ 1184 1;
BA_ "DiagState" BO_ 1184 0;
BA_ "DiagRequest" BO_ 1184 0;
BA_ "DiagResponse" BO_ 1184 0;
BA_ "GenMsgStartValue" BO_ 1184 "0";
BA_ "GenMsgDelayTime" BO_ 1184 100;
BA_ "GenMsgNrOfRepetition" BO_ 1184 0;
BA_ "GenMsgCycleTime" BO_ 1184 1000;
BA_ "GenMsgSendType" BO_ 1184 5;
    */
    _AWD_TCASE_Disp_Rq_AR_Timebase =         c_tDBKomTimer_20ms;
    _AWD_TCASE_Disp_Rq_AR_CycleCount =     1000 / _AWD_TCASE_Disp_Rq_AR_Timebase;
    _AWD_TCASE_Disp_Rq_AR_StartDelay =        0 / _AWD_TCASE_Disp_Rq_AR_Timebase;
    _AWD_TCASE_Disp_Rq_AR_MinDelay =        100 / _AWD_TCASE_Disp_Rq_AR_Timebase;
    _AWD_TCASE_Disp_Rq_AR_Cnt = _AWD_TCASE_Disp_Rq_AR_StartDelay;
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 0;
    _AWD_TCASE_Disp_Rq_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_AWD_TCASE_Disp_Rq_AR, _AWD_TCASE_Disp_Rq_AR_StartDelay * _AWD_TCASE_Disp_Rq_AR_Timebase );

    _mAWD_TCASE_Disp_Rq_AR.AWD_Msg1_Disp_Rq.phys = getValue( HMI_AWD_Msg1_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.AWD_Msg2_Disp_Rq.phys = getValue( HMI_AWD_Msg2_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.DiffLk_Msg1_Disp_Rq.phys = getValue( HMI_DiffLk_Msg1_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.DiffLk_Msg2_Disp_Rq.phys = getValue( HMI_DiffLk_Msg2_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.DiffLk_Msg3_Disp_Rq.phys = getValue( HMI_DiffLk_Msg3_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.DiffLk_Msg4_Disp_Rq.phys = getValue( HMI_DiffLk_Msg4_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.DiffLk_Msg5_Disp_Rq.phys = getValue( HMI_DiffLk_Msg5_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.DiffLk_Msg6_Disp_Rq.phys = getValue( HMI_DiffLk_Msg6_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.DiffLk_Msg7_Disp_Rq.phys = getValue( HMI_DiffLk_Msg7_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.DiffLk_Msg8_Disp_Rq.phys = getValue( HMI_DiffLk_Msg8_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.DiffLk_Msg9_Disp_Rq.phys = getValue( HMI_DiffLk_Msg9_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.DriftMd_Disp_Rq_AMG.phys = getValue( HMI_DriftMd_Disp_Rq_AMG );
    _mAWD_TCASE_Disp_Rq_AR.DriftMd_IconDisp_Rq_AMG.phys = getValue( HMI_DriftMd_IconDisp_Rq_AMG );
    _mAWD_TCASE_Disp_Rq_AR.DPC_Disp_TrgRq_TCASE.phys = getValue( HMI_DPC_Disp_TrgRq_TCASE );
    _mAWD_TCASE_Disp_Rq_AR.TCASE_GrLo_IndLmp_On_Rq.phys = getValue( HMI_TCASE_GrLo_IndLmp_On_Rq );
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg1_Disp_Rq.phys = getValue( HMI_TCASE_Msg1_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg2_Disp_Rq.phys = getValue( HMI_TCASE_Msg2_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg3_Disp_Rq.phys = getValue( HMI_TCASE_Msg3_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg4_Disp_Rq.phys = getValue( HMI_TCASE_Msg4_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg5_Disp_Rq.phys = getValue( HMI_TCASE_Msg5_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg6_Disp_Rq.phys = getValue( HMI_TCASE_Msg6_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg7_Disp_Rq.phys = getValue( HMI_TCASE_Msg7_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg8_Disp_Rq.phys = getValue( HMI_TCASE_Msg8_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg9_Disp_Rq.phys = getValue( HMI_TCASE_Msg9_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg10_Disp_Rq.phys = getValue( HMI_TCASE_Msg10_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg11_Disp_Rq.phys = getValue( HMI_TCASE_Msg11_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg12_Disp_Rq.phys = getValue( HMI_TCASE_Msg12_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg13_Disp_Rq.phys = getValue( HMI_TCASE_Msg13_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg14_Disp_Rq.phys = getValue( HMI_TCASE_Msg14_Disp_Rq );
    _mAWD_TCASE_Disp_Rq_AR.OffRoad_Score.phys = getValue( HMI_OffRoad_Score );
    _mAWD_TCASE_Disp_Rq_AR.OffRoad_Guide_info.phys = getValue( HMI_OffRoad_Guide_info );
}

AWD_TCASE_Disp_Rq_AR_output()
{
    output( _mAWD_TCASE_Disp_Rq_AR );
}

AWD_TCASE_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: AWD_TCASE_Disp_Rq_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_AWD_TCASE_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_AWD_TCASE_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_AWD_TCASE_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_AWD_TCASE_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AWD_Msg1_Disp_Rq := %X\n", getValue( HMI_AWD_Msg1_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AWD_Msg2_Disp_Rq := %X\n", getValue( HMI_AWD_Msg2_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DiffLk_Msg1_Disp_Rq := %X\n", getValue( HMI_DiffLk_Msg1_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DiffLk_Msg2_Disp_Rq := %X\n", getValue( HMI_DiffLk_Msg2_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DiffLk_Msg3_Disp_Rq := %X\n", getValue( HMI_DiffLk_Msg3_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DiffLk_Msg4_Disp_Rq := %X\n", getValue( HMI_DiffLk_Msg4_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DiffLk_Msg5_Disp_Rq := %X\n", getValue( HMI_DiffLk_Msg5_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DiffLk_Msg6_Disp_Rq := %X\n", getValue( HMI_DiffLk_Msg6_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DiffLk_Msg7_Disp_Rq := %X\n", getValue( HMI_DiffLk_Msg7_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DiffLk_Msg8_Disp_Rq := %X\n", getValue( HMI_DiffLk_Msg8_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DiffLk_Msg9_Disp_Rq := %X\n", getValue( HMI_DiffLk_Msg9_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Disp_TrgRq_TCASE := %X\n", getValue( HMI_DPC_Disp_TrgRq_TCASE ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCASE_GrLo_IndLmp_On_Rq := %X\n", getValue( HMI_TCASE_GrLo_IndLmp_On_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCASE_Msg1_Disp_Rq := %X\n", getValue( HMI_TCASE_Msg1_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCASE_Msg2_Disp_Rq := %X\n", getValue( HMI_TCASE_Msg2_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCASE_Msg3_Disp_Rq := %X\n", getValue( HMI_TCASE_Msg3_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCASE_Msg4_Disp_Rq := %X\n", getValue( HMI_TCASE_Msg4_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCASE_Msg5_Disp_Rq := %X\n", getValue( HMI_TCASE_Msg5_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCASE_Msg6_Disp_Rq := %X\n", getValue( HMI_TCASE_Msg6_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCASE_Msg7_Disp_Rq := %X\n", getValue( HMI_TCASE_Msg7_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCASE_Msg8_Disp_Rq := %X\n", getValue( HMI_TCASE_Msg8_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCASE_Msg9_Disp_Rq := %X\n", getValue( HMI_TCASE_Msg9_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCASE_Msg10_Disp_Rq := %X\n", getValue( HMI_TCASE_Msg10_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCASE_Msg11_Disp_Rq := %X\n", getValue( HMI_TCASE_Msg11_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCASE_Msg12_Disp_Rq := %X\n", getValue( HMI_TCASE_Msg12_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCASE_Msg13_Disp_Rq := %X\n", getValue( HMI_TCASE_Msg13_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCASE_Msg14_Disp_Rq := %X\n", getValue( HMI_TCASE_Msg14_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount(buffer), "0.0000 HMI_DriftMd_Disp_Rq_AMG := %X\n", getValue( HMI_DriftMd_Disp_Rq_AMG ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_DriftMd_IconDisp_Rq_AMG := %X\n", getValue( HMI_DriftMd_IconDisp_Rq_AMG ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_OffRoad_Score := %X\n", getValue( HMI_OffRoad_Score ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_OffRoad_Guide_info := %X\n", getValue( HMI_OffRoad_Guide_info ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tAWD_TCASE_Disp_Rq_AR
{
    putValue( HMI__STMSG_AWD_TCASE_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_AWD_TCASE_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_AWD_TCASE_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tAWD_TCASE_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_AWD_TCASE_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_AWD_TCASE_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("AWD_TCASE_Disp_Rq_AR");
}

on EnvVar HMI_AWD_Msg1_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.AWD_Msg1_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_AWD_Msg2_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.AWD_Msg2_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DiffLk_Msg1_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.DiffLk_Msg1_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DiffLk_Msg2_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.DiffLk_Msg2_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DiffLk_Msg3_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.DiffLk_Msg3_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DiffLk_Msg4_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.DiffLk_Msg4_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DiffLk_Msg5_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.DiffLk_Msg5_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DiffLk_Msg6_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.DiffLk_Msg6_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DiffLk_Msg7_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.DiffLk_Msg7_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DiffLk_Msg8_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.DiffLk_Msg8_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DiffLk_Msg9_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.DiffLk_Msg9_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Disp_TrgRq_TCASE
{
    _mAWD_TCASE_Disp_Rq_AR.DPC_Disp_TrgRq_TCASE.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCASE_GrLo_IndLmp_On_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.TCASE_GrLo_IndLmp_On_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCASE_Msg1_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg1_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCASE_Msg2_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg2_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCASE_Msg3_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg3_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCASE_Msg4_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg4_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCASE_Msg5_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg5_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCASE_Msg6_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg6_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCASE_Msg7_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg7_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCASE_Msg8_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg8_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCASE_Msg9_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg9_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCASE_Msg10_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg10_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCASE_Msg11_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg11_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCASE_Msg12_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg12_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCASE_Msg13_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg13_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCASE_Msg14_Disp_Rq
{
    _mAWD_TCASE_Disp_Rq_AR.TCASE_Msg14_Disp_Rq.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DriftMd_Disp_Rq_AMG
{
    _mAWD_TCASE_Disp_Rq_AR.DriftMd_Disp_Rq_AMG.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DriftMd_IconDisp_Rq_AMG
{
    _mAWD_TCASE_Disp_Rq_AR.DriftMd_IconDisp_Rq_AMG.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_OffRoad_Score
{
    _mAWD_TCASE_Disp_Rq_AR.OffRoad_Score.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_OffRoad_Guide_info
{
    _mAWD_TCASE_Disp_Rq_AR.OffRoad_Guide_info.phys = getValue(this);
    _AWD_TCASE_Disp_Rq_AR_SpontanFlag = 1;
}
BC_F_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_BC_F_Disp_Rq_AR ) )
    {
    //  message   BC_F_Disp_Rq_AR ID: 823 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _BC_F_Disp_Rq_AR_Cnt--;
        if( _BC_F_Disp_Rq_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            BC_F_Disp_Rq_AR_output();
            _BC_F_Disp_Rq_AR_Cnt = _BC_F_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _BC_F_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _BC_F_Disp_Rq_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            BC_F_Disp_Rq_AR_output();
            _BC_F_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

BC_F_Disp_Rq_AR_init()
{   /* Botschaft BC_F_Disp_Rq_AR ID: 823 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 823 0;
BA_ "NmAsrMessage" BO_ 823 0;
BA_ "GenMsgMinAcceptLength" BO_ 823 4;
BA_ "GenMsgILSupport" BO_ 823 1;
BA_ "DiagState" BO_ 823 0;
BA_ "DiagRequest" BO_ 823 0;
BA_ "DiagResponse" BO_ 823 0;
BA_ "GenMsgStartValue" BO_ 823 "0";
BA_ "GenMsgStartDelayTime" BO_ 823 0;
BA_ "GenMsgDelayTime" BO_ 823 5;
BA_ "GenMsgNrOfRepetitions" BO_ 823 0;
BA_ "GenMsgCycleTime" BO_ 823 1000;
BA_ "GenMsgSendType" BO_ 823 5;
    */
    _BC_F_Disp_Rq_AR_Timebase =         c_tDBKomTimer_20ms;
    _BC_F_Disp_Rq_AR_CycleCount =     1000 / _BC_F_Disp_Rq_AR_Timebase;
    _BC_F_Disp_Rq_AR_StartDelay =        0 / _BC_F_Disp_Rq_AR_Timebase;
    _BC_F_Disp_Rq_AR_Cnt = _BC_F_Disp_Rq_AR_StartDelay;
    _BC_F_Disp_Rq_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_BC_F_Disp_Rq_AR, _BC_F_Disp_Rq_AR_StartDelay * _BC_F_Disp_Rq_AR_Timebase );

    _mBC_F_Disp_Rq_AR.BrkFldIndLmp_On_Rq.phys = getValue( HMI_BrkFldIndLmp_On_Rq );
    _mBC_F_Disp_Rq_AR.BrkLnWearIndLmp_On_Rq.phys = getValue( HMI_BrkLnWearIndLmp_On_Rq );
    _mBC_F_Disp_Rq_AR.CoolIndLmp_On_Rq.phys = getValue( HMI_CoolIndLmp_On_Rq );
    _mBC_F_Disp_Rq_AR.EngHd_Flt_Stat_BC_F.phys = getValue( HMI_EngHd_Flt_Stat_BC_F );
    _mBC_F_Disp_Rq_AR.EngHd_Stat_BC_F.phys = getValue( HMI_EngHd_Stat_BC_F );
    _mBC_F_Disp_Rq_AR.SEB_WarnDisp_Rq.phys = getValue( HMI_SEB_WarnDisp_Rq );
    _mBC_F_Disp_Rq_AR.SRS_IndLmp_Rq_SEB.phys = getValue( HMI_SRS_IndLmp_Rq_SEB );
    _mBC_F_Disp_Rq_AR.WashWtrIndLmp_LowTemp_On_Rq.phys = getValue( HMI_WashWtrIndLmp_LowTemp_On_Rq );
    _mBC_F_Disp_Rq_AR.WashWtrIndLmp_On_Rq.phys = getValue( HMI_WashWtrIndLmp_On_Rq );
}

BC_F_Disp_Rq_AR_output(void)
{
    output( _mBC_F_Disp_Rq_AR );
}

BC_F_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: BC_F_Disp_Rq_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_BC_F_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_BC_F_Disp_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_BC_F_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_BC_F_Disp_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkFldIndLmp_On_Rq := %X\n", getValue( HMI_BrkFldIndLmp_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkLnWearIndLmp_On_Rq := %X\n", getValue( HMI_BrkLnWearIndLmp_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CoolIndLmp_On_Rq := %X\n", getValue( HMI_CoolIndLmp_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngHd_Flt_Stat_BC_F := %X\n", getValue( HMI_EngHd_Flt_Stat_BC_F ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngHd_Stat_BC_F := %X\n", getValue( HMI_EngHd_Stat_BC_F ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SEB_WarnDisp_Rq := %X\n", getValue( HMI_SEB_WarnDisp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SRS_IndLmp_Rq_SEB := %X\n", getValue( HMI_SRS_IndLmp_Rq_SEB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WashWtrIndLmp_LowTemp_On_Rq := %X\n", getValue( HMI_WashWtrIndLmp_LowTemp_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WashWtrIndLmp_On_Rq := %X\n", getValue( HMI_WashWtrIndLmp_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tBC_F_Disp_Rq_AR
{
    putValue( HMI__STMSG_BC_F_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_BC_F_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_BC_F_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tBC_F_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_BC_F_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_BC_F_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("BC_F_Disp_Rq_AR");
}

on EnvVar HMI_BrkFldIndLmp_On_Rq
{
    _mBC_F_Disp_Rq_AR.BrkFldIndLmp_On_Rq.phys = getValue(this);
    _BC_F_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BrkLnWearIndLmp_On_Rq
{
    _mBC_F_Disp_Rq_AR.BrkLnWearIndLmp_On_Rq.phys = getValue(this);
    _BC_F_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_CoolIndLmp_On_Rq
{
    _mBC_F_Disp_Rq_AR.CoolIndLmp_On_Rq.phys = getValue(this);
    _BC_F_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EngHd_Flt_Stat_BC_F
{
    _mBC_F_Disp_Rq_AR.EngHd_Flt_Stat_BC_F.phys = getValue(this);
    _BC_F_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EngHd_Stat_BC_F
{
    _mBC_F_Disp_Rq_AR.EngHd_Stat_BC_F.phys = getValue(this);
    _BC_F_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SEB_WarnDisp_Rq
{
    _mBC_F_Disp_Rq_AR.SEB_WarnDisp_Rq.phys = getValue(this);
    _BC_F_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SRS_IndLmp_Rq_SEB
{
    _mBC_F_Disp_Rq_AR.SRS_IndLmp_Rq_SEB.phys = getValue(this);
    _BC_F_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_WashWtrIndLmp_LowTemp_On_Rq
{
    _mBC_F_Disp_Rq_AR.WashWtrIndLmp_LowTemp_On_Rq.phys = getValue(this);
    _BC_F_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_WashWtrIndLmp_On_Rq
{
    _mBC_F_Disp_Rq_AR.WashWtrIndLmp_On_Rq.phys = getValue(this);
    _BC_F_Disp_Rq_AR_SpontanFlag = 1;
}

BC_Stat1_VAN_AR_check_output()
{
    if( !getValue( HMI__STMSG_BC_Stat1_VAN_AR ) )
    {
    //  message   BC_Stat1_VAN_AR ID: 1156 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _BC_Stat1_VAN_AR_Cnt--;
        if( _BC_Stat1_VAN_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            BC_Stat1_VAN_AR_output();
            _BC_Stat1_VAN_AR_Cnt = _BC_Stat1_VAN_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _BC_Stat1_VAN_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _BC_Stat1_VAN_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            BC_Stat1_VAN_AR_output();
            _BC_Stat1_VAN_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

BC_Stat1_VAN_AR_init()
{   /* Botschaft BC_Stat1_VAN_AR ID: 1156 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 821 0;
BA_ "NmAsrMessage" BO_ 821 0;
BA_ "GenMsgMinAcceptLength" BO_ 821 8;
BA_ "GenMsgILSupport" BO_ 821 1;
BA_ "DiagState" BO_ 821 0;
BA_ "DiagRequest" BO_ 821 0;
BA_ "DiagResponse" BO_ 821 0;
BA_ "GenMsgStartValue" BO_ 821 "0";
BA_ "GenMsgStartDelayTime" BO_ 821 0;
BA_ "GenMsgDelayTime" BO_ 821 5;
BA_ "GenMsgNrOfRepetitions" BO_ 821 0;
BA_ "GenMsgCycleTime" BO_ 821 500;
BA_ "GenMsgSendType" BO_ 821 5;
    */
    _BC_Stat1_VAN_AR_Timebase =         c_tDBKomTimer_20ms;
    _BC_Stat1_VAN_AR_CycleCount =     500 / _BC_Stat1_VAN_AR_Timebase;
    _BC_Stat1_VAN_AR_StartDelay =       0 / _BC_Stat1_VAN_AR_Timebase;
    _BC_Stat1_VAN_AR_Cnt = _BC_F_Stat2_AR_StartDelay;
    _BC_Stat1_VAN_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_BC_Stat1_VAN_AR, _BC_Stat1_VAN_AR_StartDelay * _BC_Stat1_VAN_AR_Timebase );

    _mBC_Stat1_VAN_AR.IL_R_BoxBody_Stat.phys = getValue( HMI_IL_R_BoxBody_Stat );
    _mBC_Stat1_VAN_AR.DrvProgSelect_Sw_Psd_ASBM.phys = getValue( HMI_DrvProgSelect_Sw_Psd_ASBM );
    _mBC_Stat1_VAN_AR.DSR_Sw_Psd_ASBM.phys = getValue( HMI_DSR_Sw_Psd_ASBM );
    _mBC_Stat1_VAN_AR.MPkBrk_Stat.phys = getValue( HMI_MPkBrk_Stat );
    _mBC_Stat1_VAN_AR.RainSens_Snsty_Stat.phys = getValue( HMI_RainSens_Snsty_Stat );
    _mBC_Stat1_VAN_AR.RLS_Off_Posn.phys = getValue( HMI_RLS_Off_Posn );
    _mBC_Stat1_VAN_AR.VTA_ITS_DsablSw_Stat_OHCM.phys = getValue( HMI_VTA_ITS_DsablSw_Stat_OHCM );
    _mBC_Stat1_VAN_AR.VTA_TPS_DsablSw_Stat_OHCM.phys = getValue( HMI_VTA_TPS_DsablSw_Stat_OHCM );
    _mBC_Stat1_VAN_AR.DL_RLtch_Dedicated_Stat.phys = getValue( HMI_DL_RLtch_Dedicated_Stat );
    _mBC_Stat1_VAN_AR.ENDA_ContEngRun_Sw.phys = getValue( HMI_ENDA_ContEngRun_Sw );
    _mBC_Stat1_VAN_AR.ENDA_DrvProgSelect_Sw.phys = getValue( HMI_ENDA_DrvProgSelect_Sw );
    _mBC_Stat1_VAN_AR.ENDA_DSR_Sw.phys = getValue( HMI_ENDA_DSR_Sw );
    _mBC_Stat1_VAN_AR.ENDA_PSDLtSw.phys = getValue( HMI_ENDA_PSDLtSw );
    _mBC_Stat1_VAN_AR.ENDA_PSDRtSw.phys = getValue( HMI_ENDA_PSDRtSw );
    _mBC_Stat1_VAN_AR.ENDA_TaxiRadCon_Sw.phys = getValue( HMI_ENDA_TaxiRadCon_Sw );
    _mBC_Stat1_VAN_AR.FW_RLtch_Stat.phys = getValue( HMI_FW_RLtch_Stat );
    
}

BC_Stat1_VAN_AR_output(void)
{
    output( _mBC_Stat1_VAN_AR );
}

BC_Stat1_VAN_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: BC_F_Stat2_AR\n", 27, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_BC_Stat1_VAN_AR := %X\n", getValue( HMI__STMSG_BC_Stat1_VAN_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_BC_Stat1_VAN_AR := %X\n", getValue( HMI__STMSGT_BC_Stat1_VAN_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IL_R_BoxBody_Stat := %X\n", getValue( HMI_IL_R_BoxBody_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrvProgSelect_Sw_Psd_ASBM := %X\n", getValue( HMI_DrvProgSelect_Sw_Psd_ASBM ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DSR_Sw_Psd_ASBM := %X\n", getValue( HMI_DSR_Sw_Psd_ASBM ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPkBrk_Stat := %X\n", getValue( HMI_MPkBrk_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RainSens_Snsty_Stat := %X\n", getValue( HMI_RainSens_Snsty_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RLS_Off_Posn := %X\n", getValue( HMI_RLS_Off_Posn ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VTA_ITS_DsablSw_Stat_OHCM := %X\n", getValue( HMI_VTA_ITS_DsablSw_Stat_OHCM ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VTA_TPS_DsablSw_Stat_OHCM := %X\n", getValue( HMI_VTA_TPS_DsablSw_Stat_OHCM ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DL_RLtch_Dedicated_Stat := %X\n", getValue( HMI_DL_RLtch_Dedicated_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ENDA_ContEngRun_Sw := %X\n", getValue( HMI_ENDA_ContEngRun_Sw ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ENDA_DrvProgSelect_Sw := %X\n", getValue( HMI_ENDA_DrvProgSelect_Sw ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ENDA_DSR_Sw := %X\n", getValue( HMI_ENDA_DSR_Sw ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ENDA_PSDLtSw := %X\n", getValue( HMI_ENDA_PSDLtSw ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ENDA_PSDRtSw := %X\n", getValue( HMI_ENDA_PSDRtSw ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ENDA_TaxiRadCon_Sw := %X\n", getValue( HMI_ENDA_TaxiRadCon_Sw ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FW_RLtch_Stat := %X\n", getValue( HMI_FW_RLtch_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tBC_Stat1_VAN_AR
{
    putValue( HMI__STMSG_BC_Stat1_VAN_AR, 0 );
}

on EnvVar HMI__STMSG_BC_Stat1_VAN_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_BC_Stat1_VAN_AR );
        if( tDelay > 0)    
            setTimer( _tBC_Stat1_VAN_AR, tDelay );
        else
            putValue( HMI__STMSG_BC_Stat1_VAN_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_BC_Stat1_VAN_AR
{
    if( getValue( this ) )
        openPanel("BC_Stat1_VAN_AR");
}

on EnvVar HMI_IL_R_BoxBody_Stat
{
    _mBC_Stat1_VAN_AR.IL_R_BoxBody_Stat.phys = getValue(this);
    _BC_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrvProgSelect_Sw_Psd_ASBM
{
    _mBC_Stat1_VAN_AR.DrvProgSelect_Sw_Psd_ASBM.phys = getValue(this);
    _BC_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_DSR_Sw_Psd_ASBM
{
    _mBC_Stat1_VAN_AR.DSR_Sw_Psd_ASBM.phys = getValue(this);
    _BC_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_MPkBrk_Stat
{
    _mBC_Stat1_VAN_AR.MPkBrk_Stat.phys = getValue(this);
    _BC_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_RainSens_Snsty_Stat
{
    _mBC_Stat1_VAN_AR.RainSens_Snsty_Stat.phys = getValue(this);
    _BC_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_RLS_Off_Posn
{
    _mBC_Stat1_VAN_AR.RLS_Off_Posn.phys = getValue(this);
    _BC_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_VTA_ITS_DsablSw_Stat_OHCM
{
    _mBC_Stat1_VAN_AR.VTA_ITS_DsablSw_Stat_OHCM.phys = getValue(this);
    _BC_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_VTA_TPS_DsablSw_Stat_OHCM
{
    _mBC_Stat1_VAN_AR.VTA_TPS_DsablSw_Stat_OHCM.phys = getValue(this);
    _BC_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_DL_RLtch_Dedicated_Stat
{
    _mBC_Stat1_VAN_AR.DL_RLtch_Dedicated_Stat.phys = getValue(this);
    _BC_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_ENDA_ContEngRun_Sw
{
    _mBC_Stat1_VAN_AR.ENDA_ContEngRun_Sw.phys = getValue(this);
    _BC_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_ENDA_DrvProgSelect_Sw
{
    _mBC_Stat1_VAN_AR.ENDA_DrvProgSelect_Sw.phys = getValue(this);
    _BC_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_ENDA_DSR_Sw
{
    _mBC_Stat1_VAN_AR.ENDA_DSR_Sw.phys = getValue(this);
    _BC_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_ENDA_PSDLtSw
{
    _mBC_Stat1_VAN_AR.ENDA_PSDLtSw.phys = getValue(this);
    _BC_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_ENDA_PSDRtSw
{
    _mBC_Stat1_VAN_AR.ENDA_PSDRtSw.phys = getValue(this);
    _BC_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_ENDA_TaxiRadCon_Sw
{
    _mBC_Stat1_VAN_AR.ENDA_TaxiRadCon_Sw.phys = getValue(this);
    _BC_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_FW_RLtch_Stat
{
    _mBC_Stat1_VAN_AR.FW_RLtch_Stat.phys = getValue(this);
    _BC_Stat1_VAN_AR_SpontanFlag = 1;
}

BC_F_Stat1_AR_check_output()
{
    if( !getValue( HMI__STMSG_BC_F_Stat1_AR ) )
    {
    //  message   BC_F_Stat1_AR ID: 825 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _BC_F_Stat1_AR_DelayCnt > 0) _BC_F_Stat1_AR_DelayCnt--; // Mindestsendeabstand
        _BC_F_Stat1_AR_Cnt--;
        if( _BC_F_Stat1_AR_Cnt < 1 )
        {
            if( _BC_F_Stat1_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                BC_F_Stat1_AR_output();
                _BC_F_Stat1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _BC_F_Stat1_AR_DelayCnt = _BC_F_Stat1_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _BC_F_Stat1_AR_SpontanFlag = 1;
            }
            _BC_F_Stat1_AR_Cnt = _BC_F_Stat1_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _BC_F_Stat1_AR_SpontanFlag)
        {
            if( _BC_F_Stat1_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                BC_F_Stat1_AR_output();
                _BC_F_Stat1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _BC_F_Stat1_AR_DelayCnt = _BC_F_Stat1_AR_MinDelay;
            }
        }
    }
}

BC_F_Stat1_AR_init()
{   /* Botschaft BC_F_Stat1_AR ID: 825 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 825 0;
BA_ "NmAsrMessage" BO_ 825 0;
BA_ "GenMsgMinAcceptLength" BO_ 825 8;
BA_ "GenMsgILSupport" BO_ 825 1;
BA_ "DiagState" BO_ 825 0;
BA_ "DiagRequest" BO_ 825 0;
BA_ "DiagResponse" BO_ 825 0;
BA_ "GenMsgStartValue" BO_ 825 "0";
BA_ "GenMsgStartDelayTime" BO_ 825 0;
BA_ "GenMsgDelayTime" BO_ 825 50;
BA_ "GenMsgNrOfRepetitions" BO_ 825 0;
BA_ "GenMsgCycleTime" BO_ 825 100;
BA_ "GenMsgSendType" BO_ 825 5;
    */
    _BC_F_Stat1_AR_Timebase =          c_tDBKomTimer_5ms;
    _BC_F_Stat1_AR_CycleCount =      100 / _BC_F_Stat1_AR_Timebase;
    _BC_F_Stat1_AR_StartDelay =        0 / _BC_F_Stat1_AR_Timebase;
    _BC_F_Stat1_AR_MinDelay =         50 / _BC_F_Stat1_AR_Timebase;
    _BC_F_Stat1_AR_Cnt = _BC_F_Stat1_AR_StartDelay;
    _BC_F_Stat1_AR_SpontanFlag = 0;
    _BC_F_Stat1_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_BC_F_Stat1_AR, _BC_F_Stat1_AR_StartDelay * _BC_F_Stat1_AR_Timebase );

    putValue( HMI_AirTemp_Outsd, 20 );  // 60� Difference * 0.5� resolution := 20�C
    _mBC_F_Stat1_AR.AirTemp_Outsd.phys = getValue( HMI_AirTemp_Outsd );
    putValue( HMI_AirTemp_Outsd_Sens_Stat, 0 ); 
    _mBC_F_Stat1_AR.AirTemp_Outsd_Sens_Stat.phys = getValue( HMI_AirTemp_Outsd_Sens_Stat );
    _mBC_F_Stat1_AR.CLkS_Akust_Lk_Rq_Stat.phys = getValue( HMI_CLkS_Akust_Lk_Rq_Stat );
    _mBC_F_Stat1_AR.CLkS_Emg_Unlk_Rq.phys = getValue( HMI_CLkS_Emg_Unlk_Rq );
    _mBC_F_Stat1_AR.DL_Lk_V2.phys = getValue( HMI_DL_Lk_V2 );
    _mBC_F_Stat1_AR.DrSw_D_Vld_Stat.phys = getValue( HMI_DrSw_D_Vld_Stat );
    _mBC_F_Stat1_AR.ESL_Lk_Appl_BC_F.phys = getValue( HMI_ESL_Lk_Appl_BC_F );
    _mBC_F_Stat1_AR.Hrn_On.phys = getValue( HMI_Hrn_On );
    _mBC_F_Stat1_AR.IP_Brt.phys = getValue( HMI_IP_Brt );
    _mBC_F_Stat1_AR.PwrSup15_On.phys = getValue( HMI_PwrSup15_On );
    _mBC_F_Stat1_AR.PwrSup15_On_Diag.phys = getValue( HMI_PwrSup15_On_Diag );
    _mBC_F_Stat1_AR.PwrSup15R_On.phys = getValue( HMI_PwrSup15R_On );
    _mBC_F_Stat1_AR.PwrSup15R_On_Diag.phys = getValue( HMI_PwrSup15R_On_Diag );
    putValue( HMI_SwIllLvl_Ctrl_Style, 1 );
    _mBC_F_Stat1_AR.SwIllLvl_Ctrl_Style.phys = getValue( HMI_SwIllLvl_Ctrl_Style );
    _mBC_F_Stat1_AR.SwIllLvl_Raw.phys = getValue( HMI_SwIllLvl_Raw );
    _mBC_F_Stat1_AR.TSSR_Cls_Rq.phys = getValue( HMI_TSSR_Cls_Rq );
    _mBC_F_Stat1_AR.TSSR_RainCls_Event_Info.phys = getValue( HMI_TSSR_RainCls_Event_Info );
    _mBC_F_Stat1_AR.TSSR_RB_Sw_Psd_OHCM.phys = getValue( HMI_TSSR_RB_Sw_Psd_OHCM );
    _mBC_F_Stat1_AR.TSSR_Sw_Stat_OHCM.phys = getValue( HMI_TSSR_Sw_Stat_OHCM );
	_mBC_F_Stat1_AR.WprPkHt_Stat.phys = getValue( HMI_WprPkHt_Stat );
}

BC_F_Stat1_AR_output(void)
{
    output( _mBC_F_Stat1_AR );
}

BC_F_Stat1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: BC_F_Stat1_AR\n", 27, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_BC_F_Stat1_AR := %X\n", getValue( HMI__STMSG_BC_F_Stat1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_BC_F_Stat1_AR := %X\n", getValue( HMI__STMSGT_BC_F_Stat1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AirTemp_Outsd := %X\n", getValue( HMI_AirTemp_Outsd ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AirTemp_Outsd_Sens_Stat := %X\n", getValue( HMI_AirTemp_Outsd_Sens_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Akust_Lk_Rq_Stat := %X\n", getValue( HMI_CLkS_Akust_Lk_Rq_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Emg_Unlk_Rq := %X\n", getValue( HMI_CLkS_Emg_Unlk_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DL_Lk_V2 := %X\n", getValue( HMI_DL_Lk_V2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrSw_D_Vld_Stat := %X\n", getValue( HMI_DrSw_D_Vld_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ESL_Lk_Appl_BC_F := %X\n", getValue( HMI_ESL_Lk_Appl_BC_F ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Hrn_On := %X\n", getValue( HMI_Hrn_On ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IP_Brt := %X\n", getValue( HMI_IP_Brt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PwrSup15_On := %X\n", getValue( HMI_PwrSup15_On ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PwrSup15_On_Diag := %X\n", getValue( HMI_PwrSup15_On_Diag ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PwrSup15R_On := %X\n", getValue( HMI_PwrSup15R_On ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PwrSup15R_On_Diag := %X\n", getValue( HMI_PwrSup15R_On_Diag ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SwIllLvl_Ctrl_Style := %X\n", getValue( HMI_SwIllLvl_Ctrl_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SwIllLvl_Raw := %X\n", getValue( HMI_SwIllLvl_Raw ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSSR_Cls_Rq := %X\n", getValue( HMI_TSSR_Cls_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSSR_RainCls_Event_Info := %X\n", getValue( HMI_TSSR_RainCls_Event_Info ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSSR_RB_Sw_Psd_OHCM := %X\n", getValue( HMI_TSSR_RB_Sw_Psd_OHCM ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSSR_Sw_Stat_OHCM := %X\n", getValue( HMI_TSSR_Sw_Stat_OHCM ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_WprPkHt_Stat := %X\n", getValue( HMI_WprPkHt_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tBC_F_Stat1_AR
{
    putValue( HMI__STMSG_BC_F_Stat1_AR, 0 );
}

on EnvVar HMI__STMSG_BC_F_Stat1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_BC_F_Stat1_AR );
        if( tDelay > 0)    
            setTimer( _tBC_F_Stat1_AR, tDelay );
        else
            putValue( HMI__STMSG_BC_F_Stat1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_BC_F_Stat1_AR
{
    if( getValue( this ) )
        openPanel("BC_F_Stat1_AR");
}

on EnvVar HMI_AirTemp_Outsd
{
    _mBC_F_Stat1_AR.AirTemp_Outsd.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_AirTemp_Outsd_Sens_Stat
{
    _mBC_F_Stat1_AR.AirTemp_Outsd_Sens_Stat.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_CLkS_Akust_Lk_Rq_Stat
{
    _mBC_F_Stat1_AR.CLkS_Akust_Lk_Rq_Stat.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_CLkS_Emg_Unlk_Rq
{
    _mBC_F_Stat1_AR.CLkS_Emg_Unlk_Rq.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DL_Lk_V2
{
    _mBC_F_Stat1_AR.DL_Lk_V2.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrSw_D_Vld_Stat
{
    _mBC_F_Stat1_AR.DrSw_D_Vld_Stat.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_ESL_Lk_Appl_BC_F
{
    _mBC_F_Stat1_AR.ESL_Lk_Appl_BC_F.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Hrn_On
{
    _mBC_F_Stat1_AR.Hrn_On.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_IP_Brt
{
    _mBC_F_Stat1_AR.IP_Brt.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PwrSup15_On
{
    _mBC_F_Stat1_AR.PwrSup15_On.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PwrSup15_On_Diag
{
    _mBC_F_Stat1_AR.PwrSup15_On_Diag.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PwrSup15R_On
{
    _mBC_F_Stat1_AR.PwrSup15R_On.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PwrSup15R_On_Diag
{
    _mBC_F_Stat1_AR.PwrSup15R_On_Diag.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_SwIllLvl_Ctrl_Style
{
    _mBC_F_Stat1_AR.SwIllLvl_Ctrl_Style.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_SwIllLvl_Raw
{
    _mBC_F_Stat1_AR.SwIllLvl_Raw.phys = getValue(this)-100;
//    _BC_F_Stat1_AR_SpontanFlag = 1;    !!!! blocked for getting incremental dimming
}

on EnvVar HMI_TSSR_Cls_Rq
{
    _mBC_F_Stat1_AR.TSSR_Cls_Rq.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSSR_RainCls_Event_Info
{
    _mBC_F_Stat1_AR.TSSR_RainCls_Event_Info.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSSR_RB_Sw_Psd_OHCM
{
    _mBC_F_Stat1_AR.TSSR_RB_Sw_Psd_OHCM.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSSR_Sw_Stat_OHCM
{
    _mBC_F_Stat1_AR.TSSR_Sw_Stat_OHCM.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

on EnvVar HMI_WprPkHt_Stat
{
    _mBC_F_Stat1_AR.WprPkHt_Stat.phys = getValue(this);
    _BC_F_Stat1_AR_SpontanFlag = 1;
}

BC_F_Stat2_AR_check_output()
{
    if( !getValue( HMI__STMSG_BC_F_Stat2_AR ) )
    {
    //  message   BC_F_Stat2_AR ID: 821 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _BC_F_Stat2_AR_Cnt--;
        if( _BC_F_Stat2_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            BC_F_Stat2_AR_output();
            _BC_F_Stat2_AR_Cnt = _BC_F_Stat2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _BC_F_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _BC_F_Stat2_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            BC_F_Stat2_AR_output();
            _BC_F_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

BC_F_Stat2_AR_init()
{   /* Botschaft BC_F_Stat2_AR ID: 821 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 821 0;
BA_ "NmAsrMessage" BO_ 821 0;
BA_ "GenMsgMinAcceptLength" BO_ 821 8;
BA_ "GenMsgILSupport" BO_ 821 1;
BA_ "DiagState" BO_ 821 0;
BA_ "DiagRequest" BO_ 821 0;
BA_ "DiagResponse" BO_ 821 0;
BA_ "GenMsgStartValue" BO_ 821 "0";
BA_ "GenMsgStartDelayTime" BO_ 821 0;
BA_ "GenMsgDelayTime" BO_ 821 5;
BA_ "GenMsgNrOfRepetitions" BO_ 821 0;
BA_ "GenMsgCycleTime" BO_ 821 500;
BA_ "GenMsgSendType" BO_ 821 5;
    */
    _BC_F_Stat2_AR_Timebase =         c_tDBKomTimer_20ms;
    _BC_F_Stat2_AR_CycleCount =     500 / _BC_F_Stat2_AR_Timebase;
    _BC_F_Stat2_AR_StartDelay =       0 / _BC_F_Stat2_AR_Timebase;
    _BC_F_Stat2_AR_Cnt = _BC_F_Stat2_AR_StartDelay;
    _BC_F_Stat2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_BC_F_Stat2_AR, _BC_F_Stat2_AR_StartDelay * _BC_F_Stat2_AR_Timebase );

    _mBC_F_Stat2_AR.BeltHdOvrSw_Psd_V2.phys = getValue( HMI_BeltHdOvrSw_Psd_V2 );
    _mBC_F_Stat2_AR.BMM_Status.phys = getValue( HMI_BMM_Status );
	_mBC_F_Stat2_AR.BrkLnWear_PreWarn_Actv.phys = getValue( HMI_BrkLnWear_PreWarn_Actv );
	_mBC_F_Stat2_AR.CPD_Disp_MsgRq.phys = getValue( HMI_CPD_Disp_MsgRq );
	_mBC_F_Stat2_AR.CPD_Disp_TrgrRq.phys = getValue( HMI_CPD_Disp_TrgrRq );
	_mBC_F_Stat2_AR.CPD_DispIcon_Stat.phys = getValue( HMI_CPD_DispIcon_Stat );
	_mBC_F_Stat2_AR.CPD_UsrActn_Stat.phys = getValue( HMI_CPD_UsrActn_Stat );
    _mBC_F_Stat2_AR.DTQ_Sw_Md.phys = getValue( HMI_DTQ_Sw_Md );
    _mBC_F_Stat2_AR.CPF_Ft_Stat.phys = getValue( HMI_CPF_Ft_Stat );
    _mBC_F_Stat2_AR.HdRst_R_Rq.phys = getValue( HMI_HdRst_R_Rq );
    _mBC_F_Stat2_AR.HUD_Sw_Psd.phys = getValue( HMI_HUD_Sw_Psd );
    _mBC_F_Stat2_AR.LDP_Sw_Md.phys = getValue( HMI_LDP_Sw_Md );
    _mBC_F_Stat2_AR.LDP_LongPress_Msg_Disp_Rq.phys = getValue( HMI_LDP_LongPress_Msg_Disp_Rq );
    _mBC_F_Stat2_AR.NV_Sw_Psd.phys = getValue( HMI_NV_Sw_Psd );
    _mBC_F_Stat2_AR.ParkSw_Psd.phys = getValue( HMI_ParkSw_Psd );
    _mBC_F_Stat2_AR.RainCls_Mon_Stat.phys = getValue( HMI_RainCls_Mon_Stat );
    _mBC_F_Stat2_AR.RainCls_Win_FL_Rq.phys = getValue( HMI_RainCls_Win_FL_Rq );
    _mBC_F_Stat2_AR.RainCls_Win_FR_Rq.phys = getValue( HMI_RainCls_Win_FR_Rq );
    _mBC_F_Stat2_AR.RainCls_Win_RL_Rq.phys = getValue( HMI_RainCls_Win_RL_Rq );
    _mBC_F_Stat2_AR.RainCls_Win_RR_Rq.phys = getValue( HMI_RainCls_Win_RR_Rq );    
    _mBC_F_Stat2_AR.RB_R_Sw_Psd_Ft.phys = getValue( HMI_RB_R_Sw_Psd_Ft );
    _mBC_F_Stat2_AR.RLS_AutoPosn.phys = getValue( HMI_RLS_AutoPosn );
    _mBC_F_Stat2_AR.RLS_FogLmp_Ft_Posn.phys = getValue( HMI_RLS_FogLmp_Ft_Posn );
    _mBC_F_Stat2_AR.RLS_FogLmp_R_Posn.phys = getValue( HMI_RLS_FogLmp_R_Posn );
    _mBC_F_Stat2_AR.RLS_LoBm_Posn.phys = getValue( HMI_RLS_LoBm_Posn );
    _mBC_F_Stat2_AR.RLS_PkLmp_Posn_Lt.phys = getValue( HMI_RLS_PkLmp_Posn_Lt );
    _mBC_F_Stat2_AR.RLS_PkLmp_Posn_Rt.phys = getValue( HMI_RLS_PkLmp_Posn_Rt );
    _mBC_F_Stat2_AR.RLS_PosnLmp_Posn.phys = getValue( HMI_RLS_PosnLmp_Posn );
    _mBC_F_Stat2_AR.SuspLvlAdjSw_Psd_AMG.phys = getValue( HMI_SuspLvlAdjSw_Psd_AMG );
    _mBC_F_Stat2_AR.SVS_Sw_Psd.phys = getValue( HMI_SVS_Sw_Psd );
}

BC_F_Stat2_AR_output(void)
{
    output( _mBC_F_Stat2_AR );
}

BC_F_Stat2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: BC_F_Stat2_AR\n", 27, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_BC_F_Stat2_AR := %X\n", getValue( HMI__STMSG_BC_F_Stat2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_BC_F_Stat2_AR := %X\n", getValue( HMI__STMSGT_BC_F_Stat2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BeltHdOvrSw_Psd_V2 := %X\n", getValue( HMI_BeltHdOvrSw_Psd_V2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BMM_Status := %X\n", getValue( HMI_BMM_Status ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkLnWear_PreWarn_Actv := %X\n", getValue( HMI_BrkLnWear_PreWarn_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CPD_Disp_MsgRq := %X\n", getValue( HMI_CPD_Disp_MsgRq ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CPD_Disp_TrgrRq := %X\n", getValue( HMI_CPD_Disp_TrgrRq ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CPD_DispIcon_Stat := %X\n", getValue( HMI_CPD_DispIcon_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CPD_UsrActn_Stat := %X\n", getValue( HMI_CPD_UsrActn_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CPF_Ft_Stat := %X\n", getValue( HMI_CPF_Ft_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_Sw_Md := %X\n", getValue( HMI_DTQ_Sw_Md ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HdRst_R_Rq := %X\n", getValue( HMI_HdRst_R_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HUD_Sw_Psd := %X\n", getValue( HMI_HUD_Sw_Psd ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_Sw_Md := %X\n", getValue( HMI_LDP_Sw_Md ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_NV_Sw_Psd := %X\n", getValue( HMI_NV_Sw_Psd ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSw_Psd := %X\n", getValue( HMI_ParkSw_Psd ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RainCls_Mon_Stat := %X\n", getValue( HMI_RainCls_Mon_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RainCls_Win_FL_Rq := %X\n", getValue( HMI_RainCls_Win_FL_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RainCls_Win_FR_Rq := %X\n", getValue( HMI_RainCls_Win_FR_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RainCls_Win_RL_Rq := %X\n", getValue( HMI_RainCls_Win_RL_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RainCls_Win_RR_Rq := %X\n", getValue( HMI_RainCls_Win_RR_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );  
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RB_R_Sw_Psd_Ft := %X\n", getValue( HMI_RB_R_Sw_Psd_Ft ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RLS_AutoPosn := %X\n", getValue( HMI_RLS_AutoPosn ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RLS_FogLmp_Ft_Posn := %X\n", getValue( HMI_RLS_FogLmp_Ft_Posn ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RLS_FogLmp_R_Posn := %X\n", getValue( HMI_RLS_FogLmp_R_Posn ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RLS_LoBm_Posn := %X\n", getValue( HMI_RLS_LoBm_Posn ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RLS_PkLmp_Posn_Lt := %X\n", getValue( HMI_RLS_PkLmp_Posn_Lt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RLS_PkLmp_Posn_Rt := %X\n", getValue( HMI_RLS_PkLmp_Posn_Rt ) );        filePutString ( buffer, elcount( buffer ), hFile );
