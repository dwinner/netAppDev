on EnvVar HMI_LDC_WTSL_Spd_Max_Stat
{
    _mLDC_Disp_Rq_ESP_AR.LDC_WTSL_Spd_Max_Stat.phys = getValue(this);
    _LDC_Disp_Rq_ESP_AR_SpontanFlag = 1;
}

LDC_Disp_Rq2_ESP_AR_check_output()
{
    if( !getValue( HMI__STMSG_LDC_Disp_Rq2_ESP_AR ) )
    {
    //  message   LDC_Disp_Rq2_ESP_AR ID: 1004 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _LDC_Disp_Rq2_ESP_AR_DelayCnt > 0) _LDC_Disp_Rq2_ESP_AR_DelayCnt--; // Mindestsendeabstand
        _LDC_Disp_Rq2_ESP_AR_Cnt--;
        if( _LDC_Disp_Rq2_ESP_AR_Cnt < 1 )
        {
            if( _LDC_Disp_Rq2_ESP_AR_DelayCnt < 1 )
            {
                LDC_Disp_Rq2_ESP_AR_output();  // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                 _LDC_Disp_Rq2_ESP_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _LDC_Disp_Rq2_ESP_AR_DelayCnt = _LDC_Disp_Rq2_ESP_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _LDC_Disp_Rq2_ESP_AR_SpontanFlag = 1;
            }
            _LDC_Disp_Rq2_ESP_AR_Cnt = _LDC_Disp_Rq2_ESP_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _LDC_Disp_Rq2_ESP_AR_SpontanFlag )
        {
            if( _LDC_Disp_Rq2_ESP_AR_DelayCnt < 1 )
            {
                LDC_Disp_Rq2_ESP_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _LDC_Disp_Rq2_ESP_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _LDC_Disp_Rq2_ESP_AR_DelayCnt = _LDC_Disp_Rq2_ESP_AR_MinDelay;
            }
        }
    }
}

LDC_Disp_Rq2_ESP_AR_init()
{   /* Botschaft LDC_Disp_Rq2_ESP_AR ID: 1004 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1004 0;
BA_ "NmAsrMessage" BO_ 1004 0;
BA_ "GenMsgMinAcceptLength" BO_ 1004 4;
BA_ "GenMsgILSupport" BO_ 1004 1;
BA_ "DiagState" BO_ 1004 0;
BA_ "DiagRequest" BO_ 1004 0;
BA_ "DiagResponse" BO_ 1004 0;
BA_ "GenMsgStartValue" BO_ 1004 "0";
BA_ "GenMsgDelayTime" BO_ 1004 40;
BA_ "GenMsgNrOfRepetition" BO_ 1004 0;
BA_ "GenMsgCycleTime" BO_ 1004 200;
BA_ "GenMsgSendType" BO_ 1004 5;
    */
    _LDC_Disp_Rq2_ESP_AR_Timebase =          c_tDBKomTimer_20ms;
    _LDC_Disp_Rq2_ESP_AR_CycleCount =       200 / _LDC_Disp_Rq2_ESP_AR_Timebase;
    _LDC_Disp_Rq2_ESP_AR_StartDelay =         0 / _LDC_Disp_Rq2_ESP_AR_Timebase;
    _LDC_Disp_Rq2_ESP_AR_MinDelay =          40 / _LDC_Disp_Rq2_ESP_AR_Timebase;
    _LDC_Disp_Rq2_ESP_AR_Cnt = _LDC_Disp_Rq2_ESP_AR_StartDelay;
    _LDC_Disp_Rq2_ESP_AR_SpontanFlag = 0;
    _LDC_Disp_Rq2_ESP_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_LDC_Disp_Rq2_ESP_AR, _LDC_Disp_Rq2_ESP_AR_StartDelay * _LDC_Disp_Rq2_ESP_AR_Timebase );

    _mLDC_Disp_Rq2_ESP_AR.LDC_MsgDisp_Rq_V2_ESP.phys =           getValue( HMI_LDC_MsgDisp_Rq_V2_ESP );
    _mLDC_Disp_Rq2_ESP_AR.LDC_SpdLimit_ESP.phys =  getValue( HMI_LDC_SpdLimit_ESP );
    _mLDC_Disp_Rq2_ESP_AR.LDC_SpdOffset_Unit_ESP.phys =    getValue( HMI_LDC_SpdOffset_Unit_ESP );
    _mLDC_Disp_Rq2_ESP_AR.LDC_SpdOffset_Val_ESP.phys =      getValue( HMI_LDC_SpdOffset_Val_ESP );
    _mLDC_Disp_Rq2_ESP_AR.FDC_MsgDisp_Func_Avl_ESP.phys =      getValue( HMI_FDC_MsgDisp_Func_Avl_ESP );
}

LDC_Disp_Rq2_ESP_AR_output(void)
{
    output( _mLDC_Disp_Rq2_ESP_AR );
}

LDC_Disp_Rq2_ESP_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: LDC_Disp_Rq2_ESP_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_LDC_Disp_Rq2_ESP_AR := %X\n", getValue( HMI__STMSG_LDC_Disp_Rq2_ESP_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_LDC_Disp_Rq2_ESP_AR := %X\n", getValue( HMI__STMSGT_LDC_Disp_Rq2_ESP_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_MsgDisp_Rq_V2_ESP := %X\n", getValue( HMI_LDC_MsgDisp_Rq_V2_ESP ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_SpdLimit_ESP := %X\n", getValue( HMI_LDC_SpdLimit_ESP ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_SpdOffset_Unit_ESP := %X\n", getValue( HMI_LDC_SpdOffset_Unit_ESP ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_SpdOffset_Val_ESP := %X\n", getValue( HMI_LDC_SpdOffset_Val_ESP ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FDC_MsgDisp_Func_Avl_ESP := %X\n", getValue( HMI_FDC_MsgDisp_Func_Avl_ESP ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tLDC_Disp_Rq2_ESP_AR
{
    putValue( HMI__STMSG_LDC_Disp_Rq2_ESP_AR, 0 );
}

on EnvVar HMI__STMSG_LDC_Disp_Rq2_ESP_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_LDC_Disp_Rq2_ESP_AR );
        if( tDelay > 0)    
            setTimer( _tLDC_Disp_Rq2_ESP_AR, tDelay );
        else
            putValue( HMI__STMSG_LDC_Disp_Rq2_ESP_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_LDC_Disp_Rq2_ESP_AR
{
    if( getValue( this ) )
        openPanel("LDC_Disp_Rq2_ESP_AR");
}

on EnvVar HMI_LDC_MsgDisp_Rq_V2_ESP
{
    _mLDC_Disp_Rq2_ESP_AR.LDC_MsgDisp_Rq_V2_ESP.phys = getValue(this);
    _LDC_Disp_Rq2_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_SpdLimit_ESP
{
    _mLDC_Disp_Rq2_ESP_AR.LDC_SpdLimit_ESP.phys = getValue(this);
    _LDC_Disp_Rq2_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_SpdOffset_Unit_ESP
{
    _mLDC_Disp_Rq2_ESP_AR.LDC_SpdOffset_Unit_ESP.phys = getValue(this);
    _LDC_Disp_Rq2_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_SpdOffset_Val_ESP
{
    _mLDC_Disp_Rq2_ESP_AR.LDC_SpdOffset_Val_ESP.phys = getValue(this);
    _LDC_Disp_Rq2_ESP_AR_SpontanFlag = 1;
}

on EnvVar HMI_FDC_MsgDisp_Func_Avl_ESP
{
    _mLDC_Disp_Rq2_ESP_AR.FDC_MsgDisp_Func_Avl_ESP.phys = getValue(this);
    _LDC_Disp_Rq2_ESP_AR_SpontanFlag = 1;
}

LDC_Disp_Rq_RDU_AR_check_output()
{
    if( !getValue( HMI__STMSG_LDC_Disp_Rq_RDU_AR ) )
    {
    //  message   LDC_Disp_Rq_RDU_AR ID: 1027 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _LDC_Disp_Rq_RDU_AR_Cnt--;
        if( _LDC_Disp_Rq_RDU_AR_Cnt < 1 )
        {
            LDC_Disp_Rq_RDU_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _LDC_Disp_Rq_RDU_AR_Cnt = _LDC_Disp_Rq_RDU_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _LDC_Disp_Rq_RDU_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _LDC_Disp_Rq_RDU_AR_SpontanFlag)
        {
            LDC_Disp_Rq_RDU_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _LDC_Disp_Rq_RDU_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

LDC_Disp_Rq_RDU_AR_init()
{   /* Botschaft LDC_Disp_Rq_RDU_AR ID: 1027 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1027 0;
BA_ "NmAsrMessage" BO_ 1027 0;
BA_ "GenMsgMinAcceptLength" BO_ 1027 8;
BA_ "GenMsgILSupport" BO_ 1027 1;
BA_ "DiagState" BO_ 1027 0;
BA_ "DiagRequest" BO_ 1027 0;
BA_ "DiagResponse" BO_ 1027 0;
BA_ "GenMsgStartValue" BO_ 1027 "0";
BA_ "GenMsgStartDelayTime" BO_ 1027 0;
BA_ "GenMsgDelayTime" BO_ 1027 5;
BA_ "GenMsgNrOfRepetitions" BO_ 1027 0;
BA_ "GenMsgCycleTime" BO_ 1027 200;
BA_ "GenMsgSendType" BO_ 1027 5;
    */
    _LDC_Disp_Rq_RDU_AR_Timebase =           c_tDBKomTimer_20ms;
    _LDC_Disp_Rq_RDU_AR_CycleCount =        200 / _LDC_Disp_Rq_RDU_AR_Timebase;
    _LDC_Disp_Rq_RDU_AR_StartDelay =          0 / _LDC_Disp_Rq_RDU_AR_Timebase;
    _LDC_Disp_Rq_RDU_AR_Cnt = _LDC_Disp_Rq_RDU_AR_StartDelay;
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_LDC_Disp_Rq_RDU_AR, _LDC_Disp_Rq_RDU_AR_StartDelay * _LDC_Disp_Rq_RDU_AR_Timebase );

    _mLDC_Disp_Rq_RDU_AR.LDC_AcustWarn_Rq_RDU.phys = getValue( HMI_LDC_AcustWarn_Rq_RDU );
    _mLDC_Disp_Rq_RDU_AR.LDC_CMS_MsgDisp_Rq_RDU.phys = getValue( HMI_LDC_CMS_MsgDisp_Rq_RDU );
    _mLDC_Disp_Rq_RDU_AR.LDC_CMS_Warn_MsgDisp_Rq_RDU.phys = getValue( HMI_LDC_CMS_Warn_MsgDisp_Rq_RDU );
    _mLDC_Disp_Rq_RDU_AR.LDC_CMS_Stat_RDU.phys = getValue( HMI_LDC_CMS_Stat_RDU );
    _mLDC_Disp_Rq_RDU_AR.LDC_Dist_Dsr_RDU.phys = getValue( HMI_LDC_Dist_Dsr_RDU );
    _mLDC_Disp_Rq_RDU_AR.LDC_Dist_RDU.phys = getValue( HMI_LDC_Dist_RDU );
    _mLDC_Disp_Rq_RDU_AR.LDC_DTR_IndLmp_On_Rq_RDU.phys = getValue( HMI_LDC_DTR_IndLmp_On_Rq_RDU );
    _mLDC_Disp_Rq_RDU_AR.LDC_DTR_MsgDisp_Rq_RDU.phys = getValue( HMI_LDC_DTR_MsgDisp_Rq_RDU );
    _mLDC_Disp_Rq_RDU_AR.LDC_DTR_Stat_RDU_V2.phys = getValue( HMI_LDC_DTR_Stat_RDU_V2 );
    _mLDC_Disp_Rq_RDU_AR.LDC_IconDisp_Rq_RDU.phys = getValue( HMI_LDC_IconDisp_Rq_RDU );
    _mLDC_Disp_Rq_RDU_AR.LDC_MsgDisp_Rq_RDU.phys = getValue( HMI_LDC_MsgDisp_Rq_RDU );
    _mLDC_Disp_Rq_RDU_AR.LDC_MsgDisp_TrgrRq_RDU.phys = getValue( HMI_LDC_MsgDisp_TrgrRq_RDU );
    _mLDC_Disp_Rq_RDU_AR.LDC_RadarSensSoil_Disp_Rq_RDU.phys = getValue( HMI_LDC_RadarSensSoil_Disp_Rq_RDU );
    _mLDC_Disp_Rq_RDU_AR.LDC_Spd_Add_RDU.phys = getValue( HMI_LDC_Spd_Add_RDU );
    _mLDC_Disp_Rq_RDU_AR.LDC_Spd_Dsr_RDU.phys = getValue( HMI_LDC_Spd_Dsr_RDU );
    _mLDC_Disp_Rq_RDU_AR.LDC_SpdUnit_Rs_RDU.phys = getValue( HMI_LDC_SpdUnit_Rs_RDU );
    _mLDC_Disp_Rq_RDU_AR.LDC_SPEEDO_SegRing_Disp_Rq_RDU.phys = getValue( HMI_LDC_SPEEDO_SegRing_Disp_Rq_RDU );
    _mLDC_Disp_Rq_RDU_AR.TSA_Warn_Supp_Rq_RDU.phys = getValue( HMI_TSA_Warn_Supp_Rq_RDU );
}

LDC_Disp_Rq_RDU_AR_output(void)
{
    output( _mLDC_Disp_Rq_RDU_AR );
}

LDC_Disp_Rq_RDU_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: LDC_Disp_Rq_RDU_AR\n", 32, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_LDC_Disp_Rq_RDU := %X\n", getValue( HMI__STMSG_LDC_Disp_Rq_RDU_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_LDC_Disp_Rq_RDU := %X\n", getValue( HMI__STMSGT_LDC_Disp_Rq_RDU_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_AcustWarn_Rq_RDU := %X\n", getValue( HMI_LDC_AcustWarn_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_CMS_MsgDisp_Rq_RDU := %X\n", getValue( HMI_LDC_CMS_MsgDisp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_CMS_Warn_MsgDisp_Rq_RDU := %X\n", getValue( HMI_LDC_CMS_Warn_MsgDisp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_CMS_Stat_RDU := %X\n", getValue( HMI_LDC_CMS_Stat_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_Dist_Dsr_RDU := %X\n", getValue( HMI_LDC_Dist_Dsr_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_Dist_RDU := %X\n", getValue( HMI_LDC_Dist_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_DTR_IndLmp_On_Rq_RDU := %X\n", getValue( HMI_LDC_DTR_IndLmp_On_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_DTR_MsgDisp_Rq_RDU := %X\n", getValue( HMI_LDC_DTR_MsgDisp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_DTR_Stat_RDU_V2 := %X\n", getValue( HMI_LDC_DTR_Stat_RDU_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_IconDisp_Rq_RDU := %X\n", getValue( HMI_LDC_IconDisp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_MsgDisp_Rq_RDU := %X\n", getValue( HMI_LDC_MsgDisp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_MsgDisp_TrgrRq_RDU := %X\n", getValue( HMI_LDC_MsgDisp_TrgrRq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_RadarSensSoil_Disp_Rq_RDU := %X\n", getValue( HMI_LDC_RadarSensSoil_Disp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_Spd_Add_RDU := %X\n", getValue( HMI_LDC_Spd_Add_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_Spd_Dsr_RDU := %X\n", getValue( HMI_LDC_Spd_Dsr_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_SpdUnit_Rs_RDU := %X\n", getValue( HMI_LDC_SpdUnit_Rs_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_SPEEDO_SegRing_Disp_Rq_RDU := %X\n", getValue( HMI_LDC_SPEEDO_SegRing_Disp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_Warn_Supp_Rq_RDU := %X\n", getValue( HMI_TSA_Warn_Supp_Rq_RDU ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tLDC_Disp_Rq_RDU_AR
{
    putValue( HMI__STMSG_LDC_Disp_Rq_RDU_AR, 0 );
}

on EnvVar HMI__STMSG_LDC_Disp_Rq_RDU_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_LDC_Disp_Rq_RDU_AR );
        if( tDelay > 0)    
            setTimer( _tLDC_Disp_Rq_RDU_AR, tDelay );
        else
            putValue( HMI__STMSG_LDC_Disp_Rq_RDU_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_LDC_Disp_Rq_RDU_AR
{
    if( getValue( this ) )
        openPanel("LDC_Disp_Rq_RDU_AR");
}

on EnvVar HMI_LDC_AcustWarn_Rq_RDU
{
    _mLDC_Disp_Rq_RDU_AR.LDC_AcustWarn_Rq_RDU.phys = getValue(this);
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_CMS_MsgDisp_Rq_RDU
{
    _mLDC_Disp_Rq_RDU_AR.LDC_CMS_MsgDisp_Rq_RDU.phys = getValue(this);
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_CMS_Warn_MsgDisp_Rq_RDU
{
    _mLDC_Disp_Rq_RDU_AR.LDC_CMS_Warn_MsgDisp_Rq_RDU.phys = getValue(this);
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_CMS_Stat_RDU
{
    _mLDC_Disp_Rq_RDU_AR.LDC_CMS_Stat_RDU.phys = getValue(this);
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_Dist_Dsr_RDU
{
    _mLDC_Disp_Rq_RDU_AR.LDC_Dist_Dsr_RDU.phys = getValue(this);
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_Dist_RDU
{
    _mLDC_Disp_Rq_RDU_AR.LDC_Dist_RDU.phys = getValue(this);
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_DTR_IndLmp_On_Rq_RDU
{
    _mLDC_Disp_Rq_RDU_AR.LDC_DTR_IndLmp_On_Rq_RDU.phys = getValue(this);
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_DTR_MsgDisp_Rq_RDU
{
    _mLDC_Disp_Rq_RDU_AR.LDC_DTR_MsgDisp_Rq_RDU.phys = getValue(this);
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_DTR_Stat_RDU_V2
{
    _mLDC_Disp_Rq_RDU_AR.LDC_DTR_Stat_RDU_V2.phys = getValue(this);
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_IconDisp_Rq_RDU
{
    _mLDC_Disp_Rq_RDU_AR.LDC_IconDisp_Rq_RDU.phys = getValue(this);
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_MsgDisp_Rq_RDU
{
    _mLDC_Disp_Rq_RDU_AR.LDC_MsgDisp_Rq_RDU.phys = getValue(this);
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_MsgDisp_TrgrRq_RDU
{
    _mLDC_Disp_Rq_RDU_AR.LDC_MsgDisp_TrgrRq_RDU.phys = getValue(this);
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_RadarSensSoil_Disp_Rq_RDU
{
    _mLDC_Disp_Rq_RDU_AR.LDC_RadarSensSoil_Disp_Rq_RDU.phys = getValue(this);
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_Spd_Add_RDU
{
    _mLDC_Disp_Rq_RDU_AR.LDC_Spd_Add_RDU.phys = getValue(this);
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_Spd_Dsr_RDU
{
    _mLDC_Disp_Rq_RDU_AR.LDC_Spd_Dsr_RDU.phys = getValue(this);
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_SpdUnit_Rs_RDU
{
    _mLDC_Disp_Rq_RDU_AR.LDC_SpdUnit_Rs_RDU.phys = getValue(this);
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_SPEEDO_SegRing_Disp_Rq_RDU
{
    _mLDC_Disp_Rq_RDU_AR.LDC_SPEEDO_SegRing_Disp_Rq_RDU.phys = getValue(this);
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSA_Warn_Supp_Rq_RDU
{
    _mLDC_Disp_Rq_RDU_AR.TSA_Warn_Supp_Rq_RDU.phys = getValue(this);
    _LDC_Disp_Rq_RDU_AR_SpontanFlag = 1;
}

LDP_Warn_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_LDP_Warn_Rq_AR ) )
    {
    //  message   LDP_Warn_Rq_AR ID: 1026 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _LDP_Warn_Rq_AR_Cnt--;
        if( _LDP_Warn_Rq_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            LDP_Warn_Rq_AR_output();
            _LDP_Warn_Rq_AR_Cnt = _LDP_Warn_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _LDP_Warn_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _LDP_Warn_Rq_AR_SpontanFlag )
        {
            // Nachricht wg. spontaner �nderung ausgeben
            LDP_Warn_Rq_AR_output();
            _LDP_Warn_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

LDC_Disp_Rq2_RDU_AR_check_output()
{
    if( !getValue( HMI__STMSG_LDC_Disp_Rq2_RDU_AR ) )
    {
    //  message   LDC_Disp_Rq2_RDU_AR ID: 1020 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _LDC_Disp_Rq2_RDU_AR_DelayCnt > 0) _LDC_Disp_Rq2_RDU_AR_DelayCnt--; // Mindestsendeabstand
        _LDC_Disp_Rq2_RDU_AR_Cnt--;
        if( _LDC_Disp_Rq2_RDU_AR_Cnt < 1 )
        {
            if( _LDC_Disp_Rq2_RDU_AR_DelayCnt < 1 )
            {
                LDC_Disp_Rq2_RDU_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                 _LDC_Disp_Rq2_RDU_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _LDC_Disp_Rq2_RDU_AR_DelayCnt = _LDC_Disp_Rq2_RDU_AR_MinDelay;
            }
            else
            {
                 _LDC_Disp_Rq2_RDU_AR_SpontanFlag = 1; // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
            }
            _LDC_Disp_Rq2_RDU_AR_Cnt = _LDC_Disp_Rq2_RDU_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _LDC_Disp_Rq2_RDU_AR_SpontanFlag)
        {
            if( _LDC_Disp_Rq2_RDU_AR_DelayCnt < 1 )
            {
                LDC_Disp_Rq2_RDU_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _LDC_Disp_Rq2_RDU_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _LDC_Disp_Rq2_RDU_AR_DelayCnt = _LDC_Disp_Rq2_RDU_AR_MinDelay;
            }
        }
    }
}

LDC_Disp_Rq2_RDU_AR_init()
{   /* Botschaft LDC_Disp_Rq2_RDU_AR ID: 1020 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1020 0;
BA_ "NmAsrMessage" BO_ 1020 0;
BA_ "GenMsgMinAcceptLength" BO_ 1020 4;
BA_ "GenMsgILSupport" BO_ 1020 1;
BA_ "DiagState" BO_ 1020 0;
BA_ "DiagRequest" BO_ 1020 0;
BA_ "DiagResponse" BO_ 1020 0;
BA_ "GenMsgStartValue" BO_ 1020 "0";
BA_ "GenMsgDelayTime" BO_ 1020 40;
BA_ "GenMsgNrOfRepetition" BO_ 1020 0;
BA_ "GenMsgCycleTime" BO_ 1020 200;
BA_ "GenMsgSendType" BO_ 1020 5;
    */
    _LDC_Disp_Rq2_RDU_AR_Timebase =               c_tDBKomTimer_5ms;
    _LDC_Disp_Rq2_RDU_AR_CycleCount =            200 / _LDC_Disp_Rq2_RDU_AR_Timebase;
    _LDC_Disp_Rq2_RDU_AR_StartDelay =               0 / _LDC_Disp_Rq2_RDU_AR_Timebase;
    _LDC_Disp_Rq2_RDU_AR_MinDelay =                40 / _LDC_Disp_Rq2_RDU_AR_Timebase;
    _LDC_Disp_Rq2_RDU_AR_Cnt = _LDC_Disp_Rq2_RDU_AR_StartDelay;
    _LDC_Disp_Rq2_RDU_AR_SpontanFlag = 0;
    _LDC_Disp_Rq2_RDU_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_LDC_Disp_Rq2_RDU_AR, _LDC_Disp_Rq2_RDU_AR_StartDelay * _LDC_Disp_Rq2_RDU_AR_Timebase );

    _mLDC_Disp_Rq2_RDU_AR.DTR_EmgBrkAssist_DoorUnlk_Rq.phys = getValue( HMI_DTR_EmgBrkAssist_DoorUnlk_Rq );
    _mLDC_Disp_Rq2_RDU_AR.DTR_EmgBrkAssist_SOS_Call_Rq.phys = getValue( HMI_DTR_EmgBrkAssist_SOS_Call_Rq );
    _mLDC_Disp_Rq2_RDU_AR.LDC_DTR_Curve_Event.phys = getValue( HMI_LDC_DTR_Curve_Event );
    _mLDC_Disp_Rq2_RDU_AR.LDC_DTR_Curve_Stat.phys = getValue( HMI_LDC_DTR_Curve_Stat );
    _mLDC_Disp_Rq2_RDU_AR.LDC_MsgDisp_Rq_V2_RDU.phys = getValue( HMI_LDC_MsgDisp_Rq_V2_RDU );
    _mLDC_Disp_Rq2_RDU_AR.LDC_SpdLimit_RDU.phys = getValue( HMI_LDC_SpdLimit_RDU );
    _mLDC_Disp_Rq2_RDU_AR.LDC_SpdOffset_Unit_RDU.phys = getValue( HMI_LDC_SpdOffset_Unit_RDU );
    _mLDC_Disp_Rq2_RDU_AR.LDC_SpdOffset_Val_RDU.phys = getValue( HMI_LDC_SpdOffset_Val_RDU );
    _mLDP_Warn_Rq_AR.ALDW_Md_Stat.phys = getValue( HMI_ALDW_Md_Stat );
    _mLDP_Warn_Rq_AR.DTQ_Acust_Md_Disp_Rq.phys = getValue( HMI_DTQ_Acust_Md_Disp_Rq );
    _mLDP_Warn_Rq_AR.DTQ_Acust_Md_Stat.phys = getValue( HMI_DTQ_Acust_Md_Stat );
    _mLDP_Warn_Rq_AR.LDP_Sensitive_Md_Stat.phys = getValue( HMI_LDP_Sensitive_Md_Stat );
}

LDC_Disp_Rq2_RDU_AR_output(void)
{
    output( _mLDC_Disp_Rq2_RDU_AR );
}

LDC_Disp_Rq2_RDU_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: LDC_Disp_Rq2_RDU_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_LDC_Disp_Rq2_RDU_AR := %X\n", getValue( HMI__STMSG_LDC_Disp_Rq2_RDU_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_LDC_Disp_Rq2_RDU_AR := %X\n", getValue( HMI__STMSGT_LDC_Disp_Rq2_RDU_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_EmgBrkAssist_DoorUnlk_Rq := %X\n", getValue( HMI_DTR_EmgBrkAssist_DoorUnlk_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_EmgBrkAssist_SOS_Call_Rq := %X\n", getValue( HMI_DTR_EmgBrkAssist_SOS_Call_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_DTR_Curve_Event := %X\n", getValue( HMI_LDC_DTR_Curve_Event ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_DTR_Curve_Stat := %X\n", getValue( HMI_LDC_DTR_Curve_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_MsgDisp_Rq_V2_RDU := %X\n", getValue( HMI_LDC_MsgDisp_Rq_V2_RDU ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_SpdLimit_RDU := %X\n", getValue( HMI_LDC_SpdLimit_RDU ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_SpdOffset_Unit_RDU := %X\n", getValue( HMI_LDC_SpdOffset_Unit_RDU ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDC_SpdOffset_Val_RDU := %X\n", getValue( HMI_LDC_SpdOffset_Val_RDU ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount(buffer), "0.0000 HMI_ALDW_Md_Stat := %X\n", getValue( HMI_ALDW_Md_Stat ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_DTQ_Acust_Md_Disp_Rq := %X\n", getValue( HMI_DTQ_Acust_Md_Disp_Rq ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_DTQ_Acust_Md_Stat := %X\n", getValue( HMI_DTQ_Acust_Md_Stat ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_LDP_Sensitive_Md_Stat := %X\n", getValue( HMI_LDP_Sensitive_Md_Stat ) );        filePutString( buffer, elcount(buffer), hFile);
}

on timer _tLDC_Disp_Rq2_RDU_AR
{
    putValue( HMI__STMSG_LDC_Disp_Rq2_RDU_AR, 0 );
}

on EnvVar HMI__STMSG_LDC_Disp_Rq2_RDU_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_LDC_Disp_Rq2_RDU_AR );
        if( tDelay > 0)    
            setTimer( _tLDC_Disp_Rq2_RDU_AR, tDelay );
        else
            putValue( HMI__STMSG_LDC_Disp_Rq2_RDU_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_LDC_Disp_Rq2_RDU_AR
{
    if( getValue( this ) )
        openPanel("LDC_Disp_Rq2_RDU_AR");
}

on EnvVar HMI_DTR_EmgBrkAssist_DoorUnlk_Rq
{
    _mLDC_Disp_Rq2_RDU_AR.DTR_EmgBrkAssist_DoorUnlk_Rq.phys = getValue(this);
    _LDC_Disp_Rq2_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTR_EmgBrkAssist_SOS_Call_Rq
{
    _mLDC_Disp_Rq2_RDU_AR.DTR_EmgBrkAssist_SOS_Call_Rq.phys = getValue(this);
    _LDC_Disp_Rq2_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_DTR_Curve_Stat
{
    _mLDC_Disp_Rq2_RDU_AR.LDC_DTR_Curve_Stat.phys = getValue(this);
    _LDC_Disp_Rq2_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_DTR_Curve_Event
{
    _mLDC_Disp_Rq2_RDU_AR.LDC_DTR_Curve_Event.phys = getValue(this);
    _LDC_Disp_Rq2_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_MsgDisp_Rq_V2_RDU
{
    _mLDC_Disp_Rq2_RDU_AR.LDC_MsgDisp_Rq_V2_RDU.phys = getValue(this);
    _LDC_Disp_Rq2_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_SpdLimit_RDU
{
    _mLDC_Disp_Rq2_RDU_AR.LDC_SpdLimit_RDU.phys = getValue(this);
    _LDC_Disp_Rq2_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_SpdOffset_Unit_RDU
{
    _mLDC_Disp_Rq2_RDU_AR.LDC_SpdOffset_Unit_RDU.phys = getValue(this);
    _LDC_Disp_Rq2_RDU_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDC_SpdOffset_Val_RDU
{
    _mLDC_Disp_Rq2_RDU_AR.LDC_SpdOffset_Val_RDU.phys = getValue(this);
    _LDC_Disp_Rq2_RDU_AR_SpontanFlag = 1;
}

LDP_Warn_Rq_AR_init()
{   /* Botschaft LDP_Warn_Rq_AR ID: 1026 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1026 0;
BA_ "NmAsrMessage" BO_ 1026 0;
BA_ "GenMsgMinAcceptLength" BO_ 1026 8;
BA_ "GenMsgILSupport" BO_ 1026 1;
BA_ "DiagState" BO_ 1026 0;
BA_ "DiagRequest" BO_ 1026 0;
BA_ "DiagResponse" BO_ 1026 0;
BA_ "GenMsgStartValue" BO_ 1026 "0";
BA_ "GenMsgDelayTime" BO_ 1026 20;
BA_ "GenMsgNrOfRepetitions" BO_ 1026 0;
BA_ "GenMsgCycleTime" BO_ 1026 200;
BA_ "GenMsgSendType" BO_ 1026 5;
    */
    _LDP_Warn_Rq_AR_Timebase =             c_tDBKomTimer_20ms;
    _LDP_Warn_Rq_AR_CycleCount =          200 / _LDP_Warn_Rq_AR_Timebase;
    _LDP_Warn_Rq_AR_StartDelay =            0 / _LDP_Warn_Rq_AR_Timebase;
    _LDP_Warn_Rq_AR_MinDelay =             20 / _LDP_Warn_Rq_AR_Timebase;
    _LDP_Warn_Rq_AR_Cnt = _LDP_Warn_Rq_AR_StartDelay;
    _LDP_Warn_Rq_AR_SpontanFlag = 0;
    _LDP_Warn_Rq_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_LDP_Warn_Rq_AR, _LDP_Warn_Rq_AR_StartDelay * _LDP_Warn_Rq_AR_Timebase );
    
    _mLDP_Warn_Rq_AR.LDP_BrkMsgDisp_Rq.phys = getValue( HMI_LDP_BrkMsgDisp_Rq );
    _mLDP_Warn_Rq_AR.LDP_IndLmp_On_Rq_V2.phys = getValue( HMI_LDP_IndLmp_On_Rq_V2 );
    _mLDP_Warn_Rq_AR.LDP_Md_Stat.phys = getValue( HMI_LDP_Md_Stat );
    _mLDP_Warn_Rq_AR.LDP_MsgDisp_Rq_V2.phys = getValue( HMI_LDP_MsgDisp_Rq_V2 );
}

LDP_Warn_Rq_AR_output()
{
    output( _mLDP_Warn_Rq_AR );
}

LDP_Warn_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: LDP_Warn_Rq_AR\n", 30, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_LDP_Warn_Rq_AR := %X\n", getValue( HMI__STMSG_LDP_Warn_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_LDP_Warn_Rq_AR := %X\n", getValue( HMI__STMSGT_LDP_Warn_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_BrkMsgDisp_Rq := %X\n", getValue( HMI_LDP_BrkMsgDisp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_IndLmp_On_Rq_V2 := %X\n", getValue( HMI_LDP_IndLmp_On_Rq_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_Md_Stat := %X\n", getValue( HMI_LDP_Md_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_MsgDisp_Rq_V2 := %X\n", getValue( HMI_LDP_MsgDisp_Rq_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tLDP_Warn_Rq_AR
{
    putValue( HMI__STMSG_LDP_Warn_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_LDP_Warn_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_LDP_Warn_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tLDP_Warn_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_LDP_Warn_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_LDP_Warn_Rq_AR
{
    if( getValue( this ) )
        openPanel("LDP_Warn_Rq_AR");
}

on EnvVar HMI_LDP_BrkMsgDisp_Rq
{
    _mLDP_Warn_Rq_AR.LDP_BrkMsgDisp_Rq.phys = getValue(this);
    _LDP_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDP_IndLmp_On_Rq_V2
{
    _mLDP_Warn_Rq_AR.LDP_IndLmp_On_Rq_V2.phys = getValue(this);
    _LDP_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDP_Md_Stat
{
    _mLDP_Warn_Rq_AR.LDP_Md_Stat.phys = getValue(this);
    _LDP_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDP_MsgDisp_Rq_V2
{
    _mLDP_Warn_Rq_AR.LDP_MsgDisp_Rq_V2.phys = getValue(this);
    _LDP_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ALDW_Md_Stat
{
    _mLDP_Warn_Rq_AR.ALDW_Md_Stat.phys = getValue(this);
    _LDP_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_Acust_Md_Disp_Rq
{
    _mLDP_Warn_Rq_AR.DTQ_Acust_Md_Disp_Rq.phys = getValue(this);
    _LDP_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DTQ_Acust_Md_Stat
{
    _mLDP_Warn_Rq_AR.DTQ_Acust_Md_Stat.phys = getValue(this);
    _LDP_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDP_Sensitive_Md_Stat
{
    _mLDP_Warn_Rq_AR.LDP_Sensitive_Md_Stat.phys = getValue(this);
    _LDP_Warn_Rq_AR_SpontanFlag = 1;
}

LgtSens_State_AR_check_output()
{
    if( !getValue( HMI__STMSG_LgtSens_State_AR ) )
    {
    //  message   LgtSens_State_AR ID: 783 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _LgtSens_State_AR_DelayCnt > 0) _LgtSens_State_AR_DelayCnt--; // Mindestsendeabstand
        _LgtSens_State_AR_Cnt--;
        if( _LgtSens_State_AR_Cnt < 1 )
        {
            if( _LgtSens_State_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                LgtSens_State_AR_output();
                _LgtSens_State_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _LgtSens_State_AR_DelayCnt = _LgtSens_State_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _LgtSens_State_AR_SpontanFlag = 1;
            }
            _LgtSens_State_AR_Cnt = _LgtSens_State_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _LgtSens_State_AR_SpontanFlag)
        {
            if( _LgtSens_State_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                LgtSens_State_AR_output();
                _LgtSens_State_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _LgtSens_State_AR_DelayCnt = _LgtSens_State_AR_MinDelay;
            }
        }
    }
}

LgtSens_State_AR_init()
{   /* Botschaft LgtSens_State_AR ID: 783 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 783 0;
BA_ "NmAsrMessage" BO_ 783 0;
BA_ "GenMsgMinAcceptLength" BO_ 783 6;
BA_ "GenMsgILSupport" BO_ 783 1;
BA_ "DiagState" BO_ 783 0;
BA_ "DiagRequest" BO_ 783 0;
BA_ "DiagResponse" BO_ 783 0;
BA_ "GenMsgStartValue" BO_ 783 "0";
BA_ "GenMsgDelayTime" BO_ 783 100;
BA_ "GenMsgNrOfRepetitions" BO_ 783 0;
BA_ "GenMsgCycleTime" BO_ 783 1000;
BA_ "GenMsgSendType" BO_ 783 5;
    */
    _LgtSens_State_AR_Timebase =               c_tDBKomTimer_20ms;
    _LgtSens_State_AR_CycleCount =           1000 / _LgtSens_State_AR_Timebase;
    _LgtSens_State_AR_StartDelay =              0 / _LgtSens_State_AR_Timebase;
    _LgtSens_State_AR_MinDelay =              100 / _LgtSens_State_AR_Timebase;
    _LgtSens_State_AR_Cnt = _LgtSens_State_AR_StartDelay;
    _LgtSens_State_AR_SpontanFlag = 0;
    _LgtSens_State_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_LgtSens_State_AR, _LgtSens_State_AR_StartDelay * _LgtSens_State_AR_Timebase );

    putValue( HMI_LgtSens_SNA, 0 );
    _mLgtSens_State_AR.HUD_Sens_Actv.phys = getValue( HMI_HUD_Sens_Actv );
    _mLgtSens_State_AR.HUD_Sens_Init.phys = getValue( HMI_HUD_Sens_Init );
    _mLgtSens_State_AR.HUD_Sens_Value.phys = getValue( HMI_HUD_Sens_Value );
    _mLgtSens_State_AR.HUD_Sens_Variant.phys = getValue( HMI_HUD_Sens_Variant );
    _mLgtSens_State_AR.HUD_SensCode_Flt.phys = getValue( HMI_HUD_SensCode_Flt );
    _mLgtSens_State_AR.HUD_SensInt_Flt.phys = getValue( HMI_HUD_SensInt_Flt );
    _mLgtSens_State_AR.LgtSens_Flt.phys = getValue( HMI_LgtSens_Flt );
    _mLgtSens_State_AR.LgtSens_LoBm_On_Rq.phys = getValue( HMI_LgtSens_LoBm_On_Rq );
    _mLgtSens_State_AR.LgtSens_Night.phys = getValue( HMI_LgtSens_Night );
    _mLgtSens_State_AR.LgtSens_Night2.phys = getValue( HMI_LgtSens_Night2 );
    _mLgtSens_State_AR.LgtSens_Night3.phys = getValue( HMI_LgtSens_Night3 );
    _mLgtSens_State_AR.LgtSens_SNA.phys = getValue( HMI_LgtSens_SNA );
    _mLgtSens_State_AR.LgtSens_Tunnel.phys = getValue( HMI_LgtSens_Tunnel );
    _mLgtSens_State_AR.LgtSens_Twlgt.phys = getValue( HMI_LgtSens_Twlgt );
    _mLgtSens_State_AR.SunInsty_Actv.phys = getValue( HMI_SunInsty_Actv );
    _mLgtSens_State_AR.SunInsty_FL.phys = getValue( HMI_SunInsty_FL );
    _mLgtSens_State_AR.SunInsty_Flt.phys = getValue( HMI_SunInsty_Flt );
    _mLgtSens_State_AR.SunInsty_FR.phys = getValue( HMI_SunInsty_FR );
}

LgtSens_State_AR_output()
{
    output( _mLgtSens_State_AR );
}

LgtSens_State_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: LgtSens_State_AR\n", 30, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_LgtSens_State_AR := %X\n", getValue( HMI__STMSG_LgtSens_State_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_LgtSens_State_AR := %X\n", getValue( HMI__STMSGT_LgtSens_State_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HUD_Sens_Actv := %X\n", getValue( HMI_HUD_Sens_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HUD_Sens_Init := %X\n", getValue( HMI_HUD_Sens_Init ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HUD_Sens_Value := %X\n", getValue( HMI_HUD_Sens_Value ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HUD_Sens_Variant := %X\n", getValue( HMI_HUD_Sens_Variant ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HUD_SensCode_Flt := %X\n", getValue( HMI_HUD_SensCode_Flt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HUD_SensInt_Flt := %X\n", getValue( HMI_HUD_SensInt_Flt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LgtSens_Flt := %X\n", getValue( HMI_LgtSens_Flt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LgtSens_LoBm_On_Rq := %X\n", getValue( HMI_LgtSens_LoBm_On_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LgtSens_Night := %X\n", getValue( HMI_LgtSens_Night ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LgtSens_Night2 := %X\n", getValue( HMI_LgtSens_Night2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LgtSens_Night3 := %X\n", getValue( HMI_LgtSens_Night3 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LgtSens_SNA := %X\n", getValue( HMI_LgtSens_SNA ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LgtSens_Tunnel := %X\n", getValue( HMI_LgtSens_Tunnel ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LgtSens_Twlgt := %X\n", getValue( HMI_LgtSens_Twlgt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SunInsty_Actv := %X\n", getValue( HMI_SunInsty_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SunInsty_FL := %X\n", getValue( HMI_SunInsty_FL ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SunInsty_Flt := %X\n", getValue( HMI_SunInsty_Flt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SunInsty_FR := %X\n", getValue( HMI_SunInsty_FR ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tLgtSens_State_AR
{
    putValue( HMI__STMSG_LgtSens_State_AR, 0 );
}

on EnvVar HMI__STMSG_LgtSens_State_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_LgtSens_State_AR );
        if( tDelay > 0)    
            setTimer( _tLgtSens_State_AR, tDelay );
        else
            putValue( HMI__STMSG_LgtSens_State_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_LgtSens_State_AR
{
    if( getValue( this ) )
        openPanel("LgtSens_State_AR");
}

on EnvVar HMI_HUD_Sens_Actv
{
    _mLgtSens_State_AR.HUD_Sens_Actv.phys = getValue(this);
    _LgtSens_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_HUD_Sens_Init
{
    _mLgtSens_State_AR.HUD_Sens_Init.phys = getValue(this);
    _LgtSens_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_HUD_Sens_Value
{
    _mLgtSens_State_AR.HUD_Sens_Value.phys = getValue(this);
    _LgtSens_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_HUD_Sens_Variant
{
    _mLgtSens_State_AR.HUD_Sens_Variant.phys = getValue(this);
    _LgtSens_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_HUD_SensCode_Flt
{
    _mLgtSens_State_AR.HUD_SensCode_Flt.phys = getValue(this);
    _LgtSens_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_HUD_SensInt_Flt
{
    _mLgtSens_State_AR.HUD_SensInt_Flt.phys = getValue(this);
    _LgtSens_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_LgtSens_Flt
{
    _mLgtSens_State_AR.LgtSens_Flt.phys = getValue(this);
    _LgtSens_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_LgtSens_LoBm_On_Rq
{
    _mLgtSens_State_AR.LgtSens_LoBm_On_Rq.phys = getValue(this);
    _LgtSens_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_LgtSens_Night
{
     _mLgtSens_State_AR.LgtSens_Night.phys = getValue(this);
    _LgtSens_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_LgtSens_Night2
{
    _mLgtSens_State_AR.LgtSens_Night2.phys = getValue(this);
    _LgtSens_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_LgtSens_Night3
{
    _mLgtSens_State_AR.LgtSens_Night3.phys = getValue(this);
    _LgtSens_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_LgtSens_SNA
{
    _mLgtSens_State_AR.LgtSens_SNA.phys = getValue(this);
    _LgtSens_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_LgtSens_Tunnel
{
    _mLgtSens_State_AR.LgtSens_Tunnel.phys = getValue(this);
    _LgtSens_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_LgtSens_Twlgt
{
    _mLgtSens_State_AR.LgtSens_Twlgt.phys = getValue(this);
    _LgtSens_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_SunInsty_Actv
{
    _mLgtSens_State_AR.SunInsty_Actv.phys = getValue(this);
    _LgtSens_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_SunInsty_FL
{
    _mLgtSens_State_AR.SunInsty_FL.phys = getValue(this);
    _LgtSens_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_SunInsty_Flt
{
    _mLgtSens_State_AR.SunInsty_Flt.phys = getValue(this);
    _LgtSens_State_AR_SpontanFlag = 1;
}

on EnvVar HMI_SunInsty_FR
{
    _mLgtSens_State_AR.SunInsty_FR.phys = getValue(this);
    _LgtSens_State_AR_SpontanFlag = 1;
}

MCMS_FL_AR_check_output()
{
    if( !getValue( HMI__STMSG_MCMS_FL_AR ) )
    {
    //  message   MCMS_FL_AR ID: 793 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _MCMS_FL_AR_Cnt--;
        if( _MCMS_FL_AR_Cnt < 1 )
        {
            MCMS_FL_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _MCMS_FL_AR_Cnt = _MCMS_FL_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _MCMS_FL_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _MCMS_FL_AR_SpontanFlag )
        {
            MCMS_FL_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _MCMS_FL_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

MCMS_FL_AR_init()
{   /* Botschaft MCMS_FL_AR ID: 793 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 793 0;
BA_ "NmAsrMessage" BO_ 793 0;
BA_ "GenMsgMinAcceptLength" BO_ 793 8;
BA_ "GenMsgILSupport" BO_ 793 1;
BA_ "DiagState" BO_ 793 0;
BA_ "DiagRequest" BO_ 793 0;
BA_ "DiagResponse" BO_ 793 0;
BA_ "GenMsgStartValue" BO_ 793 "0";
BA_ "GenMsgDelayTime" BO_ 793 5;
BA_ "GenMsgNrOfRepetitions" BO_ 793 0;
BA_ "GenMsgCycleTime" BO_ 793 1000;
BA_ "GenMsgSendType" BO_ 793 5;
    */
    _MCMS_FL_AR_Timebase =           c_tDBKomTimer_20ms;
    _MCMS_FL_AR_CycleCount =        1000 / _MCMS_FL_AR_Timebase;
    _MCMS_FL_AR_StartDelay =           0 / _MCMS_FL_AR_Timebase;
    _MCMS_FL_AR_Cnt = _MCMS_FL_AR_StartDelay;
    _MCMS_FL_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_MCMS_FL_AR, _MCMS_FL_AR_StartDelay * _MCMS_FL_AR_Timebase );

    _mMCMS_FL_AR.HotStn_FL_On_Rq.phys = getValue( HMI_HotStn_FL_On_Rq );
    _mMCMS_FL_AR.MCMS_ActvComf_FL_Stat.phys = getValue( HMI_MCMS_ActvComf_FL_Stat );
    _mMCMS_FL_AR.MCMS_ActvComfProg_FL_Stat.phys = getValue( HMI_MCMS_ActvComfProg_FL_Stat );
    _mMCMS_FL_AR.MCMS_FL_On.phys = getValue( HMI_MCMS_FL_On );
    _mMCMS_FL_AR.MCMS_LumPad_FL.phys = getValue( HMI_MCMS_LumPad_FL );
    _mMCMS_FL_AR.MCMS_LumPosn_FL.phys = getValue( HMI_MCMS_LumPosn_FL );
    _mMCMS_FL_AR.MCMS_Pmp_FL_Rq.phys = getValue( HMI_MCMS_Pmp_FL_Rq );
    _mMCMS_FL_AR.MCMS_SdRstPad_FL.phys = getValue( HMI_MCMS_SdRstPad_FL );
    _mMCMS_FL_AR.MCMS_SeatPad_FL.phys = getValue( HMI_MCMS_SeatPad_FL );
    _mMCMS_FL_AR.MCMS_ShldrPad_FL.phys = getValue( HMI_MCMS_ShldrPad_FL );
}

MCMS_FL_AR_output(void)
{
    output( _mMCMS_FL_AR );
}

MCMS_FL_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: MCMS_FL_AR\n", 24, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_MCMS_FL := %X\n", getValue( HMI__STMSG_MCMS_FL_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_MCMS_FL := %X\n", getValue( HMI__STMSGT_MCMS_FL_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HotStn_FL_On_Rq := %X\n", getValue( HMI_HotStn_FL_On_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_ActvComf_FL_Stat := %X\n", getValue( HMI_MCMS_ActvComf_FL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_ActvComfProg_FL_Stat := %X\n", getValue( HMI_MCMS_ActvComfProg_FL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_FL_On := %X\n", getValue( HMI_MCMS_FL_On ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_LumPad_FL := %X\n", getValue( HMI_MCMS_LumPad_FL ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_LumPosn_FL := %X\n", getValue( HMI_MCMS_LumPosn_FL ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_Pmp_FL_Rq := %X\n", getValue( HMI_MCMS_Pmp_FL_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_SdRstPad_FL := %X\n", getValue( HMI_MCMS_SdRstPad_FL ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_SeatPad_FL := %X\n", getValue( HMI_MCMS_SeatPad_FL ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_ShldrPad_FL := %X\n", getValue( HMI_MCMS_ShldrPad_FL ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tMCMS_FL_AR
{
    putValue( HMI__STMSG_MCMS_FL_AR, 0 );
}

on EnvVar HMI__STMSG_MCMS_FL_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_MCMS_FL_AR );
        if( tDelay > 0)    
            setTimer( _tMCMS_FL_AR, tDelay );
        else
            putValue( HMI__STMSG_MCMS_FL_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_MCMS_FL_AR
{
    if( getValue( this ) )
        openPanel("MCMS_FL_AR");
}

on EnvVar HMI_HotStn_FL_On_Rq
{
    _mMCMS_FL_AR.HotStn_FL_On_Rq.phys = getValue(this);
    _MCMS_FL_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_ActvComf_FL_Stat
{
    _mMCMS_FL_AR.MCMS_ActvComf_FL_Stat.phys = getValue(this);
    _MCMS_FL_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_ActvComfProg_FL_Stat
{
    _mMCMS_FL_AR.MCMS_ActvComfProg_FL_Stat.phys = getValue(this);
    _MCMS_FL_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_FL_On
{
    _mMCMS_FL_AR.MCMS_FL_On.phys = getValue(this);
    _MCMS_FL_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_LumPad_FL
{
    _mMCMS_FL_AR.MCMS_LumPad_FL.phys = getValue(this);
    _MCMS_FL_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_LumPosn_FL
{
    _mMCMS_FL_AR.MCMS_LumPosn_FL.phys = getValue(this);
    _MCMS_FL_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_Pmp_FL_Rq
{
    _mMCMS_FL_AR.MCMS_Pmp_FL_Rq.phys = getValue(this);
    _MCMS_FL_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_SdRstPad_FL
{
    _mMCMS_FL_AR.MCMS_SdRstPad_FL.phys = getValue(this);
    _MCMS_FL_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_SeatPad_FL
{
    _mMCMS_FL_AR.MCMS_SeatPad_FL.phys = getValue(this);
    _MCMS_FL_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_ShldrPad_FL
{
    _mMCMS_FL_AR.MCMS_ShldrPad_FL.phys = getValue(this);
    _MCMS_FL_AR_SpontanFlag = 1;
}

MCMS_FL_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_MCMS_FL_Stat_AR ) )
    {
    //  message   MCMS_FL_Stat_AR ID: 795 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _MCMS_FL_Stat_AR_Cnt--;
        if( _MCMS_FL_Stat_AR_Cnt < 1 )
        {
            MCMS_FL_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _MCMS_FL_Stat_AR_Cnt = _MCMS_FL_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _MCMS_FL_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _MCMS_FL_Stat_AR_SpontanFlag )
        {
            MCMS_FL_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _MCMS_FL_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

MCMS_FL_Stat_AR_init()
{   /* Botschaft MCMS_FL_Stat_AR ID: 795 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 795 0;
BA_ "NmAsrMessage" BO_ 795 0;
BA_ "GenMsgMinAcceptLength" BO_ 795 8;
BA_ "GenMsgILSupport" BO_ 795 1;
BA_ "DiagState" BO_ 795 0;
BA_ "DiagRequest" BO_ 795 0;
BA_ "DiagResponse" BO_ 795 0;
BA_ "GenMsgStartValue" BO_ 795 "0";
BA_ "GenMsgDelayTime" BO_ 795 5;
BA_ "GenMsgNrOfRepetitions" BO_ 795 0;
BA_ "GenMsgCycleTime" BO_ 795 1000;
BA_ "GenMsgSendType" BO_ 795 5;
    */
    _MCMS_FL_Stat_AR_Timebase =           c_tDBKomTimer_20ms;
    _MCMS_FL_Stat_AR_CycleCount =       1000 / _MCMS_FL_Stat_AR_Timebase;
    _MCMS_FL_Stat_AR_StartDelay =          0 / _MCMS_FL_Stat_AR_Timebase;
    _MCMS_FL_Stat_AR_Cnt = _MCMS_FL_Stat_AR_StartDelay;
    _MCMS_FL_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_MCMS_FL_Stat_AR, _MCMS_FL_Stat_AR_StartDelay * _MCMS_FL_Stat_AR_Timebase );

    _mMCMS_FL_Stat_AR.MCMS_AmbPress_FL.phys = getValue( HMI_MCMS_AmbPress_FL );
    _mMCMS_FL_Stat_AR.MCMS_DrvDynSeat_FL_Actv.phys = getValue( HMI_MCMS_DrvDynSeat_FL_Actv );
    _mMCMS_FL_Stat_AR.MCMS_DrvDynSeatMd_FL_Stat.phys = getValue( HMI_MCMS_DrvDynSeatMd_FL_Stat );
    _mMCMS_FL_Stat_AR.MCMS_HotStnInsty_FL_Stat.phys = getValue( HMI_MCMS_HotStnInsty_FL_Stat );
    _mMCMS_FL_Stat_AR.MCMS_LumPad_FL_Stat.phys = getValue( HMI_MCMS_LumPad_FL_Stat );
    _mMCMS_FL_Stat_AR.MCMS_LumPosn_FL_Stat.phys = getValue( HMI_MCMS_LumPosn_FL_Stat );
    _mMCMS_FL_Stat_AR.MCMS_Mass_FL_On.phys = getValue( HMI_MCMS_Mass_FL_On );
    _mMCMS_FL_Stat_AR.MCMS_MassAdj_FL_Stat_V3.phys = getValue( HMI_MCMS_MassAdj_FL_Stat_V3 );
    _mMCMS_FL_Stat_AR.MCMS_MassInsty_FL_Stat.phys = getValue( HMI_MCMS_MassInsty_FL_Stat );
    _mMCMS_FL_Stat_AR.MCMS_SdRstPad_FL_Stat.phys = getValue( HMI_MCMS_SdRstPad_FL_Stat );
    _mMCMS_FL_Stat_AR.MCMS_SeatPad_FL_Stat.phys = getValue( HMI_MCMS_SeatPad_FL_Stat );
    _mMCMS_FL_Stat_AR.MCMS_ShldrPad_FL_Stat.phys = getValue( HMI_MCMS_ShldrPad_FL_Stat );
}

MCMS_FL_Stat_AR_output(void)
{
    output( _mMCMS_FL_Stat_AR );
}

MCMS_FL_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: MCMS_FL_Stat_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_MCMS_FL_Stat := %X\n", getValue( HMI__STMSG_MCMS_FL_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_MCMS_FL_Stat := %X\n", getValue( HMI__STMSGT_MCMS_FL_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_AmbPress_FL := %X\n", getValue( HMI_MCMS_AmbPress_FL ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_DrvDynSeat_FL_Actv := %X\n", getValue( HMI_MCMS_DrvDynSeat_FL_Actv ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_DrvDynSeatMd_FL_Stat := %X\n", getValue( HMI_MCMS_DrvDynSeatMd_FL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_HotStnInsty_FL_Stat := %X\n", getValue( HMI_MCMS_HotStnInsty_FL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_LumPad_FL_Stat := %X\n", getValue( HMI_MCMS_LumPad_FL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_LumPosn_FL_Stat := %X\n", getValue( HMI_MCMS_LumPosn_FL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_Mass_FL_On := %X\n", getValue( HMI_MCMS_Mass_FL_On ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_MassAdj_FL_Stat_V3 := %X\n", getValue( HMI_MCMS_MassAdj_FL_Stat_V3 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_MassInsty_FL_Stat := %X\n", getValue( HMI_MCMS_MassInsty_FL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_SdRstPad_FL_Stat := %X\n", getValue( HMI_MCMS_SdRstPad_FL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_SeatPad_FL_Stat := %X\n", getValue( HMI_MCMS_SeatPad_FL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_ShldrPad_FL_Stat := %X\n", getValue( HMI_MCMS_ShldrPad_FL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tMCMS_FL_Stat_AR
{
    putValue( HMI__STMSG_MCMS_FL_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_MCMS_FL_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_MCMS_FL_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tMCMS_FL_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_MCMS_FL_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_MCMS_FL_Stat_AR
{
    if( getValue( this ) )
        openPanel("MCMS_FL_Stat_AR");
}

on EnvVar HMI_MCMS_AmbPress_FL
{
    _mMCMS_FL_Stat_AR.MCMS_AmbPress_FL.phys = getValue(this);
    _MCMS_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_DrvDynSeat_FL_Actv
{
    _mMCMS_FL_Stat_AR.MCMS_DrvDynSeat_FL_Actv.phys = getValue(this);
    _MCMS_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_DrvDynSeatMd_FL_Stat
{
    _mMCMS_FL_Stat_AR.MCMS_DrvDynSeatMd_FL_Stat.phys = getValue(this);
    _MCMS_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_HotStnInsty_FL_Stat
{
    _mMCMS_FL_Stat_AR.MCMS_HotStnInsty_FL_Stat.phys = getValue(this);
    _MCMS_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_LumPad_FL_Stat
{
    _mMCMS_FL_Stat_AR.MCMS_LumPad_FL_Stat.phys = getValue(this);
    _MCMS_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_LumPosn_FL_Stat
{
    _mMCMS_FL_Stat_AR.MCMS_LumPosn_FL_Stat.phys = getValue(this);
    _MCMS_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_Mass_FL_On
{
    _mMCMS_FL_Stat_AR.MCMS_Mass_FL_On.phys = getValue(this);
    _MCMS_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_MassAdj_FL_Stat_V3
{
    _mMCMS_FL_Stat_AR.MCMS_MassAdj_FL_Stat_V3.phys = getValue(this);
    _MCMS_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_MassInsty_FL_Stat
{
    _mMCMS_FL_Stat_AR.MCMS_MassInsty_FL_Stat.phys = getValue(this);
    _MCMS_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_SdRstPad_FL_Stat
{
    _mMCMS_FL_Stat_AR.MCMS_SdRstPad_FL_Stat.phys = getValue(this);
    _MCMS_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_SeatPad_FL_Stat
{
    _mMCMS_FL_Stat_AR.MCMS_SeatPad_FL_Stat.phys = getValue(this);
    _MCMS_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_ShldrPad_FL_Stat
{
    _mMCMS_FL_Stat_AR.MCMS_ShldrPad_FL_Stat.phys = getValue(this);
    _MCMS_FL_Stat_AR_SpontanFlag = 1;
}

MCMS_FR_AR_check_output()
{
    if( !getValue( HMI__STMSG_MCMS_FR_AR ) )
    {
    //  message   MCMS_FR_AR ID: 799 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _MCMS_FR_AR_Cnt--;
        if( _MCMS_FR_AR_Cnt < 1 )
        {
            MCMS_FR_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _MCMS_FR_AR_Cnt = _MCMS_FR_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _MCMS_FR_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _MCMS_FR_AR_SpontanFlag )
        {
            MCMS_FR_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _MCMS_FR_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

MCMS_FR_AR_init()
{   /* Botschaft MCMS_FR_AR ID: 799 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 799 0;
BA_ "NmAsrMessage" BO_ 799 0;
BA_ "GenMsgMinAcceptLength" BO_ 799 8;
BA_ "GenMsgILSupport" BO_ 799 1;
BA_ "DiagState" BO_ 799 0;
BA_ "DiagRequest" BO_ 799 0;
BA_ "DiagResponse" BO_ 799 0;
BA_ "GenMsgStartValue" BO_ 799 "0";
BA_ "GenMsgDelayTime" BO_ 799 5;
BA_ "GenMsgNrOfRepetitions" BO_ 799 0;
BA_ "GenMsgCycleTime" BO_ 799 1000;
BA_ "GenMsgSendType" BO_ 799 5;
    */
    _MCMS_FR_AR_Timebase =           c_tDBKomTimer_20ms;
    _MCMS_FR_AR_CycleCount =       1000 / _MCMS_FR_AR_Timebase;
    _MCMS_FR_AR_StartDelay =          0 / _MCMS_FR_AR_Timebase;
    _MCMS_FR_AR_Cnt = _MCMS_FR_AR_StartDelay;
    _MCMS_FR_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_MCMS_FR_AR, _MCMS_FR_AR_StartDelay * _MCMS_FR_AR_Timebase );

    _mMCMS_FR_AR.HotStn_FR_On_Rq.phys = getValue( HMI_HotStn_FR_On_Rq );
    _mMCMS_FR_AR.MCMS_ActvComf_FR_Stat.phys = getValue( HMI_MCMS_ActvComf_FR_Stat );
    _mMCMS_FR_AR.MCMS_ActvComfProg_FR_Stat.phys = getValue( HMI_MCMS_ActvComfProg_FR_Stat );
    _mMCMS_FR_AR.MCMS_FR_On.phys = getValue( HMI_MCMS_FR_On );
    _mMCMS_FR_AR.MCMS_LumPad_FR.phys = getValue( HMI_MCMS_LumPad_FR );
    _mMCMS_FR_AR.MCMS_LumPosn_FR.phys = getValue( HMI_MCMS_LumPosn_FR );
    _mMCMS_FR_AR.MCMS_Pmp_FR_Rq.phys = getValue( HMI_MCMS_Pmp_FR_Rq );
    _mMCMS_FR_AR.MCMS_SdRstPad_FR.phys = getValue( HMI_MCMS_SdRstPad_FR );
    _mMCMS_FR_AR.MCMS_SeatPad_FR.phys = getValue( HMI_MCMS_SeatPad_FR );
    _mMCMS_FR_AR.MCMS_ShldrPad_FR.phys = getValue( HMI_MCMS_ShldrPad_FR );
}

MCMS_FR_AR_output(void)
{
    output( _mMCMS_FR_AR );
}

MCMS_FR_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: MCMS_FR_AR\n", 24, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_MCMS_FR := %X\n", getValue( HMI__STMSG_MCMS_FR_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_MCMS_FR := %X\n", getValue( HMI__STMSGT_MCMS_FR_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HotStn_FR_On_Rq := %X\n", getValue( HMI_HotStn_FR_On_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_ActvComf_FR_Stat := %X\n", getValue( HMI_MCMS_ActvComf_FR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_ActvComfProg_FR_Stat := %X\n", getValue( HMI_MCMS_ActvComfProg_FR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_FR_On := %X\n", getValue( HMI_MCMS_FR_On ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_LumPad_FR := %X\n", getValue( HMI_MCMS_LumPad_FR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_LumPosn_FR := %X\n", getValue( HMI_MCMS_LumPosn_FR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_Pmp_FR_Rq := %X\n", getValue( HMI_MCMS_Pmp_FR_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_SdRstPad_FR := %X\n", getValue( HMI_MCMS_SdRstPad_FR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_SeatPad_FR := %X\n", getValue( HMI_MCMS_SeatPad_FR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_ShldrPad_FR := %X\n", getValue( HMI_MCMS_ShldrPad_FR ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tMCMS_FR_AR
{
    putValue( HMI__STMSG_MCMS_FR_AR, 0 );
}

on EnvVar HMI__STMSG_MCMS_FR_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_MCMS_FR_AR );
        if( tDelay > 0)    
            setTimer( _tMCMS_FR_AR, tDelay );
        else
            putValue( HMI__STMSG_MCMS_FR_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_MCMS_FR_AR
{
    if( getValue( this ) )
        openPanel("MCMS_FR_AR");
}

on EnvVar HMI_HotStn_FR_On_Rq
{
    _mMCMS_FR_AR.HotStn_FR_On_Rq.phys = getValue(this);
    _MCMS_FR_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_ActvComf_FR_Stat
{
    _mMCMS_FR_AR.MCMS_ActvComf_FR_Stat.phys = getValue(this);
    _MCMS_FR_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_ActvComfProg_FR_Stat
{
    _mMCMS_FR_AR.MCMS_ActvComfProg_FR_Stat.phys = getValue(this);
    _MCMS_FR_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_FR_On
{
    _mMCMS_FR_AR.MCMS_FR_On.phys = getValue(this);
    _MCMS_FR_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_LumPad_FR
{
    _mMCMS_FR_AR.MCMS_LumPad_FR.phys = getValue(this);
    _MCMS_FR_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_LumPosn_FR
{
    _mMCMS_FR_AR.MCMS_LumPosn_FR.phys = getValue(this);
    _MCMS_FR_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_Pmp_FR_Rq
{
    _mMCMS_FR_AR.MCMS_Pmp_FR_Rq.phys = getValue(this);
    _MCMS_FR_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_SdRstPad_FR
{
    _mMCMS_FR_AR.MCMS_SdRstPad_FR.phys = getValue(this);
    _MCMS_FR_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_SeatPad_FR
{
    _mMCMS_FR_AR.MCMS_SeatPad_FR.phys = getValue(this);
    _MCMS_FR_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_ShldrPad_FR
{
    _mMCMS_FR_AR.MCMS_ShldrPad_FR.phys = getValue(this);
    _MCMS_FR_AR_SpontanFlag = 1;
}

MCMS_FR_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_MCMS_FR_Stat_AR ) )
    {
    //  message   MCMS_FR_Stat_AR ID: 801 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _MCMS_FR_Stat_AR_Cnt--;
        if( _MCMS_FR_Stat_AR_Cnt < 1 )
        {
            MCMS_FR_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _MCMS_FR_Stat_AR_Cnt = _MCMS_FR_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _MCMS_FR_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _MCMS_FR_Stat_AR_SpontanFlag )
        {
            MCMS_FR_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _MCMS_FR_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

MCMS_FR_Stat_AR_init()
{   /* Botschaft MCMS_FR_Stat_AR ID: 801 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 801 0;
BA_ "NmAsrMessage" BO_ 801 0;
BA_ "GenMsgMinAcceptLength" BO_ 801 8;
BA_ "GenMsgILSupport" BO_ 801 1;
BA_ "DiagState" BO_ 801 0;
BA_ "DiagRequest" BO_ 801 0;
BA_ "DiagResponse" BO_ 801 0;
BA_ "GenMsgStartValue" BO_ 801 "0";
BA_ "GenMsgDelayTime" BO_ 801 5;
BA_ "GenMsgNrOfRepetitions" BO_ 801 0;
BA_ "GenMsgCycleTime" BO_ 801 1000;
BA_ "GenMsgSendType" BO_ 801 5;
    */
    _MCMS_FR_Stat_AR_Timebase =           c_tDBKomTimer_20ms;
    _MCMS_FR_Stat_AR_CycleCount =       1000 / _MCMS_FR_Stat_AR_Timebase;
    _MCMS_FR_Stat_AR_StartDelay =          0 / _MCMS_FR_Stat_AR_Timebase;
    _MCMS_FR_Stat_AR_Cnt = _MCMS_FR_Stat_AR_StartDelay;
    _MCMS_FR_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_MCMS_FR_Stat_AR, _MCMS_FR_Stat_AR_StartDelay * _MCMS_FR_Stat_AR_Timebase );

    _mMCMS_FR_Stat_AR.MCMS_AmbPress_FR.phys = getValue( HMI_MCMS_AmbPress_FR );
    _mMCMS_FR_Stat_AR.MCMS_DrvDynSeat_FR_Actv.phys = getValue( HMI_MCMS_DrvDynSeat_FR_Actv );
    _mMCMS_FR_Stat_AR.MCMS_DrvDynSeatMd_FR_Stat.phys = getValue( HMI_MCMS_DrvDynSeatMd_FR_Stat );
    _mMCMS_FR_Stat_AR.MCMS_HotStnInsty_FR_Stat.phys = getValue( HMI_MCMS_HotStnInsty_FR_Stat );
    _mMCMS_FR_Stat_AR.MCMS_LumPad_FR_Stat.phys = getValue( HMI_MCMS_LumPad_FR_Stat );
    _mMCMS_FR_Stat_AR.MCMS_LumPosn_FR_Stat.phys = getValue( HMI_MCMS_LumPosn_FR_Stat );
    _mMCMS_FR_Stat_AR.MCMS_Mass_FR_On.phys = getValue( HMI_MCMS_Mass_FR_On );
    _mMCMS_FR_Stat_AR.MCMS_MassAdj_FR_Stat_V3.phys = getValue( HMI_MCMS_MassAdj_FR_Stat_V3 );
    _mMCMS_FR_Stat_AR.MCMS_MassInsty_FR_Stat.phys = getValue( HMI_MCMS_MassInsty_FR_Stat );
    _mMCMS_FR_Stat_AR.MCMS_SdRstPad_FR_Stat.phys = getValue( HMI_MCMS_SdRstPad_FR_Stat );
    _mMCMS_FR_Stat_AR.MCMS_SeatPad_FR_Stat.phys = getValue( HMI_MCMS_SeatPad_FR_Stat );
    _mMCMS_FR_Stat_AR.MCMS_ShldrPad_FR_Stat.phys = getValue( HMI_MCMS_ShldrPad_FR_Stat );
}

MCMS_FR_Stat_AR_output(void)
{
    output( _mMCMS_FR_Stat_AR );
}

MCMS_FR_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: MCMS_FR_Stat_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_MCMS_FR_Stat := %X\n", getValue( HMI__STMSG_MCMS_FR_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_MCMS_FR_Stat := %X\n", getValue( HMI__STMSGT_MCMS_FR_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_AmbPress_FR := %X\n", getValue( HMI_MCMS_AmbPress_FR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_DrvDynSeat_FR_Actv := %X\n", getValue( HMI_MCMS_DrvDynSeat_FR_Actv ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_DrvDynSeatMd_FR_Stat := %X\n", getValue( HMI_MCMS_DrvDynSeatMd_FR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_HotStnInsty_FR_Stat := %X\n", getValue( HMI_MCMS_HotStnInsty_FR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_LumPad_FR_Stat := %X\n", getValue( HMI_MCMS_LumPad_FR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_LumPosn_FR_Stat := %X\n", getValue( HMI_MCMS_LumPosn_FR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_Mass_FR_On := %X\n", getValue( HMI_MCMS_Mass_FR_On ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_MassAdj_FR_Stat_V3 := %X\n", getValue( HMI_MCMS_MassAdj_FR_Stat_V3 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_MassInsty_FR_Stat := %X\n", getValue( HMI_MCMS_MassInsty_FR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_SdRstPad_FR_Stat := %X\n", getValue( HMI_MCMS_SdRstPad_FR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_SeatPad_FR_Stat := %X\n", getValue( HMI_MCMS_SeatPad_FR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_ShldrPad_FR_Stat := %X\n", getValue( HMI_MCMS_ShldrPad_FR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tMCMS_FR_Stat_AR
{
    putValue( HMI__STMSG_MCMS_FR_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_MCMS_FR_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_MCMS_FR_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tMCMS_FR_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_MCMS_FR_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_MCMS_FR_Stat_AR
{
    if( getValue( this ) )
        openPanel("MCMS_FR_Stat_AR");
}

on EnvVar HMI_MCMS_AmbPress_FR
{
    _mMCMS_FR_Stat_AR.MCMS_AmbPress_FR.phys = getValue(this);
    _MCMS_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_DrvDynSeat_FR_Actv
{
    _mMCMS_FR_Stat_AR.MCMS_DrvDynSeat_FR_Actv.phys = getValue(this);
    _MCMS_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_DrvDynSeatMd_FR_Stat
{
    _mMCMS_FR_Stat_AR.MCMS_DrvDynSeatMd_FR_Stat.phys = getValue(this);
    _MCMS_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_HotStnInsty_FR_Stat
{
    _mMCMS_FR_Stat_AR.MCMS_HotStnInsty_FR_Stat.phys = getValue(this);
    _MCMS_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_LumPad_FR_Stat
{
    _mMCMS_FR_Stat_AR.MCMS_LumPad_FR_Stat.phys = getValue(this);
    _MCMS_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_LumPosn_FR_Stat
{
    _mMCMS_FR_Stat_AR.MCMS_LumPosn_FR_Stat.phys = getValue(this);
    _MCMS_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_Mass_FR_On
{
    _mMCMS_FR_Stat_AR.MCMS_Mass_FR_On.phys = getValue(this);
    _MCMS_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_MassAdj_FR_Stat_V3
{
    _mMCMS_FR_Stat_AR.MCMS_MassAdj_FR_Stat_V3.phys = getValue(this);
    _MCMS_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_MassInsty_FR_Stat
{
    _mMCMS_FR_Stat_AR.MCMS_MassInsty_FR_Stat.phys = getValue(this);
    _MCMS_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_SdRstPad_FR_Stat
{
    _mMCMS_FR_Stat_AR.MCMS_SdRstPad_FR_Stat.phys = getValue(this);
    _MCMS_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_SeatPad_FR_Stat
{
    _mMCMS_FR_Stat_AR.MCMS_SeatPad_FR_Stat.phys = getValue(this);
    _MCMS_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_ShldrPad_FR_Stat
{
    _mMCMS_FR_Stat_AR.MCMS_ShldrPad_FR_Stat.phys = getValue(this);
    _MCMS_FR_Stat_AR_SpontanFlag = 1;
}

MCMS_RL_AR_check_output()
{
    if( !getValue( HMI__STMSG_MCMS_RL_AR ) )
    {
    //  message   MCMS_RL_AR ID: 807 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _MCMS_RL_AR_Cnt--;
        if( _MCMS_RL_AR_Cnt < 1 )
        {
            MCMS_RL_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _MCMS_RL_AR_Cnt = _MCMS_RL_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _MCMS_RL_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _MCMS_RL_AR_SpontanFlag )
        {
            MCMS_RL_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _MCMS_RL_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

MCMS_RL_AR_init()
{   /* Botschaft MCMS_RL_AR ID: 807 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 807 0;
BA_ "NmAsrMessage" BO_ 807 0;
BA_ "GenMsgMinAcceptLength" BO_ 807 8;
BA_ "GenMsgILSupport" BO_ 807 1;
BA_ "DiagState" BO_ 807 0;
BA_ "DiagRequest" BO_ 807 0;
BA_ "DiagResponse" BO_ 807 0;
BA_ "GenMsgStartValue" BO_ 807 "0";
BA_ "GenMsgDelayTime" BO_ 807 5;
BA_ "GenMsgNrOfRepetitions" BO_ 807 0;
BA_ "GenMsgCycleTime" BO_ 807 1000;
BA_ "GenMsgSendType" BO_ 807 5;
    */
    _MCMS_RL_AR_Timebase =           c_tDBKomTimer_20ms;
    _MCMS_RL_AR_CycleCount =      1000 / _MCMS_RL_AR_Timebase;
    _MCMS_RL_AR_StartDelay =         0 / _MCMS_RL_AR_Timebase;
    _MCMS_RL_AR_Cnt = _MCMS_RL_AR_StartDelay;
    _MCMS_RL_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_MCMS_RL_AR, _MCMS_RL_AR_StartDelay * _MCMS_RL_AR_Timebase );

    _mMCMS_RL_AR.HotStn_RL_On_Rq.phys = getValue( HMI_HotStn_RL_On_Rq );
    _mMCMS_RL_AR.MCMS_ActvComf_RL_Stat.phys = getValue( HMI_MCMS_ActvComf_RL_Stat );
    _mMCMS_RL_AR.MCMS_ActvComfProg_RL_Stat.phys = getValue( HMI_MCMS_ActvComfProg_RL_Stat );
    _mMCMS_RL_AR.MCMS_LumPad_RL.phys = getValue( HMI_MCMS_LumPad_RL );
    _mMCMS_RL_AR.MCMS_LumPosn_RL.phys = getValue( HMI_MCMS_LumPosn_RL );
    _mMCMS_RL_AR.MCMS_Pmp_RL_Rq.phys = getValue( HMI_MCMS_Pmp_RL_Rq );
    _mMCMS_RL_AR.MCMS_RL_On.phys = getValue( HMI_MCMS_RL_On );
    _mMCMS_RL_AR.MCMS_SdRstPad_RL.phys = getValue( HMI_MCMS_SdRstPad_RL );
}

MCMS_RL_AR_output(void)
{
    output( _mMCMS_RL_AR );
}

MCMS_RL_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: MCMS_RL_AR\n", 24, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_MCMS_RL := %X\n", getValue( HMI__STMSG_MCMS_RL_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_MCMS_RL := %X\n", getValue( HMI__STMSGT_MCMS_RL_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HotStn_RL_On_Rq := %X\n", getValue( HMI_HotStn_RL_On_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_ActvComf_RL_Stat := %X\n", getValue( HMI_MCMS_ActvComf_RL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_ActvComfProg_RL_Stat := %X\n", getValue( HMI_MCMS_ActvComfProg_RL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_LumPad_RL := %X\n", getValue( HMI_MCMS_LumPad_RL ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_LumPosn_RL := %X\n", getValue( HMI_MCMS_LumPosn_RL ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_Pmp_RL_Rq := %X\n", getValue( HMI_MCMS_Pmp_RL_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_RL_On := %X\n", getValue( HMI_MCMS_RL_On ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_SdRstPad_RL := %X\n", getValue( HMI_MCMS_SdRstPad_RL ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tMCMS_RL_AR
{
    putValue( HMI__STMSG_MCMS_RL_AR, 0 );
}

on EnvVar HMI__STMSG_MCMS_RL_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_MCMS_RL_AR );
        if( tDelay > 0)    
            setTimer( _tMCMS_RL_AR, tDelay );
        else
            putValue( HMI__STMSG_MCMS_RL_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_MCMS_RL_AR
{
    if( getValue( this ) )
        openPanel("MCMS_RL_AR");
}

on EnvVar HMI_HotStn_RL_On_Rq
{
    _mMCMS_RL_AR.HotStn_RL_On_Rq.phys = getValue(this);
    _MCMS_RL_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_ActvComf_RL_Stat
{
    _mMCMS_RL_AR.MCMS_ActvComf_RL_Stat.phys = getValue(this);
    _MCMS_RL_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_ActvComfProg_RL_Stat
{
    _mMCMS_RL_AR.MCMS_ActvComfProg_RL_Stat.phys = getValue(this);
    _MCMS_RL_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_LumPad_RL
{
    _mMCMS_RL_AR.MCMS_LumPad_RL.phys = getValue(this);
    _MCMS_RL_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_LumPosn_RL
{
    _mMCMS_RL_AR.MCMS_LumPosn_RL.phys = getValue(this);
    _MCMS_RL_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_Pmp_RL_Rq
{
    _mMCMS_RL_AR.MCMS_Pmp_RL_Rq.phys = getValue(this);
    _MCMS_RL_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_RL_On
{
    _mMCMS_RL_AR.MCMS_RL_On.phys = getValue(this);
    _MCMS_RL_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_SdRstPad_RL
{
    _mMCMS_RL_AR.MCMS_SdRstPad_RL.phys = getValue(this);
    _MCMS_RL_AR_SpontanFlag = 1;
}

MCMS_RL_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_MCMS_RL_Stat_AR ) )
    {
    //  message   MCMS_RL_Stat_AR ID: 809 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _MCMS_RL_Stat_AR_Cnt--;
        if( _MCMS_RL_Stat_AR_Cnt < 1 )
        {
            MCMS_RL_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _MCMS_RL_Stat_AR_Cnt = _MCMS_RL_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _MCMS_RL_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _MCMS_RL_Stat_AR_SpontanFlag )
        {
            MCMS_RL_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _MCMS_RL_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

MCMS_RL_Stat_AR_init()
{   /* Botschaft MCMS_RL_Stat_AR ID: 809 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 809 0;
BA_ "NmAsrMessage" BO_ 809 0;
BA_ "GenMsgMinAcceptLength" BO_ 809 8;
BA_ "GenMsgILSupport" BO_ 809 1;
BA_ "DiagState" BO_ 809 0;
BA_ "DiagRequest" BO_ 809 0;
BA_ "DiagResponse" BO_ 809 0;
BA_ "GenMsgStartValue" BO_ 809 "0";
BA_ "GenMsgDelayTime" BO_ 809 5;
BA_ "GenMsgNrOfRepetitions" BO_ 809 0;
BA_ "GenMsgCycleTime" BO_ 809 1000;
BA_ "GenMsgSendType" BO_ 809 5;
    */
    _MCMS_RL_Stat_AR_Timebase =           c_tDBKomTimer_20ms;
    _MCMS_RL_Stat_AR_CycleCount =        1000 / _MCMS_RL_Stat_AR_Timebase;
    _MCMS_RL_Stat_AR_StartDelay =           0 / _MCMS_RL_Stat_AR_Timebase;
    _MCMS_RL_Stat_AR_Cnt = _MCMS_RL_Stat_AR_StartDelay;
    _MCMS_RL_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_MCMS_RL_Stat_AR, _MCMS_RL_Stat_AR_StartDelay * _MCMS_RL_Stat_AR_Timebase );

    _mMCMS_RL_Stat_AR.MCMS_AmbPress_RL.phys = getValue( HMI_MCMS_AmbPress_RL );
    _mMCMS_RL_Stat_AR.MCMS_HotStnInsty_RL_Stat.phys = getValue( HMI_MCMS_HotStnInsty_RL_Stat );
    _mMCMS_RL_Stat_AR.MCMS_LumPad_RL_Stat.phys = getValue( HMI_MCMS_LumPad_RL_Stat );
    _mMCMS_RL_Stat_AR.MCMS_LumPosn_RL_Stat.phys = getValue( HMI_MCMS_LumPosn_RL_Stat );
    _mMCMS_RL_Stat_AR.MCMS_Mass_RL_On.phys = getValue( HMI_MCMS_Mass_RL_On );
    _mMCMS_RL_Stat_AR.MCMS_MassAdj_RL_Stat_V3.phys = getValue( HMI_MCMS_MassAdj_RL_Stat_V3 );
    _mMCMS_RL_Stat_AR.MCMS_MassInsty_RL_Stat.phys = getValue( HMI_MCMS_MassInsty_RL_Stat );
    _mMCMS_RL_Stat_AR.MCMS_SdRstPad_RL_Stat.phys = getValue( HMI_MCMS_SdRstPad_RL_Stat );
}

MCMS_RL_Stat_AR_output(void)
{
    output( _mMCMS_RL_Stat_AR );
}

MCMS_RL_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: MCMS_RL_Stat_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_MCMS_RL_Stat := %X\n", getValue( HMI__STMSG_MCMS_RL_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_MCMS_RL_Stat := %X\n", getValue( HMI__STMSGT_MCMS_RL_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_AmbPress_RL := %X\n", getValue( HMI_MCMS_AmbPress_RL ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_HotStnInsty_RL_Stat := %X\n", getValue( HMI_MCMS_HotStnInsty_RL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_LumPad_RL_Stat := %X\n", getValue( HMI_MCMS_LumPad_RL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_LumPosn_RL_Stat := %X\n", getValue( HMI_MCMS_LumPosn_RL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_Mass_RL_On := %X\n", getValue( HMI_MCMS_Mass_RL_On ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_MassAdj_RL_Stat_V3 := %X\n", getValue( HMI_MCMS_MassAdj_RL_Stat_V3 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_MassInsty_RL_Stat := %X\n", getValue( HMI_MCMS_MassInsty_RL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_SdRstPad_RL_Stat := %X\n", getValue( HMI_MCMS_SdRstPad_RL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tMCMS_RL_Stat_AR
{
    putValue( HMI__STMSG_MCMS_RL_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_MCMS_RL_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_MCMS_RL_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tMCMS_RL_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_MCMS_RL_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_MCMS_RL_Stat_AR
{
    if( getValue( this ) )
        openPanel("MCMS_RL_Stat_AR");
}

on EnvVar HMI_MCMS_AmbPress_RL
{
    _mMCMS_RL_Stat_AR.MCMS_AmbPress_RL.phys = getValue(this);
    _MCMS_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_HotStnInsty_RL_Stat
{
    _mMCMS_RL_Stat_AR.MCMS_HotStnInsty_RL_Stat.phys = getValue(this);
    _MCMS_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_LumPad_RL_Stat
{
    _mMCMS_RL_Stat_AR.MCMS_LumPad_RL_Stat.phys = getValue(this);
    _MCMS_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_LumPosn_RL_Stat
{
    _mMCMS_RL_Stat_AR.MCMS_LumPosn_RL_Stat.phys = getValue(this);
    _MCMS_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_Mass_RL_On
{
    _mMCMS_RL_Stat_AR.MCMS_Mass_RL_On.phys = getValue(this);
    _MCMS_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_MassAdj_RL_Stat_V3
{
    _mMCMS_RL_Stat_AR.MCMS_MassAdj_RL_Stat_V3.phys = getValue(this);
    _MCMS_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_MassInsty_RL_Stat
{
    _mMCMS_RL_Stat_AR.MCMS_MassInsty_RL_Stat.phys = getValue(this);
    _MCMS_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_SdRstPad_RL_Stat
{
    _mMCMS_RL_Stat_AR.MCMS_SdRstPad_RL_Stat.phys = getValue(this);
    _MCMS_RL_Stat_AR_SpontanFlag = 1;
}

MCMS_RR_AR_check_output()
{
    if( !getValue( HMI__STMSG_MCMS_RR_AR ) )
    {
    //  message   MCMS_RR_AR ID: 813 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _MCMS_RR_AR_Cnt--;
        if( _MCMS_RR_AR_Cnt < 1 )
        {
            MCMS_RR_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _MCMS_RR_AR_Cnt = _MCMS_RR_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _MCMS_RR_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _MCMS_RR_AR_SpontanFlag )
        {
            MCMS_RR_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _MCMS_RR_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

MCMS_RR_AR_init()
{   /* Botschaft MCMS_RR_AR ID: 813 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 813 0;
BA_ "NmAsrMessage" BO_ 813 0;
BA_ "GenMsgMinAcceptLength" BO_ 813 8;
BA_ "GenMsgILSupport" BO_ 813 1;
BA_ "DiagState" BO_ 813 0;
BA_ "DiagRequest" BO_ 813 0;
BA_ "DiagResponse" BO_ 813 0;
BA_ "GenMsgStartValue" BO_ 813 "0";
BA_ "GenMsgDelayTime" BO_ 813 5;
BA_ "GenMsgNrOfRepetitions" BO_ 813 0;
BA_ "GenMsgCycleTime" BO_ 813 1000;
BA_ "GenMsgSendType" BO_ 813 5;
    */
    _MCMS_RR_AR_Timebase =           c_tDBKomTimer_20ms;
    _MCMS_RR_AR_CycleCount =       1000 / _MCMS_RR_AR_Timebase;
    _MCMS_RR_AR_StartDelay =          0 / _MCMS_RR_AR_Timebase;
    _MCMS_RR_AR_Cnt = _MCMS_RR_AR_StartDelay;
    _MCMS_RR_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_MCMS_RR_AR, _MCMS_RR_AR_StartDelay * _MCMS_RR_AR_Timebase );

    _mMCMS_RR_AR.HotStn_RR_On_Rq.phys = getValue( HMI_HotStn_RR_On_Rq );
    _mMCMS_RR_AR.MCMS_ActvComf_RR_Stat.phys = getValue( HMI_MCMS_ActvComf_RR_Stat );
    _mMCMS_RR_AR.MCMS_ActvComfProg_RR_Stat.phys = getValue( HMI_MCMS_ActvComfProg_RR_Stat );
    _mMCMS_RR_AR.MCMS_LumPad_RR.phys = getValue( HMI_MCMS_LumPad_RR );
    _mMCMS_RR_AR.MCMS_LumPosn_RR.phys = getValue( HMI_MCMS_LumPosn_RR );
    _mMCMS_RR_AR.MCMS_Pmp_RR_Rq.phys = getValue( HMI_MCMS_Pmp_RR_Rq );
    _mMCMS_RR_AR.MCMS_RR_On.phys = getValue( HMI_MCMS_RR_On );
    _mMCMS_RR_AR.MCMS_SdRstPad_RR.phys = getValue( HMI_MCMS_SdRstPad_RR );
}

MCMS_RR_AR_output(void)
{
    output( _mMCMS_RR_AR );
}

MCMS_RR_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: MCMS_RR_AR\n", 24, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_MCMS_RR := %X\n", getValue( HMI__STMSG_MCMS_RR_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_MCMS_RR := %X\n", getValue( HMI__STMSGT_MCMS_RR_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HotStn_RR_On_Rq := %X\n", getValue( HMI_HotStn_RR_On_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_ActvComf_RR_Stat := %X\n", getValue( HMI_MCMS_ActvComf_RR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_ActvComfProg_RR_Stat := %X\n", getValue( HMI_MCMS_ActvComfProg_RR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_LumPad_RR := %X\n", getValue( HMI_MCMS_LumPad_RR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_LumPosn_RR := %X\n", getValue( HMI_MCMS_LumPosn_RR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_Pmp_RR_Rq := %X\n", getValue( HMI_MCMS_Pmp_RR_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_RR_On := %X\n", getValue( HMI_MCMS_RR_On ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_SdRstPad_RR := %X\n", getValue( HMI_MCMS_SdRstPad_RR ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tMCMS_RR_AR
{
    putValue( HMI__STMSG_MCMS_RR_AR, 0 );
}

on EnvVar HMI__STMSG_MCMS_RR_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_MCMS_RR_AR );
        if( tDelay > 0)    
            setTimer( _tMCMS_RR_AR, tDelay );
        else
            putValue( HMI__STMSG_MCMS_RR_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_MCMS_RR_AR
{
    if( getValue( this ) )
        openPanel("MCMS_RR_AR");
}

on EnvVar HMI_HotStn_RR_On_Rq
{
    _mMCMS_RR_AR.HotStn_RR_On_Rq.phys = getValue(this);
    _MCMS_RR_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_ActvComf_RR_Stat
{
    _mMCMS_RR_AR.MCMS_ActvComf_RR_Stat.phys = getValue(this);
    _MCMS_RR_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_ActvComfProg_RR_Stat
{
    _mMCMS_RR_AR.MCMS_ActvComfProg_RR_Stat.phys = getValue(this);
    _MCMS_RR_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_LumPad_RR
{
    _mMCMS_RR_AR.MCMS_LumPad_RR.phys = getValue(this);
    _MCMS_RR_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_LumPosn_RR
{
    _mMCMS_RR_AR.MCMS_LumPosn_RR.phys = getValue(this);
    _MCMS_RR_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_Pmp_RR_Rq
{
    _mMCMS_RR_AR.MCMS_Pmp_RR_Rq.phys = getValue(this);
    _MCMS_RR_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_RR_On
{
    _mMCMS_RR_AR.MCMS_RR_On.phys = getValue(this);
    _MCMS_RR_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_SdRstPad_RR
{
    _mMCMS_RR_AR.MCMS_SdRstPad_RR.phys = getValue(this);
    _MCMS_RR_AR_SpontanFlag = 1;
}

MCMS_RR_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_MCMS_RR_Stat_AR ) )
    {
    //  message   MCMS_RR_Stat_AR ID: 815 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _MCMS_RR_Stat_AR_Cnt--;
        if( _MCMS_RR_Stat_AR_Cnt < 1 )
        {
            MCMS_RR_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _MCMS_RR_Stat_AR_Cnt = _MCMS_RR_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _MCMS_RR_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _MCMS_RR_Stat_AR_SpontanFlag )
        {
            MCMS_RR_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _MCMS_RR_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

MCMS_RR_Stat_AR_init()
{   /* Botschaft MCMS_RR_Stat_AR ID: 815 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 815 0;
BA_ "NmAsrMessage" BO_ 815 0;
BA_ "GenMsgMinAcceptLength" BO_ 815 8;
BA_ "GenMsgILSupport" BO_ 815 1;
BA_ "DiagState" BO_ 815 0;
BA_ "DiagRequest" BO_ 815 0;
BA_ "DiagResponse" BO_ 815 0;
BA_ "GenMsgStartValue" BO_ 815 "0";
BA_ "GenMsgDelayTime" BO_ 815 5;
BA_ "GenMsgNrOfRepetitions" BO_ 815 0;
BA_ "GenMsgCycleTime" BO_ 815 1000;
BA_ "GenMsgSendType" BO_ 815 5;
    */
    _MCMS_RR_Stat_AR_Timebase =           c_tDBKomTimer_20ms;
    _MCMS_RR_Stat_AR_CycleCount =       1000 / _MCMS_RR_Stat_AR_Timebase;
    _MCMS_RR_Stat_AR_StartDelay =          0 / _MCMS_RR_Stat_AR_Timebase;
    _MCMS_RR_Stat_AR_Cnt = _MCMS_RR_Stat_AR_StartDelay;
    _MCMS_RR_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_MCMS_RR_Stat_AR, _MCMS_RR_Stat_AR_StartDelay * _MCMS_RR_Stat_AR_Timebase );

    _mMCMS_RR_Stat_AR.MCMS_AmbPress_RR.phys = getValue( HMI_MCMS_AmbPress_RR );
    _mMCMS_RR_Stat_AR.MCMS_HotStnInsty_RR_Stat.phys = getValue( HMI_MCMS_HotStnInsty_RR_Stat );
    _mMCMS_RR_Stat_AR.MCMS_LumPad_RR_Stat.phys = getValue( HMI_MCMS_LumPad_RR_Stat );
    _mMCMS_RR_Stat_AR.MCMS_LumPosn_RR_Stat.phys = getValue( HMI_MCMS_LumPosn_RR_Stat );
    _mMCMS_RR_Stat_AR.MCMS_Mass_RR_On.phys = getValue( HMI_MCMS_Mass_RR_On );
    _mMCMS_RR_Stat_AR.MCMS_MassAdj_RR_Stat_V3.phys = getValue( HMI_MCMS_MassAdj_RR_Stat_V3 );
    _mMCMS_RR_Stat_AR.MCMS_MassInsty_RR_Stat.phys = getValue( HMI_MCMS_MassInsty_RR_Stat );
    _mMCMS_RR_Stat_AR.MCMS_SdRstPad_RR_Stat.phys = getValue( HMI_MCMS_SdRstPad_RR_Stat );
}

MCMS_RR_Stat_AR_output(void)
{
    output( _mMCMS_RR_Stat_AR );
}

MCMS_RR_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: MCMS_RR_Stat_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_MCMS_RR_Stat := %X\n", getValue( HMI__STMSG_MCMS_RR_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_MCMS_RR_Stat := %X\n", getValue( HMI__STMSGT_MCMS_RR_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_AmbPress_RR := %X\n", getValue( HMI_MCMS_AmbPress_RR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_HotStnInsty_RR_Stat := %X\n", getValue( HMI_MCMS_HotStnInsty_RR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_LumPad_RR_Stat := %X\n", getValue( HMI_MCMS_LumPad_RR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_LumPosn_RR_Stat := %X\n", getValue( HMI_MCMS_LumPosn_RR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_Mass_RR_On := %X\n", getValue( HMI_MCMS_Mass_RR_On ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_MassAdj_RR_Stat_V3 := %X\n", getValue( HMI_MCMS_MassAdj_RR_Stat_V3 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_MassInsty_RR_Stat := %X\n", getValue( HMI_MCMS_MassInsty_RR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MCMS_SdRstPad_RR_Stat := %X\n", getValue( HMI_MCMS_SdRstPad_RR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tMCMS_RR_Stat_AR
{
    putValue( HMI__STMSG_MCMS_RR_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_MCMS_RR_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_MCMS_RR_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tMCMS_RR_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_MCMS_RR_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_MCMS_RR_Stat_AR
{
    if( getValue( this ) )
        openPanel("MCMS_RR_Stat_AR");
}

on EnvVar HMI_MCMS_AmbPress_RR
{
    _mMCMS_RR_Stat_AR.MCMS_AmbPress_RR.phys = getValue(this);
    _MCMS_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_HotStnInsty_RR_Stat
{
    _mMCMS_RR_Stat_AR.MCMS_HotStnInsty_RR_Stat.phys = getValue(this);
    _MCMS_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_LumPosn_RR_Stat
{
    _mMCMS_RR_Stat_AR.MCMS_LumPosn_RR_Stat.phys = getValue(this);
    _MCMS_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_LumPad_RR_Stat
{
    _mMCMS_RR_Stat_AR.MCMS_LumPad_RR_Stat.phys = getValue(this);
    _MCMS_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_Mass_RR_On
{
    _mMCMS_RR_Stat_AR.MCMS_Mass_RR_On.phys = getValue(this);
    _MCMS_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_MassAdj_RR_Stat_V3
{
    _mMCMS_RR_Stat_AR.MCMS_MassAdj_RR_Stat_V3.phys = getValue(this);
    _MCMS_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_MassInsty_RR_Stat
{
    _mMCMS_RR_Stat_AR.MCMS_MassInsty_RR_Stat.phys = getValue(this);
    _MCMS_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MCMS_SdRstPad_RR_Stat
{
    _mMCMS_RR_Stat_AR.MCMS_SdRstPad_RR_Stat.phys = getValue(this);
    _MCMS_RR_Stat_AR_SpontanFlag = 1;
}

OffRoad_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_OffRoad_Disp_Rq_AR ) )
    {
    //  message   OffRoad_Disp_Rq_AR ID: 918 --- Sendeart 0 cyclicX --- 
        _OffRoad_Disp_Rq_AR_Cnt--;
        if( _OffRoad_Disp_Rq_AR_Cnt < 1 )
        {
            OffRoad_Disp_Rq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _OffRoad_Disp_Rq_AR_Cnt = _OffRoad_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

OffRoad_Disp_Rq_AR_init()
{   /* Botschaft OffRoad_Disp_Rq_AR ID: 918 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 918 0;
BA_ "NmAsrMessage" BO_ 918 0;
BA_ "GenMsgMinAcceptLength" BO_ 918 8;
BA_ "GenMsgILSupport" BO_ 918 1;
BA_ "DiagState" BO_ 918 0;
BA_ "DiagRequest" BO_ 918 0;
BA_ "DiagResponse" BO_ 918 0;
BA_ "GenMsgStartValue" BO_ 918 "0";
BA_ "GenMsgCycleTime" BO_ 918 100;
BA_ "GenMsgSendType" BO_ 918 0;
    */
    _OffRoad_Disp_Rq_AR_Timebase =           c_tDBKomTimer_20ms;
    _OffRoad_Disp_Rq_AR_CycleCount =        100 / _OffRoad_Disp_Rq_AR_Timebase;
    _OffRoad_Disp_Rq_AR_StartDelay =          0 / _OffRoad_Disp_Rq_AR_Timebase;
    _OffRoad_Disp_Rq_AR_Cnt = _OffRoad_Disp_Rq_AR_StartDelay;
    _OffRoad_Disp_Rq_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_OffRoad_Disp_Rq_AR, _OffRoad_Disp_Rq_AR_StartDelay * _OffRoad_Disp_Rq_AR_Timebase );

    _mOffRoad_Disp_Rq_AR.OffRoadDisp_Bar0_Actv.phys = getValue( HMI_OffRoadDisp_Bar0_Actv );
    _mOffRoad_Disp_Rq_AR.OffRoadDisp_Bar1_Actv.phys = getValue( HMI_OffRoadDisp_Bar1_Actv );
    _mOffRoad_Disp_Rq_AR.OffRoadDisp_Bar2_Actv.phys = getValue( HMI_OffRoadDisp_Bar2_Actv );
    _mOffRoad_Disp_Rq_AR.OffRoadDisp_Bar3_Actv.phys = getValue( HMI_OffRoadDisp_Bar3_Actv );
    _mOffRoad_Disp_Rq_AR.OffRoadDisp_RedNum.phys = getValue( HMI_OffRoadDisp_RedNum );
    _mOffRoad_Disp_Rq_AR.OffRoadDisp_SportBar_Actv.phys = getValue( HMI_OffRoadDisp_SportBar_Actv );
	_mOffRoad_Disp_Rq_AR.OffRoadDisp_SportPlusBar_Actv.phys = getValue( HMI_OffRoadDisp_SportPlusBar_Actv );
	_mOffRoad_Disp_Rq_AR.SPC_RockingFree_Disp_Rq.phys = getValue( HMI_SPC_RockingFree_Disp_Rq );
	_mOffRoad_Disp_Rq_AR.SPC_RockingFree_Stat.phys = getValue( HMI_SPC_RockingFree_Stat );
	_mOffRoad_Disp_Rq_AR.SPC_VehLvl_Actv.phys = getValue( HMI_SPC_VehLvl_Actv );
    _mOffRoad_Disp_Rq_AR.VehLvl_Bmpr_Disp_Rq.phys = getValue( HMI_VehLvl_Bmpr_Disp_Rq );
    _mOffRoad_Disp_Rq_AR.VehLvl_Bmpr_Disp_Rq_V2.phys = getValue( HMI_VehLvl_Bmpr_Disp_Rq_V2 );
    _mOffRoad_Disp_Rq_AR.VehLvl_FL_Disp_Rq_V2.phys = getValue( HMI_VehLvl_FL_Disp_Rq_V2 );
    _mOffRoad_Disp_Rq_AR.VehLvl_FR_Disp_Rq_V2.phys = getValue( HMI_VehLvl_FR_Disp_Rq_V2 );
    _mOffRoad_Disp_Rq_AR.VehLvl_RL_Disp_Rq_V2.phys = getValue( HMI_VehLvl_RL_Disp_Rq_V2 );
    _mOffRoad_Disp_Rq_AR.VehLvl_RR_Disp_Rq_V2.phys = getValue( HMI_VehLvl_RR_Disp_Rq_V2 );
}

OffRoad_Disp_Rq_AR_output(void)
{
    output( _mOffRoad_Disp_Rq_AR );
}

OffRoad_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: OffRoad_Disp_Rq_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_OffRoad_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_OffRoad_Disp_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_OffRoad_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_OffRoad_Disp_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_OffRoadDisp_Bar0_Actv := %X\n", getValue( HMI_OffRoadDisp_Bar0_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_OffRoadDisp_Bar1_Actv := %X\n", getValue( HMI_OffRoadDisp_Bar1_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_OffRoadDisp_Bar2_Actv := %X\n", getValue( HMI_OffRoadDisp_Bar2_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_OffRoadDisp_Bar3_Actv := %X\n", getValue( HMI_OffRoadDisp_Bar3_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_OffRoadDisp_RedNum := %X\n", getValue( HMI_OffRoadDisp_RedNum ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_OffRoadDisp_SportBar_Actv := %X\n", getValue( HMI_OffRoadDisp_SportBar_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 OffRoadDisp_SportPlusBar_Actv := %X\n", getValue( HMI_OffRoadDisp_SportPlusBar_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_RockingFree_Disp_Rq := %X\n", getValue( HMI_SPC_RockingFree_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_RockingFree_Stat := %X\n", getValue( HMI_SPC_RockingFree_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_VehLvl_Actv := %X\n", getValue( HMI_SPC_VehLvl_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLvl_Bmpr_Disp_Rq := %X\n", getValue( HMI_VehLvl_Bmpr_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLvl_Bmpr_Disp_Rq_V2 := %X\n", getValue( HMI_VehLvl_Bmpr_Disp_Rq_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLvl_FL_Disp_Rq_V2 := %X\n", getValue( HMI_VehLvl_FL_Disp_Rq_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLvl_FR_Disp_Rq_V2 := %X\n", getValue( HMI_VehLvl_FR_Disp_Rq_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLvl_RL_Disp_Rq_V2 := %X\n", getValue( HMI_VehLvl_RL_Disp_Rq_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLvl_RR_Disp_Rq_V2 := %X\n", getValue( HMI_VehLvl_RR_Disp_Rq_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tOffRoad_Disp_Rq_AR
{
    putValue( HMI__STMSG_OffRoad_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_OffRoad_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_OffRoad_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tOffRoad_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_OffRoad_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_OffRoad_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("OffRoad_Disp_Rq_AR");
}

on EnvVar HMI_OffRoadDisp_Bar0_Actv
{
    _mOffRoad_Disp_Rq_AR.OffRoadDisp_Bar0_Actv.phys = getValue(this);
}

on EnvVar HMI_OffRoadDisp_Bar1_Actv
{
    _mOffRoad_Disp_Rq_AR.OffRoadDisp_Bar1_Actv.phys = getValue(this);
}

on EnvVar HMI_OffRoadDisp_Bar2_Actv
{
    _mOffRoad_Disp_Rq_AR.OffRoadDisp_Bar2_Actv.phys = getValue(this);
}

on EnvVar HMI_OffRoadDisp_Bar3_Actv
{
    _mOffRoad_Disp_Rq_AR.OffRoadDisp_Bar3_Actv.phys = getValue(this);
}

on EnvVar HMI_OffRoadDisp_RedNum
{
    _mOffRoad_Disp_Rq_AR.OffRoadDisp_RedNum.phys = getValue(this);
}

on EnvVar HMI_OffRoadDisp_SportBar_Actv
{
    _mOffRoad_Disp_Rq_AR.OffRoadDisp_SportBar_Actv.phys = getValue(this);
}

on EnvVar HMI_OffRoadDisp_SportPlusBar_Actv
{
    _mOffRoad_Disp_Rq_AR.OffRoadDisp_SportPlusBar_Actv.phys = getValue(this);
}

on EnvVar HMI_SPC_VehLvl_Actv
{
    _mOffRoad_Disp_Rq_AR.SPC_VehLvl_Actv.phys = getValue(this);
}

on EnvVar HMI_SPC_RockingFree_Disp_Rq
{
    _mOffRoad_Disp_Rq_AR.SPC_RockingFree_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_SPC_RockingFree_Stat
{
    _mOffRoad_Disp_Rq_AR.SPC_RockingFree_Stat.phys = getValue(this);
}

on EnvVar HMI_VehLvl_Bmpr_Disp_Rq
{
    _mOffRoad_Disp_Rq_AR.VehLvl_Bmpr_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_VehLvl_Bmpr_Disp_Rq_V2
{
    _mOffRoad_Disp_Rq_AR.VehLvl_Bmpr_Disp_Rq_V2.phys = getValue(this);
}

on EnvVar HMI_VehLvl_FL_Disp_Rq_V2
{
    _mOffRoad_Disp_Rq_AR.VehLvl_FL_Disp_Rq_V2.phys = getValue(this);
}

on EnvVar HMI_VehLvl_FR_Disp_Rq_V2
{
    _mOffRoad_Disp_Rq_AR.VehLvl_FR_Disp_Rq_V2.phys = getValue(this);
}

on EnvVar HMI_VehLvl_RL_Disp_Rq_V2
{
    _mOffRoad_Disp_Rq_AR.VehLvl_RL_Disp_Rq_V2.phys = getValue(this);
}

on EnvVar HMI_VehLvl_RR_Disp_Rq_V2
{
    _mOffRoad_Disp_Rq_AR.VehLvl_RR_Disp_Rq_V2.phys = getValue(this);
}

Park_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_Park_Disp_Rq_AR ) )
    {
    //  message   Park_Disp_Rq_AR ID: 393 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _Park_Disp_Rq_AR_Cnt--;
        if( _Park_Disp_Rq_AR_Cnt < 1 )
        {
            Park_Disp_Rq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _Park_Disp_Rq_AR_Cnt = _Park_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _Park_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _Park_Disp_Rq_AR_SpontanFlag)
        {
            Park_Disp_Rq_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _Park_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

Park_Disp_Rq_AR_init()
{   /* Botschaft Park_Disp_Rq_AR ID: 393 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 393 0;
BA_ "NmAsrMessage" BO_ 393 0;
BA_ "GenMsgMinAcceptLength" BO_ 393 8;
BA_ "GenMsgILSupport" BO_ 393 1;
BA_ "DiagState" BO_ 393 0;
BA_ "DiagRequest" BO_ 393 0;
BA_ "DiagResponse" BO_ 393 0;
BA_ "GenMsgStartValue" BO_ 393 "0";
BA_ "GenMsgDelayTime" BO_ 393 40;
BA_ "GenMsgNrOfRepetitions" BO_ 393 0;
BA_ "GenMsgCycleTime" BO_ 393 200;
BA_ "GenMsgSendType" BO_ 393 5;
    */
    _Park_Disp_Rq_AR_Timebase =           c_tDBKomTimer_20ms;
    _Park_Disp_Rq_AR_CycleCount =       200 / _Park_Disp_Rq_AR_Timebase;
    _Park_Disp_Rq_AR_StartDelay =         0 / _Park_Disp_Rq_AR_Timebase;
    _Park_Disp_Rq_AR_MinDelay =          40 / _Park_Disp_Rq_AR_Timebase;
    _Park_Disp_Rq_AR_Cnt = _Park_Disp_Rq_AR_StartDelay;
    _Park_Disp_Rq_AR_SpontanFlag = 0;
    _Park_Disp_Rq_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_Park_Disp_Rq_AR, _Park_Disp_Rq_AR_StartDelay * _Park_Disp_Rq_AR_Timebase );

    _mPark_Disp_Rq_AR.PARK_Hitch_Instrct_Disp_Rq.phys = getValue( HMI_PARK_Hitch_Instrct_Disp_Rq );
	  _mPark_Disp_Rq_AR.PARK_Hitch_KinkAngl.phys = getValue( HMI_PARK_Hitch_KinkAngl );
	  _mPark_Disp_Rq_AR.PARK_Hitch_KinkAngl_Rng.phys = getValue( HMI_PARK_Hitch_KinkAngl_Rng );
//	  _mPark_Disp_Rq_AR.PARK_Hitch_KinkAngl_Vld.phys = getValue( HMI_PARK_Hitch_KinkAngl_Vld );
//	  _mPark_Disp_Rq_AR.PARK_Hitch_Maneuver_Stat.phys = getValue( HMI_PARK_Hitch_Maneuver_Stat );
	  _mPark_Disp_Rq_AR.Park_IconDisp_Rq.phys = getValue( HMI_Park_IconDisp_Rq );
	  _mPark_Disp_Rq_AR.PARK_Pilot_Md.phys = getValue( HMI_PARK_Pilot_Md );
    _mPark_Disp_Rq_AR.Park_Sound_Rq.phys = getValue( HMI_Park_Sound_Rq );
    _mPark_Disp_Rq_AR.Park_Warn1_Disp_Rq.phys = getValue( HMI_Park_Warn1_Disp_Rq );
//   _mPark_Disp_Rq_AR.Rsrv0_Park_Disp_Rq.phys = getValue( HMI_Rsrv0_Park_Disp_Rq );
    _mPark_Disp_Rq_AR.Park_HandsOff_Icon_Disp_Rq.phys = getValue( HMI_Park_HandsOff_Icon_Disp_Rq );
    _mPark_Disp_Rq_AR.Rsrv2_Park_Disp_Rq.phys = getValue( HMI_Rsrv2_Park_Disp_Rq );
    _mPark_Disp_Rq_AR.Rsrv3_Park_Disp_Rq.phys = getValue( HMI_Rsrv3_Park_Disp_Rq );
    _mPark_Disp_Rq_AR.Rsrv4_Park_Disp_Rq.phys = getValue( HMI_Rsrv4_Park_Disp_Rq );
}

Park_Disp_Rq_AR_output()
{
    byte crc;
    byte SQC_help;
    byte dataId = 0x31;

    SQC_help = getValue( HMI_SQC_Park_Disp_Rq ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_Park_Disp_Rq_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _Park_Disp_Rq_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _Park_Disp_Rq_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_Park_Disp_Rq_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _Park_Disp_Rq_AR_SQC_WrongSeqJump != 0 ) &&
            ( _Park_Disp_Rq_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _Park_Disp_Rq_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _Park_Disp_Rq_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _Park_Disp_Rq_AR_SQC_RepeatedCnt ) &&
            ( _Park_Disp_Rq_AR_E2E_Armed == 1  )    )
        {
            _Park_Disp_Rq_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_Park_Disp_Rq, SQC_help );
    }
    _mPark_Disp_Rq_AR.SQC_Park_Disp_Rq = SQC_help;

    if( getValue( HMI_CRC_Park_Disp_Rq_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_Park_Disp_Rq_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mPark_Disp_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mPark_Disp_Rq_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mPark_Disp_Rq_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mPark_Disp_Rq_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mPark_Disp_Rq_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mPark_Disp_Rq_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mPark_Disp_Rq_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mPark_Disp_Rq_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _Park_Disp_Rq_AR_CRC_Offset[ _mPark_Disp_Rq_AR.SQC_Park_Disp_Rq ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _Park_Disp_Rq_AR_CRC_ErrorCnt   && ( _Park_Disp_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Park_Disp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _Park_Disp_Rq_AR_CRC_ErrorCnt > 0 )
                    _Park_Disp_Rq_AR_CRC_ErrorCnt--; 
            }
            _mPark_Disp_Rq_AR.CRC_Park_Disp_Rq = crc;
            putValue( HMI_CRC_Park_Disp_Rq, crc );
        }
        else
            _mPark_Disp_Rq_AR.CRC_Park_Disp_Rq = getValue( HMI_CRC_Park_Disp_Rq );
    }
    else
    {
        if( !getValue( HMI_CRC_Park_Disp_Rq_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mPark_Disp_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mPark_Disp_Rq_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mPark_Disp_Rq_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mPark_Disp_Rq_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mPark_Disp_Rq_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mPark_Disp_Rq_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mPark_Disp_Rq_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mPark_Disp_Rq_AR.byte( 7 ) ];
            crc = crctable[ crc ^ dataId ];
            crc = (crc ^ 0xFF);
            if( ( _Park_Disp_Rq_AR_CRC_ErrorCnt   && ( _Park_Disp_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Park_Disp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _Park_Disp_Rq_AR_CRC_ErrorCnt > 0 )
                    _Park_Disp_Rq_AR_CRC_ErrorCnt--; 
            }
            _mPark_Disp_Rq_AR.CRC_Park_Disp_Rq = crc;
            putValue( HMI_CRC_Park_Disp_Rq, crc );
        }
        else
            _mPark_Disp_Rq_AR.CRC_Park_Disp_Rq = getValue( HMI_CRC_Park_Disp_Rq );
    }
    if( ( _Park_Disp_Rq_AR_MSG_DropCnt > 0 ) &&
        ( _Park_Disp_Rq_AR_E2E_Armed == 1  )    )
    {
        _Park_Disp_Rq_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mPark_Disp_Rq_AR );
        
    if( _Park_Disp_Rq_AR_E2E_Armed == 1 )
    {
        if ( ( _Park_Disp_Rq_AR_MSG_DropCnt == 0      ) &&
             ( _Park_Disp_Rq_AR_CRC_ErrorCnt == 0     ) &&
             ( _Park_Disp_Rq_AR_SQC_RepeatedCnt == 0  ) &&
             ( _Park_Disp_Rq_AR_SQC_WrongSeqJump == 0 )    )
        {
            _Park_Disp_Rq_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_Park_Disp_Rq_State, 0 );
        }
    }
}

Park_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Park_Disp_Rq_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Park_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_Park_Disp_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Park_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_Park_Disp_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Park_Disp_Rq := %X\n", getValue( HMI_CRC_Park_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Park_Disp_Rq_Auto := %X\n", getValue( HMI_CRC_Park_Disp_Rq_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_IconDisp_Rq := %X\n", getValue( HMI_Park_IconDisp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Hitch_Instrct_Disp_Rq := %X\n", getValue( HMI_PARK_Hitch_Instrct_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Hitch_KinkAngl := %X\n", getValue( HMI_PARK_Hitch_KinkAngl ) );    filePutString( buffer, elcount( buffer ), hFile );
	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Hitch_KinkAngl_Rng := %X\n", getValue( HMI_PARK_Hitch_KinkAngl_Rng ) );    filePutString( buffer, elcount( buffer ), hFile );
//	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Hitch_KinkAngl_Vld := %X\n", getValue( HMI_PARK_Hitch_KinkAngl_Vld ) );    filePutString( buffer, elcount( buffer ), hFile );
//	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Hitch_Maneuver_Stat := %X\n", getValue( HMI_PARK_Hitch_Maneuver_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Pilot_Md := %X\n", getValue( HMI_PARK_Pilot_Md ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_Sound_Rq := %X\n", getValue( HMI_Park_Sound_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_Warn1_Disp_Rq := %X\n", getValue( HMI_Park_Warn1_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv0_Park_Disp_Rq := %X\n", getValue( HMI_Rsrv0_Park_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_HandsOff_Icon_Disp_Rq := %X\n", getValue( HMI_Park_HandsOff_Icon_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_Park_Disp_Rq := %X\n", getValue( HMI_Rsrv2_Park_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv3_Park_Disp_Rq := %X\n", getValue( HMI_Rsrv3_Park_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv4_Park_Disp_Rq := %X\n", getValue( HMI_Rsrv4_Park_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Park_Disp_Rq := %X\n", getValue( HMI_SQC_Park_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Park_Disp_Rq_Auto := %X\n", getValue( HMI_SQC_Park_Disp_Rq_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPark_Disp_Rq_AR
{
    putValue( HMI__STMSG_Park_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_Park_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Park_Disp_Rq_AR );
        if( tDelay > 0 )
            setTimer( _tPark_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_Park_Disp_Rq_AR, 0 );
    }
}

on EnvVar HMI__AUTOMSG_Park_Disp_Rq_AR
{
    if( getValue( this ) )
    {
        putValue( HMI_PARK_Hitch_Instrct_Disp_Rq, 0 );
        putValue( HMI_PARK_Hitch_KinkAngl, 0 );
        putValue( HMI_PARK_Hitch_KinkAngl_Rng, 0 );
        putValue( HMI_Park_IconDisp_Rq, 0 );
        putValue( HMI_PARK_Pilot_Md, 0 );
//		    putValue( HMI_PARK_Hitch_KinkAngl_Vld, 0 );
//		    putValue( HMI_PARK_Hitch_Maneuver_Stat, 0 );
        putValue( HMI_Park_Sound_Rq, 0 );
        putValue( HMI_Park_Warn1_Disp_Rq, 0 );
        putValue( HMI_Park_HandsOff_Icon_Disp_Rq, 0 );
        putValue( HMI_Rsrv2_Park_Disp_Rq, 7 );
        putValue( HMI_Rsrv3_Park_Disp_Rq, 7 );
//        putValue( HMI_Rsrv4_Park_Disp_Rq, 7 );
        _mPark_Disp_Rq_AR.PARK_Hitch_Instrct_Disp_Rq.phys =   getValue( HMI_PARK_Hitch_Instrct_Disp_Rq );
        _mPark_Disp_Rq_AR.PARK_Hitch_KinkAngl.phys =   getValue( HMI_PARK_Hitch_KinkAngl );
        _mPark_Disp_Rq_AR.PARK_Hitch_KinkAngl_Rng.phys =   getValue( HMI_PARK_Hitch_KinkAngl_Rng );
        _mPark_Disp_Rq_AR.Park_IconDisp_Rq.phys =   getValue( HMI_Park_IconDisp_Rq );
        _mPark_Disp_Rq_AR.PARK_Pilot_Md.phys =   getValue( HMI_PARK_Pilot_Md );
//		    _mPark_Disp_Rq_AR.PARK_Hitch_KinkAngl_Vld.phys = getValue( HMI_PARK_Hitch_KinkAngl_Vld );
//		    _mPark_Disp_Rq_AR.PARK_Hitch_Maneuver_Stat.phys = getValue( HMI_PARK_Hitch_Maneuver_Stat );
        _mPark_Disp_Rq_AR.Park_Sound_Rq.phys =      getValue( HMI_Park_Sound_Rq );
        _mPark_Disp_Rq_AR.Park_Warn1_Disp_Rq.phys = getValue( HMI_Park_Warn1_Disp_Rq );
        _mPark_Disp_Rq_AR.Park_HandsOff_Icon_Disp_Rq.phys = getValue( HMI_Park_HandsOff_Icon_Disp_Rq );
        _mPark_Disp_Rq_AR.Rsrv2_Park_Disp_Rq.phys = getValue( HMI_Rsrv2_Park_Disp_Rq );
        _mPark_Disp_Rq_AR.Rsrv3_Park_Disp_Rq.phys = getValue( HMI_Rsrv3_Park_Disp_Rq );
        _mPark_Disp_Rq_AR.Rsrv4_Park_Disp_Rq.phys = getValue( HMI_Rsrv4_Park_Disp_Rq );
        _Park_Disp_Rq_AR_SpontanFlag = 1;
    }
}

on EnvVar HMI__TRIGMSG_Park_Disp_Rq_AR
{
    if( getValue( this ) )
    {
        _mPark_Disp_Rq_AR.PARK_Hitch_Instrct_Disp_Rq.phys =   getValue( HMI_PARK_Hitch_Instrct_Disp_Rq );
        _mPark_Disp_Rq_AR.PARK_Hitch_KinkAngl.phys =   getValue( HMI_PARK_Hitch_KinkAngl );
        _mPark_Disp_Rq_AR.PARK_Hitch_KinkAngl_Rng.phys =   getValue( HMI_PARK_Hitch_KinkAngl_Rng );
        _mPark_Disp_Rq_AR.Park_IconDisp_Rq.phys =   getValue( HMI_Park_IconDisp_Rq );
        _mPark_Disp_Rq_AR.PARK_Pilot_Md.phys =   getValue( HMI_PARK_Pilot_Md );
//		    _mPark_Disp_Rq_AR.PARK_Hitch_KinkAngl_Vld.phys = getValue( HMI_PARK_Hitch_KinkAngl_Vld );
//		    _mPark_Disp_Rq_AR.PARK_Hitch_Maneuver_Stat.phys = getValue( HMI_PARK_Hitch_Maneuver_Stat );		
        _mPark_Disp_Rq_AR.Park_Sound_Rq.phys =      getValue( HMI_Park_Sound_Rq );
        _mPark_Disp_Rq_AR.Park_Warn1_Disp_Rq.phys = getValue( HMI_Park_Warn1_Disp_Rq );
        _mPark_Disp_Rq_AR.Park_HandsOff_Icon_Disp_Rq.phys = getValue( HMI_Park_HandsOff_Icon_Disp_Rq );
        _mPark_Disp_Rq_AR.Rsrv2_Park_Disp_Rq.phys = getValue( HMI_Rsrv2_Park_Disp_Rq );
        _mPark_Disp_Rq_AR.Rsrv3_Park_Disp_Rq.phys = getValue( HMI_Rsrv3_Park_Disp_Rq );
        _mPark_Disp_Rq_AR.Rsrv4_Park_Disp_Rq.phys = getValue( HMI_Rsrv4_Park_Disp_Rq );
        _Park_Disp_Rq_AR_SpontanFlag = 1;
    }
}

on envVar HMI__STMSG_PO_Park_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("Park_Disp_Rq_AR");
}

on envVar HMI_E2E_Park_Disp_Rq_Inject
{
    if( getValue( this ) )
    {
        _Park_Disp_Rq_AR_CRC_ErrorCnt = getValue( HMI_CRC_Park_Disp_Rq_ErrorCount );
        _Park_Disp_Rq_AR_SQC_TriggPos = getValue( HMI_SQC_Park_Disp_Rq_TriggerPosition );
        _Park_Disp_Rq_AR_SQC_WrongSeqJump = getValue( HMI_SQC_Park_Disp_Rq_WrongSeq );
        _Park_Disp_Rq_AR_SQC_RepeatedCnt = getValue( HMI_SQC_Park_Disp_Rq_Repeated );
        _Park_Disp_Rq_AR_MSG_DropCnt = getValue( HMI_SQC_Park_Disp_Rq_MSG_DropCnt );
        putValue( HMI_E2E_Park_Disp_Rq_State, 2 );
        _Park_Disp_Rq_AR_E2E_Armed = 2;  //armed
    }
}

on envVar HMI_PARK_Hitch_Instrct_Disp_Rq
{
    if( getValue( HMI__AUTOMSG_Park_Disp_Rq_AR ) == cAUTO )
    {
        _mPark_Disp_Rq_AR.PARK_Hitch_Instrct_Disp_Rq.phys = getValue(this);
        _Park_Disp_Rq_AR_SpontanFlag = 1;
    }
}

on envVar HMI_PARK_Hitch_KinkAngl
{
    if( getValue( HMI__AUTOMSG_Park_Disp_Rq_AR ) == cAUTO )
    {
        _mPark_Disp_Rq_AR.PARK_Hitch_KinkAngl.phys = getValue(this);
        _Park_Disp_Rq_AR_SpontanFlag = 1;
    }
}

on envVar HMI_PARK_Hitch_KinkAngl_Rng
{
    if( getValue( HMI__AUTOMSG_Park_Disp_Rq_AR ) == cAUTO )
    {
        _mPark_Disp_Rq_AR.PARK_Hitch_KinkAngl_Rng.phys = getValue(this);
        _Park_Disp_Rq_AR_SpontanFlag = 1;
    }
}

on envVar HMI_Park_IconDisp_Rq
{
    if( getValue( HMI__AUTOMSG_Park_Disp_Rq_AR ) == cAUTO )
    {
        _mPark_Disp_Rq_AR.Park_IconDisp_Rq.phys = getValue(this);
        _Park_Disp_Rq_AR_SpontanFlag = 1;
    }
}

on envVar HMI_PARK_Pilot_Md
{
    if( getValue( HMI__AUTOMSG_Park_Disp_Rq_AR ) == cAUTO )
    {
        _mPark_Disp_Rq_AR.PARK_Pilot_Md.phys = getValue(this);
        _Park_Disp_Rq_AR_SpontanFlag = 1;
    }
}

//on envVar HMI_PARK_Hitch_KinkAngl_Vld
//{
//    if( getValue( HMI__AUTOMSG_Park_Disp_Rq_AR ) == cAUTO )
//    {
//        _mPark_Disp_Rq_AR.PARK_Hitch_KinkAngl_Vld.phys = getValue(this);
//        _Park_Disp_Rq_AR_SpontanFlag = 1;
//    }
//}
//
//on envVar HMI_PARK_Hitch_Maneuver_Stat
//{
//    if( getValue( HMI__AUTOMSG_Park_Disp_Rq_AR ) == cAUTO )
//    {
//        _mPark_Disp_Rq_AR.PARK_Hitch_Maneuver_Stat.phys = getValue(this);
//        _Park_Disp_Rq_AR_SpontanFlag = 1;
//    }
//}

on envVar HMI_Park_Sound_Rq
{
    if( getValue( HMI__AUTOMSG_Park_Disp_Rq_AR ) == cAUTO )
    {
        _mPark_Disp_Rq_AR.Park_Sound_Rq.phys = getValue(this);
        _Park_Disp_Rq_AR_SpontanFlag = 1;
    }
}

on envVar HMI_Park_Warn1_Disp_Rq
{
    if( getValue( HMI__AUTOMSG_Park_Disp_Rq_AR ) == cAUTO )
    {
        _mPark_Disp_Rq_AR.Park_Warn1_Disp_Rq.phys = getValue(this);
        _Park_Disp_Rq_AR_SpontanFlag = 1;
    }
}

on envVar HMI_Park_HandsOff_Icon_Disp_Rq
{
    if( getValue( HMI__AUTOMSG_Park_Disp_Rq_AR ) == cAUTO )
    {
        _mPark_Disp_Rq_AR.Park_HandsOff_Icon_Disp_Rq.phys = getValue(this);
        _Park_Disp_Rq_AR_SpontanFlag = 1;
    }
}

on envVar HMI_Rsrv2_Park_Disp_Rq
{
    if( getValue( HMI__AUTOMSG_Park_Disp_Rq_AR ) == cAUTO )
    {
        _mPark_Disp_Rq_AR.Rsrv2_Park_Disp_Rq.phys = getValue(this);
        _Park_Disp_Rq_AR_SpontanFlag = 1;
    }
}

on envVar HMI_Rsrv3_Park_Disp_Rq
{
    if( getValue( HMI__AUTOMSG_Park_Disp_Rq_AR ) == cAUTO )
    {
        _mPark_Disp_Rq_AR.Rsrv3_Park_Disp_Rq.phys = getValue(this);
        _Park_Disp_Rq_AR_SpontanFlag = 1;
    }
}

on envVar HMI_Rsrv4_Park_Disp_Rq
{
    if( getValue( HMI__AUTOMSG_Park_Disp_Rq_AR ) == cAUTO )
    {
        _mPark_Disp_Rq_AR.Rsrv4_Park_Disp_Rq.phys = getValue(this);
        _Park_Disp_Rq_AR_SpontanFlag = 1;
    }
}

Park_Set_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_Park_Set_Stat_AR ) )
    {
    //  message   Park_Set_Stat_AR ID: 1092 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _Park_Set_Stat_AR_DelayCnt > 0) _Park_Set_Stat_AR_DelayCnt--; // Mindestsendeabstand
        _Park_Set_Stat_AR_Cnt--;
        if( _Park_Set_Stat_AR_Cnt < 1 )
        {
            if( _Park_Set_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                Park_Set_Stat_AR_output();
                _Park_Set_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Park_Set_Stat_AR_DelayCnt = _Park_Set_Stat_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _Park_Set_Stat_AR_SpontanFlag = 1;
            }
            _Park_Set_Stat_AR_Cnt = _Park_Set_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _Park_Set_Stat_AR_SpontanFlag)
        {
            if( _Park_Set_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                Park_Set_Stat_AR_output();
                _Park_Set_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Park_Set_Stat_AR_DelayCnt = _Park_Set_Stat_AR_MinDelay;
            }
        }
    }
}

Park_Set_Stat_AR_init()
{   /* Botschaft Park_Set_Stat_AR ID: 1092 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1092 0;
BA_ "NmAsrMessage" BO_ 1092 0;
BA_ "GenMsgMinAcceptLength" BO_ 1092 8;
BA_ "GenMsgILSupport" BO_ 1092 1;
BA_ "DiagState" BO_ 1092 0;
BA_ "DiagRequest" BO_ 1092 0;
BA_ "DiagResponse" BO_ 1092 0;
BA_ "GenMsgStartValue" BO_ 1092 "0";
BA_ "GenMsgDelayTime" BO_ 1092 100;
BA_ "GenMsgNrOfRepetitions" BO_ 1092 0;
BA_ "GenMsgCycleTime" BO_ 1092 500;
BA_ "GenMsgSendType" BO_ 1092 5;
    */
    _Park_Set_Stat_AR_Timebase =                c_tDBKomTimer_20ms;
    _Park_Set_Stat_AR_CycleCount =             500 / _Park_Set_Stat_AR_Timebase;
    _Park_Set_Stat_AR_StartDelay =               0 / _Park_Set_Stat_AR_Timebase;
    _Park_Set_Stat_AR_MinDelay =               100 / _Park_Set_Stat_AR_Timebase;
    _Park_Set_Stat_AR_Cnt = _Park_Set_Stat_AR_StartDelay;
    _Park_Set_Stat_AR_SpontanFlag = 0;
    _Park_Set_Stat_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_Park_Set_Stat_AR, _Park_Set_Stat_AR_StartDelay * _Park_Set_Stat_AR_Timebase );

    _mPark_Set_Stat_AR.Park_AccelMd_Stat.phys = getValue( HMI_Park_AccelMd_Stat );
    _mPark_Set_Stat_AR.Park_Attenuat_Rq.phys = getValue( HMI_Park_Attenuat_Rq );
    _mPark_Set_Stat_AR.Park_AttenuatMd_Stat.phys = getValue( HMI_Park_AttenuatMd_Stat );
    _mPark_Set_Stat_AR.Park_BrkMd_Stat.phys = getValue( HMI_Park_BrkMd_Stat );
    _mPark_Set_Stat_AR.Park_CTA_Md_Stat.phys = getValue( HMI_Park_CTA_Md_Stat );
//	  _mPark_Set_Stat_AR.PARK_Hitch_Maneuver_Avl.phys = getValue( HMI_PARK_Hitch_Maneuver_Avl );
    _mPark_Set_Stat_AR.Park_ObjDtctMd_Stat.phys = getValue( HMI_Park_ObjDtctMd_Stat );
    _mPark_Set_Stat_AR.Park_RevGrMd_Stat.phys = getValue( HMI_Park_RevGrMd_Stat );
    _mPark_Set_Stat_AR.Park_Sonar_Ft_Md_Stat.phys = getValue( HMI_Park_Sonar_Ft_Md_Stat );
    _mPark_Set_Stat_AR.Park_Sonar_R_Md_Stat.phys = getValue( HMI_Park_Sonar_R_Md_Stat );
    _mPark_Set_Stat_AR.Park_StMd_Stat.phys = getValue( HMI_Park_StMd_Stat );
    _mPark_Set_Stat_AR.Park_StyleMd_State.phys = getValue( HMI_Park_StyleMd_State );
    _mPark_Set_Stat_AR.Park_WarnFreq_Ft_Stat.phys = getValue( HMI_Park_WarnFreq_Ft_Stat );
    _mPark_Set_Stat_AR.Park_Sonar_Sd_Md_Stat.phys = getValue( HMI_Park_Sonar_Sd_Md_Stat );
    _mPark_Set_Stat_AR.Park_WarnVol_Ft_Stat.phys = getValue( HMI_Park_WarnVol_Ft_Stat );
    _mPark_Set_Stat_AR.Park_WarnVol_R_Stat.phys = getValue( HMI_Park_WarnVol_R_Stat );
    _mPark_Set_Stat_AR.SAplus_AR_TLA_Md_Stat.phys = getValue( HMI_SAplus_AR_TLA_Md_Stat );
}

Park_Set_Stat_AR_output(void)
{
    output( _mPark_Set_Stat_AR );
}

Park_Set_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Park_Set_Stat_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Park_Set_Stat_AR := %X\n", getValue( HMI__STMSG_Park_Set_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Park_Set_Stat_AR := %X\n", getValue( HMI__STMSGT_Park_Set_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_AccelMd_Stat := %X\n", getValue( HMI_Park_AccelMd_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_Attenuat_Rq := %X\n", getValue( HMI_Park_Attenuat_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_AttenuatMd_Stat := %X\n", getValue( HMI_Park_AttenuatMd_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_BrkMd_Stat := %X\n", getValue( HMI_Park_BrkMd_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_CTA_Md_Stat := %X\n", getValue( HMI_Park_CTA_Md_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
//	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_Hitch_Maneuver_Avlt := %X\n", getValue( HMI_PARK_Hitch_Maneuver_Avl ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_ObjDtctMd_Stat := %X\n", getValue( HMI_Park_ObjDtctMd_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_RevGrMd_Stat := %X\n", getValue( HMI_Park_RevGrMd_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_Sonar_Ft_Md_Stat := %X\n", getValue( HMI_Park_Sonar_Ft_Md_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_Sonar_R_Md_Stat := %X\n", getValue( HMI_Park_Sonar_R_Md_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_StMd_Stat := %X\n", getValue( HMI_Park_StMd_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_StyleMd_State := %X\n", getValue( HMI_Park_StyleMd_State ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_WarnFreq_Ft_Stat := %X\n", getValue( HMI_Park_WarnFreq_Ft_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_Sonar_Sd_Md_Stat := %X\n", getValue( HMI_Park_Sonar_Sd_Md_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_WarnVol_Ft_Stat := %X\n", getValue( HMI_Park_WarnVol_Ft_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_WarnVol_R_Stat := %X\n", getValue( HMI_Park_WarnVol_R_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SAplus_AR_TLA_Md_Stat := %X\n", getValue( HMI_SAplus_AR_TLA_Md_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPark_Set_Stat_AR
{
    putValue( HMI__STMSG_Park_Set_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_Park_Set_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Park_Set_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tPark_Set_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_Park_Set_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Park_Set_Stat_AR
{
    if( getValue( this ) )
        openPanel("Park_Set_Stat_AR");
}

on EnvVar HMI_Park_AccelMd_Stat
{
    _mPark_Set_Stat_AR.Park_AccelMd_Stat.phys = getValue(this);
    _Park_Set_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Park_Attenuat_Rq
{
    _mPark_Set_Stat_AR.Park_Attenuat_Rq.phys = getValue(this);
    _Park_Set_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Park_AttenuatMd_Stat
{
    _mPark_Set_Stat_AR.Park_AttenuatMd_Stat.phys = getValue(this);
    _Park_Set_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Park_BrkMd_Stat
{
    _mPark_Set_Stat_AR.Park_BrkMd_Stat.phys = getValue(this);
    _Park_Set_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Park_CTA_Md_Stat
{
    _mPark_Set_Stat_AR.Park_CTA_Md_Stat.phys = getValue(this);
    _Park_Set_Stat_AR_SpontanFlag = 1;
}

//on EnvVar HMI_PARK_Hitch_Maneuver_Avl
//{
//    _mPark_Set_Stat_AR.PARK_Hitch_Maneuver_Avl.phys = getValue(this);
//    _Park_Set_Stat_AR_SpontanFlag = 1;
//}

on EnvVar HMI_Park_ObjDtctMd_Stat
{
    _mPark_Set_Stat_AR.Park_ObjDtctMd_Stat.phys = getValue(this);
    _Park_Set_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Park_RevGrMd_Stat
{
    _mPark_Set_Stat_AR.Park_RevGrMd_Stat.phys = getValue(this);
    _Park_Set_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Park_Sonar_Ft_Md_Stat
{
    _mPark_Set_Stat_AR.Park_Sonar_Ft_Md_Stat.phys = getValue(this);
    _Park_Set_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Park_Sonar_R_Md_Stat
{
    _mPark_Set_Stat_AR.Park_Sonar_R_Md_Stat.phys = getValue(this);
    _Park_Set_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Park_StMd_Stat
{
    _mPark_Set_Stat_AR.Park_StMd_Stat.phys = getValue(this);
    _Park_Set_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Park_StyleMd_State
{
    _mPark_Set_Stat_AR.Park_StyleMd_State.phys = getValue(this);
    _Park_Set_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Park_WarnFreq_Ft_Stat
{
    _mPark_Set_Stat_AR.Park_WarnFreq_Ft_Stat.phys = getValue(this);
    _Park_Set_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Park_Sonar_Sd_Md_Stat
{
    _mPark_Set_Stat_AR.Park_Sonar_Sd_Md_Stat.phys = getValue(this);
    _Park_Set_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Park_WarnVol_Ft_Stat
{
    _mPark_Set_Stat_AR.Park_WarnVol_Ft_Stat.phys = getValue(this);
    _Park_Set_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Park_WarnVol_R_Stat
{
    _mPark_Set_Stat_AR.Park_WarnVol_R_Stat.phys = getValue(this);
    _Park_Set_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SAplus_AR_TLA_Md_Stat
{
    _mPark_Set_Stat_AR.SAplus_AR_TLA_Md_Stat.phys = getValue(this);
    _Park_Set_Stat_AR_SpontanFlag = 1;
}

Park_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_Park_Stat_AR ) )
    {
    //  message   Park_Stat_AR ID: 1018 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _Park_Stat_AR_DelayCnt > 0) _Park_Stat_AR_DelayCnt--; // Mindestsendeabstand
        _Park_Stat_AR_Cnt--;
        if( _Park_Stat_AR_Cnt < 1 )
        {
            if( _Park_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                Park_Stat_AR_output();
                 _Park_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Park_Stat_AR_DelayCnt = _Park_Stat_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _Park_Stat_AR_SpontanFlag = 1;
            }
            _Park_Stat_AR_Cnt = _Park_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _Park_Stat_AR_SpontanFlag)
        {
            if( _Park_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                Park_Stat_AR_output();
                _Park_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Park_Stat_AR_DelayCnt = _Park_Stat_AR_MinDelay;
            }
        }
    }
}

Park_Stat_AR_init()
{   /* Botschaft Park_Stat_AR  ID: 1018 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1018 0;
BA_ "NmAsrMessage" BO_ 1018 0;
BA_ "GenMsgMinAcceptLength" BO_ 1018 8;
BA_ "GenMsgILSupport" BO_ 1018 1;
BA_ "DiagState" BO_ 1018 0;
BA_ "DiagRequest" BO_ 1018 0;
BA_ "DiagResponse" BO_ 1018 0;
BA_ "GenMsgStartValue" BO_ 1018 "0";
BA_ "GenMsgDelayTime" BO_ 1018 20;
BA_ "GenMsgNrOfRepetition" BO_ 1018 0;
BA_ "GenMsgCycleTime" BO_ 1018 200;
BA_ "GenMsgSendType" BO_ 1018 5;
    */
    _Park_Stat_AR_Timebase =             c_tDBKomTimer_20ms;
    _Park_Stat_AR_CycleCount =          200 / _Park_Stat_AR_Timebase;
    _Park_Stat_AR_StartDelay =            0 / _Park_Stat_AR_Timebase;
    _Park_Stat_AR_MinDelay =             20 / _Park_Stat_AR_Timebase;
    _Park_Stat_AR_Cnt = _Park_Stat_AR_StartDelay;
    _Park_Stat_AR_SpontanFlag = 0;
    _Park_Stat_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_Park_Stat_AR, _Park_Stat_AR_StartDelay * _Park_Stat_AR_Timebase);
    
    _mPark_Stat_AR.Park_HUD_Disp_Rq.phys = getValue( HMI_Park_HUD_Disp_Rq );
    _mPark_Stat_AR.Park_Softkey_Stat.phys = getValue( HMI_Park_Softkey_Stat_ );
    _mPark_Stat_AR.ParkGuid_Stat.phys = getValue( HMI_ParkGuid_Stat_ );
    _mPark_Stat_AR.ParkSeg_F_InnerLt_Stat.phys = getValue( HMI_ParkSeg_F_InnerLt_Stat );
    _mPark_Stat_AR.ParkSeg_F_InnerRt_Stat.phys = getValue( HMI_ParkSeg_F_InnerRt_Stat );
    _mPark_Stat_AR.ParkSeg_F_Lt1_Stat.phys = getValue( HMI_ParkSeg_F_Lt1_Stat );
    _mPark_Stat_AR.ParkSeg_F_Lt2_Stat.phys = getValue( HMI_ParkSeg_F_Lt2_Stat );
    _mPark_Stat_AR.ParkSeg_F_OuterLt_Stat.phys = getValue( HMI_ParkSeg_F_OuterLt_Stat );
    _mPark_Stat_AR.ParkSeg_F_OuterRt_Stat.phys = getValue( HMI_ParkSeg_F_OuterRt_Stat );
    _mPark_Stat_AR.ParkSeg_F_Rt1_Stat.phys = getValue( HMI_ParkSeg_F_Rt1_Stat );
    _mPark_Stat_AR.ParkSeg_F_Rt2_Stat.phys = getValue( HMI_ParkSeg_F_Rt2_Stat );
    _mPark_Stat_AR.ParkStyle_V2.phys = getValue( HMI_ParkStyle_V2_ );
	  _mPark_Stat_AR.Rsrv1_ParkCfg_Stat.phys = getValue( HMI_Rsrv1_ParkCfg_Stat );
	  _mPark_Stat_AR.Rsrv2_ParkCfg_Stat.phys = getValue( HMI_Rsrv2_ParkCfg_Stat );
    _mPark_Stat_AR.ParkSeg_Avl.phys = getValue( HMI_ParkSeg_Avl );
}

Park_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_ParkCfg_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_ParkCfg_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _Park_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _Park_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_ParkCfg_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _Park_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _Park_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _Park_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _Park_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _Park_Stat_AR_SQC_RepeatedCnt ) &&
            ( _Park_Stat_AR_E2E_Armed == 1  )    )
        {
            _Park_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_ParkCfg_Stat, SQC_help );
    }
    _mPark_Stat_AR.SQC_ParkCfg_Stat = SQC_help;

    if( getValue( HMI_CRC_ParkCfg_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_ParkCfg_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable_profile02[ crc ^ _mPark_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mPark_Stat_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mPark_Stat_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mPark_Stat_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mPark_Stat_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mPark_Stat_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mPark_Stat_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mPark_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _Park_Stat_AR_CRC_Offset[ _mPark_Stat_AR.SQC_ParkCfg_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _Park_Stat_AR_CRC_ErrorCnt   && ( _Park_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_ParkCfg_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _Park_Stat_AR_CRC_ErrorCnt > 0 )
                    _Park_Stat_AR_CRC_ErrorCnt--; 
            }
            _mPark_Stat_AR.CRC_ParkCfg_Stat = crc;
            putValue( HMI_CRC_ParkCfg_Stat, crc );
        }
        else
            _mPark_Stat_AR.CRC_ParkCfg_Stat = getValue( HMI_CRC_ParkCfg_Stat );
    }
    else
    {
        if( !getValue( HMI_CRC_ParkCfg_Stat_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mPark_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mPark_Stat_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mPark_Stat_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mPark_Stat_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mPark_Stat_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mPark_Stat_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mPark_Stat_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mPark_Stat_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _Park_Stat_AR_CRC_ErrorCnt   && ( _Park_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_ParkCfg_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _Park_Stat_AR_CRC_ErrorCnt > 0 )
                    _Park_Stat_AR_CRC_ErrorCnt--; 
            }
            _mPark_Stat_AR.CRC_ParkCfg_Stat = crc;
            putValue( HMI_CRC_ParkCfg_Stat, crc );
        }
        else
            _mPark_Stat_AR.CRC_ParkCfg_Stat = getValue( HMI_CRC_ParkCfg_Stat );
    }
    if( ( _Park_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _Park_Stat_AR_E2E_Armed == 1  )    )
    {
        _Park_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mPark_Stat_AR );
        
    if( _Park_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _Park_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _Park_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _Park_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _Park_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _Park_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_ParkCfg_Stat_State, 0 );
        }
    }
}

Park_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Park_Stat_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Park_Stat_AR := %X\n", getValue( HMI__STMSG_Park_Stat_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Park_Stat_AR := %X\n", getValue( HMI__STMSGT_Park_Stat_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ParkCfg_Stat := %X\n", getValue( HMI_CRC_ParkCfg_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ParkCfg_Stat_Auto := %X\n", getValue( HMI_CRC_ParkCfg_Stat_Auto ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ParkCfg_Stat_Profile_02 := %X\n", getValue( HMI_CRC_ParkCfg_Stat_Profile_02 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_HUD_Disp_Rq := %X\n", getValue( HMI_Park_HUD_Disp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_Softkey_Stat_ := %X\n", getValue( HMI_Park_Softkey_Stat_ ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkGuid_Stat_ := %X\n", getValue( HMI_ParkGuid_Stat_ ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSeg_F_InnerLt_Stat := %X\n", getValue( HMI_ParkSeg_F_InnerLt_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSeg_F_InnerRt_Stat := %X\n", getValue( HMI_ParkSeg_F_InnerRt_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSeg_F_Lt1_Stat := %X\n", getValue( HMI_ParkSeg_F_Lt1_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSeg_F_Lt2_Stat := %X\n", getValue( HMI_ParkSeg_F_Lt2_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSeg_F_OuterLt_Stat := %X\n", getValue( HMI_ParkSeg_F_OuterLt_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSeg_F_OuterRt_Stat := %X\n", getValue( HMI_ParkSeg_F_OuterRt_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSeg_F_Rt1_Stat := %X\n", getValue( HMI_ParkSeg_F_Rt1_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSeg_F_Rt2_Stat := %X\n", getValue( HMI_ParkSeg_F_Rt2_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkStyle_V2_ := %X\n", getValue( HMI_ParkStyle_V2_ ) );    filePutString ( buffer, elcount( buffer ), hFile );
	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_ParkCfg_Stat := %X\n", getValue( HMI_Rsrv1_ParkCfg_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_ParkCfg_Stat := %X\n", getValue( HMI_Rsrv2_ParkCfg_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_ParkCfg_Stat := %X\n", getValue( HMI_SQC_ParkCfg_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_ParkCfg_Stat_Auto := %X\n", getValue( HMI_SQC_ParkCfg_Stat_Auto ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSeg_Avl := %X\n", getValue( HMI_ParkSeg_Avl ) );    filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tPark_Stat_AR
{
    putValue( HMI__STMSG_Park_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_Park_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Park_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tPark_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_Park_Stat_AR, 0 );
    }
}

on envVar HMI_E2E_ParkCfg_Stat_Inject
{
    if( getValue( this ) )
    {
        _Park_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_ParkCfg_Stat_ErrorCount );
        _Park_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_ParkCfg_Stat_TriggerPosition );
        _Park_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_ParkCfg_Stat_WrongSeq );
        _Park_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_ParkCfg_Stat_Repeated );
        _Park_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_ParkCfg_Stat_MSG_DropCnt );
        putValue( HMI_E2E_ParkCfg_Stat_State, 2 );
        _Park_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on envVar HMI__STMSG_PO_Park_Stat_AR
{
    if( getValue( this ) )
        openPanel("Park_Stat_AR");
}

on EnvVar HMI_Park_HUD_Disp_Rq
{
    _mPark_Stat_AR.Park_HUD_Disp_Rq.phys = getValue(this);
    _Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Park_Softkey_Stat_
{
    _mPark_Stat_AR.Park_Softkey_Stat.phys = getValue(this);
    _Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkGuid_Stat_
{
    _mPark_Stat_AR.ParkGuid_Stat.phys = getValue(this);
    _Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSeg_F_InnerLt_Stat
{
    _mPark_Stat_AR.ParkSeg_F_InnerLt_Stat.phys = getValue(this);
    _Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSeg_F_InnerRt_Stat
{
    _mPark_Stat_AR.ParkSeg_F_InnerRt_Stat.phys = getValue(this);
    _Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSeg_F_Lt1_Stat
{
    _mPark_Stat_AR.ParkSeg_F_Lt1_Stat.phys = getValue(this);
    _Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSeg_F_Lt2_Stat
{
    _mPark_Stat_AR.ParkSeg_F_Lt2_Stat.phys = getValue(this);
    _Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSeg_F_OuterLt_Stat
{
    _mPark_Stat_AR.ParkSeg_F_OuterLt_Stat.phys = getValue(this);
    _Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSeg_F_OuterRt_Stat
{
    _mPark_Stat_AR.ParkSeg_F_OuterRt_Stat.phys = getValue(this);
    _Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSeg_F_Rt1_Stat
{
    _mPark_Stat_AR.ParkSeg_F_Rt1_Stat.phys = getValue(this);
    _Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSeg_F_Rt2_Stat
{
    _mPark_Stat_AR.ParkSeg_F_Rt2_Stat.phys = getValue(this);
    _Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkStyle_V2_
{
    _mPark_Stat_AR.ParkStyle_V2.phys = getValue(this);
    _Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_ParkCfg_Stat
{
    _mPark_Stat_AR.Rsrv1_ParkCfg_Stat.phys = getValue(this);
    _Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv2_ParkCfg_Stat
{
    _mPark_Stat_AR.Rsrv2_ParkCfg_Stat.phys = getValue(this);
    _Park_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSeg_Avl
{
    _mPark_Stat_AR.ParkSeg_Avl.phys = getValue(this);
    _Park_Stat_AR_SpontanFlag = 1;
}

ParkSpace_Posn_AR_check_output()
{
    if( !getValue( HMI__STMSG_ParkSpace_Posn_AR ) )
    {
    //  message   ParkSpace_Posn_AR ID: 1060 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _ParkSpace_Posn_AR_DelayCnt > 0) _ParkSpace_Posn_AR_DelayCnt--; // Mindestsendeabstand
        _ParkSpace_Posn_AR_Cnt--;
        if( _ParkSpace_Posn_AR_Cnt < 1 )
        {
            if( _ParkSpace_Posn_AR_DelayCnt < 1 )
            {
                ParkSpace_Posn_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                _ParkSpace_Posn_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _ParkSpace_Posn_AR_DelayCnt = _ParkSpace_Posn_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _ParkSpace_Posn_AR_SpontanFlag = 1;
            }
            _ParkSpace_Posn_AR_Cnt = _ParkSpace_Posn_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _ParkSpace_Posn_AR_SpontanFlag)
        {
            if( _ParkSpace_Posn_AR_DelayCnt < 1 )
            {
                ParkSpace_Posn_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _ParkSpace_Posn_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _ParkSpace_Posn_AR_DelayCnt = _ParkSpace_Posn_AR_MinDelay;
            }
        }
    }
}

ParkSpace_Posn_AR_init()
{   /* Botschaft ParkSpace_Posn_AR ID: 1060 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1060 0;
BA_ "NmAsrMessage" BO_ 1060 0;
BA_ "GenMsgMinAcceptLength" BO_ 1060 8;
BA_ "GenMsgILSupport" BO_ 1060 1;
BA_ "DiagState" BO_ 1060 0;
BA_ "DiagRequest" BO_ 1060 0;
BA_ "DiagResponse" BO_ 1060 0;
BA_ "GenMsgStartValue" BO_ 1060 "0";
BA_ "GenMsgDelayTime" BO_ 1060 100;
BA_ "GenMsgNrOfRepetition" BO_ 1060 0;
BA_ "GenMsgCycleTime" BO_ 1060 1000;
BA_ "GenMsgSendType" BO_ 1060 5;
    */
    _ParkSpace_Posn_AR_Timebase =           c_tDBKomTimer_20ms;
    _ParkSpace_Posn_AR_CycleCount =      1000 / _ParkSpace_Posn_AR_Timebase;
    _ParkSpace_Posn_AR_StartDelay =         0 / _ParkSpace_Posn_AR_Timebase;
    _ParkSpace_Posn_AR_MinDelay =         100 / _ParkSpace_Posn_AR_Timebase;
    _ParkSpace_Posn_AR_Cnt = _ParkSpace_Posn_AR_StartDelay;
    _ParkSpace_Posn_AR_SpontanFlag = 0;
    _ParkSpace_Posn_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_ParkSpace_Posn_AR, _ParkSpace_Posn_AR_StartDelay * _ParkSpace_Posn_AR_Timebase );

    _mParkSpace_Posn_AR.ParkSpace_Lt_1_TouchVar.phys = getValue( HMI_ParkSpace_Lt_1_TouchVar );
    _mParkSpace_Posn_AR.ParkSpace_Lt_1_VertTouchPosn.phys = getValue( HMI_ParkSpace_Lt_1_VertTouchPosn );
    _mParkSpace_Posn_AR.ParkSpace_Lt_2_TouchVar.phys = getValue( HMI_ParkSpace_Lt_2_TouchVar );
    _mParkSpace_Posn_AR.ParkSpace_Lt_2_VertTouchPosn.phys = getValue( HMI_ParkSpace_Lt_2_VertTouchPosn );
    _mParkSpace_Posn_AR.ParkSpace_Lt_3_TouchVar.phys = getValue( HMI_ParkSpace_Lt_3_TouchVar );
    _mParkSpace_Posn_AR.ParkSpace_Lt_3_VertTouchPosn.phys = getValue( HMI_ParkSpace_Lt_3_VertTouchPosn );
    _mParkSpace_Posn_AR.ParkSpace_Mid_1_TouchVar.phys = getValue( HMI_ParkSpace_Mid_1_TouchVar );
    _mParkSpace_Posn_AR.ParkSpace_Mid_1_VertTouchPosn.phys = getValue( HMI_ParkSpace_Mid_1_VertTouchPosn );
    _mParkSpace_Posn_AR.ParkSpace_Rt_1_TouchVar.phys = getValue( HMI_ParkSpace_Rt_1_TouchVar );
    _mParkSpace_Posn_AR.ParkSpace_Rt_1_VertTouchPosn.phys = getValue( HMI_ParkSpace_Rt_1_VertTouchPosn );
    _mParkSpace_Posn_AR.ParkSpace_Rt_2_TouchVar.phys = getValue( HMI_ParkSpace_Rt_2_TouchVar );
    _mParkSpace_Posn_AR.ParkSpace_Rt_2_VertTouchPosn.phys = getValue( HMI_ParkSpace_Rt_2_VertTouchPosn );
    _mParkSpace_Posn_AR.ParkSpace_Rt_3_TouchVar.phys = getValue( HMI_ParkSpace_Rt_3_TouchVar );
    _mParkSpace_Posn_AR.ParkSpace_Rt_3_VertTouchPosn.phys = getValue( HMI_ParkSpace_Rt_3_VertTouchPosn );
}

ParkSpace_Posn_AR_output()
{
    output( _mParkSpace_Posn_AR );
}

ParkSpace_Posn_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: ParkSpace_Posn_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_ParkSpace_Posn_AR := %X\n", getValue( HMI__STMSG_ParkSpace_Posn_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_ParkSpace_Posn_AR := %X\n", getValue( HMI__STMSGT_ParkSpace_Posn_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpace_Lt_1_TouchVar := %X\n", getValue( HMI_ParkSpace_Lt_1_TouchVar ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpace_Lt_1_VertTouchPosn := %X\n", getValue( HMI_ParkSpace_Lt_1_VertTouchPosn ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpace_Lt_2_TouchVar := %X\n", getValue( HMI_ParkSpace_Lt_2_TouchVar ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpace_Lt_2_VertTouchPosn := %X\n", getValue( HMI_ParkSpace_Lt_2_VertTouchPosn ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpace_Lt_3_TouchVar := %X\n", getValue( HMI_ParkSpace_Lt_3_TouchVar ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpace_Lt_3_VertTouchPosn := %X\n", getValue( HMI_ParkSpace_Lt_3_VertTouchPosn ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpace_Mid_1_TouchVar := %X\n", getValue( HMI_ParkSpace_Mid_1_TouchVar ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpace_Mid_1_VertTouchPosn := %X\n", getValue( HMI_ParkSpace_Mid_1_VertTouchPosn ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpace_Rt_1_TouchVar := %X\n", getValue( HMI_ParkSpace_Rt_1_TouchVar ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpace_Rt_1_VertTouchPosn := %X\n", getValue( HMI_ParkSpace_Rt_1_VertTouchPosn ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpace_Rt_2_TouchVar := %X\n", getValue( HMI_ParkSpace_Rt_2_TouchVar ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpace_Rt_2_VertTouchPosn := %X\n", getValue( HMI_ParkSpace_Rt_2_VertTouchPosn ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpace_Rt_3_TouchVar := %X\n", getValue( HMI_ParkSpace_Rt_3_TouchVar ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpace_Rt_3_VertTouchPosn := %X\n", getValue( HMI_ParkSpace_Rt_3_VertTouchPosn ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tParkSpace_Posn_AR
{
    putValue( HMI__STMSG_ParkSpace_Posn_AR, 0 );
}

on EnvVar HMI__STMSG_ParkSpace_Posn_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_ParkSpace_Posn_AR );
        if( tDelay > 0)    
            setTimer( _tParkSpace_Posn_AR, tDelay );
        else
            putValue( HMI__STMSG_ParkSpace_Posn_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_ParkSpace_Posn_AR
{
    if( getValue( this ) )
        openPanel("ParkSpace_Posn_AR");
}

on EnvVar HMI_ParkSpace_Lt_1_TouchVar
{
    _mParkSpace_Posn_AR.ParkSpace_Lt_1_TouchVar.phys = getValue(this);
    _ParkSpace_Posn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpace_Lt_1_VertTouchPosn
{
    _mParkSpace_Posn_AR.ParkSpace_Lt_1_VertTouchPosn.phys = getValue(this);
    _ParkSpace_Posn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpace_Lt_2_TouchVar
{
    _mParkSpace_Posn_AR.ParkSpace_Lt_2_TouchVar.phys = getValue(this);
    _ParkSpace_Posn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpace_Lt_2_VertTouchPosn
{
    _mParkSpace_Posn_AR.ParkSpace_Lt_2_VertTouchPosn.phys = getValue(this);
    _ParkSpace_Posn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpace_Lt_3_TouchVar
{
    _mParkSpace_Posn_AR.ParkSpace_Lt_3_TouchVar.phys = getValue(this);
    _ParkSpace_Posn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpace_Lt_3_VertTouchPosn
{
    _mParkSpace_Posn_AR.ParkSpace_Lt_3_VertTouchPosn.phys = getValue(this);
    _ParkSpace_Posn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpace_Mid_1_TouchVar
{
    _mParkSpace_Posn_AR.ParkSpace_Mid_1_TouchVar.phys = getValue(this);
    _ParkSpace_Posn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpace_Mid_1_VertTouchPosn
{
    _mParkSpace_Posn_AR.ParkSpace_Mid_1_VertTouchPosn.phys = getValue(this);
    _ParkSpace_Posn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpace_Rt_1_TouchVar
{
    _mParkSpace_Posn_AR.ParkSpace_Rt_1_TouchVar.phys = getValue(this);
    _ParkSpace_Posn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpace_Rt_1_VertTouchPosn
{
    _mParkSpace_Posn_AR.ParkSpace_Rt_1_VertTouchPosn.phys = getValue(this);
    _ParkSpace_Posn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpace_Rt_2_TouchVar
{
    _mParkSpace_Posn_AR.ParkSpace_Rt_2_TouchVar.phys = getValue(this);
    _ParkSpace_Posn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpace_Rt_2_VertTouchPosn
{
    _mParkSpace_Posn_AR.ParkSpace_Rt_2_VertTouchPosn.phys = getValue(this);
    _ParkSpace_Posn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpace_Rt_3_TouchVar
{
    _mParkSpace_Posn_AR.ParkSpace_Rt_3_TouchVar.phys = getValue(this);
    _ParkSpace_Posn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpace_Rt_3_VertTouchPosn
{
    _mParkSpace_Posn_AR.ParkSpace_Rt_3_VertTouchPosn.phys = getValue(this);
    _ParkSpace_Posn_AR_SpontanFlag = 1;
}

ParkSpaceMeas_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_ParkSpaceMeas_Stat_AR ) )
    {
    //  message   ParkSpaceMeas_Stat_AR ID: 675 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _ParkSpaceMeas_Stat_AR_DelayCnt > 0) _ParkSpaceMeas_Stat_AR_DelayCnt--; // Mindestsendeabstand
        _ParkSpaceMeas_Stat_AR_Cnt--;
        if( _ParkSpaceMeas_Stat_AR_Cnt < 1 )
        {
            if( _ParkSpaceMeas_Stat_AR_DelayCnt < 1 )
            {
                ParkSpaceMeas_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                _ParkSpaceMeas_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _ParkSpaceMeas_Stat_AR_DelayCnt = _ParkSpaceMeas_Stat_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _ParkSpaceMeas_Stat_AR_SpontanFlag = 1;
            }
            _ParkSpaceMeas_Stat_AR_Cnt = _ParkSpaceMeas_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _ParkSpaceMeas_Stat_AR_SpontanFlag)
        {
            if( _ParkSpaceMeas_Stat_AR_DelayCnt < 1 )
            {
                ParkSpaceMeas_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _ParkSpaceMeas_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _ParkSpaceMeas_Stat_AR_DelayCnt = _ParkSpaceMeas_Stat_AR_MinDelay;
            }
        }
    }
}

ParkSpaceMeas_Stat_AR_init()
{   /* Botschaft ParkSpaceMeas_Stat_AR ID: 675 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 675 0;
BA_ "NmAsrMessage" BO_ 675 0;
BA_ "GenMsgMinAcceptLength" BO_ 675 8;
BA_ "GenMsgILSupport" BO_ 675 1;
BA_ "DiagState" BO_ 675 0;
BA_ "DiagRequest" BO_ 675 0;
BA_ "DiagResponse" BO_ 675 0;
BA_ "GenMsgStartValue" BO_ 675 "0";
BA_ "GenMsgDelayTime" BO_ 675 100;
BA_ "GenMsgNrOfRepetitions" BO_ 675 0;
BA_ "GenMsgCycleTime" BO_ 675 1000;
BA_ "GenMsgSendType" BO_ 675 5;
    */
    _ParkSpaceMeas_Stat_AR_Timebase =           c_tDBKomTimer_20ms;
    _ParkSpaceMeas_Stat_AR_CycleCount =      1000 / _ParkSpaceMeas_Stat_AR_Timebase;
    _ParkSpaceMeas_Stat_AR_StartDelay =         0 / _ParkSpaceMeas_Stat_AR_Timebase;
    _ParkSpaceMeas_Stat_AR_MinDelay =         100 / _ParkSpaceMeas_Stat_AR_Timebase;
    _ParkSpaceMeas_Stat_AR_Cnt = _ParkSpaceMeas_Stat_AR_StartDelay;
    _ParkSpaceMeas_Stat_AR_SpontanFlag = 0;
    _ParkSpaceMeas_Stat_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_ParkSpaceMeas_Stat_AR, _ParkSpaceMeas_Stat_AR_StartDelay * _ParkSpaceMeas_Stat_AR_Timebase );

    _mParkSpaceMeas_Stat_AR.ParkSeg_F_InnerLt_ObstclDist.phys = getValue( HMI_ParkSeg_F_InnerLt_ObstclDist );
    _mParkSpaceMeas_Stat_AR.ParkSeg_F_InnerRt_ObstclDist.phys = getValue( HMI_ParkSeg_F_InnerRt_ObstclDist );
    _mParkSpaceMeas_Stat_AR.ParkSeg_F_OuterLt_ObstclDist.phys = getValue( HMI_ParkSeg_F_OuterLt_ObstclDist );
    _mParkSpaceMeas_Stat_AR.ParkSeg_F_OuterRt_ObstclDist.phys = getValue( HMI_ParkSeg_F_OuterRt_ObstclDist );
    _mParkSpaceMeas_Stat_AR.ParkSeg_R_InnerLt_ObstclDist.phys = getValue( HMI_ParkSeg_R_InnerLt_ObstclDist );
    _mParkSpaceMeas_Stat_AR.ParkSeg_R_InnerRt_ObstclDist.phys = getValue( HMI_ParkSeg_R_InnerRt_ObstclDist );
    _mParkSpaceMeas_Stat_AR.ParkSeg_R_OuterLt_ObstclDist.phys = getValue( HMI_ParkSeg_R_OuterLt_ObstclDist );
    _mParkSpaceMeas_Stat_AR.ParkSeg_R_OuterRt_ObstclDist.phys = getValue( HMI_ParkSeg_R_OuterRt_ObstclDist );
    _mParkSpaceMeas_Stat_AR.ParkSpace_FL_ObstclDist.phys = getValue( HMI_ParkSpace_FL_ObstclDist );
    _mParkSpaceMeas_Stat_AR.ParkSpace_FR_ObstclDist.phys = getValue( HMI_ParkSpace_FR_ObstclDist );
    _mParkSpaceMeas_Stat_AR.ParkSpace_RL_ObstclDist.phys = getValue( HMI_ParkSpace_RL_ObstclDist );
    _mParkSpaceMeas_Stat_AR.ParkSpace_RR_ObstclDist.phys = getValue( HMI_ParkSpace_RR_ObstclDist );
    _mParkSpaceMeas_Stat_AR.ParkSpaceMeas_F_Actv.phys = getValue( HMI_ParkSpaceMeas_F_Actv );
    _mParkSpaceMeas_Stat_AR.ParkSpaceMeas_R_Actv.phys = getValue( HMI_ParkSpaceMeas_R_Actv );
    _mParkSpaceMeas_Stat_AR.ParkSys_Flt.phys = getValue( HMI_ParkSys_Flt );
}

ParkSpaceMeas_Stat_AR_output()
{
    output( _mParkSpaceMeas_Stat_AR );
}

ParkSpaceMeas_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: ParkSpaceMeas_Stat_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_ParkSpaceMeas_Stat_AR := %X\n", getValue( HMI__STMSG_ParkSpaceMeas_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_ParkSpaceMeas_Stat_AR := %X\n", getValue( HMI__STMSGT_ParkSpaceMeas_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSeg_F_InnerLt_ObstclDist := %X\n", getValue( HMI_ParkSeg_F_InnerLt_ObstclDist ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSeg_F_InnerRt_ObstclDist := %X\n", getValue( HMI_ParkSeg_F_InnerRt_ObstclDist ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSeg_F_OuterLt_ObstclDist := %X\n", getValue( HMI_ParkSeg_F_OuterLt_ObstclDist ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSeg_F_OuterRt_ObstclDist := %X\n", getValue( HMI_ParkSeg_F_OuterRt_ObstclDist ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSeg_R_InnerLt_ObstclDist := %X\n", getValue( HMI_ParkSeg_R_InnerLt_ObstclDist ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSeg_R_InnerRt_ObstclDist := %X\n", getValue( HMI_ParkSeg_R_InnerRt_ObstclDist ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSeg_R_OuterLt_ObstclDist := %X\n", getValue( HMI_ParkSeg_R_OuterLt_ObstclDist ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSeg_R_OuterRt_ObstclDist := %X\n", getValue( HMI_ParkSeg_R_OuterRt_ObstclDist ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpace_FL_ObstclDist := %X\n", getValue( HMI_ParkSpace_FL_ObstclDist ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpace_FR_ObstclDist := %X\n", getValue( HMI_ParkSpace_FR_ObstclDist ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpace_RL_ObstclDist := %X\n", getValue( HMI_ParkSpace_RL_ObstclDist ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpace_RR_ObstclDist := %X\n", getValue( HMI_ParkSpace_RR_ObstclDist ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpaceMeas_F_Actv := %X\n", getValue( HMI_ParkSpaceMeas_F_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSpaceMeas_R_Actv := %X\n", getValue( HMI_ParkSpaceMeas_R_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSys_Flt := %X\n", getValue( HMI_ParkSys_Flt ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tParkSpaceMeas_Stat_AR
{
    putValue( HMI__STMSG_ParkSpaceMeas_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_ParkSpaceMeas_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_ParkSpaceMeas_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tParkSpaceMeas_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_ParkSpaceMeas_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_ParkSpaceMeas_Stat_AR
{
    if( getValue( this ) )
        openPanel("ParkSpaceMeas_Stat_AR");
}

on EnvVar HMI_ParkSeg_F_InnerLt_ObstclDist
{
    _mParkSpaceMeas_Stat_AR.ParkSeg_F_InnerLt_ObstclDist.phys = getValue(this);
    _ParkSpaceMeas_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSeg_F_InnerRt_ObstclDist
{
    _mParkSpaceMeas_Stat_AR.ParkSeg_F_InnerRt_ObstclDist.phys = getValue(this);
    _ParkSpaceMeas_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSeg_F_OuterLt_ObstclDist
{
    _mParkSpaceMeas_Stat_AR.ParkSeg_F_OuterLt_ObstclDist.phys = getValue(this);
    _ParkSpaceMeas_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSeg_F_OuterRt_ObstclDist
{
    _mParkSpaceMeas_Stat_AR.ParkSeg_F_OuterRt_ObstclDist.phys = getValue(this);
    _ParkSpaceMeas_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSeg_R_InnerLt_ObstclDist
{
    _mParkSpaceMeas_Stat_AR.ParkSeg_R_InnerLt_ObstclDist.phys = getValue(this);
    _ParkSpaceMeas_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSeg_R_InnerRt_ObstclDist
{
    _mParkSpaceMeas_Stat_AR.ParkSeg_R_InnerRt_ObstclDist.phys = getValue(this);
    _ParkSpaceMeas_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSeg_R_OuterLt_ObstclDist
{
    _mParkSpaceMeas_Stat_AR.ParkSeg_R_OuterLt_ObstclDist.phys = getValue(this);
    _ParkSpaceMeas_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSeg_R_OuterRt_ObstclDist
{
    _mParkSpaceMeas_Stat_AR.ParkSeg_R_OuterRt_ObstclDist.phys = getValue(this);
    _ParkSpaceMeas_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpace_FL_ObstclDist
{
    _mParkSpaceMeas_Stat_AR.ParkSpace_FL_ObstclDist.phys = getValue(this);
    _ParkSpaceMeas_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpace_FR_ObstclDist
{
    _mParkSpaceMeas_Stat_AR.ParkSpace_FR_ObstclDist.phys = getValue(this);
    _ParkSpaceMeas_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpace_RL_ObstclDist
{
    _mParkSpaceMeas_Stat_AR.ParkSpace_RL_ObstclDist.phys = getValue(this);
    _ParkSpaceMeas_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpace_RR_ObstclDist
{
    _mParkSpaceMeas_Stat_AR.ParkSpace_RR_ObstclDist.phys = getValue(this);
    _ParkSpaceMeas_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpaceMeas_F_Actv
{
    _mParkSpaceMeas_Stat_AR.ParkSpaceMeas_F_Actv.phys = getValue(this);
    _ParkSpaceMeas_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSpaceMeas_R_Actv
{
    _mParkSpaceMeas_Stat_AR.ParkSpaceMeas_R_Actv.phys = getValue(this);
    _ParkSpaceMeas_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSys_Flt
{
    _mParkSpaceMeas_Stat_AR.ParkSys_Flt.phys = getValue(this);
    _ParkSpaceMeas_Stat_AR_SpontanFlag = 1;
}

ParkWarn_AR_check_output()
{
    if( !getValue( HMI__STMSG_ParkWarn_AR ) )
    {
    //  message   ParkWarn_AR ID: 1075 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _ParkWarn_AR_Cnt--;
        if( _ParkWarn_AR_Cnt < 1 )
        {
            ParkWarn_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _ParkWarn_AR_Cnt = _ParkWarn_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _ParkWarn_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _ParkWarn_AR_SpontanFlag)
        {
            ParkWarn_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _ParkWarn_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

ParkWarn_AR_init()
{   /* Botschaft ParkWarn_AR ID: 1075 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1075 0;
BA_ "NmAsrMessage" BO_ 1075 0;
BA_ "GenMsgMinAcceptLength" BO_ 1075 8;
BA_ "GenMsgILSupport" BO_ 1075 1;
BA_ "DiagState" BO_ 1075 0;
BA_ "DiagRequest" BO_ 1075 0;
BA_ "DiagResponse" BO_ 1075 0;
BA_ "GenMsgStartValue" BO_ 1075 "0";
BA_ "GenMsgDelayTime" BO_ 1075 20;
BA_ "GenMsgNrOfRepetitions" BO_ 1075 0;
BA_ "GenMsgCycleTime" BO_ 1075 200;
BA_ "GenMsgSendType" BO_ 1075 5;
    */
    _ParkWarn_AR_Timebase =           c_tDBKomTimer_20ms;
    _ParkWarn_AR_CycleCount =        200 / _ParkWarn_AR_Timebase;
    _ParkWarn_AR_StartDelay =          0 / _ParkWarn_AR_Timebase;
    _ParkWarn_AR_Cnt = _ParkWarn_AR_StartDelay;
    _ParkWarn_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_ParkWarn_AR, _ParkWarn_AR_StartDelay * _ParkWarn_AR_Timebase );

    _mParkWarn_AR.AcustWarn_Actv_PARK.phys = getValue( HMI_AcustWarn_Actv_PARK );
    _mParkWarn_AR.Park_Off.phys = getValue( HMI_Park_Off );
    _mParkWarn_AR.PARK_TP_Flt.phys = getValue( HMI_PARK_TP_Flt );
    _mParkWarn_AR.ParkSideProt_Lt_Warn_Rq.phys = getValue( HMI_ParkSideProt_Lt_Warn_Rq );
    _mParkWarn_AR.ParkSideProt_Rt_Warn_Rq.phys = getValue( HMI_ParkSideProt_Rt_Warn_Rq );
    _mParkWarn_AR.ParkSwLED_Rq.phys = getValue( HMI_ParkSwLED_Rq );
    _mParkWarn_AR.ParkWarnElem_FL_Stat.phys = getValue( HMI_ParkWarnElem_FL_Stat );
    _mParkWarn_AR.ParkWarnElem_FR_Stat.phys = getValue( HMI_ParkWarnElem_FR_Stat );
    _mParkWarn_AR.ParkWarnElem_RL_Stat.phys = getValue( HMI_ParkWarnElem_RL_Stat );
    _mParkWarn_AR.ParkWarnElem_RR_Stat.phys = getValue( HMI_ParkWarnElem_RR_Stat );
    _mParkWarn_AR.ParkWarnFreq_Ft.phys = getValue( HMI_ParkWarnFreq_Ft );
    _mParkWarn_AR.ParkWarnFreq_R.phys = getValue( HMI_ParkWarnFreq_R );
    _mParkWarn_AR.ParkWarnSnd_FL.phys = getValue( HMI_ParkWarnSnd_FL );
    _mParkWarn_AR.ParkWarnSnd_FR.phys = getValue( HMI_ParkWarnSnd_FR );
    _mParkWarn_AR.ParkWarnSnd_Ft_Rq.phys = getValue( HMI_ParkWarnSnd_Ft_Rq );
    _mParkWarn_AR.ParkWarnSnd_R_Rq.phys = getValue( HMI_ParkWarnSnd_R_Rq );
    _mParkWarn_AR.ParkWarnSnd_RL.phys = getValue( HMI_ParkWarnSnd_RL );
    _mParkWarn_AR.ParkWarnSnd_RR.phys = getValue( HMI_ParkWarnSnd_RR );
    _mParkWarn_AR.ParkWarnVol_Ft.phys = getValue( HMI_ParkWarnVol_Ft );
    _mParkWarn_AR.ParkWarnVol_R.phys = getValue( HMI_ParkWarnVol_R );
}

ParkWarn_AR_output(void)
{
    output( _mParkWarn_AR );
}

ParkWarn_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: ParkWarn_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_ParkWarn := %X\n", getValue( HMI__STMSG_ParkWarn_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_ParkWarn := %X\n", getValue( HMI__STMSGT_ParkWarn_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AcustWarn_Actv_PARK := %X\n", getValue( HMI_AcustWarn_Actv_PARK ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Park_Off := %X\n", getValue( HMI_Park_Off ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PARK_TP_Flt := %X\n", getValue( HMI_PARK_TP_Flt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSideProt_Lt_Warn_Rq := %X\n", getValue( HMI_ParkSideProt_Lt_Warn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSideProt_Rt_Warn_Rq := %X\n", getValue( HMI_ParkSideProt_Rt_Warn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkSwLED_Rq := %X\n", getValue( HMI_ParkSwLED_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkWarnElem_FL_Stat := %X\n", getValue( HMI_ParkWarnElem_FL_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkWarnElem_FR_Stat := %X\n", getValue( HMI_ParkWarnElem_FR_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkWarnElem_RL_Stat := %X\n", getValue( HMI_ParkWarnElem_RL_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkWarnElem_RR_Stat := %X\n", getValue( HMI_ParkWarnElem_RR_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkWarnFreq_Ft := %X\n", getValue( HMI_ParkWarnFreq_Ft ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkWarnFreq_R := %X\n", getValue( HMI_ParkWarnFreq_R ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkWarnSnd_FL := %X\n", getValue( HMI_ParkWarnSnd_FL ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkWarnSnd_FR := %X\n", getValue( HMI_ParkWarnSnd_FR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkWarnSnd_Ft_Rq := %X\n", getValue( HMI_ParkWarnSnd_Ft_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkWarnSnd_R_Rq := %X\n", getValue( HMI_ParkWarnSnd_R_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkWarnSnd_RL := %X\n", getValue( HMI_ParkWarnSnd_RL ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkWarnSnd_RR := %X\n", getValue( HMI_ParkWarnSnd_RR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkWarnVol_Ft := %X\n", getValue( HMI_ParkWarnVol_Ft ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParkWarnVol_R := %X\n", getValue( HMI_ParkWarnVol_R ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tParkWarn_AR
{
    putValue( HMI__STMSG_ParkWarn_AR, 0 );
}

on EnvVar HMI__STMSG_ParkWarn_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_ParkWarn_AR );
        if( tDelay > 0)    
            setTimer( _tParkWarn_AR, tDelay );
        else
            putValue( HMI__STMSG_ParkWarn_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_ParkWarn_AR
{
    if( getValue( this ) )
        openPanel("ParkWarn_AR");
}

on EnvVar HMI_AcustWarn_Actv_PARK
{
    _mParkWarn_AR.AcustWarn_Actv_PARK.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on EnvVar HMI_Park_Off
{
    _mParkWarn_AR.Park_Off.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on EnvVar HMI_PARK_TP_Flt
{
    _mParkWarn_AR.PARK_TP_Flt.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSideProt_Lt_Warn_Rq
{
    _mParkWarn_AR.ParkSideProt_Lt_Warn_Rq.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSideProt_Rt_Warn_Rq
{
    _mParkWarn_AR.ParkSideProt_Rt_Warn_Rq.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkSwLED_Rq
{
    _mParkWarn_AR.ParkSwLED_Rq.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkWarnElem_FL_Stat
{
    _mParkWarn_AR.ParkWarnElem_FL_Stat.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkWarnElem_FR_Stat
{
    _mParkWarn_AR.ParkWarnElem_FR_Stat.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkWarnElem_RL_Stat
{
    _mParkWarn_AR.ParkWarnElem_RL_Stat.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkWarnElem_RR_Stat
{
    _mParkWarn_AR.ParkWarnElem_RR_Stat.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkWarnFreq_Ft
{
    _mParkWarn_AR.ParkWarnFreq_Ft.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on EnvVar HMI_ParkWarnFreq_R
{
    _mParkWarn_AR.ParkWarnFreq_R.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on envVar HMI_ParkWarnSnd_FL
{
    _mParkWarn_AR.ParkWarnSnd_FL.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on envVar HMI_ParkWarnSnd_FR
{
    _mParkWarn_AR.ParkWarnSnd_FR.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on envVar HMI_ParkWarnSnd_Ft_Rq
{
    _mParkWarn_AR.ParkWarnSnd_Ft_Rq.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on envVar HMI_ParkWarnSnd_R_Rq
{
    _mParkWarn_AR.ParkWarnSnd_R_Rq.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on envVar HMI_ParkWarnSnd_RL
{
    _mParkWarn_AR.ParkWarnSnd_RL.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on envVar HMI_ParkWarnSnd_RR
{
    _mParkWarn_AR.ParkWarnSnd_RR.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on envVar HMI_ParkWarnVol_Ft
{
    _mParkWarn_AR.ParkWarnVol_Ft.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

on envVar HMI_ParkWarnVol_R
{
    _mParkWarn_AR.ParkWarnVol_R.phys = getValue(this);
    _ParkWarn_AR_SpontanFlag = 1;
}

PERIPHERY_HMI_R1_AR_check_output()
{
    if( !getValue( HMI__STMSG_PERIPHERY_HMI_R1_AR ) )
    {
    //  message   PERIPHERY_HMI_R1_AR ID: 611 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _PERIPHERY_HMI_R1_AR_Cnt--;
        if( _PERIPHERY_HMI_R1_AR_Cnt < 1 )
        {
            PERIPHERY_HMI_R1_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _PERIPHERY_HMI_R1_AR_Cnt = _PERIPHERY_HMI_R1_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _PERIPHERY_HMI_R1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _PERIPHERY_HMI_R1_AR_SpontanFlag )
        {
            PERIPHERY_HMI_R1_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _PERIPHERY_HMI_R1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

PERIPHERY_HMI_R1_AR_init()
{   /* Botschaft PERIPHERY_HMI_R1_AR ID: 611 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 611 0;
BA_ "NmAsrMessage" BO_ 611 0;
BA_ "GenMsgMinAcceptLength" BO_ 611 8;
BA_ "GenMsgILSupport" BO_ 611 1;
BA_ "DiagState" BO_ 611 0;
BA_ "DiagRequest" BO_ 611 0;
BA_ "DiagResponse" BO_ 611 0;
BA_ "GenMsgStartValue" BO_ 611 "0";
BA_ "GenMsgStartDelayTime" BO_ 611 90;
BA_ "GenMsgDelayTime" BO_ 611 5;
BA_ "GenMsgNrOfRepetitions" BO_ 611 0;
BA_ "GenMsgCycleTime" BO_ 611 200;
BA_ "GenMsgSendType" BO_ 611 5;
    */
    _PERIPHERY_HMI_R1_AR_Timebase =           c_tDBKomTimer_20ms;
    _PERIPHERY_HMI_R1_AR_CycleCount =       200 / _PERIPHERY_HMI_R1_AR_Timebase;
    _PERIPHERY_HMI_R1_AR_StartDelay =        90 / _PERIPHERY_HMI_R1_AR_Timebase;
    _PERIPHERY_HMI_R1_AR_Cnt = _PERIPHERY_HMI_R1_AR_StartDelay;
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_PERIPHERY_HMI_R1_AR, _PERIPHERY_HMI_R1_AR_StartDelay * _PERIPHERY_HMI_R1_AR_Timebase );

    _mPERIPHERY_HMI_R1_AR.AFS_Md_Cfg_Stat.phys = getValue( HMI_AFS_Md_Cfg_Stat );
    _mPERIPHERY_HMI_R1_AR.AFS_Md_Cfg_Stat_UB.phys = getValue( HMI_AFS_Md_Cfg_Stat_UB );
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg2_Disp_Rq_UB.phys = getValue( HMI_HLM_LT_Msg2_Disp_Rq_UB );
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg2_Disp_Rq.phys = getValue( HMI_HLM_LT_Msg2_Disp_Rq );
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg4_Disp_Rq_UB.phys = getValue( HMI_HLM_LT_Msg4_Disp_Rq_UB );
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg4_Disp_Rq.phys = getValue( HMI_HLM_LT_Msg4_Disp_Rq );
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg5_Disp_Rq_UB.phys = getValue( HMI_HLM_LT_Msg5_Disp_Rq_UB );
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg5_Disp_Rq.phys = getValue( HMI_HLM_LT_Msg5_Disp_Rq );
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg6_Disp_Rq_UB.phys = getValue( HMI_HLM_LT_Msg6_Disp_Rq_UB );
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg6_Disp_Rq.phys = getValue( HMI_HLM_LT_Msg6_Disp_Rq );
    _mPERIPHERY_HMI_R1_AR.HLM_RT_Msg4_Disp_Rq_UB.phys = getValue( HMI_HLM_RT_Msg4_Disp_Rq_UB );
    _mPERIPHERY_HMI_R1_AR.HLM_RT_Msg4_Disp_Rq.phys = getValue( HMI_HLM_RT_Msg4_Disp_Rq );
    _mPERIPHERY_HMI_R1_AR.IHC_Lgt_Stat_HLI_UB.phys = getValue( HMI_IHC_Lgt_Stat_HLI_UB );
    _mPERIPHERY_HMI_R1_AR.IHC_Lgt_Stat_HLI_2_AR_UB.phys = getValue( HMI_IHC_Lgt_Stat_HLI_2_AR_UB );
    _mPERIPHERY_HMI_R1_AR.IHC_Stat_HLM_LT.phys = getValue( HMI_IHC_Stat_HLM_LT );
    _mPERIPHERY_HMI_R1_AR.ILS_TouristMd_Cfg_Stat.phys = getValue( HMI_ILS_TouristMd_Cfg_Stat );
    _mPERIPHERY_HMI_R1_AR.ILS_TouristMd_Cfg_Stat_UB.phys = getValue( HMI_ILS_TouristMd_Cfg_Stat_UB );
    _mPERIPHERY_HMI_R1_AR.VehLvl_Ft_HLM.phys = getValue( HMI_VehLvl_Ft_HLM );
    _mPERIPHERY_HMI_R1_AR.VehLvl_R_HLM.phys = getValue( HMI_VehLvl_R_HLM );  
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg7_Disp_Rq.phys = getValue( HMI_HLM_LT_Msg7_Disp_Rq );
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg7_Disp_Rq_UB.phys = getValue( HMI_HLM_LT_Msg7_Disp_Rq_UB );
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg8_Disp_Rq.phys = getValue( HMI_HLM_LT_Msg8_Disp_Rq );
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg8_Disp_Rq_UB.phys = getValue( HMI_HLM_LT_Msg8_Disp_Rq_UB );
    _mPERIPHERY_HMI_R1_AR.ILS_TouristMd_TrffcStyle_Stat.phys = getValue( HMI_ILS_TouristMd_TrffcStyle_Stat );
    _mPERIPHERY_HMI_R1_AR.ILS_TouristMd_TrffcStyle_Stat_UB.phys = getValue( HMI_ILS_TouristMd_TrffcStyle_Stat_UB );

}

PERIPHERY_HMI_R1_AR_output(void)
{
    output( _mPERIPHERY_HMI_R1_AR );
}

PERIPHERY_HMI_R1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PERIPHERY_HMI_R1_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PERIPHERY_HMI_R1_AR := %X\n", getValue( HMI__STMSG_PERIPHERY_HMI_R1_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PERIPHERY_HMI_R1_AR := %X\n", getValue( HMI__STMSGT_PERIPHERY_HMI_R1_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AFS_Md_Cfg_Stat := %X\n", getValue( HMI_AFS_Md_Cfg_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AFS_Md_Cfg_Stat_UB := %X\n", getValue( HMI_AFS_Md_Cfg_Stat_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HLM_LT_Msg2_Disp_Rq_UB := %X\n", getValue( HMI_HLM_LT_Msg2_Disp_Rq_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HLM_LT_Msg2_Disp_Rq := %X\n", getValue( HMI_HLM_LT_Msg2_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HLM_LT_Msg4_Disp_Rq_UB := %X\n", getValue( HMI_HLM_LT_Msg4_Disp_Rq_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HLM_LT_Msg4_Disp_Rq := %X\n", getValue( HMI_HLM_LT_Msg4_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HLM_LT_Msg5_Disp_Rq_UB := %X\n", getValue( HMI_HLM_LT_Msg5_Disp_Rq_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HLM_LT_Msg5_Disp_Rq := %X\n", getValue( HMI_HLM_LT_Msg5_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HLM_LT_Msg6_Disp_Rq_UB := %X\n", getValue( HMI_HLM_LT_Msg6_Disp_Rq_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HLM_LT_Msg6_Disp_Rq := %X\n", getValue( HMI_HLM_LT_Msg6_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HLM_RT_Msg4_Disp_Rq_UB := %X\n", getValue( HMI_HLM_RT_Msg4_Disp_Rq_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HLM_RT_Msg4_Disp_Rq := %X\n", getValue( HMI_HLM_RT_Msg4_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_Lgt_Stat_HLI_UB := %X\n", getValue( HMI_IHC_Lgt_Stat_HLI_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_Lgt_Stat_HLI_2_AR_UB := %X\n", getValue( HMI_IHC_Lgt_Stat_HLI_2_AR_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_Stat_HLM_LT := %X\n", getValue( HMI_IHC_Stat_HLM_LT ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ILS_TouristMd_Cfg_Stat := %X\n", getValue( HMI_ILS_TouristMd_Cfg_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ILS_TouristMd_Cfg_Stat_UB := %X\n", getValue( HMI_ILS_TouristMd_Cfg_Stat_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLvl_Ft_HLM := %X\n", getValue( HMI_VehLvl_Ft_HLM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLvl_R_HLM := %X\n", getValue( HMI_VehLvl_R_HLM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HLM_LT_Msg7_Disp_Rq := %X\n", getValue( HMI_HLM_LT_Msg7_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HLM_LT_Msg7_Disp_Rq_UB := %X\n", getValue( HMI_HLM_LT_Msg7_Disp_Rq_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HLM_LT_Msg8_Disp_Rq := %X\n", getValue( HMI_HLM_LT_Msg8_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HLM_LT_Msg8_Disp_Rq_UB := %X\n", getValue( HMI_HLM_LT_Msg8_Disp_Rq_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ILS_TouristMd_TrffcStyle_Stat := %X\n", getValue( HMI_ILS_TouristMd_TrffcStyle_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ILS_TouristMd_TrffcStyle_Stat_UB := %X\n", getValue( HMI_ILS_TouristMd_TrffcStyle_Stat_UB ) );        filePutString( buffer, elcount( buffer ), hFile );

}

on timer _tPERIPHERY_HMI_R1_AR
{
    putValue( HMI__STMSG_PERIPHERY_HMI_R1_AR, 0 );
}

on EnvVar HMI__STMSG_PERIPHERY_HMI_R1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PERIPHERY_HMI_R1_AR );
        if( tDelay > 0)    
            setTimer( _tPERIPHERY_HMI_R1_AR, tDelay );
        else
            putValue( HMI__STMSG_PERIPHERY_HMI_R1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PERIPHERY_HMI_R1_AR
{
    if( getValue( this ) )
        openPanel("PERIPHERY_HMI_R1_AR");
}

on envVar HMI_AFS_Md_Cfg_Stat
{
    _mPERIPHERY_HMI_R1_AR.AFS_Md_Cfg_Stat.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_AFS_Md_Cfg_Stat_UB
{
    _mPERIPHERY_HMI_R1_AR.AFS_Md_Cfg_Stat_UB.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_HLM_LT_Msg2_Disp_Rq_UB
{
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg2_Disp_Rq_UB.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_HLM_LT_Msg2_Disp_Rq
{
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg2_Disp_Rq.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_HLM_LT_Msg4_Disp_Rq_UB
{
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg4_Disp_Rq_UB.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_HLM_LT_Msg4_Disp_Rq
{
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg4_Disp_Rq.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_HLM_LT_Msg5_Disp_Rq_UB
{
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg5_Disp_Rq_UB.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_HLM_LT_Msg5_Disp_Rq
{
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg5_Disp_Rq.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_HLM_LT_Msg6_Disp_Rq_UB
{
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg6_Disp_Rq_UB.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_HLM_LT_Msg6_Disp_Rq
{
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg6_Disp_Rq.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_HLM_RT_Msg4_Disp_Rq_UB
{
    _mPERIPHERY_HMI_R1_AR.HLM_RT_Msg4_Disp_Rq_UB.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_HLM_RT_Msg4_Disp_Rq
{
    _mPERIPHERY_HMI_R1_AR.HLM_RT_Msg4_Disp_Rq.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_IHC_Lgt_Stat_HLI_UB
{
    _mPERIPHERY_HMI_R1_AR.IHC_Lgt_Stat_HLI_UB.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_IHC_Lgt_Stat_HLI_2_AR_UB
{
    _mPERIPHERY_HMI_R1_AR.IHC_Lgt_Stat_HLI_2_AR_UB.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_IHC_Stat_HLM_LT
{
    _mPERIPHERY_HMI_R1_AR.IHC_Stat_HLM_LT.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_ILS_TouristMd_Cfg_Stat
{
    _mPERIPHERY_HMI_R1_AR.ILS_TouristMd_Cfg_Stat.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_ILS_TouristMd_Cfg_Stat_UB
{
    _mPERIPHERY_HMI_R1_AR.ILS_TouristMd_Cfg_Stat_UB.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_VehLvl_Ft_HLM
{
    _mPERIPHERY_HMI_R1_AR.VehLvl_Ft_HLM.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_HLM_LT_Msg7_Disp_Rq
{
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg7_Disp_Rq.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_HLM_LT_Msg7_Disp_Rq_UB
{
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg7_Disp_Rq_UB.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_VehLvl_R_HLM
{
    _mPERIPHERY_HMI_R1_AR.VehLvl_R_HLM.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_HLM_LT_Msg8_Disp_Rq
{
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg8_Disp_Rq.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_HLM_LT_Msg8_Disp_Rq_UB
{
    _mPERIPHERY_HMI_R1_AR.HLM_LT_Msg8_Disp_Rq_UB.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_ILS_TouristMd_TrffcStyle_Stat
{
    _mPERIPHERY_HMI_R1_AR.ILS_TouristMd_TrffcStyle_Stat.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

on envVar HMI_ILS_TouristMd_TrffcStyle_Stat_UB
{
    _mPERIPHERY_HMI_R1_AR.ILS_TouristMd_TrffcStyle_Stat_UB.phys = getValue(this);
    _PERIPHERY_HMI_R1_AR_SpontanFlag = 1;
}

PN14_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_PN14_Disp_Rq_AR ) )
    {
    //  message   PN14_Disp_Rq_AR ID: 833 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _PN14_Disp_Rq_AR_DelayCnt > 0) _PN14_Disp_Rq_AR_DelayCnt--; // Mindestsendeabstand
        _PN14_Disp_Rq_AR_Cnt--;
        if( _PN14_Disp_Rq_AR_Cnt < 1 )
        {
            if( _PN14_Disp_Rq_AR_DelayCnt < 1 )
            {
                PN14_Disp_Rq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                _PN14_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _PN14_Disp_Rq_AR_DelayCnt = _PN14_Disp_Rq_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _PN14_Disp_Rq_AR_SpontanFlag = 1;
            }
            _PN14_Disp_Rq_AR_Cnt = _PN14_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _PN14_Disp_Rq_AR_SpontanFlag)
        {
            if( _PN14_Disp_Rq_AR_DelayCnt < 1 )
            {
                PN14_Disp_Rq_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _PN14_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _PN14_Disp_Rq_AR_DelayCnt = _PN14_Disp_Rq_AR_MinDelay;
            }
        }
    }
}

PN14_Disp_Rq_AR_init()
{   /* Botschaft PN14_Disp_Rq_AR ID: 833 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 833 0;
BA_ "NmAsrMessage" BO_ 833 0;
BA_ "GenMsgMinAcceptLength" BO_ 833 8;
BA_ "GenMsgILSupport" BO_ 833 1;
BA_ "DiagState" BO_ 833 0;
BA_ "DiagRequest" BO_ 833 0;
BA_ "DiagResponse" BO_ 833 0;
BA_ "GenMsgStartValue" BO_ 833 "0";
BA_ "GenMsgDelayTime" BO_ 833 200;
BA_ "GenMsgNrOfRepetitions" BO_ 833 0;
BA_ "GenMsgCycleTime" BO_ 833 1000;
BA_ "GenMsgSendType" BO_ 833 5;
    */
    _PN14_Disp_Rq_AR_Timebase =           c_tDBKomTimer_20ms;
    _PN14_Disp_Rq_AR_CycleCount =      1000 / _PN14_Disp_Rq_AR_Timebase;
    _PN14_Disp_Rq_AR_StartDelay =         0 / _PN14_Disp_Rq_AR_Timebase;
    _PN14_Disp_Rq_AR_MinDelay =         200 / _PN14_Disp_Rq_AR_Timebase;
    _PN14_Disp_Rq_AR_Cnt = _PN14_Disp_Rq_AR_StartDelay;
    _PN14_Disp_Rq_AR_SpontanFlag = 0;
    _PN14_Disp_Rq_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_PN14_Disp_Rq_AR, _PN14_Disp_Rq_AR_StartDelay * _PN14_Disp_Rq_AR_Timebase );

    _mPN14_Disp_Rq_AR.PN14_EOL_Disp_Rq.phys = getValue( HMI_PN14_EOL_Disp_Rq );
    _mPN14_Disp_Rq_AR.PN14_Msg1_Disp_Rq.phys = getValue( HMI_PN14_Msg1_Disp_Rq );
    _mPN14_Disp_Rq_AR.PN14_Msg2_Disp_Rq.phys = getValue( HMI_PN14_Msg2_Disp_Rq );
    _mPN14_Disp_Rq_AR.PN14_Msg6_Disp_Rq.phys = getValue( HMI_PN14_Msg6_Disp_Rq );
    _mPN14_Disp_Rq_AR.PN14_Msg7_Disp_Rq.phys = getValue( HMI_PN14_Msg7_Disp_Rq );
    _mPN14_Disp_Rq_AR.PN14_Msg8_Disp_Rq.phys = getValue( HMI_PN14_Msg8_Disp_Rq );
    _mPN14_Disp_Rq_AR.PN14_ProdMdDisp_Rq.phys = getValue( HMI_PN14_ProdMdDisp_Rq );
    _mPN14_Disp_Rq_AR.PN14_SupBat_Curr_Extd.phys = getValue( HMI_PN14_SupBat_Curr_Extd );
    _mPN14_Disp_Rq_AR.PN14_ProdMode_BatState.phys = getValue( HMI_PN14_ProdMode_BatState );
    _mPN14_Disp_Rq_AR.PN14_SupBat_State.phys = getValue( HMI_PN14_SupBat_State );
    _mPN14_Disp_Rq_AR.PN14_SupBat_Temp.phys = getValue( HMI_PN14_SupBat_Temp );
    _mPN14_Disp_Rq_AR.PN14_TransMd_RemTm.phys = getValue( HMI_PN14_TransMd_RemTm );
    _mPN14_Disp_Rq_AR.PN14_TransMdDisp_Rq.phys = getValue( HMI_PN14_TransMdDisp_Rq );
  
    
}

PN14_Disp_Rq_AR_output()
{
    output( _mPN14_Disp_Rq_AR );
}

void PN14_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PN14_Disp_Rq_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PN14_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_PN14_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PN14_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_PN14_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_EOL_Disp_Rq := %X\n", getValue( HMI_PN14_EOL_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_Msg1_Disp_Rq := %X\n", getValue( HMI_PN14_Msg1_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_Msg2_Disp_Rq := %X\n", getValue( HMI_PN14_Msg2_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_Msg6_Disp_Rq := %X\n", getValue( HMI_PN14_Msg6_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_Msg7_Disp_Rq := %X\n", getValue( HMI_PN14_Msg7_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_Msg8_Disp_Rq := %X\n", getValue( HMI_PN14_Msg8_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_ProdMdDisp_Rq := %X\n", getValue( HMI_PN14_ProdMdDisp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_SupBat_Curr_Extd := %X\n", getValue( HMI_PN14_SupBat_Curr_Extd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_SupBat_State := %X\n", getValue( HMI_PN14_SupBat_State ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_SupBat_Temp := %X\n", getValue( HMI_PN14_SupBat_Temp ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_TransMd_RemTm := %X\n", getValue( HMI_PN14_TransMd_RemTm ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_TransMdDisp_Rq := %X\n", getValue( HMI_PN14_TransMdDisp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_ProdMode_BatState := %X\n", getValue( HMI_PN14_ProdMode_BatState ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPN14_Disp_Rq_AR
{
    putValue( HMI__STMSG_PN14_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_PN14_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PN14_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tPN14_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_PN14_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PN14_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("PN14_Disp_Rq_AR");
}

on EnvVar HMI_PN14_EOL_Disp_Rq
{
    _mPN14_Disp_Rq_AR.PN14_EOL_Disp_Rq.phys = getValue(this);
    _PN14_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_Msg1_Disp_Rq
{
    _mPN14_Disp_Rq_AR.PN14_Msg1_Disp_Rq.phys = getValue(this);
    _PN14_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_Msg2_Disp_Rq
{
    _mPN14_Disp_Rq_AR.PN14_Msg2_Disp_Rq.phys = getValue(this);
    _PN14_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_Msg6_Disp_Rq
{
    _mPN14_Disp_Rq_AR.PN14_Msg6_Disp_Rq.phys = getValue(this);
    _PN14_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_Msg7_Disp_Rq
{
    _mPN14_Disp_Rq_AR.PN14_Msg7_Disp_Rq.phys = getValue(this);
    _PN14_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_Msg8_Disp_Rq
{
    _mPN14_Disp_Rq_AR.PN14_Msg8_Disp_Rq.phys = getValue(this);
    _PN14_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_ProdMdDisp_Rq
{
    _mPN14_Disp_Rq_AR.PN14_ProdMdDisp_Rq.phys = getValue(this);
    _PN14_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_SupBat_Curr_Extd
{
    _mPN14_Disp_Rq_AR.PN14_SupBat_Curr_Extd.phys = getValue(this);
    _PN14_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_SupBat_State
{
    _mPN14_Disp_Rq_AR.PN14_SupBat_State.phys = getValue(this);
    _PN14_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_SupBat_Temp
{
    _mPN14_Disp_Rq_AR.PN14_SupBat_Temp.phys = getValue(this);
    _PN14_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_TransMd_RemTm
{
    _mPN14_Disp_Rq_AR.PN14_TransMd_RemTm.phys = getValue(this);
    _PN14_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_ProdMode_BatState
{
    _mPN14_Disp_Rq_AR.PN14_ProdMode_BatState.phys = getValue(this);
    _PN14_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_TransMdDisp_Rq
{
    _mPN14_Disp_Rq_AR.PN14_TransMdDisp_Rq.phys = getValue(this);
    _PN14_Disp_Rq_AR_SpontanFlag = 1;
}

PN14_Disp_Rq2_AR_check_output()
{
    if( !getValue( HMI__STMSG_PN14_Disp_Rq2_AR ) )
    {
    //  message   PN14_Disp_Rq2_AR ID: 834 --- Sendeart 5 cyclicAndSpontanWithDelay
        _PN14_Disp_Rq2_AR_Cnt--;
        if( _PN14_Disp_Rq2_AR_Cnt < 1 )
        {
            PN14_Disp_Rq2_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _PN14_Disp_Rq2_AR_Cnt = _PN14_Disp_Rq2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _PN14_Disp_Rq2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _PN14_Disp_Rq2_AR_SpontanFlag)
        {
            PN14_Disp_Rq2_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _PN14_Disp_Rq2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

PN14_Disp_Rq2_AR_init()
{   /* Botschaft PN14_Disp_Rq2_AR ID: 834 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 834 0;
BA_ "NmAsrMessage" BO_ 834 0;
BA_ "GenMsgMinAcceptLength" BO_ 834 8;
BA_ "GenMsgILSupport" BO_ 834 1;
BA_ "DiagState" BO_ 834 0;
BA_ "DiagRequest" BO_ 834 0;
BA_ "DiagResponse" BO_ 834 0;
BA_ "GenMsgStartValue" BO_ 834 "0";
BA_ "GenMsgDelayTime" BO_ 834 200;
BA_ "GenMsgNrOfRepetitions" BO_ 834 0;
BA_ "GenMsgCycleTime" BO_ 834 1000;
BA_ "GenMsgSendType" BO_ 834 5;
    */
    _PN14_Disp_Rq2_AR_Timebase =      c_tDBKomTimer_20ms;
    _PN14_Disp_Rq2_AR_CycleCount =   1000 / _PN14_Disp_Rq2_AR_Timebase;
    _PN14_Disp_Rq2_AR_StartDelay =      0 / _PN14_Disp_Rq2_AR_Timebase;
    _PN14_Disp_Rq2_AR_MinDelay =      200 / _PN14_Disp_Rq2_AR_Timebase;
    _PN14_Disp_Rq2_AR_Cnt = _PN14_Disp_Rq2_AR_StartDelay;
    _PN14_Disp_Rq2_AR_SpontanFlag = 0;
    _PN14_Disp_Rq2_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_PN14_Disp_Rq2_AR, _PN14_Disp_Rq2_AR_StartDelay * _PN14_Disp_Rq2_AR_Timebase );

    _PN14_Disp_Rq2_AR_Cnt = 10;
    _PN14_Disp_Rq2_AR_SpontanFlag = 0;
    _mPN14_Disp_Rq2_AR.PN14_WarnIcon1_Disp_Rq.phys = getValue( HMI_PN14_WarnIcon1_Disp_Rq );
    _mPN14_Disp_Rq2_AR.Rsrv1_PN14_Disp_Rq2.phys = getValue( HMI_Rsrv1_PN14_Disp_Rq2 );
    _mPN14_Disp_Rq2_AR.PN14_Disp_Rq2_UB.phys = getValue( HMI_PN14_Disp_Rq2_UB );
}

PN14_Disp_Rq2_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_PN14_Disp_Rq2 ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_PN14_Disp_Rq2_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _PN14_Disp_Rq2_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _PN14_Disp_Rq2_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_PN14_Disp_Rq2_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _PN14_Disp_Rq2_AR_SQC_WrongSeqJump != 0 ) &&
            ( _PN14_Disp_Rq2_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _PN14_Disp_Rq2_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _PN14_Disp_Rq2_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _PN14_Disp_Rq2_AR_SQC_RepeatedCnt ) &&
            ( _PN14_Disp_Rq2_AR_E2E_Armed == 1  )    )
        {
            _PN14_Disp_Rq2_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_PN14_Disp_Rq2, SQC_help );
    }
    _mPN14_Disp_Rq2_AR.SQC_PN14_Disp_Rq2 = SQC_help;

    if( getValue( HMI_CRC_PN14_Disp_Rq2_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_PN14_Disp_Rq2_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mPN14_Disp_Rq2_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mPN14_Disp_Rq2_AR.byte( 1 ) ];
//            crc = crctable_profile02[ crc ^ _mPN14_Disp_Rq2_AR.byte( 2 ) ];
//            crc = crctable_profile02[ crc ^ _mPN14_Disp_Rq2_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mPN14_Disp_Rq2_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mPN14_Disp_Rq2_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mPN14_Disp_Rq2_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mPN14_Disp_Rq2_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _PN14_Disp_Rq2_AR_CRC_Offset[ _mPN14_Disp_Rq2_AR.SQC_PN14_Disp_Rq2 ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _PN14_Disp_Rq2_AR_CRC_ErrorCnt   && ( _PN14_Disp_Rq2_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_PN14_Disp_Rq2_Invalid )                                         )    )
            {
                crc++;
                if( _PN14_Disp_Rq2_AR_CRC_ErrorCnt > 0 )
                    _PN14_Disp_Rq2_AR_CRC_ErrorCnt--; 
            }
            _mPN14_Disp_Rq2_AR.CRC_PN14_Disp_Rq2 = crc;
            putValue( HMI_CRC_PN14_Disp_Rq2, crc );
        }
        else
            _mPN14_Disp_Rq2_AR.CRC_PN14_Disp_Rq2 = getValue( HMI_CRC_PN14_Disp_Rq2 );
    }
    else
    {
        if( !getValue( HMI_CRC_PN14_Disp_Rq2_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mPN14_Disp_Rq2_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mPN14_Disp_Rq2_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mPN14_Disp_Rq2_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mPN14_Disp_Rq2_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mPN14_Disp_Rq2_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mPN14_Disp_Rq2_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mPN14_Disp_Rq2_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mPN14_Disp_Rq2_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _PN14_Disp_Rq2_AR_CRC_ErrorCnt   && ( _PN14_Disp_Rq2_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_PN14_Disp_Rq2_Invalid )                                         )    )
            {
                crc++;
                if( _PN14_Disp_Rq2_AR_CRC_ErrorCnt > 0 )
                    _PN14_Disp_Rq2_AR_CRC_ErrorCnt--; 
            }
            _mPN14_Disp_Rq2_AR.CRC_PN14_Disp_Rq2 = crc;
            putValue( HMI_CRC_PN14_Disp_Rq2, crc );
        }
        else
            _mPN14_Disp_Rq2_AR.CRC_PN14_Disp_Rq2 = getValue( HMI_CRC_PN14_Disp_Rq2 );
    }
    if( ( _PN14_Disp_Rq2_AR_MSG_DropCnt > 0 ) &&
        ( _PN14_Disp_Rq2_AR_E2E_Armed == 1  )    )
    {
        _PN14_Disp_Rq2_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mPN14_Disp_Rq2_AR );
        
    if( _PN14_Disp_Rq2_AR_E2E_Armed == 1 )
    {
        if ( ( _PN14_Disp_Rq2_AR_MSG_DropCnt == 0      ) &&
             ( _PN14_Disp_Rq2_AR_CRC_ErrorCnt == 0     ) &&
             ( _PN14_Disp_Rq2_AR_SQC_RepeatedCnt == 0  ) &&
             ( _PN14_Disp_Rq2_AR_SQC_WrongSeqJump == 0 )    )
        {
            _PN14_Disp_Rq2_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_PN14_Disp_Rq2_State, 0 );
        }
    }
}

void PN14_Disp_Rq2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PN14_Disp_Rq2_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PN14_Disp_Rq2_AR := %X\n", getValue( HMI__STMSG_PN14_Disp_Rq2_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PN14_Disp_Rq2_AR := %X\n", getValue( HMI__STMSGT_PN14_Disp_Rq2_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_PN14_Disp_Rq2 := %X\n", getValue( HMI_CRC_PN14_Disp_Rq2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_PN14_Disp_Rq2_Auto := %X\n", getValue( HMI_CRC_PN14_Disp_Rq2_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_WarnIcon1_Disp_Rq := %X\n", getValue( HMI_PN14_WarnIcon1_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_PN14_Disp_Rq2 := %X\n", getValue( HMI_SQC_PN14_Disp_Rq2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_PN14_Disp_Rq2_Auto := %X\n", getValue( HMI_SQC_PN14_Disp_Rq2_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_PN14_Disp_Rq2 := %X\n", getValue( HMI_Rsrv1_PN14_Disp_Rq2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_Disp_Rq2_UB := %X\n", getValue( HMI_PN14_Disp_Rq2_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPN14_Disp_Rq2_AR
{
    putValue( HMI__STMSG_PN14_Disp_Rq2_AR, 0 );
}

on EnvVar HMI__STMSG_PN14_Disp_Rq2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PN14_Disp_Rq2_AR );
        if( tDelay > 0)    
            setTimer( _tPN14_Disp_Rq2_AR, tDelay );
        else
            putValue( HMI__STMSG_PN14_Disp_Rq2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PN14_Disp_Rq2_AR
{
    if( getValue( this ) )
        openPanel("PN14_Disp_Rq2_AR");
}

on envVar HMI_E2E_PN14_Disp_Rq2_Inject
{
    if( getValue( this ) )
    {
        _PN14_Disp_Rq2_AR_CRC_ErrorCnt = getValue( HMI_CRC_PN14_Disp_Rq2_ErrorCount );
        _PN14_Disp_Rq2_AR_SQC_TriggPos = getValue( HMI_SQC_PN14_Disp_Rq2_TriggerPosition );
        _PN14_Disp_Rq2_AR_SQC_WrongSeqJump = getValue( HMI_SQC_PN14_Disp_Rq2_WrongSeq );
        _PN14_Disp_Rq2_AR_SQC_RepeatedCnt = getValue( HMI_SQC_PN14_Disp_Rq2_Repeated );
        _PN14_Disp_Rq2_AR_MSG_DropCnt = getValue( HMI_SQC_PN14_Disp_Rq2_MSG_DropCnt );
        putValue( HMI_E2E_PN14_Disp_Rq2_State, 2 );
        _PN14_Disp_Rq2_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_PN14_WarnIcon1_Disp_Rq
{
    _mPN14_Disp_Rq2_AR.PN14_WarnIcon1_Disp_Rq.phys = getValue(this);
    _PN14_Disp_Rq2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_PN14_Disp_Rq2
{
    _mPN14_Disp_Rq2_AR.Rsrv1_PN14_Disp_Rq2.phys = getValue(this);
    _PN14_Disp_Rq2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_Disp_Rq2_UB
{
    _mPN14_Disp_Rq2_AR.PN14_Disp_Rq2_UB.phys = getValue(this);
    _PN14_Disp_Rq2_AR_SpontanFlag = 1;
}

PN14_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_PN14_Stat_AR ) )
    {
    //  message   PN14_Stat_AR ID: 290 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _PN14_Stat_AR_Cnt--;
        if( _PN14_Stat_AR_Cnt < 1 )
        {
            PN14_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _PN14_Stat_AR_Cnt = _PN14_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _PN14_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _PN14_Stat_AR_SpontanFlag )
        {
            PN14_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _PN14_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

PN14_Stat_AR_init()
{   /* Botschaft PN14_Stat_AR ID: 290 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 290 0;
BA_ "NmAsrMessage" BO_ 290 0;
BA_ "GenMsgMinAcceptLength" BO_ 290 8;
BA_ "GenMsgILSupport" BO_ 290 1;
BA_ "DiagState" BO_ 290 0;
BA_ "DiagRequest" BO_ 290 0;
BA_ "DiagResponse" BO_ 290 0;
BA_ "GenMsgStartValue" BO_ 290 "0";
BA_ "GenMsgStartDelayTime" BO_ 290 0;
BA_ "GenMsgDelayTime" BO_ 290 5;
BA_ "GenMsgNrOfRepetitions" BO_ 290 0;
BA_ "GenMsgCycleTime" BO_ 290 100;
BA_ "GenMsgSendType" BO_ 290 5;
    */
    _PN14_Stat_AR_Timebase =           c_tDBKomTimer_20ms;
    _PN14_Stat_AR_CycleCount =        100 / _PN14_Stat_AR_Timebase;
    _PN14_Stat_AR_StartDelay =          0 / _PN14_Stat_AR_Timebase;
    _PN14_Stat_AR_Cnt = _PN14_Stat_AR_StartDelay;
    _PN14_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_PN14_Stat_AR, _PN14_Stat_AR_StartDelay * _PN14_Stat_AR_Timebase );

    _mPN14_Stat_AR.DPM_ExtMd_Enbl_Rq.phys = getValue( HMI_DPM_ExtMd_Enbl_Rq );
    _mPN14_Stat_AR.DPM_MdLmt_Rq.phys = getValue( HMI_DPM_MdLmt_Rq );
    _mPN14_Stat_AR.LHC_ComfSys_Rq.phys = getValue( HMI_LHC_ComfSys_Rq );
    _mPN14_Stat_AR.LHC_CoolBox_R_Rq.phys = getValue( HMI_LHC_CoolBox_R_Rq );
    _mPN14_Stat_AR.LHC_EBL_Rq.phys = getValue( HMI_LHC_EBL_Rq );
    _mPN14_Stat_AR.LHC_EngFan_50_Rq.phys = getValue( HMI_LHC_EngFan_50_Rq );
    _mPN14_Stat_AR.LHC_ICH_Rq.phys = getValue( HMI_LHC_ICH_Rq );
    _mPN14_Stat_AR.LHC_IntFan_F_50_Rq.phys = getValue( HMI_LHC_IntFan_F_50_Rq );
    _mPN14_Stat_AR.LHC_IntFan_R_0_Rq.phys = getValue( HMI_LHC_IntFan_R_0_Rq );
    _mPN14_Stat_AR.LHC_IntFan_R_50_Rq.phys = getValue( HMI_LHC_IntFan_R_50_Rq );
    _mPN14_Stat_AR.LHC_MirrHt_Rq.phys = getValue( HMI_LHC_MirrHt_Rq );
    _mPN14_Stat_AR.LHC_PkLmp_Rq.phys = getValue( HMI_LHC_PkLmp_Rq );
    _mPN14_Stat_AR.LHC_PosnLmp_Rq.phys = getValue( HMI_LHC_PosnLmp_Rq );
    _mPN14_Stat_AR.LHC_PT_Stg1_Rq.phys = getValue( HMI_LHC_PT_Stg1_Rq );
    _mPN14_Stat_AR.LHC_PT_Stg2_Rq.phys = getValue( HMI_LHC_PT_Stg2_Rq );
    _mPN14_Stat_AR.LHC_PTC1_Rq.phys = getValue( HMI_LHC_PTC1_Rq );
    _mPN14_Stat_AR.LHC_PTC2_Rq.phys = getValue( HMI_LHC_PTC2_Rq );
    _mPN14_Stat_AR.LHC_PTC3_Rq.phys = getValue( HMI_LHC_PTC3_Rq );
    _mPN14_Stat_AR.LHC_PTC4_Rq.phys = getValue( HMI_LHC_PTC4_Rq );
    _mPN14_Stat_AR.LHC_PTC5_Rq.phys = getValue( HMI_LHC_PTC5_Rq );
    _mPN14_Stat_AR.LHC_PTC6_Rq.phys = getValue( HMI_LHC_PTC6_Rq );
    _mPN14_Stat_AR.LHC_RHU_Rq.phys = getValue( HMI_LHC_RHU_Rq );
    _mPN14_Stat_AR.LHC_SeatHtStg1_Rq.phys = getValue( HMI_LHC_SeatHtStg1_Rq );
    _mPN14_Stat_AR.LHC_SeatHtStg2_Rq.phys = getValue( HMI_LHC_SeatHtStg2_Rq );
    _mPN14_Stat_AR.LHC_SeatHtStg3_Rq.phys = getValue( HMI_LHC_SeatHtStg3_Rq );
    _mPN14_Stat_AR.LHC_SeatVn_Rq.phys = getValue( HMI_LHC_SeatVn_Rq );
    _mPN14_Stat_AR.LHC_StW_Ht_Rq.phys = getValue( HMI_LHC_StW_Ht_Rq );
    _mPN14_Stat_AR.LHC_Taxi_Rq.phys = getValue( HMI_LHC_Taxi_Rq );
    _mPN14_Stat_AR.LHC_Tlm_Rq.phys = getValue( HMI_LHC_Tlm_Rq );
    _mPN14_Stat_AR.LHC_TrkSock_Rq.phys = getValue( HMI_LHC_TrkSock_Rq );
    _mPN14_Stat_AR.LHC_TrlrSock_Rq.phys = getValue( HMI_LHC_TrlrSock_Rq );
    _mPN14_Stat_AR.LHC_WprPkHt_Rq.phys = getValue( HMI_LHC_WprPkHt_Rq );
    _mPN14_Stat_AR.LHC_WShHt_50_Rq.phys = getValue( HMI_LHC_WShHt_50_Rq );
    _mPN14_Stat_AR.LHC_WShHt_Rq.phys = getValue( HMI_LHC_WShHt_Rq );
    _mPN14_Stat_AR.PN14_eHeV_Enbl.phys =  getValue( HMI_PN14_eHeV_Enbl );
    _mPN14_Stat_AR.PN14_LHC_Actv.phys = getValue( HMI_PN14_LHC_Actv );
    _mPN14_Stat_AR.PN14_SupBat_Curr.phys = getValue( HMI_PN14_SupBat_Curr );
    _mPN14_Stat_AR.PN14_SupBat_Volt.phys = getValue( HMI_PN14_SupBat_Volt );
    _mPN14_Stat_AR.PN14_SupBatCutSw_Stat.phys = getValue( HMI_PN14_SupBatCutSw_Stat );
    _mPN14_Stat_AR.PN14_TransMd_Stat.phys = getValue( HMI_PN14_TransMd_Stat );
    _mPN14_Stat_AR.PN14_TransMd_Updt_Rq.phys = getValue( HMI_PN14_TransMd_Updt_Rq );
    _mPN14_Stat_AR.SSA_EngRestart_Actv.phys = getValue( HMI_SSA_EngRestart_Actv );
}

PN14_Stat_AR_output(void)
{
    output( _mPN14_Stat_AR );
}

PN14_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PN14_Stat\n", 26, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PN14_Stat_AR := %X\n", getValue( HMI__STMSG_PN14_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PN14_Stat_AR := %X\n", getValue( HMI__STMSGT_PN14_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPM_ExtMd_Enbl_Rq := %X\n", getValue( HMI_DPM_ExtMd_Enbl_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPM_MdLmt_Rq := %X\n", getValue( HMI_DPM_MdLmt_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_ComfSys_Rq := %X\n", getValue( HMI_LHC_ComfSys_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_CoolBox_R_Rq := %X\n", getValue( HMI_LHC_CoolBox_R_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_EBL_Rq := %X\n", getValue( HMI_LHC_EBL_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_EngFan_50_Rq := %X\n", getValue( HMI_LHC_EngFan_50_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_ICH_Rq := %X\n", getValue( HMI_LHC_ICH_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_IntFan_F_50_Rq := %X\n", getValue( HMI_LHC_IntFan_F_50_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_IntFan_R_0_Rq := %X\n", getValue( HMI_LHC_IntFan_R_0_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_IntFan_R_50_Rq := %X\n", getValue( HMI_LHC_IntFan_R_50_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_MirrHt_Rq := %X\n", getValue( HMI_LHC_MirrHt_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_PkLmp_Rq := %X\n", getValue( HMI_LHC_PkLmp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_PosnLmp_Rq := %X\n", getValue( HMI_LHC_PosnLmp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_PT_Stg1_Rq := %X\n", getValue( HMI_LHC_PT_Stg1_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_PT_Stg2_Rq := %X\n", getValue( HMI_LHC_PT_Stg2_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_PTC1_Rq := %X\n", getValue( HMI_LHC_PTC1_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_PTC2_Rq := %X\n", getValue( HMI_LHC_PTC2_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_PTC3_Rq := %X\n", getValue( HMI_LHC_PTC3_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_PTC4_Rq := %X\n", getValue( HMI_LHC_PTC4_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_PTC5_Rq := %X\n", getValue( HMI_LHC_PTC5_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_PTC6_Rq := %X\n", getValue( HMI_LHC_PTC6_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_RHU_Rq := %X\n", getValue( HMI_LHC_RHU_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_SeatHtStg1_Rq := %X\n", getValue( HMI_LHC_SeatHtStg1_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_SeatHtStg2_Rq := %X\n", getValue( HMI_LHC_SeatHtStg2_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_SeatHtStg3_Rq := %X\n", getValue( HMI_LHC_SeatHtStg3_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_SeatVn_Rq := %X\n", getValue( HMI_LHC_SeatVn_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_StW_Ht_Rq := %X\n", getValue( HMI_LHC_StW_Ht_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_Taxi_Rq := %X\n", getValue( HMI_LHC_Taxi_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_Tlm_Rq := %X\n", getValue( HMI_LHC_Tlm_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_TrkSock_Rq := %X\n", getValue( HMI_LHC_TrkSock_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_TrlrSock_Rq := %X\n", getValue( HMI_LHC_TrlrSock_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_WprPkHt_Rq := %X\n", getValue( HMI_LHC_WprPkHt_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_WShHt_50_Rq := %X\n", getValue( HMI_LHC_WShHt_50_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_WShHt_Rq := %X\n", getValue( HMI_LHC_WShHt_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_LHC_Actv := %X\n", getValue( HMI_PN14_LHC_Actv ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_SupBat_Curr := %X\n", getValue( HMI_PN14_SupBat_Curr ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_SupBat_Volt := %X\n", getValue( HMI_PN14_SupBat_Volt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_SupBatCutSw_Stat := %X\n", getValue( HMI_PN14_SupBatCutSw_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_TransMd_Stat := %X\n", getValue( HMI_PN14_TransMd_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_TransMd_Updt_Rq := %X\n", getValue( HMI_PN14_TransMd_Updt_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SSA_EngRestart_Actv := %X\n", getValue( HMI_SSA_EngRestart_Actv ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPN14_Stat_AR
{
    putValue( HMI__STMSG_PN14_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_PN14_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PN14_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tPN14_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_PN14_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PN14_Stat_AR
{
    if( getValue( this ) )
        openPanel("PN14_Stat_AR");
}

on EnvVar HMI_DPM_ExtMd_Enbl_Rq
{
    _mPN14_Stat_AR.DPM_ExtMd_Enbl_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_ComfSys_Rq
{
    _mPN14_Stat_AR.LHC_ComfSys_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPM_MdLmt_Rq
{
    _mPN14_Stat_AR.DPM_MdLmt_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_CoolBox_R_Rq
{
    _mPN14_Stat_AR.LHC_CoolBox_R_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_EBL_Rq
{
    _mPN14_Stat_AR.LHC_EBL_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_EngFan_50_Rq
{
    _mPN14_Stat_AR.LHC_EngFan_50_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_ICH_Rq
{
    _mPN14_Stat_AR.LHC_ICH_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_IntFan_F_50_Rq
{
    _mPN14_Stat_AR.LHC_IntFan_F_50_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_IntFan_R_0_Rq
{
    _mPN14_Stat_AR.LHC_IntFan_R_0_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_IntFan_R_50_Rq
{
    _mPN14_Stat_AR.LHC_IntFan_R_50_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_MirrHt_Rq
{
    _mPN14_Stat_AR.LHC_MirrHt_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_PkLmp_Rq
{
    _mPN14_Stat_AR.LHC_PkLmp_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_PosnLmp_Rq
{
    _mPN14_Stat_AR.LHC_PosnLmp_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_PT_Stg1_Rq
{
    _mPN14_Stat_AR.LHC_PT_Stg1_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_PT_Stg2_Rq
{
    _mPN14_Stat_AR.LHC_PT_Stg2_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_PTC1_Rq
{
    _mPN14_Stat_AR.LHC_PTC1_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_PTC2_Rq
{
    _mPN14_Stat_AR.LHC_PTC2_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_PTC3_Rq
{
    _mPN14_Stat_AR.LHC_PTC3_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_PTC4_Rq
{
    _mPN14_Stat_AR.LHC_PTC4_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_PTC5_Rq
{
    _mPN14_Stat_AR.LHC_PTC5_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_PTC6_Rq
{
    _mPN14_Stat_AR.LHC_PTC6_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_RHU_Rq
{
    _mPN14_Stat_AR.LHC_RHU_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_SeatHtStg1_Rq
{
    _mPN14_Stat_AR.LHC_SeatHtStg1_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_SeatHtStg2_Rq
{
    _mPN14_Stat_AR.LHC_SeatHtStg2_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_SeatHtStg3_Rq
{
    _mPN14_Stat_AR.LHC_SeatHtStg3_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_SeatVn_Rq
{
    _mPN14_Stat_AR.LHC_SeatVn_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_StW_Ht_Rq
{
    _mPN14_Stat_AR.LHC_StW_Ht_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_Taxi_Rq
{
    _mPN14_Stat_AR.LHC_Taxi_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_Tlm_Rq
{
    _mPN14_Stat_AR.LHC_Tlm_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_TrkSock_Rq
{
    _mPN14_Stat_AR.LHC_TrkSock_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_TrlrSock_Rq
{
    _mPN14_Stat_AR.LHC_TrlrSock_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_WprPkHt_Rq
{
    _mPN14_Stat_AR.LHC_WprPkHt_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_WShHt_50_Rq
{
    _mPN14_Stat_AR.LHC_WShHt_50_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LHC_WShHt_Rq
{
    _mPN14_Stat_AR.LHC_WShHt_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_eHeV_Enbl
{
    _mPN14_Stat_AR.PN14_eHeV_Enbl.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_LHC_Actv
{
    _mPN14_Stat_AR.PN14_LHC_Actv.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_SupBat_Curr
{
    _mPN14_Stat_AR.PN14_SupBat_Curr.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_SupBat_Volt
{
    _mPN14_Stat_AR.PN14_SupBat_Volt.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_SupBatCutSw_Stat
{
    _mPN14_Stat_AR.PN14_SupBatCutSw_Stat.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_TransMd_Stat
{
    _mPN14_Stat_AR.PN14_TransMd_Stat.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_TransMd_Updt_Rq
{
    _mPN14_Stat_AR.PN14_TransMd_Updt_Rq.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

on envVar HMI_SSA_EngRestart_Actv
{
    _mPN14_Stat_AR.SSA_EngRestart_Actv.phys = getValue(this);
    _PN14_Stat_AR_SpontanFlag = 1;
}

PN14_Stat_VAN_AR_check_output()
{
    if( !getValue( HMI__STMSG_PN14_Stat_VAN_AR ) )
    {
    //  message   PN14_Stat_VAN_AR ID: 819 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _PN14_Stat_VAN_AR_DelayCnt > 0) _PN14_Stat_VAN_AR_DelayCnt--; // Mindestsendeabstand
        _PN14_Stat_VAN_AR_Cnt--;
        if( _PN14_Stat_VAN_AR_Cnt < 1 )
        {
            if( _PN14_Stat_VAN_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                PN14_Stat_VAN_AR_output();
                 _PN14_Stat_VAN_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _PN14_Stat_VAN_AR_DelayCnt = _PN14_Stat_VAN_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _PN14_Stat_VAN_AR_SpontanFlag = 1;
            }
            _PN14_Stat_VAN_AR_Cnt = ( getValue( HMI__STMSG_PN14_Stat_VAN_AR ) / _PN14_Stat_VAN_AR_Timebase ); //_PN14_Stat_VAN_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _PN14_Stat_VAN_AR_SpontanFlag)
        {
            if( _PN14_Stat_VAN_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                PN14_Stat_VAN_AR_output();
                _PN14_Stat_VAN_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _PN14_Stat_VAN_AR_DelayCnt = _PN14_Stat_VAN_AR_MinDelay;
            }
        }
    }
}

PN14_Stat_VAN_AR_init()
{   /* Botschaft PN14_Stat_VAN_AR ID: 1204 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1204 0;
BA_ "NmAsrMessage" BO_ 1204 0;
BA_ "GenMsgMinAcceptLength" BO_ 1204 8;
BA_ "GenMsgILSupport" BO_ 1204 1;
BA_ "DiagState" BO_ 1204 0;
BA_ "DiagRequest" BO_ 1204 0;
BA_ "DiagResponse" BO_ 1204 0;
BA_ "GenMsgStartValue" BO_ 1204 "0";
BA_ "GenMsgStartDelayTime" BO_ 1204 0;
BA_ "GenMsgDelayTime" BO_ 1204 5;
BA_ "GenMsgNrOfRepetition" BO_ 1204 0;
BA_ "GenMsgCycleTime" BO_ 1204 200;
BA_ "GenMsgSendType" BO_ 1204 5;
    */
    _PN14_Stat_VAN_AR_Timebase =             c_tDBKomTimer_20ms;
    _PN14_Stat_VAN_AR_CycleCount =          200 / _PN14_Stat_VAN_AR_Timebase;
    _PN14_Stat_VAN_AR_StartDelay =            0 / _PN14_Stat_VAN_AR_Timebase;
    _PN14_Stat_VAN_AR_MinDelay =              5 / _PN14_Stat_VAN_AR_Timebase;
    _PN14_Stat_VAN_AR_Cnt = _PN14_Stat_VAN_AR_StartDelay;
    _PN14_Stat_VAN_AR_SpontanFlag = 0;
    _PN14_Stat_VAN_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_PN14_Stat_VAN_AR, _PN14_Stat_VAN_AR_StartDelay * _PN14_Stat_VAN_AR_Timebase );
    
    _mPN14_Stat_VAN_AR.LHC_SockVAN_Rq.phys = getValue( HMI_LHC_SockVAN_Rq );
    _mPN14_Stat_VAN_AR.PN14_AddBat_Rq.phys = getValue( HMI_PN14_AddBat_Rq );
    _mPN14_Stat_VAN_AR.PN14_AddBat_Volt.phys = getValue( HMI_PN14_AddBat_Volt );
    _mPN14_Stat_VAN_AR.PN14_GenCurr_VAN.phys = getValue( HMI_PN14_GenCurr_VAN );
    _mPN14_Stat_VAN_AR.PN14_PNV_State01.phys = getValue( HMI_PN14_PNV_State01 );
    _mPN14_Stat_VAN_AR.PN14_PNV_State02.phys = getValue( HMI_PN14_PNV_State02 );
    _mPN14_Stat_VAN_AR.PN14_PNV_State03.phys = getValue( HMI_PN14_PNV_State03 );
    _mPN14_Stat_VAN_AR.PN14_PNV_State04.phys = getValue( HMI_PN14_PNV_State04 );
    _mPN14_Stat_VAN_AR.PN14_PNV_State05.phys = getValue( HMI_PN14_PNV_State05 );
    _mPN14_Stat_VAN_AR.PN14_PNV_State06.phys = getValue( HMI_PN14_PNV_State06 );
	_mPN14_Stat_VAN_AR.PN14_PNV_State07.phys = getValue( HMI_PN14_PNV_State07 );
	_mPN14_Stat_VAN_AR.PN14_PNV_State08.phys = getValue( HMI_PN14_PNV_State08 );
	_mPN14_Stat_VAN_AR.PN14_PNV_State09.phys = getValue( HMI_PN14_PNV_State09 );
	_mPN14_Stat_VAN_AR.PN14_PNV_State10.phys = getValue( HMI_PN14_PNV_State10 );
	_mPN14_Stat_VAN_AR.PN14_PNV_State11.phys = getValue( HMI_PN14_PNV_State11 );
	_mPN14_Stat_VAN_AR.PN14_PNV_State12.phys = getValue( HMI_PN14_PNV_State12 );
	_mPN14_Stat_VAN_AR.PN14_PNV_State13.phys = getValue( HMI_PN14_PNV_State13 );
	_mPN14_Stat_VAN_AR.PN14_PNV_State14.phys = getValue( HMI_PN14_PNV_State14 );
	_mPN14_Stat_VAN_AR.PN14_PNV_State15.phys = getValue( HMI_PN14_PNV_State15 );
	_mPN14_Stat_VAN_AR.PN14_PNV_State16.phys = getValue( HMI_PN14_PNV_State16 );
}

void PN14_Stat_VAN_AR_output(void)
{
    output( _mPN14_Stat_VAN_AR );
}

PN14_Stat_VAN_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PN14_Stat_VAN_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PN14_Stat_VAN_AR := %X\n", getValue( HMI__STMSG_PN14_Stat_VAN_AR ) );            filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PN14_Stat_VAN_AR := %X\n", getValue( HMI__STMSGT_PN14_Stat_VAN_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LHC_SockVAN_Rq := %X\n", getValue( HMI_LHC_SockVAN_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_AddBat_Rq := %X\n", getValue( HMI_PN14_AddBat_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_AddBat_Volt := %X\n", getValue( HMI_PN14_AddBat_Volt ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_GenCurr_VAN := %X\n", getValue( HMI_PN14_GenCurr_VAN ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_PNV_State01 := %X\n", getValue( HMI_PN14_PNV_State01 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_PNV_State02 := %X\n", getValue( HMI_PN14_PNV_State02 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_PNV_State03 := %X\n", getValue( HMI_PN14_PNV_State03 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_PNV_State04 := %X\n", getValue( HMI_PN14_PNV_State04 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_PNV_State05 := %X\n", getValue( HMI_PN14_PNV_State05 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_PNV_State06 := %X\n", getValue( HMI_PN14_PNV_State06 ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_PNV_State07 := %X\n", getValue( HMI_PN14_PNV_State07 ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_PNV_State08 := %X\n", getValue( HMI_PN14_PNV_State08 ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_PNV_State09 := %X\n", getValue( HMI_PN14_PNV_State09 ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_PNV_State10 := %X\n", getValue( HMI_PN14_PNV_State10 ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_PNV_State11 := %X\n", getValue( HMI_PN14_PNV_State11 ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_PNV_State12 := %X\n", getValue( HMI_PN14_PNV_State12 ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_PNV_State13 := %X\n", getValue( HMI_PN14_PNV_State13 ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_PNV_State14 := %X\n", getValue( HMI_PN14_PNV_State14 ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_PNV_State15 := %X\n", getValue( HMI_PN14_PNV_State15 ) );    filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_PNV_State16 := %X\n", getValue( HMI_PN14_PNV_State16 ) );    filePutString ( buffer, elcount( buffer ), hFile );	
	
}

on timer _tPN14_Stat_VAN_AR
{
    putValue( HMI__STMSG_PN14_Stat_VAN_AR, 0 );
}

on EnvVar HMI__STMSG_PN14_Stat_VAN_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PN14_Stat_VAN_AR );
        if( tDelay > 0 )
            setTimer( _tPN14_Stat_VAN_AR, tDelay );
        else
            putValue( HMI__STMSG_PN14_Stat_VAN_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PN14_Stat_VAN_AR
{
    if( getValue( this ) )
        openPanel("PN14_Stat_VAN_AR");
}

on EnvVar HMI_LHC_SockVAN_Rq
{

   _mPN14_Stat_VAN_AR.LHC_SockVAN_Rq.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_AddBat_Rq
{

   _mPN14_Stat_VAN_AR.PN14_AddBat_Rq.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_AddBat_Volt
{

   _mPN14_Stat_VAN_AR.PN14_AddBat_Volt.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_GenCurr_VAN
{

   _mPN14_Stat_VAN_AR.PN14_GenCurr_VAN.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_PNV_State01
{

   _mPN14_Stat_VAN_AR.PN14_PNV_State01.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_PNV_State02
{

   _mPN14_Stat_VAN_AR.PN14_PNV_State02.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_PNV_State03
{

   _mPN14_Stat_VAN_AR.PN14_PNV_State03.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_PNV_State04
{

   _mPN14_Stat_VAN_AR.PN14_PNV_State04.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_PNV_State05
{

   _mPN14_Stat_VAN_AR.PN14_PNV_State05.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_PNV_State06
{

   _mPN14_Stat_VAN_AR.PN14_PNV_State06.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_PNV_State07
{

   _mPN14_Stat_VAN_AR.PN14_PNV_State07.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_PNV_State08
{

   _mPN14_Stat_VAN_AR.PN14_PNV_State08.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_PNV_State09
{

   _mPN14_Stat_VAN_AR.PN14_PNV_State09.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_PNV_State10
{

   _mPN14_Stat_VAN_AR.PN14_PNV_State10.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_PNV_State11
{

   _mPN14_Stat_VAN_AR.PN14_PNV_State11.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_PNV_State12
{

   _mPN14_Stat_VAN_AR.PN14_PNV_State12.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_PNV_State13
{

   _mPN14_Stat_VAN_AR.PN14_PNV_State13.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_PNV_State14
{

   _mPN14_Stat_VAN_AR.PN14_PNV_State14.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_PNV_State15
{

   _mPN14_Stat_VAN_AR.PN14_PNV_State15.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_PNV_State16
{

   _mPN14_Stat_VAN_AR.PN14_PNV_State16.phys = getValue(this);
    _PN14_Stat_VAN_AR_SpontanFlag = 1;
}

PN48_Bat_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_PN48_Bat_Stat_AR ) )
    {
    //  message   PN48_Bat_Stat_AR ID: 858 --- Sendeart cyclic --- 
        _PN48_Bat_Stat_AR_Cnt--;
        if( _PN48_Bat_Stat_AR_Cnt < 1 )
        {
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                PN48_Bat_Stat_AR_output();
                _PN48_Bat_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
            }
            _PN48_Bat_Stat_AR_Cnt = _PN48_Bat_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _PN48_Bat_Stat_AR_SpontanFlag)
        {
            {
                // Nachricht wg. spontaner �nderung ausgeben
                PN48_Bat_Stat_AR_output();
                _PN48_Bat_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
            }
        }
    }
}

PN48_Bat_Stat_AR_init()
{   /* Botschaft PN48_Bat_Stat_AR ID: 858 --- Sendeart 0 cyclic --- 
BA_ "ApplMessage" BO_ 858 0;
BA_ "NmAsrMessage" BO_ 858 0;
BA_ "GenMsgMinAcceptLength" BO_ 858 8;
BA_ "GenMsgILSupport" BO_ 858 1;
BA_ "DiagState" BO_ 858 0;
BA_ "DiagRequest" BO_ 858 0;
BA_ "DiagResponse" BO_ 858 0;
BA_ "GenMsgStartValue" BO_ 858 "0";
BA_ "GenMsgStartDelayTime" BO_ 858 280;
BA_ "GenMsgCycleTime" BO_ 858 500;
BA_ "GenMsgSendType" BO_ 858 0;
*/
    _PN48_Bat_Stat_AR_Timebase =             c_tDBKomTimer_5ms;
    _PN48_Bat_Stat_AR_CycleCount =        500 / _PN48_Bat_Stat_AR_Timebase;
    _PN48_Bat_Stat_AR_MinDelay =            0 / _PN48_Bat_Stat_AR_Timebase;
    _PN48_Bat_Stat_AR_StartDelay =        280 / _PN48_Bat_Stat_AR_Timebase;
    _PN48_Bat_Stat_AR_Cnt = _PN48_Bat_Stat_AR_MinDelay;
    _PN48_Bat_Stat_AR_SpontanFlag = 0;
    _PN48_Bat_Stat_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_PN48_Bat_Stat_AR, _PN48_Bat_Stat_AR_StartDelay * _PN48_Bat_Stat_AR_Timebase );

    _mPN48_Bat_Stat_AR.PN48_Bat_CellVolt_Max.phys = getValue( HMI_PN48_Bat_CellVolt_Max );
    _mPN48_Bat_Stat_AR.PN48_Bat_CellVolt_Min.phys = getValue( HMI_PN48_Bat_CellVolt_Min );
    _mPN48_Bat_Stat_AR.PN48_Bat_Curr.phys = getValue( HMI_PN48_Bat_Curr );
    _mPN48_Bat_Stat_AR.PN48_Bat_DynRes.phys = getValue( HMI_PN48_Bat_DynRes );
    _mPN48_Bat_Stat_AR.PN48_Bat_Temp.phys = getValue( HMI_PN48_Bat_Temp );
    _mPN48_Bat_Stat_AR.PN48_Bat_Volt.phys = getValue( HMI_PN48_Bat_Volt );
}

PN48_Bat_Stat_AR_output()
{
    output( _mPN48_Bat_Stat_AR );
}

PN48_Bat_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PN48_Bat_Stat_AR\n", 26, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PN48_Bat_Stat_AR := %X\n", getValue( HMI__STMSG_PN48_Bat_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PN48_Bat_Stat_AR := %X\n", getValue( HMI__STMSGT_PN48_Bat_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN48_Bat_CellVolt_Max := %X\n", getValue( HMI_PN48_Bat_CellVolt_Max ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN48_Bat_CellVolt_Min := %X\n", getValue( HMI_PN48_Bat_CellVolt_Min ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN48_Bat_Curr := %X\n", getValue( HMI_PN48_Bat_Curr ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN48_Bat_DynRes := %X\n", getValue( HMI_PN48_Bat_DynRes ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN48_Bat_Temp := %X\n", getValue( HMI_PN48_Bat_Temp ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN48_Bat_Volt := %X\n", getValue( HMI_PN48_Bat_Volt ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPN48_Bat_Stat_AR
{
    putValue( HMI__STMSG_PN48_Bat_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_PN48_Bat_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PN48_Bat_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tPN48_Bat_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_PN48_Bat_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PN48_Bat_Stat_AR
{
    if( getValue( this ) )
        openPanel("PN48_Bat_Stat_AR");
}

on EnvVar HMI_PN48_Bat_CellVolt_Max
{
    _mPN48_Bat_Stat_AR.PN48_Bat_CellVolt_Max.phys = getValue(this);
}

on EnvVar HMI_PN48_Bat_CellVolt_Min
{
    _mPN48_Bat_Stat_AR.PN48_Bat_CellVolt_Min.phys = getValue(this);
}

on EnvVar HMI_PN48_Bat_Curr
{
    _mPN48_Bat_Stat_AR.PN48_Bat_Curr.phys = getValue(this);
}

on EnvVar HMI_PN48_Bat_DynRes
{
    _mPN48_Bat_Stat_AR.PN48_Bat_DynRes.phys = getValue(this);
}

on EnvVar HMI_PN48_Bat_Temp
{
    _mPN48_Bat_Stat_AR.PN48_Bat_Temp.phys = getValue(this);
}

on EnvVar HMI_PN48_Bat_Volt
{
    _mPN48_Bat_Stat_AR.PN48_Bat_Volt.phys = getValue(this);
}

PN48_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_PN48_Disp_Rq_AR ) )
    {
    //  message   PN48_Disp_Rq_AR ID: 868 --- Sendeart cyclic --- 
        if( _PN48_Disp_Rq_AR_DelayCnt > 0) _PN48_Disp_Rq_AR_DelayCnt--; // Mindestsendeabstand
        _PN48_Disp_Rq_AR_Cnt--;
        if( _PN48_Disp_Rq_AR_Cnt < 1 )
        {
            if( _PN48_Disp_Rq_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                PN48_Disp_Rq_AR_output();
                _PN48_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _PN48_Disp_Rq_AR_DelayCnt = _PN48_Disp_Rq_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _PN48_Disp_Rq_AR_SpontanFlag = 1;
            }
            _PN48_Disp_Rq_AR_Cnt = _PN48_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _PN48_Disp_Rq_AR_SpontanFlag)
        {
            if( _PN48_Disp_Rq_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                PN48_Disp_Rq_AR_output();
                _PN48_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _PN48_Disp_Rq_AR_DelayCnt = _PN48_Disp_Rq_AR_MinDelay;
            }
        }
    }
}

PN48_Disp_Rq_AR_init()
{   /* Botschaft PN48_Disp_Rq_AR ID: 868 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 868 0;
BA_ "NmAsrMessage" BO_ 868 0;
BA_ "GenMsgMinAcceptLength" BO_ 868 8;
BA_ "GenMsgILSupport" BO_ 868 1;
BA_ "DiagState" BO_ 868 0;
BA_ "DiagRequest" BO_ 868 0;
BA_ "DiagResponse" BO_ 868 0;
BA_ "GenMsgStartValue" BO_ 868 "0";
BA_ "GenMsgDelayTime" BO_ 868 50;
BA_ "GenMsgNrOfRepetitions" BO_ 868 0;
BA_ "GenMsgCycleTime" BO_ 868 1000;
BA_ "GenMsgSendType" BO_ 868 5;
    */
    _PN48_Disp_Rq_AR_Timebase =             c_tDBKomTimer_5ms;
    _PN48_Disp_Rq_AR_CycleCount =       1000 / _PN48_Disp_Rq_AR_Timebase;
    _PN48_Disp_Rq_AR_MinDelay =           50 / _PN48_Disp_Rq_AR_Timebase;
    _PN48_Disp_Rq_AR_StartDelay =          0 / _PN48_Disp_Rq_AR_Timebase;
    _PN48_Disp_Rq_AR_Cnt = _PN48_Disp_Rq_AR_MinDelay;
    _PN48_Disp_Rq_AR_SpontanFlag = 0;
    _PN48_Disp_Rq_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_PN14_Stat_AR, _PN14_Stat_AR_StartDelay * _PN48_Disp_Rq_AR_Timebase );

    _mPN48_Disp_Rq_AR.PN48_Msg1_Disp_Rq.phys = getValue( HMI_PN48_Msg1_Disp_Rq );
    _mPN48_Disp_Rq_AR.PN48_Msg2_Disp_Rq.phys = getValue( HMI_PN48_Msg2_Disp_Rq );
    _mPN48_Disp_Rq_AR.PN48_Msg3_Disp_Rq.phys = getValue( HMI_PN48_Msg3_Disp_Rq );
}

PN48_Disp_Rq_AR_output()
{
    output( _mPN48_Disp_Rq_AR );
}

PN48_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PN48_Disp_Rq_AR\n", 26, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PN48_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_PN48_Disp_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PN48_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_PN48_Disp_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN48_Msg1_Disp_Rq := %X\n", getValue( HMI_PN48_Msg1_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN48_Msg2_Disp_Rq := %X\n", getValue( HMI_PN48_Msg2_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN48_Msg3_Disp_Rq := %X\n", getValue( HMI_PN48_Msg3_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPN48_Disp_Rq_AR
{
    putValue( HMI__STMSG_PN48_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_PN48_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PN48_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tPN48_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_PN48_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PN48_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("PN48_Disp_Rq_AR");
}

on EnvVar HMI_PN48_Msg1_Disp_Rq
{
    _mPN48_Disp_Rq_AR.PN48_Msg1_Disp_Rq.phys = getValue(this);
    _PN48_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN48_Msg2_Disp_Rq
{
    _mPN48_Disp_Rq_AR.PN48_Msg2_Disp_Rq.phys = getValue(this);
    _PN48_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN48_Msg3_Disp_Rq
{
    _mPN48_Disp_Rq_AR.PN48_Msg3_Disp_Rq.phys = getValue(this);
    _PN48_Disp_Rq_AR_SpontanFlag = 1;
}

PnHt_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_PnHt_Stat_AR ) )
    {
    //  message   PnHt_Stat_AR ID: 905 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _PnHt_Stat_AR_Cnt--;
        if( _PnHt_Stat_AR_Cnt < 1 )
        {
            PnHt_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _PnHt_Stat_AR_Cnt = _PnHt_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _PnHt_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _PnHt_Stat_AR_SpontanFlag)
        {
            PnHt_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _PnHt_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

PnHt_Stat_AR_init()
{   /* Botschaft PnHt_Stat_AR ID: 905 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 905 0;
BA_ "NmAsrMessage" BO_ 905 0;
BA_ "GenMsgMinAcceptLength" BO_ 905 2;
BA_ "GenMsgILSupport" BO_ 905 1;
BA_ "DiagState" BO_ 905 0;
BA_ "DiagRequest" BO_ 905 0;
BA_ "DiagResponse" BO_ 905 0;
BA_ "GenMsgStartValue" BO_ 905 "0";
BA_ "GenMsgDelayTime" BO_ 905 5;
BA_ "GenMsgNrOfRepetitions" BO_ 905 0;
BA_ "GenMsgCycleTime" BO_ 905 1000;
BA_ "GenMsgSendType" BO_ 905 5;
    */
    _PnHt_Stat_AR_Timebase =           c_tDBKomTimer_20ms;
    _PnHt_Stat_AR_CycleCount =       1000 / _PnHt_Stat_AR_Timebase;
    _PnHt_Stat_AR_StartDelay =          0 / _PnHt_Stat_AR_Timebase;
    _PnHt_Stat_AR_Cnt = _PnHt_Stat_AR_StartDelay;
    _PnHt_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_PnHt_Stat_AR, _PnHt_Stat_AR_StartDelay * _PnHt_Stat_AR_Timebase );

    _mPnHt_Stat_AR.PnHt_CenCnsl_Ft_Actv.phys = getValue( HMI_PnHt_CenCnsl_Ft_Actv );
    _mPnHt_Stat_AR.PnHt_CenCnsl_R_Actv.phys = getValue( HMI_PnHt_CenCnsl_R_Actv );
    _mPnHt_Stat_AR.PnHt_Door_FL_Actv.phys = getValue( HMI_PnHt_Door_FL_Actv );
    _mPnHt_Stat_AR.PnHt_Door_FR_Actv.phys = getValue( HMI_PnHt_Door_FR_Actv );
    _mPnHt_Stat_AR.PnHt_Door_RL_Actv.phys = getValue( HMI_PnHt_Door_RL_Actv );
    _mPnHt_Stat_AR.PnHt_Door_RR_Actv.phys = getValue( HMI_PnHt_Door_RR_Actv );
    _mPnHt_Stat_AR.PnHt_PreCond2_Actv.phys = getValue( HMI_PnHt_PreCond2_Actv );
}

PnHt_Stat_AR_output(void)
{
    output( _mPnHt_Stat_AR );
}

PnHt_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PnHt_Stat_AR\n", 26, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PnHt_Stat := %X\n", getValue( HMI__STMSG_PnHt_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PnHt_Stat := %X\n", getValue( HMI__STMSGT_PnHt_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PnHt_CenCnsl_Ft_Actv := %X\n", getValue( HMI_PnHt_CenCnsl_Ft_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PnHt_CenCnsl_R_Actv := %X\n", getValue( HMI_PnHt_CenCnsl_R_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PnHt_Door_FL_Actv := %X\n", getValue( HMI_PnHt_Door_FL_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PnHt_Door_FR_Actv := %X\n", getValue( HMI_PnHt_Door_FR_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PnHt_Door_RL_Actv := %X\n", getValue( HMI_PnHt_Door_RL_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PnHt_Door_RR_Actv := %X\n", getValue( HMI_PnHt_Door_RR_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PnHt_PreCond2_Actv := %X\n", getValue( HMI_PnHt_PreCond2_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPnHt_Stat_AR
{
    putValue( HMI__STMSG_PnHt_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_PnHt_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PnHt_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tPnHt_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_PnHt_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PnHt_Stat_AR
{
    if( getValue( this ) )
        openPanel("PnHt_Stat_AR");
}

on EnvVar HMI_PnHt_CenCnsl_Ft_Actv
{
    _mPnHt_Stat_AR.PnHt_CenCnsl_Ft_Actv.phys = getValue(this);
    _PnHt_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PnHt_CenCnsl_R_Actv
{
    _mPnHt_Stat_AR.PnHt_CenCnsl_R_Actv.phys = getValue(this);
    _PnHt_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PnHt_Door_FL_Actv
{
    _mPnHt_Stat_AR.PnHt_Door_FL_Actv.phys = getValue(this);
    _PnHt_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PnHt_Door_FR_Actv
{
    _mPnHt_Stat_AR.PnHt_Door_FR_Actv.phys = getValue(this);
    _PnHt_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PnHt_Door_RL_Actv
{
    _mPnHt_Stat_AR.PnHt_Door_RL_Actv.phys = getValue(this);
    _PnHt_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PnHt_Door_RR_Actv
{
    _mPnHt_Stat_AR.PnHt_Door_RR_Actv.phys = getValue(this);
    _PnHt_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PnHt_PreCond2_Actv
{
    _mPnHt_Stat_AR.PnHt_PreCond2_Actv.phys = getValue(this);
    _PnHt_Stat_AR_SpontanFlag = 1;
}

PNHV_Disp_Rq1_AR_check_output()
{
    if( !getValue( HMI__STMSG_PNHV_Disp_Rq1_AR ) )
    {
    //  message   PNHV_Disp_Rq1_AR ID: 692 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _PNHV_Disp_Rq1_AR_Cnt--;
        if( _PNHV_Disp_Rq1_AR_Cnt < 1 )
        {
            PNHV_Disp_Rq1_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _PNHV_Disp_Rq1_AR_Cnt = _PNHV_Disp_Rq1_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _PNHV_Disp_Rq1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _PNHV_Disp_Rq1_AR_SpontanFlag)
        {
            PNHV_Disp_Rq1_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _PNHV_Disp_Rq1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

PNHV_Disp_Rq1_AR_init()
{   /* Botschaft PNHV_Disp_Rq1_AR ID: 692 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 692 0;
BA_ "NmAsrMessage" BO_ 692 0;
BA_ "GenMsgMinAcceptLength" BO_ 692 8;
BA_ "GenMsgILSupport" BO_ 692 1;
BA_ "DiagState" BO_ 692 0;
BA_ "DiagRequest" BO_ 692 0;
BA_ "DiagResponse" BO_ 692 0;
BA_ "GenMsgStartValue" BO_ 692 "0";
BA_ "GenMsgDelayTime" BO_ 692 100;
BA_ "GenMsgNrOfRepetition" BO_ 692 0;
BA_ "GenMsgCycleTime" BO_ 692 1000;
BA_ "GenMsgSendType" BO_ 692 5;
    */
    _PNHV_Disp_Rq1_AR_Timebase =           c_tDBKomTimer_20ms;
    _PNHV_Disp_Rq1_AR_CycleCount =         1000 / _PNHV_Disp_Rq1_AR_Timebase;
    _PNHV_Disp_Rq1_AR_StartDelay =           0 / _PNHV_Disp_Rq1_AR_Timebase;
    _PNHV_Disp_Rq1_AR_Cnt = _PNHV_Disp_Rq1_AR_StartDelay;
    _PNHV_Disp_Rq1_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_PNHV_Disp_Rq1_AR, _PNHV_Disp_Rq1_AR_StartDelay *_PNHV_Disp_Rq1_AR_Timebase );

     
    _mPNHV_Disp_Rq1_AR.PNHV_ChrgPwr_Disp_Rq_V2.phys = getValue( HMI_PNHV_ChrgPwr_Disp_Rq_V2 );
    _mPNHV_Disp_Rq1_AR.PNHV_PwrMeter_PosPwrLmt_Perc_Disp_Rq.phys = getValue( HMI_PNHV_PwrMeter_PosPwrLmt_Perc_Disp_Rq );
	_mPNHV_Disp_Rq1_AR.PNHV_PwrMeter_RecupLmt_Perc_Disp_Rq.phys = getValue( HMI_PNHV_PwrMeter_RecupLmt_Perc_Disp_Rq );	
	_mPNHV_Disp_Rq1_AR.ChrgProgSel_Stat.phys = getValue( HMI_ChrgProgSel_Stat );
    _mPNHV_Disp_Rq1_AR.PNHV_PwrMeter_Color_Disp_Rq.phys = getValue( HMI_PNHV_PwrMeter_Color_Disp_Rq );
	_mPNHV_Disp_Rq1_AR.PNHV_Rcmnd_Spd_Marker_Disp_Rq.phys = getValue( HMI_PNHV_Rcmnd_Spd_Marker_Disp_Rq );
	_mPNHV_Disp_Rq1_AR.PNHV_Rcmnd_Spd_Ring_Disp_Rq.phys = getValue( HMI_PNHV_Rcmnd_Spd_Ring_Disp_Rq );
  _mPNHV_Disp_Rq1_AR.PNHV_ChrgSys_Chrg_Stat_Ind.phys = getValue( HMI_PNHV_ChrgSys_Chrg_Stat_Ind );
  _mPNHV_Disp_Rq1_AR.PNHV_ChrgSys_ErrEval_Icon_Disp_Rq.phys = getValue( HMI_PNHV_ChrgSys_ErrEval_Icon_Disp_Rq );
  _mPNHV_Disp_Rq1_AR.PNHV_ChrgSys_ErrEval_Msg_Disp_Rq.phys = getValue( HMI_PNHV_ChrgSys_ErrEval_Msg_Disp_Rq );
    _mPNHV_Disp_Rq1_AR.PNHV_EOD_Tm_Hour_Disp_Rq.phys = getValue( HMI_PNHV_EOD_Tm_Hour_Disp_Rq );
    _mPNHV_Disp_Rq1_AR.PNHV_EOD_Tm_Minute_Disp_Rq.phys = getValue( HMI_PNHV_EOD_Tm_Minute_Disp_Rq );
    _mPNHV_Disp_Rq1_AR.PNHV_EOD_Tm_WeekDay_Disp_Rq.phys = getValue( HMI_PNHV_EOD_Tm_WeekDay_Disp_Rq );
    _mPNHV_Disp_Rq1_AR.PNHV_ChrgSys_ErrEval_Msg_Disp_Rq.phys = getValue( HMI_PNHV_ChrgSys_ErrEval_Msg_Disp_Rq );
    _mPNHV_Disp_Rq1_AR.PN48_Msg1_Disp_Rq_CPC.phys = getValue( HMI_PN48_Msg1_Disp_Rq_CPC );
    _mPNHV_Disp_Rq1_AR.PN48_Msg3_Disp_Rq_CPC.phys = getValue( HMI_PN48_Msg3_Disp_Rq_CPC );
}

PNHV_Disp_Rq1_AR_output(void)
{
    output( _mPNHV_Disp_Rq1_AR );
}

PNHV_Disp_Rq1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PNHV_Disp_Rq1_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PNHV_Disp_Rq1_AR := %X\n", getValue( HMI__STMSG_PNHV_Disp_Rq1_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PNHV_Disp_Rq1_AR := %X\n", getValue( HMI__STMSGT_PNHV_Disp_Rq1_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ChrgPwr_Disp_Rq_V2 := %X\n", getValue( HMI_PNHV_ChrgPwr_Disp_Rq_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_PwrMeter_PosPwrLmt_Perc_Disp_Rq := %X\n", getValue( HMI_PNHV_PwrMeter_PosPwrLmt_Perc_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_PwrMeter_RecupLmt_Perc_Disp_Rq := %X\n", getValue( HMI_PNHV_PwrMeter_RecupLmt_Perc_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_ChrgProgSel_Stat := %X\n", getValue( HMI_ChrgProgSel_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_PwrMeter_Color_Disp_Rq := %X\n", getValue( HMI_PNHV_PwrMeter_Color_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_Rcmnd_Spd_Marker_Disp_Rq := %X\n", getValue( HMI_PNHV_Rcmnd_Spd_Marker_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_Rcmnd_Spd_Ring_Disp_Rq := %X\n", getValue( HMI_PNHV_Rcmnd_Spd_Ring_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ChrgSys_Chrg_Stat_Ind := %X\n", getValue( HMI_PNHV_ChrgSys_Chrg_Stat_Ind ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ChrgSys_ErrEval_Icon_Disp_Rq := %X\n", getValue( HMI_PNHV_ChrgSys_ErrEval_Icon_Disp_Rq ) ); filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ChrgSys_ErrEval_Msg_Disp_Rq := %X\n", getValue( HMI_PNHV_ChrgSys_ErrEval_Msg_Disp_Rq ) );   filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_EOD_Tm_Hour_Disp_Rq := %X\n", getValue( HMI_PNHV_EOD_Tm_Hour_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_EOD_Tm_Minute_Disp_Rq := %X\n", getValue( HMI_PNHV_EOD_Tm_Minute_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_EOD_Tm_WeekDay_Disp_Rq := %X\n", getValue( HMI_PNHV_EOD_Tm_WeekDay_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN48_Msg1_Disp_Rq_CPC := %X\n", getValue( HMI_PN48_Msg1_Disp_Rq_CPC ) );   filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN48_Msg3_Disp_Rq_CPC := %X\n", getValue( HMI_PN48_Msg3_Disp_Rq_CPC ) );   filePutString( buffer, elcount( buffer ), hFile );
  
}

on timer _tPNHV_Disp_Rq1_AR
{
    putValue( HMI__STMSG_PNHV_Disp_Rq1_AR, 0 );
}

on EnvVar HMI__STMSG_PNHV_Disp_Rq1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PNHV_Disp_Rq1_AR );
        if( tDelay > 0)    
            setTimer( _tPNHV_Disp_Rq1_AR, tDelay );
        else
            putValue( HMI__STMSG_PNHV_Disp_Rq1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PNHV_Disp_Rq1_AR
{
    if( getValue( this ) )
        openPanel("PNHV_Disp_Rq1_AR");
}

on EnvVar HMI_PNHV_ChrgPwr_Disp_Rq_V2
{
    _mPNHV_Disp_Rq1_AR.PNHV_ChrgPwr_Disp_Rq_V2.phys = getValue(this);
    _PNHV_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_PwrMeter_PosPwrLmt_Perc_Disp_Rq
{
    _mPNHV_Disp_Rq1_AR.PNHV_PwrMeter_PosPwrLmt_Perc_Disp_Rq.phys = getValue(this);
    _PNHV_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_PwrMeter_RecupLmt_Perc_Disp_Rq
{
    _mPNHV_Disp_Rq1_AR.PNHV_PwrMeter_RecupLmt_Perc_Disp_Rq.phys = getValue(this);
    _PNHV_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_ChrgProgSel_Stat
{
    _mPNHV_Disp_Rq1_AR.ChrgProgSel_Stat.phys = getValue(this);
    _PNHV_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_PwrMeter_Color_Disp_Rq
{
    _mPNHV_Disp_Rq1_AR.PNHV_PwrMeter_Color_Disp_Rq.phys = getValue(this);
    _PNHV_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_Rcmnd_Spd_Marker_Disp_Rq
{
    _mPNHV_Disp_Rq1_AR.PNHV_Rcmnd_Spd_Marker_Disp_Rq.phys = getValue(this);
    _PNHV_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_Rcmnd_Spd_Ring_Disp_Rq
{
    _mPNHV_Disp_Rq1_AR.PNHV_Rcmnd_Spd_Ring_Disp_Rq.phys = getValue(this);
    _PNHV_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_ChrgSys_Chrg_Stat_Ind
{
    _mPNHV_Disp_Rq1_AR.PNHV_ChrgSys_Chrg_Stat_Ind.phys = getValue(this);
    _PNHV_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_ChrgSys_ErrEval_Icon_Disp_Rq
{
    _mPNHV_Disp_Rq1_AR.PNHV_ChrgSys_ErrEval_Icon_Disp_Rq.phys = getValue(this);
    _PNHV_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_ChrgSys_ErrEval_Msg_Disp_Rq
{
    _mPNHV_Disp_Rq1_AR.PNHV_ChrgSys_ErrEval_Msg_Disp_Rq.phys = getValue(this);
    _PNHV_Disp_Rq1_AR_SpontanFlag = 1;
}
on EnvVar HMI_PNHV_EOD_Tm_Hour_Disp_Rq
{
    _mPNHV_Disp_Rq1_AR.PNHV_EOD_Tm_Hour_Disp_Rq.phys = getValue(this);
    _PNHV_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_EOD_Tm_Minute_Disp_Rq
{
    _mPNHV_Disp_Rq1_AR.PNHV_EOD_Tm_Minute_Disp_Rq.phys = getValue(this);
    _PNHV_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_EOD_Tm_WeekDay_Disp_Rq
{
    _mPNHV_Disp_Rq1_AR.PNHV_EOD_Tm_WeekDay_Disp_Rq.phys = getValue(this);
    _PNHV_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN48_Msg1_Disp_Rq_CPC
{
    _mPNHV_Disp_Rq1_AR.PN48_Msg1_Disp_Rq_CPC.phys = getValue(this);
    _PNHV_Disp_Rq1_AR_SpontanFlag = 1;
}

	on EnvVar HMI_PN48_Msg3_Disp_Rq_CPC
{
    _mPNHV_Disp_Rq1_AR.PN48_Msg3_Disp_Rq_CPC.phys = getValue(this);
    _PNHV_Disp_Rq1_AR_SpontanFlag = 1;
}
	
void PNHV_Energy_Rq_AR_Activity(int active )
{
    if( active )
    {
        if( _PNHV_Energy_Rq_AR_SigActivity == 0)
            _PNHV_Energy_Rq_AR_Cnt = 1;
        _PNHV_Energy_Rq_AR_SigActivity++;
    }
    else
    {
        _PNHV_Energy_Rq_AR_SigActivity--;
    }
}

int PNHV_Energy_Rq_AR_Change(int lastValue, int sigValue, int inActValue )
{
    bActiveHelper = (sigValue != inActValue );
      if( !lastValue && bActiveHelper )
        PNHV_Energy_Rq_AR_Activity( 1 );
      else if( lastValue && !bActiveHelper )
        PNHV_Energy_Rq_AR_Activity(0 );
    return bActiveHelper;
}

PNHV_Energy_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_PNHV_Energy_Rq_AR ) )
    {
    //  message   PNHV_Energy_Rq_AR ID: 618 --- Sendeart 8 cyclicIfActiveFast --- 
        _PNHV_Energy_Rq_AR_Cnt--;
        if( _PNHV_Energy_Rq_AR_Cnt < 1 )
        {
            PNHV_Energy_Rq_AR_output(); // Zyklus abgelaufen, Nachricht senden
            _PNHV_Energy_Rq_AR_Cnt = _PNHV_Energy_Rq_AR_SigActivity ? _PNHV_Energy_Rq_AR_CycleCountFast : _PNHV_Energy_Rq_AR_CycleCountSlow;
        }
    }
}

PNHV_Energy_Rq_AR_init()
{   /* Botschaft PNHV_Energy_Rq_AR ID: 618 --- Sendeart 8 cyclicIfActiveFast --- 
BA_ "ApplMessage" BO_ 618 0;
BA_ "NmAsrMessage" BO_ 618 0;
BA_ "GenMsgMinAcceptLength" BO_ 618 8;
BA_ "GenMsgILSupport" BO_ 618 1;
BA_ "DiagState" BO_ 618 0;
BA_ "DiagRequest" BO_ 618 0;
BA_ "DiagResponse" BO_ 618 0;
BA_ "GenMsgStartValue" BO_ 618 "0";
BA_ "GenMsgDelayTime" BO_ 618 5;
BA_ "GenMsgCycleTime" BO_ 618 2000;
BA_ "GenMsgCycleTimeActive" BO_ 618 200;
BA_ "GenMsgSendType" BO_ 618 8;
    */
    _PNHV_Energy_Rq_AR_Timebase =                 c_tDBKomTimer_5ms;
    _PNHV_Energy_Rq_AR_CycleCountSlow =         2000 / _PNHV_Energy_Rq_AR_Timebase;
    _PNHV_Energy_Rq_AR_CycleCountFast =          200 / _PNHV_Energy_Rq_AR_Timebase;
    _PNHV_Energy_Rq_AR_StartDelay =                0 / _PNHV_Energy_Rq_AR_Timebase;
    _PNHV_Energy_Rq_AR_Cnt = _PNHV_Energy_Rq_AR_StartDelay;
    _PNHV_Energy_Rq_AR_SigActivity = 0;

    putValue( HMI__STMSGSD_PNHV_Energy_Rq_AR, _PNHV_Energy_Rq_AR_StartDelay * _PNHV_Energy_Rq_AR_Timebase );
    putValue( HMI__STMSGCT_PNHV_Energy_Rq_AR, _PNHV_Energy_Rq_AR_CycleCountSlow * _PNHV_Energy_Rq_AR_Timebase );

    _mPNHV_Energy_Rq_AR.PNHV_ActChrgOprtn_DistPred.phys = getValue( HMI_PNHV_ActChrgOprtn_DistPred );                  _PNHV_Energy_Rq_AR_PNHV_ActChrgOprtn_DistPred_LastState = PNHV_Energy_Rq_AR_Change( _PNHV_Energy_Rq_AR_PNHV_ActChrgOprtn_DistPred_LastState, _mPNHV_Energy_Rq_AR.PNHV_ActChrgOprtn_DistPred, 0 );
    _mPNHV_Energy_Rq_AR.PNHV_ActChrgOprtn_DistPred_V2.phys = getValue( HMI_PNHV_ActChrgOprtn_DistPred_V2 );                  _PNHV_Energy_Rq_AR_PNHV_ActChrgOprtn_DistPred_V2_LastState = PNHV_Energy_Rq_AR_Change( _PNHV_Energy_Rq_AR_PNHV_ActChrgOprtn_DistPred_V2_LastState, _mPNHV_Energy_Rq_AR.PNHV_ActChrgOprtn_DistPred_V2, 0 );
    _mPNHV_Energy_Rq_AR.PNHV_Dist_ActSOC.phys = getValue( HMI_PNHV_Dist_ActSOC );                  _PNHV_Energy_Rq_AR_PNHV_Dist_ActSOC_LastState = PNHV_Energy_Rq_AR_Change( _PNHV_Energy_Rq_AR_PNHV_Dist_ActSOC_LastState, _mPNHV_Energy_Rq_AR.PNHV_Dist_ActSOC, 0 );
    _mPNHV_Energy_Rq_AR.PNHV_Dist_ActSOC_V2.phys = getValue( HMI_PNHV_Dist_ActSOC_V2 );                  _PNHV_Energy_Rq_AR_PNHV_Dist_ActSOC_V2_LastState = PNHV_Energy_Rq_AR_Change( _PNHV_Energy_Rq_AR_PNHV_Dist_ActSOC_V2_LastState, _mPNHV_Energy_Rq_AR.PNHV_Dist_ActSOC_V2, 0 );
    _mPNHV_Energy_Rq_AR.PNHV_Pred_EnergyAmnt.phys = getValue( HMI_PNHV_Pred_EnergyAmnt );                  _PNHV_Energy_Rq_AR_PNHV_Pred_EnergyAmnt_LastState = PNHV_Energy_Rq_AR_Change( _PNHV_Energy_Rq_AR_PNHV_Pred_EnergyAmnt_LastState, _mPNHV_Energy_Rq_AR.PNHV_Pred_EnergyAmnt, 0 );
    _mPNHV_Energy_Rq_AR.PNHV_SCC_Actn_Rq.phys = getValue( HMI_PNHV_SCC_Actn_Rq );                  _PNHV_Energy_Rq_AR_PNHV_SCC_Actn_Rq_LastState = PNHV_Energy_Rq_AR_Change( _PNHV_Energy_Rq_AR_PNHV_SCC_Actn_Rq_LastState, _mPNHV_Energy_Rq_AR.PNHV_SCC_Actn_Rq, 0 );
    _mPNHV_Energy_Rq_AR.SCC_Restart_Trgr.phys = getValue( HMI_SCC_Restart_Trgr );                  _PNHV_Energy_Rq_AR_SCC_Restart_Trgr_LastState = PNHV_Energy_Rq_AR_Change( _PNHV_Energy_Rq_AR_SCC_Restart_Trgr_LastState, _mPNHV_Energy_Rq_AR.SCC_Restart_Trgr, 0 );
    _mPNHV_Energy_Rq_AR.TC_ElecEnergyLvl_Min_50.phys = getValue( HMI_TC_ElecEnergyLvl_Min_50_PNHV_Energy_Rq_AR );                  _PNHV_Energy_Rq_AR_TC_ElecEnergyLvl_Min_50_LastState = PNHV_Energy_Rq_AR_Change( _PNHV_Energy_Rq_AR_TC_ElecEnergyLvl_Min_50_LastState, _mPNHV_Energy_Rq_AR.TC_ElecEnergyLvl_Min_50, 0 );
}

PNHV_Energy_Rq_AR_output(void)
{
    output( _mPNHV_Energy_Rq_AR );
}

PNHV_Energy_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PNHV_Energy_Rq_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PNHV_Energy_Rq_AR := %X\n", getValue( HMI__STMSG_PNHV_Energy_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PNHV_Energy_Rq_AR := %X\n", getValue( HMI__STMSGT_PNHV_Energy_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ActChrgOprtn_DistPred := %X\n", getValue( HMI_PNHV_ActChrgOprtn_DistPred ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ActChrgOprtn_DistPred_V2 := %X\n", getValue( HMI_PNHV_ActChrgOprtn_DistPred_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_Dist_ActSOC := %X\n", getValue( HMI_PNHV_Dist_ActSOC ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_Dist_ActSOC_V2 := %X\n", getValue( HMI_PNHV_Dist_ActSOC_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_Pred_EnergyAmnt := %X\n", getValue( HMI_PNHV_Pred_EnergyAmnt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_SCC_Actn_Rq := %X\n", getValue( HMI_PNHV_SCC_Actn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SCC_Restart_Trgr := %X\n", getValue( HMI_SCC_Restart_Trgr ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_ElecEnergyLvl_Min_50 := %X\n", getValue( HMI_TC_ElecEnergyLvl_Min_50_PNHV_Energy_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPNHV_Energy_Rq_AR
{
    putValue( HMI__STMSG_PNHV_Energy_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_PNHV_Energy_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PNHV_Energy_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tPNHV_Energy_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_PNHV_Energy_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PNHV_Energy_Rq_AR
{
    if( getValue( this ) )
        openPanel("PNHV_Energy_Rq_AR");
}


on EnvVar HMI__ALLDEF_PNHV_Energy_Rq_AR
{
    if( getValue(this) )
    {
        // alle signale auf default einstellen
        putValue( HMI_PNHV_ActChrgOprtn_DistPred, 0 );
        putValue( HMI_PNHV_ActChrgOprtn_DistPred_V2, 0 );
        putValue( HMI_PNHV_Dist_ActSOC, 0 );
        putValue( HMI_PNHV_Dist_ActSOC_V2, 0 );
        putValue( HMI_PNHV_Pred_EnergyAmnt, 0 );
        putValue( HMI_PNHV_SCC_Actn_Rq, 0 );
        putValue( HMI_SCC_Restart_Trgr, 0 );
        putValue( HMI_TC_ElecEnergyLvl_Min_50_PNHV_Energy_Rq_AR, 0 );
    }
}

on EnvVar HMI__STMSGCT_PNHV_Energy_Rq_AR
{
    if( getValue( this ) > 0 )
    {
        _PNHV_Energy_Rq_AR_CycleCountSlow = getValue( this ) / _PNHV_Energy_Rq_AR_Timebase;     // set cycle counter to initial value
 //       _PNHV_Energy_Rq_AR_SpontanFlag = 1;
    }
}

on EnvVar HMI_PNHV_ActChrgOprtn_DistPred
{
    _mPNHV_Energy_Rq_AR.PNHV_ActChrgOprtn_DistPred.phys = getValue(this);
    _PNHV_Energy_Rq_AR_PNHV_ActChrgOprtn_DistPred_LastState = PNHV_Energy_Rq_AR_Change( _PNHV_Energy_Rq_AR_PNHV_ActChrgOprtn_DistPred_LastState, _mPNHV_Energy_Rq_AR.PNHV_ActChrgOprtn_DistPred, 0 );
}

on EnvVar HMI_PNHV_ActChrgOprtn_DistPred_V2
{
    _mPNHV_Energy_Rq_AR.PNHV_ActChrgOprtn_DistPred_V2.phys = getValue(this);
    _PNHV_Energy_Rq_AR_PNHV_ActChrgOprtn_DistPred_V2_LastState = PNHV_Energy_Rq_AR_Change( _PNHV_Energy_Rq_AR_PNHV_ActChrgOprtn_DistPred_V2_LastState, _mPNHV_Energy_Rq_AR.PNHV_ActChrgOprtn_DistPred_V2, 0 );
}

on EnvVar HMI_PNHV_Dist_ActSOC
{
    _mPNHV_Energy_Rq_AR.PNHV_Dist_ActSOC.phys = getValue(this);
    _PNHV_Energy_Rq_AR_PNHV_Dist_ActSOC_LastState = PNHV_Energy_Rq_AR_Change( _PNHV_Energy_Rq_AR_PNHV_Dist_ActSOC_LastState, _mPNHV_Energy_Rq_AR.PNHV_Dist_ActSOC, 0 );
}

on EnvVar HMI_PNHV_Dist_ActSOC_V2
{
    _mPNHV_Energy_Rq_AR.PNHV_Dist_ActSOC_V2.phys = getValue(this);
    _PNHV_Energy_Rq_AR_PNHV_Dist_ActSOC_V2_LastState = PNHV_Energy_Rq_AR_Change( _PNHV_Energy_Rq_AR_PNHV_Dist_ActSOC_V2_LastState, _mPNHV_Energy_Rq_AR.PNHV_Dist_ActSOC_V2, 0 );
}

on EnvVar HMI_PNHV_Pred_EnergyAmnt
{
    _mPNHV_Energy_Rq_AR.PNHV_Pred_EnergyAmnt.phys = getValue(this);
    _PNHV_Energy_Rq_AR_PNHV_Pred_EnergyAmnt_LastState = PNHV_Energy_Rq_AR_Change( _PNHV_Energy_Rq_AR_PNHV_Pred_EnergyAmnt_LastState, _mPNHV_Energy_Rq_AR.PNHV_Pred_EnergyAmnt, 0 );
}

on EnvVar HMI_PNHV_SCC_Actn_Rq
{
    _mPNHV_Energy_Rq_AR.PNHV_SCC_Actn_Rq.phys = getValue(this);
    _PNHV_Energy_Rq_AR_PNHV_SCC_Actn_Rq_LastState = PNHV_Energy_Rq_AR_Change( _PNHV_Energy_Rq_AR_PNHV_SCC_Actn_Rq_LastState, _mPNHV_Energy_Rq_AR.PNHV_SCC_Actn_Rq, 0 );
}

on EnvVar HMI_SCC_Restart_Trgr
{
    _mPNHV_Energy_Rq_AR.SCC_Restart_Trgr.phys = getValue(this);
    _PNHV_Energy_Rq_AR_SCC_Restart_Trgr_LastState = PNHV_Energy_Rq_AR_Change( _PNHV_Energy_Rq_AR_SCC_Restart_Trgr_LastState, _mPNHV_Energy_Rq_AR.SCC_Restart_Trgr, 0 );
}

on EnvVar HMI_TC_ElecEnergyLvl_Min_50_PNHV_Energy_Rq_AR
{
    _mPNHV_Energy_Rq_AR.TC_ElecEnergyLvl_Min_50.phys = getValue(this);
    _PNHV_Energy_Rq_AR_TC_ElecEnergyLvl_Min_50_LastState = PNHV_Energy_Rq_AR_Change( _PNHV_Energy_Rq_AR_TC_ElecEnergyLvl_Min_50_LastState, _mPNHV_Energy_Rq_AR.TC_ElecEnergyLvl_Min_50, 0 );
}

PNHV_EnergyMngmnt_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_PNHV_EnergyMngmnt_Disp_Rq_AR ) )
    {
    //  message   PNHV_EnergyMngmnt_Disp_Rq_AR ID: 1061 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _PNHV_EnergyMngmnt_Disp_Rq_AR_Cnt--;
        if( _PNHV_EnergyMngmnt_Disp_Rq_AR_Cnt < 1 )
        {
            PNHV_EnergyMngmnt_Disp_Rq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _PNHV_EnergyMngmnt_Disp_Rq_AR_Cnt = _PNHV_EnergyMngmnt_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag)
        {
            PNHV_EnergyMngmnt_Disp_Rq_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

PNHV_EnergyMngmnt_Disp_Rq_AR_init()
{   /* Botschaft PNHV_EnergyMngmnt_Disp_Rq_AR ID: 1061 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1061 0;
BA_ "NmAsrMessage" BO_ 1061 0;
BA_ "GenMsgMinAcceptLength" BO_ 1061 8;
BA_ "GenMsgILSupport" BO_ 1061 1;
BA_ "DiagState" BO_ 1061 0;
BA_ "DiagRequest" BO_ 1061 0;
BA_ "DiagResponse" BO_ 1061 0;
BA_ "GenMsgStartValue" BO_ 1061 "0";
BA_ "GenMsgDelayTime" BO_ 1061 100;
BA_ "GenMsgNrOfRepetition" BO_ 1061 0;
BA_ "GenMsgCycleTime" BO_ 1061 1000;
BA_ "GenMsgSendType" BO_ 1061 5;
    */
    _PNHV_EnergyMngmnt_Disp_Rq_AR_Timebase =           c_tDBKomTimer_20ms;
    _PNHV_EnergyMngmnt_Disp_Rq_AR_CycleCount =         100 / _PNHV_EnergyMngmnt_Disp_Rq_AR_Timebase;
    _PNHV_EnergyMngmnt_Disp_Rq_AR_StartDelay =           0 / _PNHV_EnergyMngmnt_Disp_Rq_AR_Timebase;
    _PNHV_EnergyMngmnt_Disp_Rq_AR_Cnt = _PNHV_EnergyMngmnt_Disp_Rq_AR_StartDelay;
    _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_PNHV_EnergyMngmnt_Disp_Rq_AR, _PNHV_EnergyMngmnt_Disp_Rq_AR_StartDelay *_PNHV_EnergyMngmnt_Disp_Rq_AR_Timebase );

    _mPNHV_EnergyMngmnt_Disp_Rq_AR.EMM_MaxSOC_Disp_On_Rq.phys = getValue( HMI_EMM_MaxSOC_Disp_On_Rq );
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.EMM_MaxSOC_Disp_Rq.phys = getValue( HMI_EMM_MaxSOC_Disp_Rq );
	  _mPNHV_EnergyMngmnt_Disp_Rq_AR.EMM_MaxSOC_LwrLmt_Rq.phys = getValue( HMI_EMM_MaxSOC_LwrLmt_Rq );
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_ChrgEnergyFlow_Disp_Rq.phys = getValue( HMI_PNHV_ChrgEnergyFlow_Disp_Rq );
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_ChrgFlap_Opn_Disp_Rq.phys = getValue( HMI_PNHV_ChrgFlap_Opn_Disp_Rq );
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_ChrgIcon_Disp_Rq.phys = getValue( HMI_PNHV_ChrgIcon_Disp_Rq );
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_ChrgPwr_Disp_Rq.phys = getValue( HMI_PNHV_ChrgPwr_Disp_Rq );
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_ChrgSrc_Type_Disp_Rq.phys = getValue( HMI_PNHV_ChrgSrc_Type_Disp_Rq );
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_ChrgStatInfo_Disp_Rq.phys = getValue( HMI_PNHV_ChrgStatInfo_Disp_Rq );
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_ConChrgPlug_MsgDisp_Rq.phys = getValue( HMI_PNHV_ConChrgPlug_MsgDisp_Rq );
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_EOC_Tm_Hour_Disp_Rq.phys = getValue( HMI_PNHV_EOC_Tm_Hour_Disp_Rq );
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_EOC_Tm_Minute_Disp_Rq.phys = getValue( HMI_PNHV_EOC_Tm_Minute_Disp_Rq );
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_EOC_Tm_WeekDay_Disp_Rq.phys = getValue( HMI_PNHV_EOC_Tm_WeekDay_Disp_Rq );
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_IC_Disp_On_Rq.phys = getValue( HMI_PNHV_IC_Disp_On_Rq );
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_ChrgSys_ErrEval.phys = getValue( HMI_PNHV_ChrgSys_ErrEval );
}

PNHV_EnergyMngmnt_Disp_Rq_AR_output(void)
{
    output( _mPNHV_EnergyMngmnt_Disp_Rq_AR );
}

PNHV_EnergyMngmnt_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PNHV_EnergyMngmnt_Disp_Rq_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PNHV_EnergyMngmnt_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_PNHV_EnergyMngmnt_Disp_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PNHV_EnergyMngmnt_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_PNHV_EnergyMngmnt_Disp_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EMM_MaxSOC_Disp_On_Rq := %X\n", getValue( HMI_EMM_MaxSOC_Disp_On_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EMM_MaxSOC_Disp_Rq := %X\n", getValue( HMI_EMM_MaxSOC_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EMM_MaxSOC_LwrLmt_Rq := %X\n", getValue( HMI_EMM_MaxSOC_LwrLmt_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ChrgEnergyFlow_Disp_Rq := %X\n", getValue( HMI_PNHV_ChrgEnergyFlow_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ChrgFlap_Opn_Disp_Rq := %X\n", getValue( HMI_PNHV_ChrgFlap_Opn_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ChrgIcon_Disp_Rq := %X\n", getValue( HMI_PNHV_ChrgIcon_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ChrgPwr_Disp_Rq := %X\n", getValue( HMI_PNHV_ChrgPwr_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ChrgSrc_Type_Disp_Rq := %X\n", getValue( HMI_PNHV_ChrgSrc_Type_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ChrgStatInfo_Disp_Rq := %X\n", getValue( HMI_PNHV_ChrgStatInfo_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ConChrgPlug_MsgDisp_Rq := %X\n", getValue( HMI_PNHV_ConChrgPlug_MsgDisp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_EOC_Tm_Hour_Disp_Rq := %X\n", getValue( HMI_PNHV_EOC_Tm_Hour_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_EOC_Tm_Minute_Disp_Rq := %X\n", getValue( HMI_PNHV_EOC_Tm_Minute_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_EOC_Tm_WeekDay_Disp_Rq := %X\n", getValue( HMI_PNHV_EOC_Tm_WeekDay_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_IC_Disp_On_Rq := %X\n", getValue( HMI_PNHV_IC_Disp_On_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ChrgSys_ErrEval := %X\n", getValue( HMI_PNHV_ChrgSys_ErrEval ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPNHV_EnergyMngmnt_Disp_Rq_AR
{
    putValue( HMI__STMSG_PNHV_EnergyMngmnt_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_PNHV_EnergyMngmnt_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PNHV_EnergyMngmnt_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tPNHV_EnergyMngmnt_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_PNHV_EnergyMngmnt_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PNHV_EnergyMngmnt_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("PNHV_EnergyMngmnt_Disp_Rq_AR");
}

on EnvVar HMI_EMM_MaxSOC_Disp_On_Rq
{
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.EMM_MaxSOC_Disp_On_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EMM_MaxSOC_Disp_Rq
{
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.EMM_MaxSOC_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EMM_MaxSOC_LwrLmt_Rq
{
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.EMM_MaxSOC_LwrLmt_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_ChrgEnergyFlow_Disp_Rq
{
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_ChrgEnergyFlow_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_ChrgFlap_Opn_Disp_Rq
{
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_ChrgFlap_Opn_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_ChrgIcon_Disp_Rq
{
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_ChrgIcon_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_ChrgPwr_Disp_Rq
{
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_ChrgPwr_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_ChrgSrc_Type_Disp_Rq
{
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_ChrgSrc_Type_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_ChrgStatInfo_Disp_Rq
{
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_ChrgStatInfo_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_ConChrgPlug_MsgDisp_Rq
{
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_ConChrgPlug_MsgDisp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_EOC_Tm_Hour_Disp_Rq
{
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_EOC_Tm_Hour_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_EOC_Tm_Minute_Disp_Rq
{
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_EOC_Tm_Minute_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_EOC_Tm_WeekDay_Disp_Rq
{
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_EOC_Tm_WeekDay_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag = 1;
}


on EnvVar HMI_PNHV_IC_Disp_On_Rq
{
    
    
    if( ( getValue( HMI__STMSG_PNHV_EnergyMngmnt_Disp_Rq_AR ) == 1)) // TO on panel is active
    {
		//do nothing
		if(_mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_IC_Disp_On_Rq.phys == 0)
		{
			_ReleaseCommRequest( cPnhvIcDispNmRequest );//make sure commReq is released
		}
    }
    else	//there is no TO
    {
		_mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_IC_Disp_On_Rq.phys = getValue(this);
		
        if( (_mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_IC_Disp_On_Rq.phys == 1)  && (getValue( HMI__NM_EIS_AutomaticModeActive ) == 1) )
        {
			_SetCommRequest( cPnhvIcDispNmRequest );    
			setTimer( t_PnhvIcDispNmCancelTimer, c_NMCancelTimer_120sec ); // 120 seconds for auto-shut-off	
        }
			
		
		_PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag = 1;
        
    }
    
}



on EnvVar HMI_PNHV_ChrgSys_ErrEval
{
    _mPNHV_EnergyMngmnt_Disp_Rq_AR.PNHV_ChrgSys_ErrEval.phys = getValue(this);
    _PNHV_EnergyMngmnt_Disp_Rq_AR_SpontanFlag = 1;
}

PNHV_EnergyMngmnt_Stat2_AR_check_output()
{
    if( !getValue( HMI__STMSG_PNHV_EnergyMngmnt_Stat2_AR ) )
    {
    //  message   PNHV_EnergyMngmnt_Stat2_AR ID: 339 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _PNHV_EnergyMngmnt_Stat2_AR_Cnt--;
        if( _PNHV_EnergyMngmnt_Stat2_AR_Cnt < 1 )
        {
            PNHV_EnergyMngmnt_Stat2_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _PNHV_EnergyMngmnt_Stat2_AR_Cnt = _PNHV_EnergyMngmnt_Stat2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag)
        {
            PNHV_EnergyMngmnt_Stat2_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

PNHV_EnergyMngmnt_Stat2_AR_init()
{   /* Botschaft PNHV_EnergyMngmnt_Stat2_AR ID: 339 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 339 0;
BA_ "NmAsrMessage" BO_ 339 0;
BA_ "GenMsgMinAcceptLength" BO_ 339 8;
BA_ "GenMsgILSupport" BO_ 339 1;
BA_ "DiagState" BO_ 339 0;
BA_ "DiagRequest" BO_ 339 0;
BA_ "DiagResponse" BO_ 339 0;
BA_ "GenMsgStartValue" BO_ 339 "0";
BA_ "GenMsgDelayTime" BO_ 339 10;
BA_ "GenMsgNrOfRepetitions" BO_ 339 0;
BA_ "GenMsgCycleTime" BO_ 339 100;
BA_ "GenMsgSendType" BO_ 339 5;
    */
    _PNHV_EnergyMngmnt_Stat2_AR_Timebase =           c_tDBKomTimer_20ms;
    _PNHV_EnergyMngmnt_Stat2_AR_CycleCount =         100 / _PNHV_EnergyMngmnt_Stat2_AR_Timebase;
    _PNHV_EnergyMngmnt_Stat2_AR_StartDelay =           0 / _PNHV_EnergyMngmnt_Stat2_AR_Timebase;
    _PNHV_EnergyMngmnt_Stat2_AR_Cnt = _PNHV_EnergyMngmnt_Stat2_AR_StartDelay;
    _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_PNHV_EnergyMngmnt_Stat2_AR, _PNHV_EnergyMngmnt_Stat2_AR_StartDelay *_PNHV_EnergyMngmnt_Stat2_AR_Timebase );

    _mPNHV_EnergyMngmnt_Stat2_AR.DCDC_PNHV_GrndStrpFlt_Disp_Rq.phys = getValue( HMI_DCDC_PNHV_GrndStrpFlt_Disp_Rq );
    _mPNHV_EnergyMngmnt_Stat2_AR.EAC_MaxCurr.phys = getValue( HMI_EAC_MaxCurr );
    _mPNHV_EnergyMngmnt_Stat2_AR.EAC_MinVolt_V2.phys = getValue( HMI_EAC_MinVolt_V2 );
    _mPNHV_EnergyMngmnt_Stat2_AR.EMM_PosnInfo_Disp_Rq.phys = getValue( HMI_EMM_PosnInfo_Disp_Rq );
    _mPNHV_EnergyMngmnt_Stat2_AR.EMM_PosnTxt_Disp_Rq.phys = getValue( HMI_EMM_PosnTxt_Disp_Rq );
    _mPNHV_EnergyMngmnt_Stat2_AR.EMM_WPT_ManSet_Stat.phys = getValue( HMI_EMM_WPT_ManSet_Stat );
    _mPNHV_EnergyMngmnt_Stat2_AR.EMM_WPT_WLAN_Off_Rsn.phys = getValue( HMI_EMM_WPT_WLAN_Off_Rsn );
    _mPNHV_EnergyMngmnt_Stat2_AR.PNHV_Bat_Curr_Disp_Rq.phys = getValue( HMI_PNHV_Bat_Curr_Disp_Rq );
    _mPNHV_EnergyMngmnt_Stat2_AR.PNHV_Bat_VoltMax_Disp_Rq.phys = getValue( HMI_PNHV_Bat_VoltMax_Disp_Rq );
    _mPNHV_EnergyMngmnt_Stat2_AR.PNHV_VoltDn_Disp_Rq.phys = getValue( HMI_PNHV_VoltDn_Disp_Rq );
	 // _mPNHV_EnergyMngmnt_Stat2_AR.SVS_ActvMd_Rq.phys = getValue( HMI_SVS_ActvMd_Rq );
    _mPNHV_EnergyMngmnt_Stat2_AR.Term61_Actv_UB.phys = getValue( HMI_Term61_Actv_UB );
    _mPNHV_EnergyMngmnt_Stat2_AR.Term61_Actv.phys = getValue( HMI_Term61_Actv );
	  _mPNHV_EnergyMngmnt_Stat2_AR.WPT_Warn_Disp_Rq.phys = getValue( HMI_WPT_Warn_Disp_Rq );
    _mPNHV_EnergyMngmnt_Stat2_AR.EV_CH2_AltDrv_Fail_IndLmp.phys = getValue( HMI_EV_CH2_AltDrv_Fail_IndLmp );
    _mPNHV_EnergyMngmnt_Stat2_AR.EV_CH2_LowPwr_IndLmp.phys = getValue( HMI_EV_CH2_LowPwr_IndLmp );
    _mPNHV_EnergyMngmnt_Stat2_AR.EV_CH2_Warn_Disp_Rq.phys = getValue( HMI_EV_CH2_Warn_Disp_Rq );

}

PNHV_EnergyMngmnt_Stat2_AR_output(void)
{
    output( _mPNHV_EnergyMngmnt_Stat2_AR );
}

PNHV_EnergyMngmnt_Stat2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PNHV_EnergyMngmnt_Stat2_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PNHV_EnergyMngmnt_Stat2_AR := %X\n", getValue( HMI__STMSG_PNHV_EnergyMngmnt_Stat2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PNHV_EnergyMngmnt_Stat2_AR := %X\n", getValue( HMI__STMSGT_PNHV_EnergyMngmnt_Stat2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DCDC_PNHV_GrndStrpFlt_Disp_Rq := %X\n", getValue( HMI_DCDC_PNHV_GrndStrpFlt_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EAC_MaxCurr := %X\n", getValue( HMI_EAC_MaxCurr ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EAC_MinVolt_V2 := %X\n", getValue( HMI_EAC_MinVolt_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EMM_PosnInfo_Disp_Rq := %X\n", getValue( HMI_EMM_PosnInfo_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EMM_PosnTxt_Disp_Rq := %X\n", getValue( HMI_EMM_PosnTxt_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EMM_WPT_ManSet_Stat := %X\n", getValue( HMI_EMM_WPT_ManSet_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EMM_WPT_WLAN_Off_Rsn := %X\n", getValue( HMI_EMM_WPT_WLAN_Off_Rsn ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_Bat_Curr_Disp_Rq := %X\n", getValue( HMI_PNHV_Bat_Curr_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_Bat_VoltMax_Disp_Rq := %X\n", getValue( HMI_PNHV_Bat_VoltMax_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_VoltDn_Disp_Rq := %X\n", getValue( HMI_PNHV_VoltDn_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_SVS_ActvMd_Rq := %X\n", getValue( HMI_SVS_ActvMd_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Term61_Actv := %X\n", getValue( HMI_Term61_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Term61_Actv_UB := %X\n", getValue( HMI_Term61_Actv_UB ) );    filePutString( buffer, elcount( buffer ), hFile );
	  snprintf( buffer, elcount( buffer ), "0.0000 HMI_WPT_Warn_Disp_Rq := %X\n", getValue( HMI_WPT_Warn_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EV_CH2_AltDrv_Fail_IndLmp := %X\n", getValue( HMI_EV_CH2_AltDrv_Fail_IndLmp ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EV_CH2_LowPwr_IndLmp := %X\n", getValue( HMI_EV_CH2_LowPwr_IndLmp ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EV_CH2_Warn_Disp_Rq := %X\n", getValue( HMI_EV_CH2_Warn_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );

}

on timer _tPNHV_EnergyMngmnt_Stat2_AR
{
    putValue( HMI__STMSG_PNHV_EnergyMngmnt_Stat2_AR, 0 );
}

on EnvVar HMI__STMSG_PNHV_EnergyMngmnt_Stat2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PNHV_EnergyMngmnt_Stat2_AR );
        if( tDelay > 0)    
            setTimer( _tPNHV_EnergyMngmnt_Stat2_AR, tDelay );
        else
            putValue( HMI__STMSG_PNHV_EnergyMngmnt_Stat2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PNHV_EnergyMngmnt_Stat2_AR
{
    if( getValue( this ) )
        openPanel("PNHV_EnergyMngmnt_Stat2_AR");
}

on EnvVar HMI_DCDC_PNHV_GrndStrpFlt_Disp_Rq
{
    _mPNHV_EnergyMngmnt_Stat2_AR.DCDC_PNHV_GrndStrpFlt_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_EAC_MaxCurr
{
    _mPNHV_EnergyMngmnt_Stat2_AR.EAC_MaxCurr.phys = getValue(this);
    _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_EAC_MinVolt_V2
{
    _mPNHV_EnergyMngmnt_Stat2_AR.EAC_MinVolt_V2.phys = getValue(this);
    _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_EMM_PosnInfo_Disp_Rq
{
    _mPNHV_EnergyMngmnt_Stat2_AR.EMM_PosnInfo_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_EMM_PosnTxt_Disp_Rq
{
    _mPNHV_EnergyMngmnt_Stat2_AR.EMM_PosnTxt_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_EMM_WPT_ManSet_Stat
{
    _mPNHV_EnergyMngmnt_Stat2_AR.EMM_WPT_ManSet_Stat.phys = getValue(this);
    _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_EMM_WPT_WLAN_Off_Rsn
{
    _mPNHV_EnergyMngmnt_Stat2_AR.EMM_WPT_WLAN_Off_Rsn.phys = getValue(this);
    _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_Bat_Curr_Disp_Rq
{
    _mPNHV_EnergyMngmnt_Stat2_AR.PNHV_Bat_Curr_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_Bat_VoltMax_Disp_Rq
{
    _mPNHV_EnergyMngmnt_Stat2_AR.PNHV_Bat_VoltMax_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_VoltDn_Disp_Rq
{
    _mPNHV_EnergyMngmnt_Stat2_AR.PNHV_VoltDn_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 1;
}

//on EnvVar HMI_SVS_ActvMd_Rq
//{
//    _mPNHV_EnergyMngmnt_Stat2_AR.SVS_ActvMd_Rq.phys = getValue(this);
//    _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 1;
//}

on EnvVar HMI_Term61_Actv
{
    _mPNHV_EnergyMngmnt_Stat2_AR.Term61_Actv.phys = getValue(this);
    _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Term61_Actv_UB
{
    _mPNHV_EnergyMngmnt_Stat2_AR.Term61_Actv_UB.phys = getValue(this);
    _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_WPT_Warn_Disp_Rq
{
    _mPNHV_EnergyMngmnt_Stat2_AR.WPT_Warn_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_EV_CH2_AltDrv_Fail_IndLmp
{
    _mPNHV_EnergyMngmnt_Stat2_AR.EV_CH2_AltDrv_Fail_IndLmp.phys = getValue(this);
    _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_EV_CH2_LowPwr_IndLmp
{
    _mPNHV_EnergyMngmnt_Stat2_AR.EV_CH2_LowPwr_IndLmp.phys = getValue(this);
    _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_EV_CH2_Warn_Disp_Rq
{
    _mPNHV_EnergyMngmnt_Stat2_AR.EV_CH2_Warn_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmnt_Stat2_AR_SpontanFlag = 1;
}

PNHV_EnergyMngmntSet_Rs1_AR_check_output()
{
    if( !getValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs1_AR ) )
    {
    //  message   PNHV_EnergyMngmntSet_Rs1_AR ID: 1155 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _PNHV_EnergyMngmntSet_Rs1_AR_DelayCnt > 0) _PNHV_EnergyMngmntSet_Rs1_AR_DelayCnt--; // Mindestsendeabstand
        _PNHV_EnergyMngmntSet_Rs1_AR_Cnt--;
        if( _PNHV_EnergyMngmntSet_Rs1_AR_Cnt < 1 )
        {
            if( _PNHV_EnergyMngmntSet_Rs1_AR_DelayCnt < 1 )
            {
                PNHV_EnergyMngmntSet_Rs1_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _PNHV_EnergyMngmntSet_Rs1_AR_DelayCnt = _PNHV_EnergyMngmntSet_Rs1_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 1;
            }
            _PNHV_EnergyMngmntSet_Rs1_AR_Cnt = _PNHV_EnergyMngmntSet_Rs1_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag)
        {
            if( _PNHV_EnergyMngmntSet_Rs1_AR_DelayCnt < 1 )
            {
                PNHV_EnergyMngmntSet_Rs1_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _PNHV_EnergyMngmntSet_Rs1_AR_DelayCnt = _PNHV_EnergyMngmntSet_Rs1_AR_MinDelay;
            }
        }
    }
}

PNHV_EnergyMngmntSet_Rs1_AR_init()
{   /* Botschaft PNHV_EnergyMngmntSet_Rs1_AR ID: 1155 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1155 0;
BA_ "NmAsrMessage" BO_ 1155 0;
BA_ "GenMsgMinAcceptLength" BO_ 1155 8;
BA_ "GenMsgILSupport" BO_ 1155 1;
BA_ "DiagState" BO_ 1155 0;
BA_ "DiagRequest" BO_ 1155 0;
BA_ "DiagResponse" BO_ 1155 0;
BA_ "GenMsgStartValue" BO_ 1155 "0";
BA_ "GenMsgStartDelayTime" BO_ 1155 0;
BA_ "GenMsgDelayTime" BO_ 1155 100;
BA_ "GenMsgNrOfRepetitions" BO_ 1155 0;
BA_ "GenMsgCycleTime" BO_ 1155 1000;
BA_ "GenMsgSendType" BO_ 1155 5;
    */
    _PNHV_EnergyMngmntSet_Rs1_AR_Timebase =           c_tDBKomTimer_20ms;
    _PNHV_EnergyMngmntSet_Rs1_AR_CycleCount =       1000 / _PNHV_EnergyMngmntSet_Rs1_AR_Timebase;
    _PNHV_EnergyMngmntSet_Rs1_AR_StartDelay =          0 / _PNHV_EnergyMngmntSet_Rs1_AR_Timebase;
    _PNHV_EnergyMngmntSet_Rs1_AR_MinDelay =          100 / _PNHV_EnergyMngmntSet_Rs1_AR_Timebase;
    _PNHV_EnergyMngmntSet_Rs1_AR_Cnt = _PNHV_EnergyMngmntSet_Rs1_AR_StartDelay;
    _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 0;
    _PNHV_EnergyMngmntSet_Rs1_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_PNHV_EnergyMngmntSet_Rs1_AR, _PNHV_EnergyMngmntSet_Rs1_AR_StartDelay * _PNHV_EnergyMngmntSet_Rs1_AR_Timebase );

    _mPNHV_EnergyMngmntSet_Rs1_AR.HDC_IHS_Disp_Rq.phys = getValue( HMI_HDC_IHS_Disp_Rq );
    _mPNHV_EnergyMngmntSet_Rs1_AR.HPPRM_EffDisp_Rq.phys = getValue( HMI_HPPRM_EffDisp_Rq );
    _mPNHV_EnergyMngmntSet_Rs1_AR.HPPRM_IconDisp_Rq.phys = getValue( HMI_HPPRM_IconDisp_Rq );
    _mPNHV_EnergyMngmntSet_Rs1_AR.Hyb_Msg_Disp_Rq.phys = getValue( HMI_Hyb_Msg_Disp_Rq );
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_AC_Curr_Max.phys = getValue( HMI_PNHV_AC_Curr_Max );
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_ChrgTmDisp_WeekDay.phys = getValue( HMI_PNHV_ChrgTmDisp_WeekDay );
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_ConChrgPlug_Disp_Rq.phys = getValue( HMI_PNHV_ConChrgPlug_Disp_Rq );
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_DepTm_Actv.phys = getValue( HMI_PNHV_DepTm_Actv );
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_DepTm_Avl_Stat.phys = getValue( HMI_PNHV_DepTm_Avl_Stat );
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_DepTm_Icon_Disp_Rq.phys = getValue( HMI_PNHV_DepTm_Icon_Disp_Rq );
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_DepTmManSet_Hour_Stat.phys = getValue( HMI_PNHV_DepTmManSet_Hour_Stat );
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_DepTmManSet_Minute_Stat.phys = getValue( HMI_PNHV_DepTmManSet_Minute_Stat );
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_PreCond1_ManSet_Stat.phys = getValue( HMI_PNHV_PreCond1_ManSet_Stat );
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_PreCond2_Dur.phys = getValue( HMI_PNHV_PreCond2_Dur );
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_PreCond2_ManSet_Icon_Disp_Rq.phys = getValue( HMI_PNHV_PreCond2_ManSet_Icon_Disp_Rq );
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_PreCond2_ManSet_Stat.phys = getValue( HMI_PNHV_PreCond2_ManSet_Stat );
    _mPNHV_EnergyMngmntSet_Rs1_AR.PT_M_Disabl_Disp_Rq.phys = getValue( HMI_PT_M_Disabl_Disp_Rq );
	
	
}

PNHV_EnergyMngmntSet_Rs1_AR_output()
{
    output( _mPNHV_EnergyMngmntSet_Rs1_AR );
}

PNHV_EnergyMngmntSet_Rs1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PNHV_EnergyMngmntSet_Rs1_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PNHV_EnergyMngmntSet_Rs1_AR := %X\n", getValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs1_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PNHV_EnergyMngmntSet_Rs1_AR := %X\n", getValue( HMI__STMSGT_PNHV_EnergyMngmntSet_Rs1_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HDC_IHS_Disp_Rq := %X\n", getValue( HMI_HDC_IHS_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HPPRM_EffDisp_Rq := %X\n", getValue( HMI_HPPRM_EffDisp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HPPRM_IconDisp_Rq := %X\n", getValue( HMI_HPPRM_IconDisp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Hyb_Msg_Disp_Rq := %X\n", getValue( HMI_Hyb_Msg_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_AC_Curr_Max := %X\n", getValue( HMI_PNHV_AC_Curr_Max ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ChrgTmDisp_WeekDay := %X\n", getValue( HMI_PNHV_ChrgTmDisp_WeekDay ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ConChrgPlug_Disp_Rq := %X\n", getValue( HMI_PNHV_ConChrgPlug_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm_Actv := %X\n", getValue( HMI_PNHV_DepTm_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm_Avl_Stat := %X\n", getValue( HMI_PNHV_DepTm_Avl_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm_Icon_Disp_Rq := %X\n", getValue( HMI_PNHV_DepTm_Icon_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTmManSet_Hour_Stat := %X\n", getValue( HMI_PNHV_DepTmManSet_Hour_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTmManSet_Minute_Stat := %X\n", getValue( HMI_PNHV_DepTmManSet_Minute_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_PreCond1_ManSet_Stat := %X\n", getValue( HMI_PNHV_PreCond1_ManSet_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_PreCond2_Dur := %X\n", getValue( HMI_PNHV_PreCond2_Dur ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_PreCond2_ManSet_Icon_Disp_Rq := %X\n", getValue( HMI_PNHV_PreCond2_ManSet_Icon_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_PreCond2_ManSet_Stat := %X\n", getValue( HMI_PNHV_PreCond2_ManSet_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT_M_Disabl_Disp_Rq := %X\n", getValue( HMI_PT_M_Disabl_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPNHV_EnergyMngmntSet_Rs1_AR
{
    putValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs1_AR, 0 );
}

on EnvVar HMI__STMSG_PNHV_EnergyMngmntSet_Rs1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PNHV_EnergyMngmntSet_Rs1_AR );
        if( tDelay > 0)    
            setTimer( _tPNHV_EnergyMngmntSet_Rs1_AR, tDelay );
        else
            putValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PNHV_EnergyMngmntSet_Rs1_AR
{
    if( getValue( this ) )
        openPanel("PNHV_EnergyMngmntSet_Rs1_AR");
}

on EnvVar HMI_HDC_IHS_Disp_Rq 
{
    _mPNHV_EnergyMngmntSet_Rs1_AR.HDC_IHS_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HPPRM_EffDisp_Rq 
{
    _mPNHV_EnergyMngmntSet_Rs1_AR.HPPRM_EffDisp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 1;
}

on EnvVar HMI_HPPRM_IconDisp_Rq 
{
    _mPNHV_EnergyMngmntSet_Rs1_AR.HPPRM_IconDisp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 1;
}

on EnvVar HMI_Hyb_Msg_Disp_Rq
{
    _mPNHV_EnergyMngmntSet_Rs1_AR.Hyb_Msg_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_AC_Curr_Max
{
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_AC_Curr_Max.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_ChrgTmDisp_WeekDay
{
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_ChrgTmDisp_WeekDay.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_ConChrgPlug_Disp_Rq
{
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_ConChrgPlug_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_DepTm_Actv
{
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_DepTm_Actv.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_DepTm_Avl_Stat
{
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_DepTm_Avl_Stat.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_DepTm_Icon_Disp_Rq
{
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_DepTm_Icon_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_DepTmManSet_Hour_Stat
{
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_DepTmManSet_Hour_Stat.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_DepTmManSet_Minute_Stat
{
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_DepTmManSet_Minute_Stat.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_PreCond1_ManSet_Stat
{
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_PreCond1_ManSet_Stat.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_PreCond2_Dur
{
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_PreCond2_Dur.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_PreCond2_ManSet_Icon_Disp_Rq
{
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_PreCond2_ManSet_Icon_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_PreCond2_ManSet_Stat
{
    _mPNHV_EnergyMngmntSet_Rs1_AR.PNHV_PreCond2_ManSet_Stat.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PT_M_Disabl_Disp_Rq
{
    _mPNHV_EnergyMngmntSet_Rs1_AR.PT_M_Disabl_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs1_AR_SpontanFlag = 1;
}

PNHV_EnergyMngmntSet_Rs2_AR_check_output()
{
    if( !getValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs2_AR ) )
    {
    //  message   PNHV_EnergyMngmntSet_Rs2_AR ID: 1073 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _PNHV_EnergyMngmntSet_Rs2_AR_Cnt--;
        if( _PNHV_EnergyMngmntSet_Rs2_AR_Cnt < 1 )
        {
            PNHV_EnergyMngmntSet_Rs2_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _PNHV_EnergyMngmntSet_Rs2_AR_Cnt = _PNHV_EnergyMngmntSet_Rs2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _PNHV_EnergyMngmntSet_Rs2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _PNHV_EnergyMngmntSet_Rs2_AR_SpontanFlag)
        {
            PNHV_EnergyMngmntSet_Rs2_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _PNHV_EnergyMngmntSet_Rs2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

PNHV_EnergyMngmntSet_Rs2_AR_init()
{   /* Botschaft PNHV_EnergyMngmntSet_Rs2_AR ID: 1073 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1073 0;
BA_ "NmAsrMessage" BO_ 1073 0;
BA_ "GenMsgMinAcceptLength" BO_ 1073 8;
BA_ "GenMsgILSupport" BO_ 1073 1;
BA_ "DiagState" BO_ 1073 0;
BA_ "DiagRequest" BO_ 1073 0;
BA_ "DiagResponse" BO_ 1073 0;
BA_ "GenMsgStartValue" BO_ 1073 "0";
BA_ "GenMsgDelayTime" BO_ 1073 5;
BA_ "GenMsgNrOfRepetitions" BO_ 1073 0;
BA_ "GenMsgCycleTime" BO_ 1073 1000;
BA_ "GenMsgSendType" BO_ 1073 5;
    */
    _PNHV_EnergyMngmntSet_Rs2_AR_Timebase =           c_tDBKomTimer_20ms;
    _PNHV_EnergyMngmntSet_Rs2_AR_CycleCount =       1000 / _PNHV_EnergyMngmntSet_Rs2_AR_Timebase;
    _PNHV_EnergyMngmntSet_Rs2_AR_StartDelay =          0 / _PNHV_EnergyMngmntSet_Rs2_AR_Timebase;
    _PNHV_EnergyMngmntSet_Rs2_AR_Cnt = _PNHV_EnergyMngmntSet_Rs2_AR_StartDelay;
    _PNHV_EnergyMngmntSet_Rs2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_PNHV_EnergyMngmntSet_Rs2_AR, _PNHV_EnergyMngmntSet_Rs2_AR_StartDelay * _PNHV_EnergyMngmntSet_Rs2_AR_Timebase );

    _mPNHV_EnergyMngmntSet_Rs2_AR.EMM_AC_Curr_Lmt.phys = getValue( HMI_EMM_AC_Curr_Lmt );
    _mPNHV_EnergyMngmntSet_Rs2_AR.EMM_AC_MaxPwr.phys = getValue( HMI_EMM_AC_MaxPwr );
    _mPNHV_EnergyMngmntSet_Rs2_AR.PNHV_ChrgTmDisp_Hour.phys = getValue( HMI_PNHV_ChrgTmDisp_Hour );
    _mPNHV_EnergyMngmntSet_Rs2_AR.PNHV_ChrgTmDisp_Minute.phys = getValue( HMI_PNHV_ChrgTmDisp_Minute );
    _mPNHV_EnergyMngmntSet_Rs2_AR.PNHV_SOC_Max_Disp_Rq.phys = getValue( HMI_PNHV_SOC_Max_Disp_Rq );
    _mPNHV_EnergyMngmntSet_Rs2_AR.PNHV_Wakeup_Rq_CntDn.phys = getValue( HMI_PNHV_Wakeup_Rq_CntDn );
    _mPNHV_EnergyMngmntSet_Rs2_AR.PNHV_WeekDepTmTbl_ActvDay.phys = getValue( HMI_PNHV_WeekDepTmTbl_ActvDay );
    _mPNHV_EnergyMngmntSet_Rs2_AR.PNHV_WeekDepTmTbl_Avl_Stat.phys = getValue( HMI_PNHV_WeekDepTmTbl_Avl_Stat );
   // _mPNHV_EnergyMngmntSet_Rs2_AR.IntelRecup_Stat.phys = getValue( HMI_IntelRecup_Stat );
}

PNHV_EnergyMngmntSet_Rs2_AR_output(void)
{
    output( _mPNHV_EnergyMngmntSet_Rs2_AR );
}

PNHV_EnergyMngmntSet_Rs2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PNHV_EnergyMngmntSet_Rs2_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PNHV_EnergyMngmntSet_Rs2_AR := %X\n", getValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PNHV_EnergyMngmntSet_Rs2_AR := %X\n", getValue( HMI__STMSGT_PNHV_EnergyMngmntSet_Rs2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EMM_AC_Curr_Lmt := %X\n", getValue( HMI_EMM_AC_Curr_Lmt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EMM_AC_MaxPwr := %X\n", getValue( HMI_EMM_AC_MaxPwr ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ChrgTmDisp_Hour := %X\n", getValue( HMI_PNHV_ChrgTmDisp_Hour ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ChrgTmDisp_Minute := %X\n", getValue( HMI_PNHV_ChrgTmDisp_Minute ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_SOC_Max_Disp_Rq := %X\n", getValue( HMI_PNHV_SOC_Max_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_Wakeup_Rq_CntDn := %X\n", getValue( HMI_PNHV_Wakeup_Rq_CntDn ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_WeekDepTmTbl_ActvDay := %X\n", getValue( HMI_PNHV_WeekDepTmTbl_ActvDay ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_WeekDepTmTbl_Avl_Stat := %X\n", getValue( HMI_PNHV_WeekDepTmTbl_Avl_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount(buffer), "0.0000 HMI_IntelRecup_Stat := %X\n", getValue( HMI_IntelRecup_Stat ) );        filePutString( buffer, elcount(buffer), hFile);
}

on timer _tPNHV_EnergyMngmntSet_Rs2_AR
{
    putValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs2_AR, 0 );
}

on EnvVar HMI__STMSG_PNHV_EnergyMngmntSet_Rs2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PNHV_EnergyMngmntSet_Rs2_AR );
        if( tDelay > 0)    
            setTimer( _tPNHV_EnergyMngmntSet_Rs2_AR, tDelay );
        else
            putValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PNHV_EnergyMngmntSet_Rs2_AR
{
    if( getValue( this ) )
        openPanel("PNHV_EnergyMngmntSet_Rs2_AR");
}

on EnvVar HMI_EMM_AC_Curr_Lmt
{
    _mPNHV_EnergyMngmntSet_Rs2_AR.EMM_AC_Curr_Lmt.phys = getValue(this);
}

on EnvVar HMI_EMM_AC_MaxPwr
{
    _mPNHV_EnergyMngmntSet_Rs2_AR.EMM_AC_MaxPwr.phys = getValue(this);
}

on EnvVar HMI_PNHV_ChrgTmDisp_Hour
{
    _mPNHV_EnergyMngmntSet_Rs2_AR.PNHV_ChrgTmDisp_Hour.phys = getValue(this);
}

on EnvVar HMI_PNHV_ChrgTmDisp_Minute
{
    _mPNHV_EnergyMngmntSet_Rs2_AR.PNHV_ChrgTmDisp_Minute.phys = getValue(this);
}

on EnvVar HMI_PNHV_SOC_Max_Disp_Rq
{
    _mPNHV_EnergyMngmntSet_Rs2_AR.PNHV_SOC_Max_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_PNHV_Wakeup_Rq_CntDn
{
    _mPNHV_EnergyMngmntSet_Rs2_AR.PNHV_Wakeup_Rq_CntDn.phys = getValue(this);
}

on EnvVar HMI_PNHV_WeekDepTmTbl_ActvDay
{
    _mPNHV_EnergyMngmntSet_Rs2_AR.PNHV_WeekDepTmTbl_ActvDay.phys = getValue(this);
}

on EnvVar HMI_PNHV_WeekDepTmTbl_Avl_Stat
{
    _mPNHV_EnergyMngmntSet_Rs2_AR.PNHV_WeekDepTmTbl_Avl_Stat.phys = getValue(this);
}

PNHV_EnergyMngmntSet_Rs3_AR_check_output()
{
    if( !getValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs3_AR ) )
    {
    //  message   PNHV_EnergyMngmntSet_Rs3_AR ID: 2462318592 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _PNHV_EnergyMngmntSet_Rs3_AR_DelayCnt > 0) _PNHV_EnergyMngmntSet_Rs3_AR_DelayCnt--; // Mindestsendeabstand
        _PNHV_EnergyMngmntSet_Rs3_AR_Cnt--;
        if( _PNHV_EnergyMngmntSet_Rs3_AR_Cnt < 1 )
        {
            if( _PNHV_EnergyMngmntSet_Rs3_AR_DelayCnt < 1 )
            {
                PNHV_EnergyMngmntSet_Rs3_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                _PNHV_EnergyMngmntSet_Rs3_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _PNHV_EnergyMngmntSet_Rs3_AR_DelayCnt = _PNHV_EnergyMngmntSet_Rs3_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _PNHV_EnergyMngmntSet_Rs3_AR_SpontanFlag = 1;
            }
            _PNHV_EnergyMngmntSet_Rs3_AR_Cnt = _PNHV_EnergyMngmntSet_Rs3_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _PNHV_EnergyMngmntSet_Rs3_AR_SpontanFlag)
        {
            if( _PNHV_EnergyMngmntSet_Rs3_AR_DelayCnt < 1 )
            {
                PNHV_EnergyMngmntSet_Rs3_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _PNHV_EnergyMngmntSet_Rs3_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _PNHV_EnergyMngmntSet_Rs3_AR_DelayCnt = _PNHV_EnergyMngmntSet_Rs3_AR_MinDelay;
            }
        }
    }
}

PNHV_EnergyMngmntSet_Rs3_AR_init()
{   /* Botschaft PNHV_EnergyMngmntSet_Rs3_AR ID: 2462318592 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 2462318592 0;
BA_ "NmAsrMessage" BO_ 2462318592 0;
BA_ "GenMsgMinAcceptLength" BO_ 2462318592 8;
BA_ "GenMsgILSupport" BO_ 2462318592 1;
BA_ "DiagState" BO_ 2462318592 0;
BA_ "DiagRequest" BO_ 2462318592 0;
BA_ "DiagResponse" BO_ 2462318592 0;
BA_ "GenMsgStartValue" BO_ 2462318592 "0";
BA_ "GenMsgDelayTime" BO_ 2462318592 400;
BA_ "GenMsgNrOfRepetition" BO_ 2462318592 0;
BA_ "GenMsgCycleTime" BO_ 2462318592 1000;
BA_ "GenMsgSendType" BO_ 2462318592 5;
    */
    _PNHV_EnergyMngmntSet_Rs3_AR_Timebase =           c_tDBKomTimer_20ms;
    _PNHV_EnergyMngmntSet_Rs3_AR_CycleCount =       1000 / _PNHV_EnergyMngmntSet_Rs3_AR_Timebase;
    _PNHV_EnergyMngmntSet_Rs3_AR_StartDelay =          0 / _PNHV_EnergyMngmntSet_Rs3_AR_Timebase;
    _PNHV_EnergyMngmntSet_Rs3_AR_MinDelay =          400 / _PNHV_EnergyMngmntSet_Rs3_AR_Timebase;
    _PNHV_EnergyMngmntSet_Rs3_AR_Cnt = _PNHV_EnergyMngmntSet_Rs3_AR_StartDelay;
    _PNHV_EnergyMngmntSet_Rs3_AR_SpontanFlag = 0;
    _PNHV_EnergyMngmntSet_Rs3_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_PNHV_EnergyMngmntSet_Rs3_AR, _PNHV_EnergyMngmntSet_Rs3_AR_StartDelay * _PNHV_EnergyMngmntSet_Rs3_AR_Timebase );
    putValue( HMI__STMSGCT_PNHV_EnergyMngmntSet_Rs3_AR, _PNHV_EnergyMngmntSet_Rs3_AR_CycleCount * _PNHV_EnergyMngmntSet_Rs3_AR_Timebase );

    _mPNHV_EnergyMngmntSet_Rs3_AR.EMM_Dischrg_Flt.phys = getValue( HMI_EMM_Dischrg_Flt );
    _mPNHV_EnergyMngmntSet_Rs3_AR.EMM_Eco_ChrgPwr_Stat.phys = getValue( HMI_EMM_Eco_ChrgPwr_Stat );
    _mPNHV_EnergyMngmntSet_Rs3_AR.EMM_PT_Preparing.phys = getValue( HMI_EMM_PT_Preparing );
    _mPNHV_EnergyMngmntSet_Rs3_AR.EMM_Bat_Temp_Disp.phys = getValue( HMI_EMM_Bat_Temp_Disp );
    _mPNHV_EnergyMngmntSet_Rs3_AR.PNHV_ChrgFlg_RelTm_Disp_Rq.phys = getValue( HMI_PNHV_ChrgFlg_RelTm_Disp_Rq );
    _mPNHV_EnergyMngmntSet_Rs3_AR.PNHV_EOC_ElecEnergyRng.phys = getValue( HMI_PNHV_EOC_ElecEnergyRng );
    _mPNHV_EnergyMngmntSet_Rs3_AR.PNHV_EOC_RelTm_Hour_Disp_Rq.phys = getValue( HMI_PNHV_EOC_RelTm_Hour_Disp_Rq );
    _mPNHV_EnergyMngmntSet_Rs3_AR.PNHV_EOC_RelTm_Minute_Disp_Rq.phys = getValue( HMI_PNHV_EOC_RelTm_Minute_Disp_Rq );
    _mPNHV_EnergyMngmntSet_Rs3_AR.PNHV_PredChrgRelTm_Hour_Disp_Rq.phys = getValue( HMI_PNHV_PredChrgRelTm_Hour_Disp_Rq );
    _mPNHV_EnergyMngmntSet_Rs3_AR.PNHV_PredChrgRelTm_Minute_Disp_Rq.phys = getValue( HMI_PNHV_PredChrgRelTm_Minute_Disp_Rq );
    _mPNHV_EnergyMngmntSet_Rs3_AR.PT4_PTCoor_DrvPrg_Recom_PT.phys = getValue( HMI_PT4_PTCoor_DrvPrg_Recom_PT );
}

PNHV_EnergyMngmntSet_Rs3_AR_output()
{
    output( _mPNHV_EnergyMngmntSet_Rs3_AR );
}

PNHV_EnergyMngmntSet_Rs3_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PNHV_EnergyMngmntSet_Rs3_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PNHV_EnergyMngmntSet_Rs3_AR := %X\n", getValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs3_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PNHV_EnergyMngmntSet_Rs3_AR := %X\n", getValue( HMI__STMSGT_PNHV_EnergyMngmntSet_Rs3_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EMM_Dischrg_Flt := %X\n", getValue( HMI_EMM_Dischrg_Flt ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EMM_Eco_ChrgPwr_Stat := %X\n", getValue( HMI_EMM_Eco_ChrgPwr_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EMM_PT_Preparing := %X\n", getValue( HMI_EMM_PT_Preparing ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EMM_Bat_Temp_Disp := %X\n", getValue( HMI_EMM_Bat_Temp_Disp ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ChrgFlg_RelTm_Disp_Rq := %X\n", getValue( HMI_PNHV_ChrgFlg_RelTm_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_EOC_ElecEnergyRng := %X\n", getValue( HMI_PNHV_EOC_ElecEnergyRng ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_EOC_RelTm_Hour_Disp_Rq := %X\n", getValue( HMI_PNHV_EOC_RelTm_Hour_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_EOC_RelTm_Minute_Disp_Rq := %X\n", getValue( HMI_PNHV_EOC_RelTm_Minute_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_PredChrgRelTm_Hour_Disp_Rq := %X\n", getValue( HMI_PNHV_PredChrgRelTm_Hour_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_PredChrgRelTm_Minute_Disp_Rq := %X\n", getValue( HMI_PNHV_PredChrgRelTm_Minute_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT4_PTCoor_DrvPrg_Recom_PT := %X\n", getValue( HMI_PT4_PTCoor_DrvPrg_Recom_PT ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPNHV_EnergyMngmntSet_Rs3_AR
{
    putValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs3_AR, 0 );
}

on EnvVar HMI__STMSG_PNHV_EnergyMngmntSet_Rs3_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PNHV_EnergyMngmntSet_Rs3_AR );
        if( tDelay > 0)    
            setTimer( _tPNHV_EnergyMngmntSet_Rs3_AR, tDelay );
        else
            putValue( HMI__STMSG_PNHV_EnergyMngmntSet_Rs3_AR, 0 );
    }
}

on EnvVar HMI__STMSGCT_PNHV_EnergyMngmntSet_Rs3_AR
{
    if( getValue( this ) > 0 )
    {
        _PNHV_EnergyMngmntSet_Rs3_AR_CycleCount = getValue( this ) / _PNHV_EnergyMngmntSet_Rs3_AR_Timebase;     // set cycle counter to initial value
        _PNHV_EnergyMngmntSet_Rs3_AR_SpontanFlag = 1;
    }
}

on envVar HMI__STMSG_PO_PNHV_EnergyMngmntSet_Rs3_AR
{
    if( getValue( this ) )
        openPanel("PNHV_EnergyMngmntSet_Rs3_AR");
}

on EnvVar HMI_EMM_Bat_Temp_Disp
{
    _mPNHV_EnergyMngmntSet_Rs3_AR.EMM_Bat_Temp_Disp.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs3_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_ChrgFlg_RelTm_Disp_Rq
{
    _mPNHV_EnergyMngmntSet_Rs3_AR.PNHV_ChrgFlg_RelTm_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs3_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_EOC_ElecEnergyRng
{
    _mPNHV_EnergyMngmntSet_Rs3_AR.PNHV_EOC_ElecEnergyRng.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs3_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_EOC_RelTm_Hour_Disp_Rq
{
    _mPNHV_EnergyMngmntSet_Rs3_AR.PNHV_EOC_RelTm_Hour_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs3_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_EOC_RelTm_Minute_Disp_Rq
{
    _mPNHV_EnergyMngmntSet_Rs3_AR.PNHV_EOC_RelTm_Minute_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs3_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_PredChrgRelTm_Hour_Disp_Rq
{
    _mPNHV_EnergyMngmntSet_Rs3_AR.PNHV_PredChrgRelTm_Hour_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs3_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_PredChrgRelTm_Minute_Disp_Rq
{
    _mPNHV_EnergyMngmntSet_Rs3_AR.PNHV_PredChrgRelTm_Minute_Disp_Rq.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs3_AR_SpontanFlag = 1;
}

on EnvVar HMI_PT4_PTCoor_DrvPrg_Recom_PT
{
    _mPNHV_EnergyMngmntSet_Rs3_AR.PT4_PTCoor_DrvPrg_Recom_PT.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs3_AR_SpontanFlag = 1;
}

on EnvVar HMI_EMM_Dischrg_Flt
{
    _mPNHV_EnergyMngmntSet_Rs3_AR.EMM_Dischrg_Flt.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs3_AR_SpontanFlag = 1;
}

on EnvVar HMI_EMM_Eco_ChrgPwr_Stat
{
    _mPNHV_EnergyMngmntSet_Rs3_AR.EMM_Eco_ChrgPwr_Stat.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs3_AR_SpontanFlag = 1;
}

on EnvVar HMI_EMM_PT_Preparing
{
    _mPNHV_EnergyMngmntSet_Rs3_AR.EMM_PT_Preparing.phys = getValue(this);
    _PNHV_EnergyMngmntSet_Rs3_AR_SpontanFlag = 1;
}

void PNHV_WeekDepTmTbl_Stat_AR_Activity(int active)
{
      if( active)
      {
          if( _PNHV_WeekDepTmTbl_Stat_AR_SigActivity == 0)
            _PNHV_WeekDepTmTbl_Stat_AR_Cnt = 1;
        _PNHV_WeekDepTmTbl_Stat_AR_SigActivity++;
      }
      else
    {
        _PNHV_WeekDepTmTbl_Stat_AR_SigActivity--;
      }
}

int PNHV_WeekDepTmTbl_Stat_AR_Change(int lastValue, int sigValue, int inActValue)
{
    bActiveHelper = (sigValue != inActValue);
      if( !lastValue && bActiveHelper)
        PNHV_WeekDepTmTbl_Stat_AR_Activity( 1 );
      else if( lastValue && !bActiveHelper)
        PNHV_WeekDepTmTbl_Stat_AR_Activity(0 );
    return bActiveHelper;
}

PNHV_WeekDepTmTbl_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_PNHV_WeekDepTmTbl_Stat_AR ) )
    {
    //  message   PNHV_WeekDepTmTbl_Stat_AR ID: 447 --- Sendeart 2 cyclicIfActive --- 
        if( _PNHV_WeekDepTmTbl_Stat_AR_SigActivity )
            _PNHV_WeekDepTmTbl_Stat_AR_Cnt--;
        if( _PNHV_WeekDepTmTbl_Stat_AR_Cnt < 1 )
        {
            PNHV_WeekDepTmTbl_Stat_AR_output(); // Zyklus abgelaufen, Nachricht senden
            _PNHV_WeekDepTmTbl_Stat_AR_Cnt = _PNHV_WeekDepTmTbl_Stat_AR_CycleCount;
        }
    }
}

PNHV_WeekDepTmTbl_Stat_AR_init()
{   /* Botschaft PNHV_WeekDepTmTbl_Stat_AR ID: 447 --- Sendeart 2 cyclicIfActive --- 
BA_ "ApplMessage" BO_ 447 0;
BA_ "NmAsrMessage" BO_ 447 0;
BA_ "GenMsgMinAcceptLength" BO_ 447 8;
BA_ "GenMsgILSupport" BO_ 447 0;
BA_ "DiagState" BO_ 447 0;
BA_ "DiagRequest" BO_ 447 0;
BA_ "DiagResponse" BO_ 447 0;
BA_ "GenMsgStartValue" BO_ 447 "0";
BA_ "GenMsgStartDelayTime" BO_ 447 0;
BA_ "GenMsgDelayTime" BO_ 447 5;
BA_ "GenMsgCycleTime" BO_ 447 0;
BA_ "GenMsgCycleTimeActive" BO_ 447 60;
BA_ "GenMsgSendType" BO_ 447 2;
    */
    _PNHV_WeekDepTmTbl_Stat_AR_Timebase =           c_tDBKomTimer_5ms;
    _PNHV_WeekDepTmTbl_Stat_AR_CycleCount =       60 / _PNHV_WeekDepTmTbl_Stat_AR_Timebase;
    _PNHV_WeekDepTmTbl_Stat_AR_StartDelay =        0 / _PNHV_WeekDepTmTbl_Stat_AR_Timebase;
    _PNHV_WeekDepTmTbl_Stat_AR_Cnt = _PNHV_WeekDepTmTbl_Stat_AR_StartDelay;
    _PNHV_WeekDepTmTbl_Stat_AR_Active = 0;
    _PNHV_WeekDepTmTbl_Stat_AR_SigActivity = 0;

    putValue( HMI__STMSGSD_PNHV_WeekDepTmTbl_Stat_AR, _PNHV_WeekDepTmTbl_Stat_AR_StartDelay * _PNHV_WeekDepTmTbl_Stat_AR_Timebase );

    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm01.phys = getValue( HMI_PNHV_DepTm01 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm02.phys = getValue( HMI_PNHV_DepTm02 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm03.phys = getValue( HMI_PNHV_DepTm03 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm04.phys = getValue( HMI_PNHV_DepTm04 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm05.phys = getValue( HMI_PNHV_DepTm05 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm06.phys = getValue( HMI_PNHV_DepTm06 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm07.phys = getValue( HMI_PNHV_DepTm07 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm08.phys = getValue( HMI_PNHV_DepTm08 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm09.phys = getValue( HMI_PNHV_DepTm09 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm10.phys = getValue( HMI_PNHV_DepTm10 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm11.phys = getValue( HMI_PNHV_DepTm11 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm12.phys = getValue( HMI_PNHV_DepTm12 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm13.phys = getValue( HMI_PNHV_DepTm13 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm14.phys = getValue( HMI_PNHV_DepTm14 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm15.phys = getValue( HMI_PNHV_DepTm15 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm16.phys = getValue( HMI_PNHV_DepTm16 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm17.phys = getValue( HMI_PNHV_DepTm17 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm18.phys = getValue( HMI_PNHV_DepTm18 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm19.phys = getValue( HMI_PNHV_DepTm19 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm20.phys = getValue( HMI_PNHV_DepTm20 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm21.phys = getValue( HMI_PNHV_DepTm21 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_1To4.phys = getValue( HMI_PNHV_DepTmUpdtCnt_1To4 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_5To8.phys = getValue( HMI_PNHV_DepTmUpdtCnt_5To8 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_9To12.phys = getValue( HMI_PNHV_DepTmUpdtCnt_9To12 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_13To16.phys = getValue( HMI_PNHV_DepTmUpdtCnt_13To16 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_17To20.phys = getValue( HMI_PNHV_DepTmUpdtCnt_17To20 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_21.phys = getValue( HMI_PNHV_DepTmUpdtCnt_21 );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_WeekDepTmTbl_New.phys = getValue( HMI_PNHV_WeekDepTmTbl_New );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_WeekDepTmTbl_PartId.phys = getValue( HMI_PNHV_WeekDepTmTbl_PartId );
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_WeekDepTmTbl_TxActv.phys = getValue( HMI_PNHV_WeekDepTmTbl_TxActv );
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm01_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm01_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm01, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm02_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm02_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm02, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm03_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm03_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm03, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm04_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm04_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm04, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm05_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm05_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm05, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm06_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm06_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm06, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm07_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm07_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm07, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm08_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm08_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm08, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm09_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm09_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm09, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm10_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm10_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm10, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm11_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm11_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm11, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm12_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm12_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm12, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm13_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm13_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm13, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm14_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm14_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm14, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm15_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm15_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm15, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm16_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm16_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm16, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm17_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm17_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm17, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm18_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm18_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm18, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm19_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm19_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm19, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm20_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm20_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm20, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm21_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm21_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm21, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_1To4_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_1To4_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_1To4, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_5To8_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_5To8_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_5To8, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_9To12_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_9To12_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_9To12, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_13To16_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_13To16_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_13To16, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_17To20_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_17To20_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_17To20, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_21_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_21_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_21, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_WeekDepTmTbl_New_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_WeekDepTmTbl_New_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_WeekDepTmTbl_New, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_WeekDepTmTbl_PartId_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_WeekDepTmTbl_PartId_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_WeekDepTmTbl_PartId, 0);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_WeekDepTmTbl_TxActv_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_WeekDepTmTbl_TxActv_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_WeekDepTmTbl_TxActv, 0);
}

PNHV_WeekDepTmTbl_Stat_AR_output()
{
    output( _mPNHV_WeekDepTmTbl_Stat_AR );
}

PNHV_WeekDepTmTbl_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PNHV_WeekDepTmTbl_Stat_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PNHV_WeekDepTmTbl_Stat_AR := %X\n", getValue( HMI__STMSG_PNHV_WeekDepTmTbl_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PNHV_WeekDepTmTbl_Stat_AR := %X\n", getValue( HMI__STMSGT_PNHV_WeekDepTmTbl_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm01 := %X\n", getValue( HMI_PNHV_DepTm01 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm02 := %X\n", getValue( HMI_PNHV_DepTm02 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm03 := %X\n", getValue( HMI_PNHV_DepTm03 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm04 := %X\n", getValue( HMI_PNHV_DepTm04 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm05 := %X\n", getValue( HMI_PNHV_DepTm05 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm06 := %X\n", getValue( HMI_PNHV_DepTm06 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm07 := %X\n", getValue( HMI_PNHV_DepTm07 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm08 := %X\n", getValue( HMI_PNHV_DepTm08 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm09 := %X\n", getValue( HMI_PNHV_DepTm09 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm10 := %X\n", getValue( HMI_PNHV_DepTm10 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm11 := %X\n", getValue( HMI_PNHV_DepTm11 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm12 := %X\n", getValue( HMI_PNHV_DepTm12 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm13 := %X\n", getValue( HMI_PNHV_DepTm13 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm14 := %X\n", getValue( HMI_PNHV_DepTm14 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm15 := %X\n", getValue( HMI_PNHV_DepTm15 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm16 := %X\n", getValue( HMI_PNHV_DepTm16 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm17 := %X\n", getValue( HMI_PNHV_DepTm17 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm18 := %X\n", getValue( HMI_PNHV_DepTm18 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm19 := %X\n", getValue( HMI_PNHV_DepTm19 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm20 := %X\n", getValue( HMI_PNHV_DepTm20 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTm21 := %X\n", getValue( HMI_PNHV_DepTm21 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTmUpdtCnt_1To4 := %X\n", getValue( HMI_PNHV_DepTmUpdtCnt_1To4 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTmUpdtCnt_5To8 := %X\n", getValue( HMI_PNHV_DepTmUpdtCnt_5To8 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTmUpdtCnt_9To12 := %X\n", getValue( HMI_PNHV_DepTmUpdtCnt_9To12 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTmUpdtCnt_13To16 := %X\n", getValue( HMI_PNHV_DepTmUpdtCnt_13To16 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTmUpdtCnt_17To20 := %X\n", getValue( HMI_PNHV_DepTmUpdtCnt_17To20 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_DepTmUpdtCnt_21 := %X\n", getValue( HMI_PNHV_DepTmUpdtCnt_21 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_WeekDepTmTbl_New := %X\n", getValue( HMI_PNHV_WeekDepTmTbl_New ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_WeekDepTmTbl_PartId := %X\n", getValue( HMI_PNHV_WeekDepTmTbl_PartId ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_WeekDepTmTbl_TxActv := %X\n", getValue( HMI_PNHV_WeekDepTmTbl_TxActv ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPNHV_WeekDepTmTbl_Stat_AR
{
    putValue( HMI__STMSG_PNHV_WeekDepTmTbl_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_PNHV_WeekDepTmTbl_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PNHV_WeekDepTmTbl_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tPNHV_WeekDepTmTbl_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_PNHV_WeekDepTmTbl_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PNHV_WeekDepTmTbl_Stat_AR
{
    if( getValue( this ) )
        openPanel("PNHV_WeekDepTmTbl_Stat_AR");
}

on EnvVar HMI_PNHV_DepTm01
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm01.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm01_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm01_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm01, 0 );
}

on EnvVar HMI_PNHV_DepTm02
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm02.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm02_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm02_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm02, 0 );
}

on EnvVar HMI_PNHV_DepTm03
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm03.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm03_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm03_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm03, 0 );
}

on EnvVar HMI_PNHV_DepTm04
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm04.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm04_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm04_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm04, 0 );
}

on EnvVar HMI_PNHV_DepTm05
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm05.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm05_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm05_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm05, 0 );
}

on EnvVar HMI_PNHV_DepTm06
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm06.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm06_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm06_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm06, 0 );
}

on EnvVar HMI_PNHV_DepTm07
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm07.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm07_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm07_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm07, 0 );
}

on EnvVar HMI_PNHV_DepTm08
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm08.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm08_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm08_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm08, 0 );
}

on EnvVar HMI_PNHV_DepTm09
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm09.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm09_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm09_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm09, 0 );
}

on EnvVar HMI_PNHV_DepTm10
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm10.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm10_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm10_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm10, 0 );
}

on EnvVar HMI_PNHV_DepTm11
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm11.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm11_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm11_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm11, 0 );
}

on EnvVar HMI_PNHV_DepTm12
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm12.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm12_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm12_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm12, 0 );
}

on EnvVar HMI_PNHV_DepTm13
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm13.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm13_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm13_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm13, 0 );
}

on EnvVar HMI_PNHV_DepTm14
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm14.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm14_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm14_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm14, 0 );
}

on EnvVar HMI_PNHV_DepTm15
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm15.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm15_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm15_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm15, 0 );
}

on EnvVar HMI_PNHV_DepTm16
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm16.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm16_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm16_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm16, 0 );
}

on EnvVar HMI_PNHV_DepTm17
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm17.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm17_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm17_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm17, 0 );
}

on EnvVar HMI_PNHV_DepTm18
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm18.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm18_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm18_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm18, 0 );
}

on EnvVar HMI_PNHV_DepTm19
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm19.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm19_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm19_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm19, 0 );
}

on EnvVar HMI_PNHV_DepTm20
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm20.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm20_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm20_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm20, 0 );
}

on EnvVar HMI_PNHV_DepTm21
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm21.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm21_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTm21_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTm21, 0 );
}

on EnvVar HMI_PNHV_DepTmUpdtCnt_1To4
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_1To4.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_1To4_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_1To4_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_1To4, 0 );
}

on EnvVar HMI_PNHV_DepTmUpdtCnt_5To8
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_5To8.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_5To8_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_5To8_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_5To8, 0 );
}

on EnvVar HMI_PNHV_DepTmUpdtCnt_9To12
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_9To12.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_9To12_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_9To12_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_9To12, 0 );
}

on EnvVar HMI_PNHV_DepTmUpdtCnt_13To16
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_13To16.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_13To16_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_13To16_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_13To16, 0 );
}

on EnvVar HMI_PNHV_DepTmUpdtCnt_17To20
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_17To20.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_17To20_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_17To20_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_17To20, 0 );
}

on EnvVar HMI_PNHV_DepTmUpdtCnt_21
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_21.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_21_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_DepTmUpdtCnt_21_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_DepTmUpdtCnt_21, 0 );
}

on EnvVar HMI_PNHV_WeekDepTmTbl_New
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_WeekDepTmTbl_New.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_WeekDepTmTbl_New_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_WeekDepTmTbl_New_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_WeekDepTmTbl_New, 0 );
}

on EnvVar HMI_PNHV_WeekDepTmTbl_PartId
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_WeekDepTmTbl_PartId.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_WeekDepTmTbl_PartId_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_WeekDepTmTbl_PartId_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_WeekDepTmTbl_PartId, 0 );
}

on EnvVar HMI_PNHV_WeekDepTmTbl_TxActv
{
    _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_WeekDepTmTbl_TxActv.phys = getValue(this);
    _PNHV_WeekDepTmTbl_Stat_AR_PNHV_WeekDepTmTbl_TxActv_LastState = PNHV_WeekDepTmTbl_Stat_AR_Change( _PNHV_WeekDepTmTbl_Stat_AR_PNHV_WeekDepTmTbl_TxActv_LastState, _mPNHV_WeekDepTmTbl_Stat_AR.PNHV_WeekDepTmTbl_TxActv, 0 );
}

PreCond_CfgStat_AR_check_output()
{
    if( !getValue( HMI__STMSG_PreCond_CfgStat_AR ) )
    {
    //  message   PreCond_CfgStat_AR ID: 1179 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _PreCond_CfgStat_AR_Cnt--;
        if( _PreCond_CfgStat_AR_Cnt < 1 )
        {
            PreCond_CfgStat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _PreCond_CfgStat_AR_Cnt = _PreCond_CfgStat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _PreCond_CfgStat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _PreCond_CfgStat_AR_SpontanFlag)
        {
            PreCond_CfgStat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _PreCond_CfgStat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

PreCond_CfgStat_AR_init()
{   /* Botschaft PreCond_CfgStat_AR ID: 1179 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1179 0;
BA_ "NmAsrMessage" BO_ 1179 0;
BA_ "GenMsgMinAcceptLength" BO_ 1179 8;
BA_ "GenMsgILSupport" BO_ 1179 1;
BA_ "DiagState" BO_ 1179 0;
BA_ "DiagRequest" BO_ 1179 0;
BA_ "DiagResponse" BO_ 1179 0;
BA_ "GenMsgStartValue" BO_ 1179 "0";
BA_ "GenMsgDelayTime" BO_ 1179 5;
BA_ "GenMsgNrOfRepetitions" BO_ 1179 0;
BA_ "GenMsgCycleTime" BO_ 1179 1000;
BA_ "GenMsgSendType" BO_ 1179 5;
    */
    _PreCond_CfgStat_AR_Timebase =           c_tDBKomTimer_20ms;
    _PreCond_CfgStat_AR_CycleCount =       1000 / _PreCond_CfgStat_AR_Timebase;
    _PreCond_CfgStat_AR_StartDelay =          0 / _PreCond_CfgStat_AR_Timebase;
    _PreCond_CfgStat_AR_Cnt = _PreCond_CfgStat_AR_StartDelay;
    _PreCond_CfgStat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_PreCond_CfgStat_AR, _PreCond_CfgStat_AR_StartDelay * _PreCond_CfgStat_AR_Timebase );

    putValue( HMI_HVAC_PreCond_Disp_Rq, 0 );
    _mPreCond_CfgStat_AR.HVAC_PreCond_Disp_Rq.phys = getValue( HMI_HVAC_PreCond_Disp_Rq );
    _mPreCond_CfgStat_AR.HVAC_PreCond2_Disp_Rq.phys = getValue( HMI_HVAC_PreCond2_Disp_Rq );
    _mPreCond_CfgStat_AR.HVAC_PreCond4_Disp_Rq.phys = getValue( HMI_HVAC_PreCond4_Disp_Rq );
    _mPreCond_CfgStat_AR.PreCond_AirFrshnr_CfgStat.phys = getValue( HMI_PreCond_AirFrshnr_CfgStat );
    _mPreCond_CfgStat_AR.PreCond_Ionzr_CfgStat.phys = getValue( HMI_PreCond_Ionzr_CfgStat );
    _mPreCond_CfgStat_AR.PreCond_Mode_CfgStat.phys = getValue( HMI_PreCond_Mode_CfgStat );
    _mPreCond_CfgStat_AR.PreCond_Seat_FL_CfgStat.phys = getValue( HMI_PreCond_Seat_FL_CfgStat );
    _mPreCond_CfgStat_AR.PreCond_Seat_FR_CfgStat.phys = getValue( HMI_PreCond_Seat_FR_CfgStat );
    _mPreCond_CfgStat_AR.PreCond_Seat_RL_CfgStat.phys = getValue( HMI_PreCond_Seat_RL_CfgStat );
    _mPreCond_CfgStat_AR.PreCond_Seat_RR_CfgStat.phys = getValue( HMI_PreCond_Seat_RR_CfgStat );
}

PreCond_CfgStat_AR_output(void)
{
    output( _mPreCond_CfgStat_AR );
}

PreCond_CfgStat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PreCond_CfgStat_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PreCond_CfgStat := %X\n", getValue( HMI__STMSG_PreCond_CfgStat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PreCond_CfgStat := %X\n", getValue( HMI__STMSGT_PreCond_CfgStat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_PreCond2_Disp_Rq := %X\n", getValue( HMI_HVAC_PreCond2_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_PreCond4_Disp_Rq := %X\n", getValue( HMI_HVAC_PreCond4_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HVAC_PreCond_Disp_Rq := %X\n", getValue( HMI_HVAC_PreCond_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PreCond_AirFrshnr_CfgStat := %X\n", getValue( HMI_PreCond_AirFrshnr_CfgStat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PreCond_Ionzr_CfgStat := %X\n", getValue( HMI_PreCond_Ionzr_CfgStat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PreCond_Mode_CfgStat := %X\n", getValue( HMI_PreCond_Mode_CfgStat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PreCond_Seat_FL_CfgStat := %X\n", getValue( HMI_PreCond_Seat_FL_CfgStat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PreCond_Seat_FR_CfgStat := %X\n", getValue( HMI_PreCond_Seat_FR_CfgStat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PreCond_Seat_RL_CfgStat := %X\n", getValue( HMI_PreCond_Seat_RL_CfgStat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PreCond_Seat_RR_CfgStat := %X\n", getValue( HMI_PreCond_Seat_RR_CfgStat ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPreCond_CfgStat_AR
{
    putValue( HMI__STMSG_PreCond_CfgStat_AR, 0 );
}

on EnvVar HMI__STMSG_PreCond_CfgStat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PreCond_CfgStat_AR );
        if( tDelay > 0)    
            setTimer( _tPreCond_CfgStat_AR, tDelay );
        else
            putValue( HMI__STMSG_PreCond_CfgStat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PreCond_CfgStat_AR
{
    if( getValue( this ) )
        openPanel("PreCond_CfgStat_AR");
}

on EnvVar HMI_HVAC_PreCond2_Disp_Rq
{
    _mPreCond_CfgStat_AR.HVAC_PreCond2_Disp_Rq.phys = getValue(this);
    _PreCond_CfgStat_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_PreCond4_Disp_Rq
{
    _mPreCond_CfgStat_AR.HVAC_PreCond4_Disp_Rq.phys = getValue(this);
    _PreCond_CfgStat_AR_SpontanFlag = 1;
}

on EnvVar HMI_HVAC_PreCond_Disp_Rq
{
    _mPreCond_CfgStat_AR.HVAC_PreCond_Disp_Rq.phys = getValue(this);
    _PreCond_CfgStat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PreCond_AirFrshnr_CfgStat
{
    _mPreCond_CfgStat_AR.PreCond_AirFrshnr_CfgStat.phys = getValue(this);
    _PreCond_CfgStat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PreCond_Ionzr_CfgStat
{
    _mPreCond_CfgStat_AR.PreCond_Ionzr_CfgStat.phys = getValue(this);
    _PreCond_CfgStat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PreCond_Mode_CfgStat
{
    _mPreCond_CfgStat_AR.PreCond_Mode_CfgStat.phys = getValue(this);
    _PreCond_CfgStat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PreCond_Seat_FL_CfgStat
{
    _mPreCond_CfgStat_AR.PreCond_Seat_FL_CfgStat.phys = getValue(this);
    _PreCond_CfgStat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PreCond_Seat_FR_CfgStat
{
    _mPreCond_CfgStat_AR.PreCond_Seat_FR_CfgStat.phys = getValue(this);
    _PreCond_CfgStat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PreCond_Seat_RL_CfgStat
{
    _mPreCond_CfgStat_AR.PreCond_Seat_RL_CfgStat.phys = getValue(this);
    _PreCond_CfgStat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PreCond_Seat_RR_CfgStat
{
    _mPreCond_CfgStat_AR.PreCond_Seat_RR_CfgStat.phys = getValue(this);
    _PreCond_CfgStat_AR_SpontanFlag = 1;
}

void PresfCtrl_Rq_ESP_Activity(int active )
{
      if( active )
      {
          if( _PresfCtrl_Rq_ESP_AR_SigActivity == 0)
            _PresfCtrl_Rq_ESP_AR_Cnt = 1;
        _PresfCtrl_Rq_ESP_AR_SigActivity++;
      }
    else
    {
        _PresfCtrl_Rq_ESP_AR_SigActivity--;
      }
}

int PresfCtrl_Rq_ESP_AR_Change(int lastValue, int sigValue, int inActValue )
{
    bActiveHelper = (sigValue != inActValue );
      if( !lastValue && bActiveHelper )
        PresfCtrl_Rq_ESP_Activity( 1 );
      else if( lastValue && !bActiveHelper )
        PresfCtrl_Rq_ESP_Activity(0 );
    return bActiveHelper;
}

PresfCtrl_Rq_ESP_AR_check_output()
{
    if( !getValue( HMI__STMSG_PresfCtrl_Rq_ESP_AR ) )
    {
    //  message   PresfCtrl_Rq_ESP_AR ID: 33 --- Sendeart 8 cyclicIfActiveFast --- 
        _PresfCtrl_Rq_ESP_AR_Cnt--;
        if( _PresfCtrl_Rq_ESP_AR_Cnt < 1 )
        {
            PresfCtrl_Rq_ESP_AR_output(); // Zyklus abgelaufen, Nachricht senden
            _PresfCtrl_Rq_ESP_AR_Cnt = _PresfCtrl_Rq_ESP_AR_SigActivity ? _PresfCtrl_Rq_ESP_AR_CycleCountFast : _PresfCtrl_Rq_ESP_AR_CycleCountSlow;
        }
    }
}

PresfCtrl_Rq_ESP_AR_init()
{   /* Botschaft PresfCtrl_Rq_ESP_AR ID: 33 --- Sendeart 8 cyclicIfActiveFast --- 
BA_ "ApplMessage" BO_ 33 0;
BA_ "NmAsrMessage" BO_ 33 0;
BA_ "GenMsgMinAcceptLength" BO_ 33 8;
BA_ "GenMsgILSupport" BO_ 33 1;
BA_ "DiagState" BO_ 33 0;
BA_ "DiagRequest" BO_ 33 0;
BA_ "DiagResponse" BO_ 33 0;
BA_ "GenMsgStartValue" BO_ 33 "0";
BA_ "GenMsgDelayTime" BO_ 33 5;
BA_ "GenMsgCycleTime" BO_ 33 200;
BA_ "GenMsgCycleTimeActive" BO_ 33 20;
BA_ "GenMsgSendType" BO_ 33 8;
    */
    _PresfCtrl_Rq_ESP_AR_Timebase =           c_tDBKomTimer_20ms;
    _PresfCtrl_Rq_ESP_AR_CycleCountSlow =     200 / _PresfCtrl_Rq_ESP_AR_Timebase;
    _PresfCtrl_Rq_ESP_AR_CycleCountFast =      20 / _PresfCtrl_Rq_ESP_AR_Timebase;
    _PresfCtrl_Rq_ESP_AR_StartDelay =           0 / _PresfCtrl_Rq_ESP_AR_Timebase;
    _PresfCtrl_Rq_ESP_AR_Cnt = _PresfCtrl_Rq_ESP_AR_StartDelay;
    _PresfCtrl_Rq_ESP_AR_SigActivity = 0;

    putValue( HMI__STMSGSD_PresfCtrl_Rq_ESP_AR, _PresfCtrl_Rq_ESP_AR_StartDelay * _PresfCtrl_Rq_ESP_AR_Timebase );
    
    _mPresfCtrl_Rq_ESP_AR.Presf_Enbl.phys = getValue( HMI_Presf_Enbl );
    _mPresfCtrl_Rq_ESP_AR.Presf_FricFctr_Lo.phys = getValue( HMI_Presf_FricFctr_Lo );
    _mPresfCtrl_Rq_ESP_AR.Presf_Lvl_V2.phys = getValue( HMI_Presf_Lvl_V2 );
    _mPresfCtrl_Rq_ESP_AR.Presf_Snd_Rq.phys = getValue( HMI_Presf_Snd_Rq );
    _mPresfCtrl_Rq_ESP_AR.PresfAccelReset_NotExcd.phys = getValue( HMI_PresfAccelReset_NotExcd );
    _mPresfCtrl_Rq_ESP_AR.PresfAct1_Adj_Rq.phys = getValue( HMI_PresfAct1_Adj_Rq );
    _mPresfCtrl_Rq_ESP_AR.PresfAct2_Adj_Rq.phys = getValue( HMI_PresfAct2_Adj_Rq );
    _mPresfCtrl_Rq_ESP_AR.PresfAct3_Adj_Rq.phys = getValue( HMI_PresfAct3_Adj_Rq );
    _mPresfCtrl_Rq_ESP_AR.PresfAct4_Adj_Rq.phys = getValue( HMI_PresfAct4_Adj_Rq );
    _mPresfCtrl_Rq_ESP_AR.PresfAct5_Adj_Rq.phys = getValue( HMI_PresfAct5_Adj_Rq );
    _mPresfCtrl_Rq_ESP_AR.PresfAct6_Adj_Rq.phys = getValue( HMI_PresfAct6_Adj_Rq );
    _mPresfCtrl_Rq_ESP_AR.PresfAct7_Adj_Rq.phys = getValue( HMI_PresfAct7_Adj_Rq );
    _mPresfCtrl_Rq_ESP_AR.PresfAct8_Adj_Rq.phys = getValue( HMI_PresfAct8_Adj_Rq );
    _mPresfCtrl_Rq_ESP_AR.PresfAct9_Adj_Rq.phys = getValue( HMI_PresfAct9_Adj_Rq );
    _mPresfCtrl_Rq_ESP_AR.PresfAct10_Adj_Rq.phys = getValue( HMI_PresfAct10_Adj_Rq );
    _mPresfCtrl_Rq_ESP_AR.PresfAct11_Adj_Rq.phys = getValue( HMI_PresfAct11_Adj_Rq );
    _mPresfCtrl_Rq_ESP_AR.PresfAct12_Adj_Rq.phys = getValue( HMI_PresfAct12_Adj_Rq );
    _mPresfCtrl_Rq_ESP_AR.PresfAct_Adj_Tgl.phys = getValue( HMI_PresfAct_Adj_Tgl );
//    _mPresfCtrl_Rq_ESP_AR.Rsrv1_PresfCtrl_Rq_ESP.phys = getValue( HMI_Rsrv1_PresfCtrl_Rq_ESP );
    _mPresfCtrl_Rq_ESP_AR.Rsrv2_PresfCtrl_Rq_ESP.phys = getValue( HMI_Rsrv2_PresfCtrl_Rq_ESP );
    _mPresfCtrl_Rq_ESP_AR.Rsrv3_PresfCtrl_Rq_ESP.phys = getValue( HMI_Rsrv3_PresfCtrl_Rq_ESP );
    _mPresfCtrl_Rq_ESP_AR.ESP_VtltCoach_Stat.phys = getValue( HMI_ESP_VtltCoach_Stat );
    _mPresfCtrl_Rq_ESP_AR.Rsrv5_PresfCtrl_Rq_ESP.phys = getValue( HMI_Rsrv5_PresfCtrl_Rq_ESP );
    _mPresfCtrl_Rq_ESP_AR.Rsrv6_PresfCtrl_Rq_ESP.phys = getValue( HMI_Rsrv6_PresfCtrl_Rq_ESP );
}

PresfCtrl_Rq_ESP_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_PresfCtrl_Rq_ESP ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_PresfCtrl_Rq_ESP_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _PresfCtrl_Rq_ESP_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _PresfCtrl_Rq_ESP_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_PresfCtrl_Rq_ESP_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _PresfCtrl_Rq_ESP_AR_SQC_WrongSeqJump != 0 ) &&
            ( _PresfCtrl_Rq_ESP_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _PresfCtrl_Rq_ESP_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _PresfCtrl_Rq_ESP_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _PresfCtrl_Rq_ESP_AR_SQC_RepeatedCnt ) &&
            ( _PresfCtrl_Rq_ESP_AR_E2E_Armed == 1  )    )
        {
            _PresfCtrl_Rq_ESP_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_PresfCtrl_Rq_ESP, SQC_help );
    }
    _mPresfCtrl_Rq_ESP_AR.SQC_PresfCtrl_Rq_ESP = SQC_help;

    if( !getValue( HMI_PresfAct_Adj_Tgl_Auto ) )
    {
       // berechne message counter
        if( _mPresfCtrl_Rq_ESP_AR.PresfAct_Adj_Tgl >= 1 ) _mPresfCtrl_Rq_ESP_AR.PresfAct_Adj_Tgl = 0;
        else _mPresfCtrl_Rq_ESP_AR.PresfAct_Adj_Tgl++;
        putValue( HMI_PresfAct_Adj_Tgl, _mPresfCtrl_Rq_ESP_AR.PresfAct_Adj_Tgl);
    }
    else
          _mPresfCtrl_Rq_ESP_AR.PresfAct_Adj_Tgl = getValue( HMI_PresfAct_Adj_Tgl);

    if( getValue( HMI_CRC_PresfCtrl_Rq_ESP_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_PresfCtrl_Rq_ESP_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mPresfCtrl_Rq_ESP_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mPresfCtrl_Rq_ESP_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mPresfCtrl_Rq_ESP_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mPresfCtrl_Rq_ESP_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mPresfCtrl_Rq_ESP_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mPresfCtrl_Rq_ESP_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mPresfCtrl_Rq_ESP_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mPresfCtrl_Rq_ESP_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _PresfCtrl_Rq_ESP_AR_CRC_Offset[ _mPresfCtrl_Rq_ESP_AR.SQC_PresfCtrl_Rq_ESP ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _PresfCtrl_Rq_ESP_AR_CRC_ErrorCnt   && ( _PresfCtrl_Rq_ESP_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_PresfCtrl_Rq_ESP_Invalid )                                         )    )
            {
                crc++;
                if( _PresfCtrl_Rq_ESP_AR_CRC_ErrorCnt > 0 )
                    _PresfCtrl_Rq_ESP_AR_CRC_ErrorCnt--; 
            }
            _mPresfCtrl_Rq_ESP_AR.CRC_PresfCtrl_Rq_ESP = crc;
            putValue( HMI_CRC_PresfCtrl_Rq_ESP, crc );
        }
        else
            _mPresfCtrl_Rq_ESP_AR.CRC_PresfCtrl_Rq_ESP = getValue( HMI_CRC_PresfCtrl_Rq_ESP );
    }
    else
    {
        if( !getValue( HMI_CRC_PresfCtrl_Rq_ESP_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mPresfCtrl_Rq_ESP_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mPresfCtrl_Rq_ESP_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mPresfCtrl_Rq_ESP_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mPresfCtrl_Rq_ESP_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mPresfCtrl_Rq_ESP_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mPresfCtrl_Rq_ESP_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mPresfCtrl_Rq_ESP_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mPresfCtrl_Rq_ESP_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _PresfCtrl_Rq_ESP_AR_CRC_ErrorCnt   && ( _PresfCtrl_Rq_ESP_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_PresfCtrl_Rq_ESP_Invalid )                                         )    )
            {
                crc++;
                if( _PresfCtrl_Rq_ESP_AR_CRC_ErrorCnt > 0 )
                    _PresfCtrl_Rq_ESP_AR_CRC_ErrorCnt--; 
            }
            _mPresfCtrl_Rq_ESP_AR.CRC_PresfCtrl_Rq_ESP = crc;
            putValue( HMI_CRC_PresfCtrl_Rq_ESP, crc );
        }
        else
            _mPresfCtrl_Rq_ESP_AR.CRC_PresfCtrl_Rq_ESP = getValue( HMI_CRC_PresfCtrl_Rq_ESP );
    }
    if( ( _PresfCtrl_Rq_ESP_AR_MSG_DropCnt > 0 ) &&
        ( _PresfCtrl_Rq_ESP_AR_E2E_Armed == 1  )    )
    {
        _PresfCtrl_Rq_ESP_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mPresfCtrl_Rq_ESP_AR );
        
    if( _PresfCtrl_Rq_ESP_AR_E2E_Armed == 1 )
    {
        if ( ( _PresfCtrl_Rq_ESP_AR_MSG_DropCnt == 0      ) &&
             ( _PresfCtrl_Rq_ESP_AR_CRC_ErrorCnt == 0     ) &&
             ( _PresfCtrl_Rq_ESP_AR_SQC_RepeatedCnt == 0  ) &&
             ( _PresfCtrl_Rq_ESP_AR_SQC_WrongSeqJump == 0 )    )
        {
            _PresfCtrl_Rq_ESP_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_PresfCtrl_Rq_ESP_State, 0 );
        }
    }
}

PresfCtrl_Rq_ESP_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PresfCtrl_Rq_ESP_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PresfCtrl_Rq_ESP := %X\n", getValue( HMI__STMSG_PresfCtrl_Rq_ESP_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PresfCtrl_Rq_ESP := %X\n", getValue( HMI__STMSGT_PresfCtrl_Rq_ESP_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_PresfCtrl_Rq_ESP := %X\n", getValue( HMI_CRC_PresfCtrl_Rq_ESP ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_PresfCtrl_Rq_ESP_Auto := %X\n", getValue( HMI_CRC_PresfCtrl_Rq_ESP_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Presf_Enbl := %X\n", getValue( HMI_Presf_Enbl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Presf_FricFctr_Lo := %X\n", getValue( HMI_Presf_FricFctr_Lo ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Presf_Lvl_V2 := %X\n", getValue( HMI_Presf_Lvl_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Presf_Snd_Rq := %X\n", getValue( HMI_Presf_Snd_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PresfAccelReset_NotExcd := %X\n", getValue( HMI_PresfAccelReset_NotExcd ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PresfAct1_Adj_Rq := %X\n", getValue( HMI_PresfAct1_Adj_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PresfAct2_Adj_Rq := %X\n", getValue( HMI_PresfAct2_Adj_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PresfAct3_Adj_Rq := %X\n", getValue( HMI_PresfAct3_Adj_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PresfAct4_Adj_Rq := %X\n", getValue( HMI_PresfAct4_Adj_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PresfAct5_Adj_Rq := %X\n", getValue( HMI_PresfAct5_Adj_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PresfAct6_Adj_Rq := %X\n", getValue( HMI_PresfAct6_Adj_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PresfAct7_Adj_Rq := %X\n", getValue( HMI_PresfAct7_Adj_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PresfAct8_Adj_Rq := %X\n", getValue( HMI_PresfAct8_Adj_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PresfAct9_Adj_Rq := %X\n", getValue( HMI_PresfAct9_Adj_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PresfAct10_Adj_Rq := %X\n", getValue( HMI_PresfAct10_Adj_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PresfAct11_Adj_Rq := %X\n", getValue( HMI_PresfAct11_Adj_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PresfAct12_Adj_Rq := %X\n", getValue( HMI_PresfAct12_Adj_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PresfAct_Adj_Tgl := %X\n", getValue( HMI_PresfAct_Adj_Tgl ) );    filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_PresfCtrl_Rq_ESP := %X\n", getValue( HMI_Rsrv1_PresfCtrl_Rq_ESP ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_PresfCtrl_Rq_ESP := %X\n", getValue( HMI_Rsrv2_PresfCtrl_Rq_ESP ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv3_PresfCtrl_Rq_ESP := %X\n", getValue( HMI_Rsrv3_PresfCtrl_Rq_ESP ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ESP_VtltCoach_Stat := %X\n", getValue( HMI_ESP_VtltCoach_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv5_PresfCtrl_Rq_ESP := %X\n", getValue( HMI_Rsrv5_PresfCtrl_Rq_ESP ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv6_PresfCtrl_Rq_ESP := %X\n", getValue( HMI_Rsrv6_PresfCtrl_Rq_ESP ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_PresfCtrl_Rq_ESP := %X\n", getValue( HMI_SQC_PresfCtrl_Rq_ESP ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_PresfCtrl_Rq_ESP_Auto := %X\n", getValue( HMI_SQC_PresfCtrl_Rq_ESP_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPresfCtrl_Rq_ESP_AR
{
    putValue( HMI__STMSG_PresfCtrl_Rq_ESP_AR, 0 );
}

on EnvVar HMI__STMSG_PresfCtrl_Rq_ESP_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PresfCtrl_Rq_ESP_AR );
        if( tDelay > 0)    
            setTimer( _tPresfCtrl_Rq_ESP_AR, tDelay );
        else
            putValue( HMI__STMSG_PresfCtrl_Rq_ESP_AR, 0 );
    }
}

on EnvVar HMI__ALLDEF_PresfCtrl_Rq_ESP_AR
{
    if( getValue(this) )
    {
        // alle signale auf default einstellen
        putValue( HMI_Rsrv6_PresfCtrl_Rq_ESP, 0 );
        putValue( HMI_Rsrv5_PresfCtrl_Rq_ESP, 0 );
        putValue( HMI_Rsrv4_PresfCtrl_Rq_ESP, 0 );
        putValue( HMI_Rsrv3_PresfCtrl_Rq_ESP, 0 );
        putValue( HMI_Rsrv2_PresfCtrl_Rq_ESP, 0 );
//        putValue( HMI_Rsrv1_PresfCtrl_Rq_ESP, 0 );
        putValue( HMI_Presf_Lvl_V2, 0 );
    }
}

on envVar HMI__STMSG_PO_PresfCtrl_Rq_ESP_AR
{
    if( getValue( this ) )
        openPanel("PresfCtrl_Rq_ESP_AR");
}

on envVar HMI_E2E_PresfCtrl_Rq_ESP_Inject
{
    if( getValue( this ) )
    {
        _PresfCtrl_Rq_ESP_AR_CRC_ErrorCnt = getValue( HMI_CRC_PresfCtrl_Rq_ESP_ErrorCount );
        _PresfCtrl_Rq_ESP_AR_SQC_TriggPos = getValue( HMI_SQC_PresfCtrl_Rq_ESP_TriggerPosition );
        _PresfCtrl_Rq_ESP_AR_SQC_WrongSeqJump = getValue( HMI_SQC_PresfCtrl_Rq_ESP_WrongSeq );
        _PresfCtrl_Rq_ESP_AR_SQC_RepeatedCnt = getValue( HMI_SQC_PresfCtrl_Rq_ESP_Repeated );
        _PresfCtrl_Rq_ESP_AR_MSG_DropCnt = getValue( HMI_SQC_PresfCtrl_Rq_ESP_MSG_DropCnt );
        putValue( HMI_E2E_PresfCtrl_Rq_ESP_State, 2 );
        _PresfCtrl_Rq_ESP_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_Presf_Enbl
{
    _mPresfCtrl_Rq_ESP_AR.Presf_Enbl.phys = getValue(this);
}

on EnvVar HMI_Presf_FricFctr_Lo
{
    _mPresfCtrl_Rq_ESP_AR.Presf_FricFctr_Lo.phys = getValue(this);
}

on EnvVar HMI_Presf_Lvl_V2
{
    _mPresfCtrl_Rq_ESP_AR.Presf_Lvl_V2.phys = getValue(this);
    _PresfCtrl_Rq_ESP_AR_Presf_Lvl_V2_LastState = PresfCtrl_Rq_ESP_AR_Change( _PresfCtrl_Rq_ESP_AR_Presf_Lvl_V2_LastState, _mPresfCtrl_Rq_ESP_AR.Presf_Lvl_V2, 0 );
}

on EnvVar HMI_Presf_Snd_Rq
{
    _mPresfCtrl_Rq_ESP_AR.Presf_Snd_Rq.phys = getValue(this);
}

on EnvVar HMI_PresfAccelReset_NotExcd
{
    _mPresfCtrl_Rq_ESP_AR.PresfAccelReset_NotExcd.phys = getValue(this);
}

on EnvVar HMI_PresfAct1_Adj_Rq
{
    _mPresfCtrl_Rq_ESP_AR.PresfAct1_Adj_Rq.phys = getValue(this);
}

on EnvVar HMI_PresfAct2_Adj_Rq
{
    _mPresfCtrl_Rq_ESP_AR.PresfAct2_Adj_Rq.phys = getValue(this);
}

on EnvVar HMI_PresfAct3_Adj_Rq
{
    _mPresfCtrl_Rq_ESP_AR.PresfAct3_Adj_Rq.phys = getValue(this);
}

on EnvVar HMI_PresfAct4_Adj_Rq
{
    _mPresfCtrl_Rq_ESP_AR.PresfAct4_Adj_Rq.phys = getValue(this);
}

on EnvVar HMI_PresfAct5_Adj_Rq
{
    _mPresfCtrl_Rq_ESP_AR.PresfAct5_Adj_Rq.phys = getValue(this);
}

on EnvVar HMI_PresfAct6_Adj_Rq
{
    _mPresfCtrl_Rq_ESP_AR.PresfAct6_Adj_Rq.phys = getValue(this);
}

on EnvVar HMI_PresfAct7_Adj_Rq
{
    _mPresfCtrl_Rq_ESP_AR.PresfAct7_Adj_Rq.phys = getValue(this);
}

on EnvVar HMI_PresfAct8_Adj_Rq
{
    _mPresfCtrl_Rq_ESP_AR.PresfAct8_Adj_Rq.phys = getValue(this);
}

on EnvVar HMI_PresfAct9_Adj_Rq
{
    _mPresfCtrl_Rq_ESP_AR.PresfAct9_Adj_Rq.phys = getValue(this);
}

on EnvVar HMI_PresfAct10_Adj_Rq
{
    _mPresfCtrl_Rq_ESP_AR.PresfAct10_Adj_Rq.phys = getValue(this);
}

on EnvVar HMI_PresfAct11_Adj_Rq
{
    _mPresfCtrl_Rq_ESP_AR.PresfAct11_Adj_Rq.phys = getValue(this);
}

on EnvVar HMI_PresfAct12_Adj_Rq
{
    _mPresfCtrl_Rq_ESP_AR.PresfAct12_Adj_Rq.phys = getValue(this);
}

on EnvVar HMI_Rsrv2_PresfCtrl_Rq_ESP
{
    _mPresfCtrl_Rq_ESP_AR.Rsrv2_PresfCtrl_Rq_ESP.phys = getValue(this);
    _PresfCtrl_Rq_ESP_AR_Rsrv2_PresfCtrl_Rq_ESP_LastState = PresfCtrl_Rq_ESP_AR_Change( _PresfCtrl_Rq_ESP_AR_Rsrv2_PresfCtrl_Rq_ESP_LastState, _mPresfCtrl_Rq_ESP_AR.Rsrv2_PresfCtrl_Rq_ESP, 0 );
}

on EnvVar HMI_Rsrv3_PresfCtrl_Rq_ESP
{
    _mPresfCtrl_Rq_ESP_AR.Rsrv3_PresfCtrl_Rq_ESP.phys = getValue(this);
    _PresfCtrl_Rq_ESP_AR_Rsrv3_PresfCtrl_Rq_ESP_LastState = PresfCtrl_Rq_ESP_AR_Change( _PresfCtrl_Rq_ESP_AR_Rsrv3_PresfCtrl_Rq_ESP_LastState, _mPresfCtrl_Rq_ESP_AR.Rsrv3_PresfCtrl_Rq_ESP, 0 );
}

on EnvVar HMI_ESP_VtltCoach_Stat
{
    _mPresfCtrl_Rq_ESP_AR.ESP_VtltCoach_Stat.phys = getValue(this);
}

on EnvVar HMI_Rsrv5_PresfCtrl_Rq_ESP
{
    _mPresfCtrl_Rq_ESP_AR.Rsrv5_PresfCtrl_Rq_ESP.phys = getValue(this);
    _PresfCtrl_Rq_ESP_AR_Rsrv5_PresfCtrl_Rq_ESP_LastState = PresfCtrl_Rq_ESP_AR_Change( _PresfCtrl_Rq_ESP_AR_Rsrv5_PresfCtrl_Rq_ESP_LastState, _mPresfCtrl_Rq_ESP_AR.Rsrv5_PresfCtrl_Rq_ESP, 0 );
}

on EnvVar HMI_Rsrv6_PresfCtrl_Rq_ESP
{
    _mPresfCtrl_Rq_ESP_AR.Rsrv6_PresfCtrl_Rq_ESP.phys = getValue(this);
    _PresfCtrl_Rq_ESP_AR_Rsrv6_PresfCtrl_Rq_ESP_LastState = PresfCtrl_Rq_ESP_AR_Change( _PresfCtrl_Rq_ESP_AR_Rsrv6_PresfCtrl_Rq_ESP_LastState, _mPresfCtrl_Rq_ESP_AR.Rsrv6_PresfCtrl_Rq_ESP, 0 );
}


PNHV_Bat_Warn_Rq_V2_AR2_check_output()
{
    if( !getValue( HMI__STMSG_PNHV_Bat_Warn_Rq_V2_AR2 ) )
    {
    //  message   PNHV_Bat_Warn_Rq_V2_AR2 ID: 1035 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _PNHV_Bat_Warn_Rq_V2_AR2_DelayCnt > 0) _PNHV_Bat_Warn_Rq_V2_AR2_DelayCnt--; // Mindestsendeabstand
        _PNHV_Bat_Warn_Rq_V2_AR2_Cnt--;
        if( _PNHV_Bat_Warn_Rq_V2_AR2_Cnt < 1 )
        {
            if( _PNHV_Bat_Warn_Rq_V2_AR2_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                PNHV_Bat_Warn_Rq_V2_AR2_output();
                 _PNHV_Bat_Warn_Rq_V2_AR2_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _PNHV_Bat_Warn_Rq_V2_AR2_DelayCnt = _PNHV_Bat_Warn_Rq_V2_AR2_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _PNHV_Bat_Warn_Rq_V2_AR2_SpontanFlag = 1;
            }
            _PNHV_Bat_Warn_Rq_V2_AR2_Cnt = _PNHV_Bat_Warn_Rq_V2_AR2_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _PNHV_Bat_Warn_Rq_V2_AR2_SpontanFlag)
        {
            if( _PNHV_Bat_Warn_Rq_V2_AR2_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                PNHV_Bat_Warn_Rq_V2_AR2_output();
                _PNHV_Bat_Warn_Rq_V2_AR2_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _PNHV_Bat_Warn_Rq_V2_AR2_DelayCnt = _PNHV_Bat_Warn_Rq_V2_AR2_MinDelay;
            }
        }
    }
}

PNHV_Bat_Warn_Rq_V2_AR2_init()
{   /* Botschaft PNHV_Bat_Warn_Rq_V2_AR2  ID: 1035 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1035 0;
BA_ "NmAsrMessage" BO_ 1035 0;
BA_ "GenMsgMinAcceptLength" BO_ 1035 8;
BA_ "GenMsgILSupport" BO_ 1035 1;
BA_ "DiagState" BO_ 1035 0;
BA_ "DiagRequest" BO_ 1035 0;
BA_ "DiagResponse" BO_ 1035 0;
BA_ "GenMsgStartValue" BO_ 1035 "0";
BA_ "GenMsgDelayTime" BO_ 1035 40;
BA_ "GenMsgNrOfRepetitions" BO_ 1035 0;
BA_ "GenMsgCycleTime" BO_ 1035 1000;
BA_ "GenMsgSendType" BO_ 1035 5;
    */
    _PNHV_Bat_Warn_Rq_V2_AR2_Timebase =             c_tDBKomTimer_20ms;
    _PNHV_Bat_Warn_Rq_V2_AR2_CycleCount =          1000 / _PNHV_Bat_Warn_Rq_V2_AR2_Timebase;
    _PNHV_Bat_Warn_Rq_V2_AR2_StartDelay =            0 / _PNHV_Bat_Warn_Rq_V2_AR2_Timebase;
    _PNHV_Bat_Warn_Rq_V2_AR2_MinDelay =             40 / _PNHV_Bat_Warn_Rq_V2_AR2_Timebase;
    _PNHV_Bat_Warn_Rq_V2_AR2_Cnt = _PNHV_Bat_Warn_Rq_V2_AR2_StartDelay;
    _PNHV_Bat_Warn_Rq_V2_AR2_SpontanFlag = 0;
    _PNHV_Bat_Warn_Rq_V2_AR2_DelayCnt = 0;

    putValue( HMI__STMSGSD_PNHV_Bat_Warn_Rq_V2_AR2, _PNHV_Bat_Warn_Rq_V2_AR2_StartDelay * _PNHV_Bat_Warn_Rq_V2_AR2_Timebase);
    
    _mPNHV_Bat_Warn_Rq_V2_AR2.PNHV_Thermal_Event_Disp_Rq_V2.phys = getValue( HMI_PNHV_Thermal_Event_Disp_Rq_V2 );
    _mPNHV_Bat_Warn_Rq_V2_AR2.Rsrv0_PNHV_Bat_Warn_Rq_V2.phys = getValue( HMI_Rsrv0_PNHV_Bat_Warn_Rq_V2 );
    _mPNHV_Bat_Warn_Rq_V2_AR2.Rsrv1_PNHV_Bat_Warn_Rq_V2.phys = getValue( HMI_Rsrv1_PNHV_Bat_Warn_Rq_V2 );
}

PNHV_Bat_Warn_Rq_V2_AR2_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_PNHV_Bat_Warn_Rq_V2 ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_PNHV_Bat_Warn_Rq_V2_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _PNHV_Bat_Warn_Rq_V2_AR2_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _PNHV_Bat_Warn_Rq_V2_AR2_E2E_Armed = 1;   // run
            putValue( HMI_E2E_PNHV_Bat_Warn_Rq_V2_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _PNHV_Bat_Warn_Rq_V2_AR2_SQC_WrongSeqJump != 0 ) &&
            ( _PNHV_Bat_Warn_Rq_V2_AR2_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _PNHV_Bat_Warn_Rq_V2_AR2_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _PNHV_Bat_Warn_Rq_V2_AR2_SQC_WrongSeqJump = 0;
        }
        
        if( ( _PNHV_Bat_Warn_Rq_V2_AR2_SQC_RepeatedCnt ) &&
            ( _PNHV_Bat_Warn_Rq_V2_AR2_E2E_Armed == 1  )    )
        {
            _PNHV_Bat_Warn_Rq_V2_AR2_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_PNHV_Bat_Warn_Rq_V2, SQC_help );
    }
    _mPNHV_Bat_Warn_Rq_V2_AR2.SQC_PNHV_Bat_Warn_Rq_V2 = SQC_help;

    if( getValue( HMI_CRC_PNHV_Bat_Warn_Rq_V2_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_PNHV_Bat_Warn_Rq_V2_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable_profile02[ crc ^ _mPNHV_Bat_Warn_Rq_V2_AR2.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mPNHV_Bat_Warn_Rq_V2_AR2.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mPNHV_Bat_Warn_Rq_V2_AR2.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mPNHV_Bat_Warn_Rq_V2_AR2.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mPNHV_Bat_Warn_Rq_V2_AR2.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mPNHV_Bat_Warn_Rq_V2_AR2.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mPNHV_Bat_Warn_Rq_V2_AR2.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mPNHV_Bat_Warn_Rq_V2_AR2.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _PNHV_Bat_Warn_Rq_V2_AR2_CRC_Offset[ _mPNHV_Bat_Warn_Rq_V2_AR2.SQC_PNHV_Bat_Warn_Rq_V2 ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _PNHV_Bat_Warn_Rq_V2_AR2_CRC_ErrorCnt   && ( _PNHV_Bat_Warn_Rq_V2_AR2_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_PNHV_Bat_Warn_Rq_V2_Invalid )                                         )    )
            {
                crc++;
                if( _PNHV_Bat_Warn_Rq_V2_AR2_CRC_ErrorCnt > 0 )
                    _PNHV_Bat_Warn_Rq_V2_AR2_CRC_ErrorCnt--; 
            }
            _mPNHV_Bat_Warn_Rq_V2_AR2.CRC_PNHV_Bat_Warn_Rq_V2 = crc;
            putValue( HMI_CRC_PNHV_Bat_Warn_Rq_V2, crc );
        }
        else
            _mPNHV_Bat_Warn_Rq_V2_AR2.CRC_PNHV_Bat_Warn_Rq_V2 = getValue( HMI_CRC_PNHV_Bat_Warn_Rq_V2 );
    }
    else
    {
        if( !getValue( HMI_CRC_PNHV_Bat_Warn_Rq_V2_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mPNHV_Bat_Warn_Rq_V2_AR2.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mPNHV_Bat_Warn_Rq_V2_AR2.byte( 1 ) ];
            crc = crctable[ crc ^ _mPNHV_Bat_Warn_Rq_V2_AR2.byte( 2 ) ];
            crc = crctable[ crc ^ _mPNHV_Bat_Warn_Rq_V2_AR2.byte( 3 ) ];
            crc = crctable[ crc ^ _mPNHV_Bat_Warn_Rq_V2_AR2.byte( 4 ) ];
            crc = crctable[ crc ^ _mPNHV_Bat_Warn_Rq_V2_AR2.byte( 5 ) ];
            crc = crctable[ crc ^ _mPNHV_Bat_Warn_Rq_V2_AR2.byte( 6 ) ];
            crc = crctable[ crc ^ _mPNHV_Bat_Warn_Rq_V2_AR2.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _PNHV_Bat_Warn_Rq_V2_AR2_CRC_ErrorCnt   && ( _PNHV_Bat_Warn_Rq_V2_AR2_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_PNHV_Bat_Warn_Rq_V2_Invalid )                                         )    )
            {
                crc++;
                if( _PNHV_Bat_Warn_Rq_V2_AR2_CRC_ErrorCnt > 0 )
                    _PNHV_Bat_Warn_Rq_V2_AR2_CRC_ErrorCnt--; 
            }
            _mPNHV_Bat_Warn_Rq_V2_AR2.CRC_PNHV_Bat_Warn_Rq_V2 = crc;
            putValue( HMI_CRC_PNHV_Bat_Warn_Rq_V2, crc );
        }
        else
            _mPNHV_Bat_Warn_Rq_V2_AR2.CRC_PNHV_Bat_Warn_Rq_V2 = getValue( HMI_CRC_PNHV_Bat_Warn_Rq_V2 );
    }
    if( ( _PNHV_Bat_Warn_Rq_V2_AR2_MSG_DropCnt > 0 ) &&
        ( _PNHV_Bat_Warn_Rq_V2_AR2_E2E_Armed == 1  )    )
    {
        _PNHV_Bat_Warn_Rq_V2_AR2_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mPNHV_Bat_Warn_Rq_V2_AR2 );
        
    if( _PNHV_Bat_Warn_Rq_V2_AR2_E2E_Armed == 1 )
    {
        if ( ( _PNHV_Bat_Warn_Rq_V2_AR2_MSG_DropCnt == 0      ) &&
             ( _PNHV_Bat_Warn_Rq_V2_AR2_CRC_ErrorCnt == 0     ) &&
             ( _PNHV_Bat_Warn_Rq_V2_AR2_SQC_RepeatedCnt == 0  ) &&
             ( _PNHV_Bat_Warn_Rq_V2_AR2_SQC_WrongSeqJump == 0 )    )
        {
            _PNHV_Bat_Warn_Rq_V2_AR2_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_PNHV_Bat_Warn_Rq_V2_State, 0 );
        }
    }
}

PNHV_Bat_Warn_Rq_V2_AR2_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PNHV_Bat_Warn_Rq_V2_AR2\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PNHV_Bat_Warn_Rq_V2_AR2 := %X\n", getValue( HMI__STMSG_PNHV_Bat_Warn_Rq_V2_AR2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PNHV_Bat_Warn_Rq_V2_AR2 := %X\n", getValue( HMI__STMSGT_PNHV_Bat_Warn_Rq_V2_AR2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_PNHV_Bat_Warn_Rq_V2 := %X\n", getValue( HMI_CRC_PNHV_Bat_Warn_Rq_V2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_PNHV_Bat_Warn_Rq_V2_Auto := %X\n", getValue( HMI_CRC_PNHV_Bat_Warn_Rq_V2_Auto ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_PNHV_Bat_Warn_Rq_V2_Profile_02 := %X\n", getValue( HMI_CRC_PNHV_Bat_Warn_Rq_V2_Profile_02 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_Thermal_Event_Disp_Rq_V2 := %X\n", getValue( HMI_PNHV_Thermal_Event_Disp_Rq_V2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv0_PNHV_Bat_Warn_Rq_V2 := %X\n", getValue( HMI_Rsrv0_PNHV_Bat_Warn_Rq_V2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_PNHV_Bat_Warn_Rq_V2 := %X\n", getValue( HMI_Rsrv1_PNHV_Bat_Warn_Rq_V2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_PNHV_Bat_Warn_Rq_V2 := %X\n", getValue( HMI_SQC_PNHV_Bat_Warn_Rq_V2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_PNHV_Bat_Warn_Rq_V2_Auto := %X\n", getValue( HMI_SQC_PNHV_Bat_Warn_Rq_V2_Auto ) );    filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tPNHV_Bat_Warn_Rq_V2_AR2
{
    putValue( HMI__STMSG_PNHV_Bat_Warn_Rq_V2_AR2, 0 );
}

on EnvVar HMI__STMSG_PNHV_Bat_Warn_Rq_V2_AR2
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PNHV_Bat_Warn_Rq_V2_AR2 );
        if( tDelay > 0)    
            setTimer( _tPNHV_Bat_Warn_Rq_V2_AR2, tDelay );
        else
            putValue( HMI__STMSG_PNHV_Bat_Warn_Rq_V2_AR2, 0 );
    }
}

on envVar HMI_E2E_PNHV_Bat_Warn_Rq_V2_Inject
{
    if( getValue( this ) )
    {
        _PNHV_Bat_Warn_Rq_V2_AR2_CRC_ErrorCnt = getValue( HMI_CRC_PNHV_Bat_Warn_Rq_V2_ErrorCount );
        _PNHV_Bat_Warn_Rq_V2_AR2_SQC_TriggPos = getValue( HMI_SQC_PNHV_Bat_Warn_Rq_V2_TriggerPosition );
        _PNHV_Bat_Warn_Rq_V2_AR2_SQC_WrongSeqJump = getValue( HMI_SQC_PNHV_Bat_Warn_Rq_V2_WrongSeq );
        _PNHV_Bat_Warn_Rq_V2_AR2_SQC_RepeatedCnt = getValue( HMI_SQC_PNHV_Bat_Warn_Rq_V2_Repeated );
        _PNHV_Bat_Warn_Rq_V2_AR2_MSG_DropCnt = getValue( HMI_SQC_PNHV_Bat_Warn_Rq_V2_MSG_DropCnt );
        putValue( HMI_E2E_PNHV_Bat_Warn_Rq_V2_State, 2 );
        _PNHV_Bat_Warn_Rq_V2_AR2_E2E_Armed = 2;  //armed
    }
}

on envVar HMI__STMSG_PO_PNHV_Bat_Warn_Rq_V2_AR2
{
    if( getValue( this ) )
        openPanel("PNHV_Bat_Warn_Rq_V2_AR2");
}

on EnvVar HMI_PNHV_Thermal_Event_Disp_Rq_V2
{
    _mPNHV_Bat_Warn_Rq_V2_AR2.PNHV_Thermal_Event_Disp_Rq_V2.phys = getValue(this);
    _PNHV_Bat_Warn_Rq_V2_AR2_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_PNHV_Bat_Warn_Rq_V2
{
    _mPNHV_Bat_Warn_Rq_V2_AR2.Rsrv1_PNHV_Bat_Warn_Rq_V2.phys = getValue(this);
    _PNHV_Bat_Warn_Rq_V2_AR2_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv0_PNHV_Bat_Warn_Rq_V2
{
    _mPNHV_Bat_Warn_Rq_V2_AR2.Rsrv0_PNHV_Bat_Warn_Rq_V2.phys = getValue(this);
    _PNHV_Bat_Warn_Rq_V2_AR2_SpontanFlag = 1;
}

PNHV_Bat_Warn_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_PNHV_Bat_Warn_Rq_AR ) )
    {
    //  Botschaft PNHV_Bat_Warn_Rq_AR ID: 934 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _PNHV_Bat_Warn_Rq_AR_Cnt--;
        if( _PNHV_Bat_Warn_Rq_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            PNHV_Bat_Warn_Rq_AR_output();
            _PNHV_Bat_Warn_Rq_AR_Cnt = _PNHV_Bat_Warn_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _PNHV_Bat_Warn_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
}
        else if( _PNHV_Bat_Warn_Rq_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            PNHV_Bat_Warn_Rq_AR_output();
            _PNHV_Bat_Warn_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

PNHV_Bat_Warn_Rq_AR_init()
{/* Botschaft PNHV_Bat_Warn_Rq_AR ID: 2459172864 --- Sendeart 5 cyclicAndSpontanWithDelay --- 

  BA_ "ApplMessage" BO_ 2459172864 0;
BA_ "NmAsrMessage" BO_ 2459172864 0;
BA_ "GenMsgMinAcceptLength" BO_ 2459172864 8;
BA_ "GenMsgILSupport" BO_ 2459172864 1;
BA_ "DiagState" BO_ 2459172864 0;
BA_ "DiagRequest" BO_ 2459172864 0;
BA_ "DiagResponse" BO_ 2459172864 0;
BA_ "GenMsgStartValue" BO_ 2459172864 "0";
BA_ "GenMsgDelayTime" BO_ 2459172864 200;
BA_ "GenMsgNrOfRepetition" BO_ 2459172864 0;
BA_ "GenMsgCycleTime" BO_ 2459172864 1000;
BA_ "GenMsgSendType" BO_ 2459172864 5;


    */
	

    _PNHV_Bat_Warn_Rq_AR_Timebase =         c_tDBKomTimer_20ms;
    _PNHV_Bat_Warn_Rq_AR_CycleCount =     1000 / _PNHV_Bat_Warn_Rq_AR_Timebase;
    _PNHV_Bat_Warn_Rq_AR_StartDelay =       0 / _PNHV_Bat_Warn_Rq_AR_Timebase;
    _PNHV_Bat_Warn_Rq_AR_Cnt = _PNHV_Bat_Warn_Rq_AR_StartDelay;
    _PNHV_Bat_Warn_Rq_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_PNHV_Bat_Warn_Rq_AR, _PNHV_Bat_Warn_Rq_AR_StartDelay * _PNHV_Bat_Warn_Rq_AR_Timebase );

    _mPNHV_Bat_Warn_Rq_AR.PNHV_Thermal_Event_Disp_Rq.phys = getValue( HMI_PNHV_Thermal_Event_Disp_Rq );
    _mPNHV_Bat_Warn_Rq_AR.Rsrv1_PNHV_Bat_Warn_Rq.phys = getValue( HMI_Rsrv1_PNHV_Bat_Warn_Rq );
    _mPNHV_Bat_Warn_Rq_AR.Rsrv0_PNHV_Bat_Warn_Rq.phys = getValue( HMI_Rsrv0_PNHV_Bat_Warn_Rq );
    _mPNHV_Bat_Warn_Rq_AR.BMS_RTM_Sync.phys = getValue( HMI_BMS_RTM_Sync );
    _mPNHV_Bat_Warn_Rq_AR.BMS_Bat_SOC_MinLim.phys = getValue( HMI_BMS_Bat_SOC_MinLim );
    _mPNHV_Bat_Warn_Rq_AR.BMS_Bat_SOC_MaxLim.phys = getValue( HMI_BMS_Bat_SOC_MaxLim );
}

PNHV_Bat_Warn_Rq_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_PNHV_Bat_Warn_Rq ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_PNHV_Bat_Warn_Rq_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _PNHV_Bat_Warn_Rq_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _PNHV_Bat_Warn_Rq_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_PSD_L_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _PNHV_Bat_Warn_Rq_AR_SQC_WrongSeqJump != 0 ) &&
            ( _PNHV_Bat_Warn_Rq_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _PNHV_Bat_Warn_Rq_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _PNHV_Bat_Warn_Rq_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _PNHV_Bat_Warn_Rq_AR_SQC_RepeatedCnt ) &&
            ( _PNHV_Bat_Warn_Rq_AR_E2E_Armed == 1  )    )
        {
            _PNHV_Bat_Warn_Rq_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_PNHV_Bat_Warn_Rq, SQC_help );
    }
    _mPNHV_Bat_Warn_Rq_AR.SQC_PNHV_Bat_Warn_Rq = SQC_help;

    if( getValue( HMI_CRC_PNHV_Bat_Warn_Rq_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_PNHV_Bat_Warn_Rq_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mPNHV_Bat_Warn_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mPNHV_Bat_Warn_Rq_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mPNHV_Bat_Warn_Rq_AR.byte( 2 ) ];
//            crc = crctable_profile02[ crc ^ _mPNHV_Bat_Warn_Rq_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mPNHV_Bat_Warn_Rq_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mPNHV_Bat_Warn_Rq_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mPNHV_Bat_Warn_Rq_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mPNHV_Bat_Warn_Rq_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _PNHV_Bat_Warn_Rq_AR_CRC_Offset[ _mPNHV_Bat_Warn_Rq_AR.SQC_PNHV_Bat_Warn_Rq ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _PNHV_Bat_Warn_Rq_AR_CRC_ErrorCnt   && ( _PNHV_Bat_Warn_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_PNHV_Bat_Warn_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _PNHV_Bat_Warn_Rq_AR_CRC_ErrorCnt > 0 )
                    _PNHV_Bat_Warn_Rq_AR_CRC_ErrorCnt--; 
            }
            _mPNHV_Bat_Warn_Rq_AR.CRC_PNHV_Bat_Warn_Rq = crc;
            putValue( HMI_CRC_PNHV_Bat_Warn_Rq, crc );
        }
        else
            _mPNHV_Bat_Warn_Rq_AR.CRC_PNHV_Bat_Warn_Rq = getValue( HMI_CRC_PNHV_Bat_Warn_Rq );
    }
    if( ( _PNHV_Bat_Warn_Rq_AR_MSG_DropCnt > 0 ) &&
        ( _PNHV_Bat_Warn_Rq_AR_E2E_Armed == 1  )    )
    {
        _PNHV_Bat_Warn_Rq_AR_MSG_DropCnt--;  // do not send message
    }
    else
    {
        output( _mPNHV_Bat_Warn_Rq_AR );
    }
        
    if( _PNHV_Bat_Warn_Rq_AR_E2E_Armed == 1 )
    {
        if ( ( _PNHV_Bat_Warn_Rq_AR_MSG_DropCnt == 0      ) &&
             ( _PNHV_Bat_Warn_Rq_AR_CRC_ErrorCnt == 0     ) &&
             ( _PNHV_Bat_Warn_Rq_AR_SQC_RepeatedCnt == 0  ) &&
             ( _PNHV_Bat_Warn_Rq_AR_SQC_WrongSeqJump == 0 )    )
        {
            _PNHV_Bat_Warn_Rq_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_PSD_L_Stat_State, 0 );
        }
    }
}

PNHV_Bat_Warn_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: PNHV_Bat_Warn_Rq_AR\n", 40, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PNHV_Bat_Warn_Rq_AR := %X\n", getValue( HMI__STMSG_PNHV_Bat_Warn_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PNHV_Bat_Warn_Rq_AR := %X\n", getValue( HMI__STMSGT_PNHV_Bat_Warn_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_PNHV_Bat_Warn_Rq := %X\n", getValue( HMI_CRC_PNHV_Bat_Warn_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_PNHV_Bat_Warn_Rq_Auto := %X\n", getValue( HMI_CRC_PNHV_Bat_Warn_Rq_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_Thermal_Event_Disp_Rq := %X\n", getValue( HMI_PNHV_Thermal_Event_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_PNHV_Bat_Warn_Rq := %X\n", getValue( HMI_SQC_PNHV_Bat_Warn_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_PNHV_Bat_Warn_Rq_Auto := %X\n", getValue( HMI_SQC_PNHV_Bat_Warn_Rq_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BMS_Bat_SOC_MaxLim := %X\n", getValue( HMI_BMS_Bat_SOC_MaxLim ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BMS_Bat_SOC_MinLim := %X\n", getValue( HMI_BMS_Bat_SOC_MinLim ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tPNHV_Bat_Warn_Rq_AR
{
    putValue( HMI__STMSG_PNHV_Bat_Warn_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_PNHV_Bat_Warn_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PNHV_Bat_Warn_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tPNHV_Bat_Warn_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_PNHV_Bat_Warn_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_PNHV_Bat_Warn_Rq_AR
{
    if( getValue( this ) )
        openPanel("PNHV_Bat_Warn_Rq_AR");
}

on EnvVar HMI_PNHV_Thermal_Event_Disp_Rq
{
    _mPNHV_Bat_Warn_Rq_AR.PNHV_Thermal_Event_Disp_Rq.phys = getValue(this);
    _PNHV_Bat_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv0_PNHV_Bat_Warn_Rq
{
    _mPNHV_Bat_Warn_Rq_AR.Rsrv0_PNHV_Bat_Warn_Rq.phys = getValue(this);
    _PNHV_Bat_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_PNHV_Bat_Warn_Rq
{
    _mPNHV_Bat_Warn_Rq_AR.Rsrv1_PNHV_Bat_Warn_Rq.phys = getValue(this);
    _PNHV_Bat_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BMS_RTM_Sync
{
    _mPNHV_Bat_Warn_Rq_AR.BMS_RTM_Sync.phys = getValue(this);
    _PNHV_Bat_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BMS_Bat_SOC_MinLim
{
    _mPNHV_Bat_Warn_Rq_AR.BMS_Bat_SOC_MinLim.phys = getValue(this);
    _PNHV_Bat_Warn_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BMS_Bat_SOC_MaxLim
{
    _mPNHV_Bat_Warn_Rq_AR.BMS_Bat_SOC_MaxLim.phys = getValue(this);
    _PNHV_Bat_Warn_Rq_AR_SpontanFlag = 1;
}

PSL_L_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_PSL_L_Stat_AR ) )
    {
    //  Botschaft PSL_L_Stat_AR ID: 934 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _PSL_L_Stat_AR_Cnt--;
        if( _PSL_L_Stat_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            PSL_L_Stat_AR_output();
            _PSL_L_Stat_AR_Cnt = _PSL_L_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _PSL_L_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _PSL_L_Stat_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            PSL_L_Stat_AR_output();
            _PSL_L_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

PSL_L_Stat_AR_init()
{   /* Botschaft PSL_L_Stat_AR ID: 934 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 934 0;
BA_ "NmAsrMessage" BO_ 934 0;
BA_ "GenMsgMinAcceptLength" BO_ 934 8;
BA_ "GenMsgILSupport" BO_ 934 1;
BA_ "DiagState" BO_ 934 0;
BA_ "DiagRequest" BO_ 934 0;
BA_ "DiagResponse" BO_ 934 0;
BA_ "GenMsgStartValue" BO_ 934 "0";
BA_ "GenMsgDelayTime" BO_ 934 5;
BA_ "GenMsgNrOfRepetition" BO_ 934 0;
BA_ "GenMsgCycleTime" BO_ 934 500;
BA_ "GenMsgSendType" BO_ 934 5;
    */
    _PSL_L_Stat_AR_Timebase =         c_tDBKomTimer_20ms;
    _PSL_L_Stat_AR_CycleCount =     500 / _PSL_L_Stat_AR_Timebase;
    _PSL_L_Stat_AR_StartDelay =       0 / _PSL_L_Stat_AR_Timebase;
    _PSL_L_Stat_AR_Cnt = _PSL_L_Stat_AR_StartDelay;
    _PSL_L_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_PSL_L_Stat_AR, _PSL_L_Stat_AR_StartDelay * _PSL_L_Stat_AR_Timebase );

    _mPSL_L_Stat_AR.DrRLtch_PSD_L_Stat.phys = getValue( HMI_DrRLtch_PSD_L_Stat );
    _mPSL_L_Stat_AR.PSD_L_A_FFB.phys = getValue( HMI_PSD_L_A_FFB );
    _mPSL_L_Stat_AR.HVAC_RecircAir_On_Rq_PSL_L.phys = getValue( HMI_HVAC_RecircAir_On_Rq_PSL_L );
    _mPSL_L_Stat_AR.PSD_L_FFB.phys = getValue( HMI_PSD_L_FFB );
    _mPSL_L_Stat_AR.PSD_L_PwrCls_Stat.phys = getValue( HMI_PSD_L_PwrCls_Stat );
