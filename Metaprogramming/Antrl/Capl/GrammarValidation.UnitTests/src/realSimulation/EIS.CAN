//            crc = crctable[ crc ^ _mDoor_FL_Stat_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mDoor_FL_Stat_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _Door_FL_Stat_AR_CRC_ErrorCnt   && ( _Door_FL_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Door_FL_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _Door_FL_Stat_AR_CRC_ErrorCnt > 0 )
                    _Door_FL_Stat_AR_CRC_ErrorCnt--; 
            }
            _mDoor_FL_Stat_AR.CRC_Door_FL_Stat = crc;
            putValue( HMI_CRC_Door_FL_Stat, crc );
        }
        else
            _mDoor_FL_Stat_AR.CRC_Door_FL_Stat = getValue( HMI_CRC_Door_FL_Stat );
    }
    if( ( _Door_FL_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _Door_FL_Stat_AR_E2E_Armed == 1  )    )
    {
        _Door_FL_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mDoor_FL_Stat_AR );
        
    if( _Door_FL_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _Door_FL_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _Door_FL_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _Door_FL_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _Door_FL_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _Door_FL_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_Door_FL_Stat_State, 0 );
        }
    }
}

Door_FL_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Door_FL_Stat_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Door_FL_Stat_AR := %X\n", getValue( HMI__STMSG_Door_FL_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Door_FL_Stat_AR := %X\n", getValue( HMI__STMSGT_Door_FL_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AddTurnLmp_Lt_Flt := %X\n", getValue( HMI_AddTurnLmp_Lt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AutoDrLk_Rq_DM_FL := %X\n", getValue( HMI_AutoDrLk_Rq_DM_FL ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_WarnUnit_Lt_Stat := %X\n", getValue( HMI_BSM_WarnUnit_Lt_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Sw_FL_Psd := %X\n", getValue( HMI_CLkS_Sw_FL_Psd ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Door_FL_Stat := %X\n", getValue( HMI_CRC_Door_FL_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Door_FL_Stat_Auto := %X\n", getValue( HMI_CRC_Door_FL_Stat_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DL_RemActn_LHD_Stat := %X\n", getValue( HMI_DL_RemActn_LHD_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Door_FL_Stat_UB := %X\n", getValue( HMI_Door_FL_Stat_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrPreLtch_FL_Engg := %X\n", getValue( HMI_DrPreLtch_FL_Engg ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrRLtch_FL_Stat := %X\n", getValue( HMI_DrRLtch_FL_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ElecTrlrHtrch_Sw_Psd_FL := %X\n", getValue( HMI_ElecTrlrHtrch_Sw_Psd_FL ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mirr_FL_Bl := %X\n", getValue( HMI_Mirr_FL_Bl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MirrAdjSw_Stat_LHD_V2 := %X\n", getValue( HMI_MirrAdjSw_Stat_LHD_V2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MirrFld_Stat_LHD := %X\n", getValue( HMI_MirrFld_Stat_LHD ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MirrFldPk_LHD_Stat := %X\n", getValue( HMI_MirrFldPk_LHD_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PwrCls_FL_Actv := %X\n", getValue( HMI_PwrCls_FL_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RemTank_Unlk_Sw_FL := %X\n", getValue( HMI_RemTank_Unlk_Sw_FL ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_Door_FL_Stat := %X\n", getValue( HMI_Rsrv1_Door_FL_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatAdj_P_LHD_Actv := %X\n", getValue( HMI_SeatAdj_P_LHD_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Door_FL_Stat := %X\n", getValue( HMI_SQC_Door_FL_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Door_FL_Stat_Auto := %X\n", getValue( HMI_SQC_Door_FL_Stat_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Tweeter_FL_Posn_Stat := %X\n", getValue( HMI_Tweeter_FL_Posn_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tDoor_FL_Stat_AR
{
    putValue( HMI__STMSG_Door_FL_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_Door_FL_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Door_FL_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tDoor_FL_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_Door_FL_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Door_FL_Stat_AR
{
    if( getValue( this ) )
        openPanel("Door_FL_Stat_AR");
}

on envVar HMI_E2E_Door_FL_Stat_Inject
{
    if( getValue( this ) )
    {
        _Door_FL_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_Door_FL_Stat_ErrorCount );
        _Door_FL_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_Door_FL_Stat_TriggerPosition );
        _Door_FL_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_Door_FL_Stat_WrongSeq );
        _Door_FL_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_Door_FL_Stat_Repeated );
        _Door_FL_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_Door_FL_Stat_MSG_DropCnt );
        putValue( HMI_E2E_Door_FL_Stat_State, 2 );
        _Door_FL_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_AddTurnLmp_Lt_Flt
{
    _mDoor_FL_Stat_AR.AddTurnLmp_Lt_Flt.phys = getValue(this);
    _Door_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_AutoDrLk_Rq_DM_FL
{
    _mDoor_FL_Stat_AR.AutoDrLk_Rq_DM_FL.phys = getValue(this);
    _Door_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_BSM_WarnUnit_Lt_Stat
{
    _mDoor_FL_Stat_AR.BSM_WarnUnit_Lt_Stat.phys = getValue(this);
    _Door_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_CLkS_Sw_FL_Psd
{
    _mDoor_FL_Stat_AR.CLkS_Sw_FL_Psd.phys = getValue(this);
    _Door_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Door_FL_Stat_UB
{
    _mDoor_FL_Stat_AR.Door_FL_Stat_UB.phys = getValue(this);
    _Door_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DL_RemActn_LHD_Stat
{
    _mDoor_FL_Stat_AR.DL_RemActn_LHD_Stat.phys = getValue(this);
    _Door_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrPreLtch_FL_Engg
{
    _mDoor_FL_Stat_AR.DrPreLtch_FL_Engg.phys = getValue(this);
    _Door_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrRLtch_FL_Stat
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cFLDoorNMRequest );
        setTimer( t_DoorNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mDoor_FL_Stat_AR.DrRLtch_FL_Stat.phys = getValue(this);
    _Door_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ElecTrlrHtrch_Sw_Psd_FL
{
    _mDoor_FL_Stat_AR.ElecTrlrHtrch_Sw_Psd_FL.phys = getValue(this);
    _Door_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Mirr_FL_Bl
{
    _mDoor_FL_Stat_AR.Mirr_FL_Bl.phys = getValue(this);
    _Door_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MirrAdjSw_Stat_LHD_V2
{
    _mDoor_FL_Stat_AR.MirrAdjSw_Stat_LHD_V2.phys = getValue(this);
    _Door_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MirrFld_Stat_LHD
{
    _mDoor_FL_Stat_AR.MirrFld_Stat_LHD.phys = getValue(this);
    _Door_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MirrFldPk_LHD_Stat
{
    _mDoor_FL_Stat_AR.MirrFldPk_LHD_Stat.phys = getValue(this);
    _Door_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PwrCls_FL_Actv
{
    _mDoor_FL_Stat_AR.PwrCls_FL_Actv.phys = getValue(this);
    _Door_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_RemTank_Unlk_Sw_FL
{
    _mDoor_FL_Stat_AR.RemTank_Unlk_Sw_FL.phys = getValue(this);
    _Door_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_Door_FL_Stat
{
    _mDoor_FL_Stat_AR.Rsrv1_Door_FL_Stat.phys = getValue(this);
    _Door_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatAdj_P_LHD_Actv
{
    _mDoor_FL_Stat_AR.SeatAdj_P_LHD_Actv.phys = getValue(this);
    _Door_FL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Tweeter_FL_Posn_Stat
{
    _mDoor_FL_Stat_AR.Tweeter_FL_Posn_Stat.phys = getValue(this);
    _Door_FL_Stat_AR_SpontanFlag = 1;
}

Door_FR_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_Door_FR_Stat_AR ) )
    {
    //  message   Door_FR_Stat_AR ID: 923 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _Door_FR_Stat_AR_DelayCnt > 0) _Door_FR_Stat_AR_DelayCnt--; // Mindestsendeabstand
        _Door_FR_Stat_AR_Cnt--;
        if( _Door_FR_Stat_AR_Cnt < 1 )
        {
            if( _Door_FR_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                Door_FR_Stat_AR_output();
                _Door_FR_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Door_FR_Stat_AR_DelayCnt = _Door_FR_Stat_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _Door_FR_Stat_AR_SpontanFlag = 1;
            }
            _Door_FR_Stat_AR_Cnt = _Door_FR_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _Door_FR_Stat_AR_SpontanFlag)
        {
            if( _Door_FR_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                Door_FR_Stat_AR_output();
                _Door_FR_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Door_FR_Stat_AR_DelayCnt = _Door_FR_Stat_AR_MinDelay;
            }
        }
    }
}

Door_FR_Stat_AR_init()
{   /* Botschaft Door_FR_Stat_AR ID: 923 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 923 0;
BA_ "NmAsrMessage" BO_ 923 0;
BA_ "GenMsgMinAcceptLength" BO_ 923 8;
BA_ "GenMsgILSupport" BO_ 923 1;
BA_ "DiagState" BO_ 923 0;
BA_ "DiagRequest" BO_ 923 0;
BA_ "DiagResponse" BO_ 923 0;
BA_ "GenMsgStartValue" BO_ 923 "0";
BA_ "GenMsgStartDelayTime" BO_ 923 0;
BA_ "GenMsgDelayTime" BO_ 923 5;
BA_ "GenMsgNrOfRepetitions" BO_ 923 0;
BA_ "GenMsgCycleTime" BO_ 923 500;
BA_ "GenMsgSendType" BO_ 923 5;
    */
    _Door_FR_Stat_AR_Timebase =          c_tDBKomTimer_20ms;
    _Door_FR_Stat_AR_CycleCount =       500 / _Door_FR_Stat_AR_Timebase;
    _Door_FR_Stat_AR_StartDelay =         0 / _Door_FR_Stat_AR_Timebase;
    _Door_FR_Stat_AR_MinDelay =           5 / _Door_FR_Stat_AR_Timebase;
    _Door_FR_Stat_AR_Cnt = _Door_FR_Stat_AR_StartDelay;
    _Door_FR_Stat_AR_SpontanFlag = 0;
    _Door_FR_Stat_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_Door_FR_Stat_AR, _Door_FR_Stat_AR_StartDelay * _Door_FR_Stat_AR_Timebase );

    _mDoor_FR_Stat_AR.AddTurnLmp_Rt_Flt.phys = getValue( HMI_AddTurnLmp_Rt_Flt );
    _mDoor_FR_Stat_AR.AutoDrLk_Rq_DM_FR.phys = getValue( HMI_AutoDrLk_Rq_DM_FR );
    _mDoor_FR_Stat_AR.BSM_WarnUnit_Rt_Stat.phys = getValue( HMI_BSM_WarnUnit_Rt_Stat );
    _mDoor_FR_Stat_AR.CLkS_Sw_FR_Psd.phys = getValue( HMI_CLkS_Sw_FR_Psd );
    _mDoor_FR_Stat_AR.Door_FR_Stat_UB.phys = getValue( HMI_Door_FR_Stat_UB );
    _mDoor_FR_Stat_AR.DL_RemActn_RHD_Stat.phys = getValue( HMI_DL_RemActn_RHD_Stat );
    _mDoor_FR_Stat_AR.DrPreLtch_FR_Engg.phys = getValue( HMI_DrPreLtch_FR_Engg );
    _mDoor_FR_Stat_AR.DrRLtch_FR_Stat.phys = getValue( HMI_DrRLtch_FR_Stat );
    _mDoor_FR_Stat_AR.ElecTrlrHtrch_Sw_Psd_FR.phys = getValue( HMI_ElecTrlrHtrch_Sw_Psd_FR );
    _mDoor_FR_Stat_AR.Mirr_FR_Bl.phys = getValue( HMI_Mirr_FR_Bl );
    _mDoor_FR_Stat_AR.MirrAdjSw_Stat_RHD_V2.phys = getValue( HMI_MirrAdjSw_Stat_RHD_V2 );
    _mDoor_FR_Stat_AR.MirrFld_Stat_RHD.phys = getValue( HMI_MirrFld_Stat_RHD );
    _mDoor_FR_Stat_AR.MirrFldPk_RHD_Stat.phys = getValue( HMI_MirrFldPk_RHD_Stat );
    _mDoor_FR_Stat_AR.PwrCls_FR_Actv.phys = getValue( HMI_PwrCls_FR_Actv );
    _mDoor_FR_Stat_AR.RemTank_Unlk_Sw_FR.phys = getValue( HMI_RemTank_Unlk_Sw_FR );
    _mDoor_FR_Stat_AR.Rsrv1_Door_FR_Stat.phys = getValue( HMI_Rsrv1_Door_FR_Stat );
    _mDoor_FR_Stat_AR.SeatAdj_P_RHD_Actv.phys = getValue( HMI_SeatAdj_P_RHD_Actv );
    _mDoor_FR_Stat_AR.Tweeter_FR_Posn_Stat.phys = getValue( HMI_Tweeter_FR_Posn_Stat );
}

Door_FR_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_Door_FR_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_Door_FR_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _Door_FR_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _Door_FR_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_Door_FR_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _Door_FR_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _Door_FR_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _Door_FR_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _Door_FR_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _Door_FR_Stat_AR_SQC_RepeatedCnt ) &&
            ( _Door_FR_Stat_AR_E2E_Armed == 1  )    )
        {
            _Door_FR_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_Door_FR_Stat, SQC_help );
    }
    _mDoor_FR_Stat_AR.SQC_Door_FR_Stat = SQC_help;

    if( getValue( HMI_CRC_Door_FR_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_Door_FR_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable_profile02[ crc ^ _mDoor_FR_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mDoor_FR_Stat_AR.byte( 1 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_FR_Stat_AR.byte( 2 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_FR_Stat_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_FR_Stat_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_FR_Stat_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_FR_Stat_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_FR_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _Door_FR_Stat_AR_CRC_Offset[ _mDoor_FR_Stat_AR.SQC_Door_FR_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _Door_FR_Stat_AR_CRC_ErrorCnt   && ( _Door_FR_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Door_FR_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _Door_FR_Stat_AR_CRC_ErrorCnt > 0 )
                    _Door_FR_Stat_AR_CRC_ErrorCnt--; 
            }
            _mDoor_FR_Stat_AR.CRC_Door_FR_Stat = crc;
            putValue( HMI_CRC_Door_FR_Stat, crc );
        }
        else
            _mDoor_FR_Stat_AR.CRC_Door_FR_Stat = getValue( HMI_CRC_Door_FR_Stat );
    }
    else
    {
        if( !getValue( HMI_CRC_Door_FR_Stat_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mDoor_FR_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mDoor_FR_Stat_AR.byte( 1 ) ];
//            crc = crctable[ crc ^ _mDoor_FR_Stat_AR.byte( 2 ) ];
//            crc = crctable[ crc ^ _mDoor_FR_Stat_AR.byte( 3 ) ];
//            crc = crctable[ crc ^ _mDoor_FR_Stat_AR.byte( 4 ) ];
//            crc = crctable[ crc ^ _mDoor_FR_Stat_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mDoor_FR_Stat_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mDoor_FR_Stat_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _Door_FR_Stat_AR_CRC_ErrorCnt   && ( _Door_FR_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Door_FR_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _Door_FR_Stat_AR_CRC_ErrorCnt > 0 )
                    _Door_FR_Stat_AR_CRC_ErrorCnt--; 
            }
            _mDoor_FR_Stat_AR.CRC_Door_FR_Stat = crc;
            putValue( HMI_CRC_Door_FR_Stat, crc );
        }
        else
            _mDoor_FR_Stat_AR.CRC_Door_FR_Stat = getValue( HMI_CRC_Door_FR_Stat );
    }
    if( ( _Door_FR_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _Door_FR_Stat_AR_E2E_Armed == 1  )    )
    {
        _Door_FR_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mDoor_FR_Stat_AR );
        
    if( _Door_FR_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _Door_FR_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _Door_FR_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _Door_FR_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _Door_FR_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _Door_FR_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_Door_FR_Stat_State, 0 );
        }
    }
}

Door_FR_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Door_FR_Stat_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Door_FR_Stat_AR := %X\n", getValue( HMI__STMSG_Door_FR_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Door_FR_Stat_AR := %X\n", getValue( HMI__STMSGT_Door_FR_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AddTurnLmp_Rt_Flt := %X\n", getValue( HMI_AddTurnLmp_Rt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AutoDrLk_Rq_DM_FR := %X\n", getValue( HMI_AutoDrLk_Rq_DM_FR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BSM_WarnUnit_Rt_Stat := %X\n", getValue( HMI_BSM_WarnUnit_Rt_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Sw_FR_Psd := %X\n", getValue( HMI_CLkS_Sw_FR_Psd ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Door_FL_Stat := %X\n", getValue( HMI_CRC_Door_FL_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Door_FL_Stat_Auto := %X\n", getValue( HMI_CRC_Door_FL_Stat_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DL_RemActn_RHD_Stat := %X\n", getValue( HMI_DL_RemActn_RHD_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Door_FL_Stat_UB := %X\n", getValue( HMI_Door_FL_Stat_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrPreLtch_FR_Engg := %X\n", getValue( HMI_DrPreLtch_FR_Engg ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrRLtch_FR_Stat := %X\n", getValue( HMI_DrRLtch_FR_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ElecTrlrHtrch_Sw_Psd_FR := %X\n", getValue( HMI_ElecTrlrHtrch_Sw_Psd_FR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Mirr_FR_Bl := %X\n", getValue( HMI_Mirr_FR_Bl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MirrAdjSw_Stat_RHD_V2 := %X\n", getValue( HMI_MirrAdjSw_Stat_RHD_V2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MirrFld_Stat_RHD := %X\n", getValue( HMI_MirrFld_Stat_RHD ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MirrFldPk_RHD_Stat := %X\n", getValue( HMI_MirrFldPk_RHD_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RemTank_Unlk_Sw_FR := %X\n", getValue( HMI_RemTank_Unlk_Sw_FR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_Door_FL_Stat := %X\n", getValue( HMI_Rsrv1_Door_FL_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SeatAdj_P_RHD_Actv := %X\n", getValue( HMI_SeatAdj_P_RHD_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Door_FL_Stat := %X\n", getValue( HMI_SQC_Door_FL_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Door_FL_Stat_Auto := %X\n", getValue( HMI_SQC_Door_FL_Stat_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Tweeter_FR_Posn_Stat := %X\n", getValue( HMI_Tweeter_FR_Posn_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tDoor_FR_Stat_AR
{
    putValue( HMI__STMSG_Door_FR_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_Door_FR_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Door_FR_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tDoor_FR_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_Door_FR_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Door_FR_Stat_AR
{
    if( getValue( this ) )
        openPanel("Door_FR_Stat_AR");
}

on envVar HMI_E2E_Door_FR_Stat_Inject
{
    if( getValue( this ) )
    {
        _Door_FR_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_Door_FR_Stat_ErrorCount );
        _Door_FR_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_Door_FR_Stat_TriggerPosition );
        _Door_FR_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_Door_FR_Stat_WrongSeq );
        _Door_FR_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_Door_FR_Stat_Repeated );
        _Door_FR_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_Door_FR_Stat_MSG_DropCnt );
        putValue( HMI_E2E_Door_FR_Stat_State, 2 );
        _Door_FR_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_AddTurnLmp_Rt_Flt
{
    _mDoor_FR_Stat_AR.AddTurnLmp_Rt_Flt.phys = getValue(this);
    _Door_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_AutoDrLk_Rq_DM_FR
{
    _mDoor_FR_Stat_AR.AutoDrLk_Rq_DM_FR.phys = getValue(this);
    _Door_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_BSM_WarnUnit_Rt_Stat
{
    _mDoor_FR_Stat_AR.BSM_WarnUnit_Rt_Stat.phys = getValue(this);
    _Door_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_CLkS_Sw_FR_Psd
{
    _mDoor_FR_Stat_AR.CLkS_Sw_FR_Psd.phys = getValue(this);
    _Door_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DL_RemActn_RHD_Stat
{
    _mDoor_FR_Stat_AR.DL_RemActn_RHD_Stat.phys = getValue(this);
    _Door_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Door_FR_Stat_UB
{
    _mDoor_FR_Stat_AR.Door_FR_Stat_UB.phys = getValue(this);
    _Door_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrPreLtch_FR_Engg
{
    _mDoor_FR_Stat_AR.DrPreLtch_FR_Engg.phys = getValue(this);
    _Door_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrRLtch_FR_Stat
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cFRDoorNMRequest );
        setTimer( t_DoorNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mDoor_FR_Stat_AR.DrRLtch_FR_Stat.phys = getValue(this);
    _Door_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ElecTrlrHtrch_Sw_Psd_FR
{
    _mDoor_FR_Stat_AR.ElecTrlrHtrch_Sw_Psd_FR.phys = getValue(this);
    _Door_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Mirr_FR_Bl
{
    _mDoor_FR_Stat_AR.Mirr_FR_Bl.phys = getValue(this);
    _Door_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MirrAdjSw_Stat_RHD_V2
{
    _mDoor_FR_Stat_AR.MirrAdjSw_Stat_RHD_V2.phys = getValue(this);
    _Door_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MirrFld_Stat_RHD
{
    _mDoor_FR_Stat_AR.MirrFld_Stat_RHD.phys = getValue(this);
    _Door_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_MirrFldPk_RHD_Stat
{
    _mDoor_FR_Stat_AR.MirrFldPk_RHD_Stat.phys = getValue(this);
    _Door_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PwrCls_FR_Actv
{
    _mDoor_FR_Stat_AR.PwrCls_FR_Actv.phys = getValue(this);
    _Door_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_RemTank_Unlk_Sw_FR
{
    _mDoor_FR_Stat_AR.RemTank_Unlk_Sw_FR.phys = getValue(this);
    _Door_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_Door_FR_Stat
{
    _mDoor_FR_Stat_AR.Rsrv1_Door_FR_Stat.phys = getValue(this);
    _Door_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SeatAdj_P_RHD_Actv
{
    _mDoor_FR_Stat_AR.SeatAdj_P_RHD_Actv.phys = getValue(this);
    _Door_FR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Tweeter_FR_Posn_Stat
{
    _mDoor_FR_Stat_AR.Tweeter_FR_Posn_Stat.phys = getValue(this);
    _Door_FR_Stat_AR_SpontanFlag = 1;
}

Door_RL_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_Door_RL_Stat_AR ) )
    {
    //  message   Door_RL_Stat_AR_AR ID: 931 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _Door_RL_Stat_AR_DelayCnt > 0) _Door_RL_Stat_AR_DelayCnt--; // Mindestsendeabstand
        _Door_RL_Stat_AR_Cnt--;
        if( _Door_RL_Stat_AR_Cnt < 1 )
        {
            if( _Door_RL_Stat_AR_DelayCnt < 1 )
            {
                Door_RL_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                _Door_RL_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Door_RL_Stat_AR_DelayCnt = _Door_RL_Stat_AR_MinDelay;
            }
            else
            {
                _Door_RL_Stat_AR_SpontanFlag = 1; // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
            }
            _Door_RL_Stat_AR_Cnt = _Door_RL_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _Door_RL_Stat_AR_SpontanFlag)
        {
            if( _Door_RL_Stat_AR_DelayCnt < 1 )
            {
                Door_RL_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _Door_RL_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Door_RL_Stat_AR_DelayCnt = _Door_RL_Stat_AR_MinDelay;
            }
        }
    }
}

Door_RL_Stat_AR_init()
{   /* Botschaft Door_RL_Stat_AR ID: 931 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 931 0;
BA_ "NmAsrMessage" BO_ 931 0;
BA_ "GenMsgMinAcceptLength" BO_ 931 8;
BA_ "GenMsgILSupport" BO_ 931 1;
BA_ "DiagState" BO_ 931 0;
BA_ "DiagRequest" BO_ 931 0;
BA_ "DiagResponse" BO_ 931 0;
BA_ "GenMsgStartValue" BO_ 931 "0";
BA_ "GenMsgDelayTime" BO_ 931 5;
BA_ "GenMsgNrOfRepetitions" BO_ 931 0;
BA_ "GenMsgCycleTime" BO_ 931 500;
BA_ "GenMsgSendType" BO_ 931 5;
    */
    _Door_RL_Stat_AR_Timebase =               c_tDBKomTimer_20ms;
    _Door_RL_Stat_AR_CycleCount =           500 / _Door_RL_Stat_AR_Timebase;
    _Door_RL_Stat_AR_StartDelay =             0 / _Door_RL_Stat_AR_Timebase;
    _Door_RL_Stat_AR_MinDelay =               5 / _Door_RL_Stat_AR_Timebase;
    _Door_RL_Stat_AR_Cnt = _Door_RL_Stat_AR_StartDelay;
    _Door_RL_Stat_AR_SpontanFlag = 0;
    _Door_RL_Stat_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_Door_RL_Stat_AR, _Door_RL_Stat_AR_StartDelay * _Door_RL_Stat_AR_Timebase );

    _mDoor_RL_Stat_AR.CSL_SeatOprtn_RHD_Actv.phys = getValue( HMI_CSL_SeatOprtn_RHD_Actv );
	_mDoor_RL_Stat_AR.CSL_SeatOprtn_RHD_Actv.phys = getValue( HMI_CSL_SeatOprtn_RHD_Actv );
    _mDoor_RL_Stat_AR.Door_RL_Stat_UB.phys = getValue( HMI_Door_RL_Stat_UB );
    _mDoor_RL_Stat_AR.DrPreLtch_RL_Engg.phys = getValue( HMI_DrPreLtch_RL_Engg );
    _mDoor_RL_Stat_AR.DrRLtch_RL_Stat.phys = getValue( HMI_DrRLtch_RL_Stat );
    _mDoor_RL_Stat_AR.FtSeatAdj_RL_Actv.phys = getValue( HMI_FtSeatAdj_RL_Actv );
    _mDoor_RL_Stat_AR.PwrCls_RL_Actv.phys = getValue( HMI_PwrCls_RL_Actv );
    _mDoor_RL_Stat_AR.Rsrv1_Door_RL_Stat.phys = getValue( HMI_Rsrv1_Door_RL_Stat );
    _mDoor_RL_Stat_AR.Tweeter_RL_Posn_Stat.phys = getValue( HMI_Tweeter_RL_Posn_Stat );
}

Door_RL_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_Door_RL_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_Door_RL_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _Door_RL_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _Door_RL_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_Door_RL_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _Door_RL_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _Door_RL_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _Door_RL_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _Door_RL_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _Door_RL_Stat_AR_SQC_RepeatedCnt ) &&
            ( _Door_RL_Stat_AR_E2E_Armed == 1  )    )
        {
            _Door_RL_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_Door_RL_Stat, SQC_help );
    }
    _mDoor_RL_Stat_AR.SQC_Door_RL_Stat = SQC_help;

    if( getValue( HMI_CRC_Door_RL_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_Door_RL_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mDoor_RL_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mDoor_RL_Stat_AR.byte( 1 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_RL_Stat_AR.byte( 2 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_RL_Stat_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_RL_Stat_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_RL_Stat_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_RL_Stat_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_RL_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _Door_RL_Stat_AR_CRC_Offset[ _mDoor_RL_Stat_AR.SQC_Door_RL_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _Door_RL_Stat_AR_CRC_ErrorCnt   && ( _Door_RL_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Door_RL_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _Door_RL_Stat_AR_CRC_ErrorCnt > 0 )
                    _Door_RL_Stat_AR_CRC_ErrorCnt--; 
            }
            _mDoor_RL_Stat_AR.CRC_Door_RL_Stat = crc;
            putValue( HMI_CRC_Door_RL_Stat, crc );
        }
        else
            _mDoor_RL_Stat_AR.CRC_Door_RL_Stat = getValue( HMI_CRC_Door_RL_Stat );
    }
    else
    {
        if( !getValue( HMI_CRC_Door_RL_Stat_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mDoor_RL_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mDoor_RL_Stat_AR.byte( 1 ) ];
//            crc = crctable[ crc ^ _mDoor_RL_Stat_AR.byte( 2 ) ];
//            crc = crctable[ crc ^ _mDoor_RL_Stat_AR.byte( 3 ) ];
//            crc = crctable[ crc ^ _mDoor_RL_Stat_AR.byte( 4 ) ];
//            crc = crctable[ crc ^ _mDoor_RL_Stat_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mDoor_RL_Stat_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mDoor_RL_Stat_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _Door_RL_Stat_AR_CRC_ErrorCnt   && ( _Door_RL_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Door_RL_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _Door_RL_Stat_AR_CRC_ErrorCnt > 0 )
                    _Door_RL_Stat_AR_CRC_ErrorCnt--; 
            }
            _mDoor_RL_Stat_AR.CRC_Door_RL_Stat = crc;
            putValue( HMI_CRC_Door_RL_Stat, crc );
        }
        else
            _mDoor_RL_Stat_AR.CRC_Door_RL_Stat = getValue( HMI_CRC_Door_RL_Stat );
    }
    if( ( _Door_RL_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _Door_RL_Stat_AR_E2E_Armed == 1  )    )
    {
        _Door_RL_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mDoor_RL_Stat_AR );
        
    if( _Door_RL_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _Door_RL_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _Door_RL_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _Door_RL_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _Door_RL_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _Door_RL_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_Door_RL_Stat_State, 0 );
        }
    }
}

Door_RL_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Door_RL_Stat_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Door_RL_Stat_AR := %X\n", getValue( HMI__STMSG_Door_RL_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Door_RL_Stat_AR := %X\n", getValue( HMI__STMSGT_Door_RL_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Sw_RL_Psd := %X\n", getValue( HMI_CLkS_Sw_RL_Psd ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CSL_SeatOprtn_RHD_Actv := %X\n", getValue( HMI_CSL_SeatOprtn_RHD_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Door_RL_Stat := %X\n", getValue( HMI_CRC_Door_RL_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Door_RL_Stat_Auto := %X\n", getValue( HMI_CRC_Door_RL_Stat_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Door_RL_Stat_UB := %X\n", getValue( HMI_Door_RL_Stat_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrPreLtch_RL_Engg := %X\n", getValue( HMI_DrPreLtch_RL_Engg ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrRLtch_RL_Stat := %X\n", getValue( HMI_DrRLtch_RL_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FtSeatAdj_RL_Actv := %X\n", getValue( HMI_FtSeatAdj_RL_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PwrCls_RL_Actv := %X\n", getValue( HMI_PwrCls_RL_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_Door_RL_Stat := %X\n", getValue( HMI_Rsrv1_Door_RL_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Door_RL_Stat := %X\n", getValue( HMI_SQC_Door_RL_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Door_RL_Stat_Auto := %X\n", getValue( HMI_SQC_Door_RL_Stat_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Tweeter_RL_Posn_Stat := %X\n", getValue( HMI_Tweeter_RL_Posn_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tDoor_RL_Stat_AR
{
    putValue( HMI__STMSG_Door_RL_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_Door_RL_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Door_RL_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tDoor_RL_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_Door_RL_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Door_RL_Stat_AR
{
    if( getValue( this ) )
        openPanel("Door_RL_Stat_AR");
}

on envVar HMI_E2E_Door_RL_Stat_Inject
{
    if( getValue( this ) )
    {
        _Door_RL_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_Door_RL_Stat_ErrorCount );
        _Door_RL_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_Door_RL_Stat_TriggerPosition );
        _Door_RL_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_Door_RL_Stat_WrongSeq );
        _Door_RL_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_Door_RL_Stat_Repeated );
        _Door_RL_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_Door_RL_Stat_MSG_DropCnt );
        putValue( HMI_E2E_Door_RL_Stat_State, 2 );
        _Door_RL_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_CLkS_Sw_RL_Psd
{
    _mDoor_RL_Stat_AR.CLkS_Sw_RL_Psd.phys = getValue(this);
    _Door_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_CSL_SeatOprtn_RHD_Actv
{
    _mDoor_RL_Stat_AR.CSL_SeatOprtn_RHD_Actv.phys = getValue(this);
    _Door_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Door_RL_Stat_UB
{
    _mDoor_RL_Stat_AR.Door_RL_Stat_UB.phys = getValue(this);
    _Door_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrPreLtch_RL_Engg
{
    _mDoor_RL_Stat_AR.DrPreLtch_RL_Engg.phys = getValue(this);
    _Door_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrRLtch_RL_Stat
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cRLDoorNMRequest );
        setTimer( t_DoorNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mDoor_RL_Stat_AR.DrRLtch_RL_Stat.phys = getValue(this);
    _Door_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FtSeatAdj_RL_Actv
{
    _mDoor_RL_Stat_AR.FtSeatAdj_RL_Actv.phys = getValue(this);
    _Door_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PwrCls_RL_Actv
{
    _mDoor_RL_Stat_AR.PwrCls_RL_Actv.phys = getValue(this);
    _Door_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_Door_RL_Stat
{
    _mDoor_RL_Stat_AR.Rsrv1_Door_RL_Stat.phys = getValue(this);
    _Door_RL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Tweeter_RL_Posn_Stat
{
    _mDoor_RL_Stat_AR.Tweeter_RL_Posn_Stat.phys = getValue(this);
    _Door_RL_Stat_AR_SpontanFlag = 1;
}

Door_RR_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_Door_RR_Stat_AR ) )
    {
    //  message   Door_RR_Stat ID: 933 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _Door_RR_Stat_AR_DelayCnt > 0) _Door_RR_Stat_AR_DelayCnt--; // Mindestsendeabstand
        _Door_RR_Stat_AR_Cnt--;
        if( _Door_RR_Stat_AR_Cnt < 1 )
        {
            if( _Door_RR_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                Door_RR_Stat_AR_output();
                 _Door_RR_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Door_RR_Stat_AR_DelayCnt = _Door_RR_Stat_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _Door_RR_Stat_AR_SpontanFlag = 1;
            }
            _Door_RR_Stat_AR_Cnt = _Door_RR_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _Door_RR_Stat_AR_SpontanFlag)
        {
            if( _Door_RR_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                Door_RR_Stat_AR_output();
                _Door_RR_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Door_RR_Stat_AR_DelayCnt = _Door_RR_Stat_AR_MinDelay;
            }
        }
    }
}

Door_RR_Stat_AR_init()
{   /* Botschaft Door_RR_Stat_AR ID: 933 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 933 0;
BA_ "NmAsrMessage" BO_ 933 0;
BA_ "GenMsgMinAcceptLength" BO_ 933 8;
BA_ "GenMsgILSupport" BO_ 933 1;
BA_ "DiagState" BO_ 933 0;
BA_ "DiagRequest" BO_ 933 0;
BA_ "DiagResponse" BO_ 933 0;
BA_ "GenMsgStartValue" BO_ 933 "0";
BA_ "GenMsgDelayTime" BO_ 933 5;
BA_ "GenMsgNrOfRepetitions" BO_ 933 0;
BA_ "GenMsgCycleTime" BO_ 933 500;
BA_ "GenMsgSendType" BO_ 933 5;
    */
    _Door_RR_Stat_AR_Timebase =          c_tDBKomTimer_20ms;
    _Door_RR_Stat_AR_CycleCount =      500 / _Door_RR_Stat_AR_Timebase;
    _Door_RR_Stat_AR_StartDelay =        0 / _Door_RR_Stat_AR_Timebase;
    _Door_RR_Stat_AR_MinDelay =          5 / _Door_RR_Stat_AR_Timebase;
    _Door_RR_Stat_AR_Cnt = _Door_RR_Stat_AR_StartDelay;
    _Door_RR_Stat_AR_SpontanFlag = 0;
    _Door_RR_Stat_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_Door_RR_Stat_AR, _Door_RR_Stat_AR_StartDelay * _Door_RR_Stat_AR_Timebase );

    _mDoor_RR_Stat_AR.CLkS_Sw_RR_Psd.phys = getValue( HMI_CLkS_Sw_RR_Psd );
	_mDoor_RR_Stat_AR.CSL_SeatOprtn_LHD_Actv.phys = getValue( HMI_CSL_SeatOprtn_LHD_Actv );
    _mDoor_RR_Stat_AR.Door_RR_Stat_UB.phys = getValue( HMI_Door_RR_Stat_UB );
    _mDoor_RR_Stat_AR.DrPreLtch_RR_Engg.phys = getValue( HMI_DrPreLtch_RR_Engg );
    _mDoor_RR_Stat_AR.DrRLtch_RR_Stat.phys = getValue( HMI_DrRLtch_RR_Stat );
    _mDoor_RR_Stat_AR.FtSeatAdj_RR_Actv.phys = getValue( HMI_FtSeatAdj_RR_Actv );
    _mDoor_RR_Stat_AR.PwrCls_RR_Actv.phys = getValue( HMI_PwrCls_RR_Actv );
    _mDoor_RR_Stat_AR.Rsrv1_Door_RR_Stat.phys = getValue( HMI_Rsrv1_Door_RR_Stat );
    _mDoor_RR_Stat_AR.Tweeter_RR_Posn_Stat.phys = getValue( HMI_Tweeter_RR_Posn_Stat );
}

Door_RR_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_Door_RR_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_Door_RR_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _Door_RR_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _Door_RR_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_Door_RR_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _Door_RR_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _Door_RR_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _Door_RR_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _Door_RR_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _Door_RR_Stat_AR_SQC_RepeatedCnt ) &&
            ( _Door_RR_Stat_AR_E2E_Armed == 1  )    )
        {
            _Door_RR_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_Door_RR_Stat, SQC_help );
    }
    _mDoor_RR_Stat_AR.SQC_Door_RR_Stat = SQC_help;

    if( getValue( HMI_CRC_Door_RR_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_Door_RR_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mDoor_RR_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mDoor_RR_Stat_AR.byte( 1 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_RR_Stat_AR.byte( 2 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_RR_Stat_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_RR_Stat_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_RR_Stat_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_RR_Stat_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mDoor_RR_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _Door_RR_Stat_AR_CRC_Offset[ _mDoor_RR_Stat_AR.SQC_Door_RR_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _Door_RR_Stat_AR_CRC_ErrorCnt   && ( _Door_RR_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Door_RR_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _Door_RR_Stat_AR_CRC_ErrorCnt > 0 )
                    _Door_RR_Stat_AR_CRC_ErrorCnt--; 
            }
            _mDoor_RR_Stat_AR.CRC_Door_RR_Stat = crc;
            putValue( HMI_CRC_Door_RR_Stat, crc );
        }
        else
            _mDoor_RR_Stat_AR.CRC_Door_RR_Stat = getValue( HMI_CRC_Door_RR_Stat );
    }
    else
    {
        if( !getValue( HMI_CRC_Door_RR_Stat_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mDoor_RR_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mDoor_RR_Stat_AR.byte( 1 ) ];
//            crc = crctable[ crc ^ _mDoor_RR_Stat_AR.byte( 2 ) ];
//            crc = crctable[ crc ^ _mDoor_RR_Stat_AR.byte( 3 ) ];
//            crc = crctable[ crc ^ _mDoor_RR_Stat_AR.byte( 4 ) ];
//            crc = crctable[ crc ^ _mDoor_RR_Stat_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mDoor_RR_Stat_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mDoor_RR_Stat_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _Door_RR_Stat_AR_CRC_ErrorCnt   && ( _Door_RR_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Door_RR_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _Door_RR_Stat_AR_CRC_ErrorCnt > 0 )
                    _Door_RR_Stat_AR_CRC_ErrorCnt--; 
            }
            _mDoor_RR_Stat_AR.CRC_Door_RR_Stat = crc;
            putValue( HMI_CRC_Door_RR_Stat, crc );
        }
        else
            _mDoor_RR_Stat_AR.CRC_Door_RR_Stat = getValue( HMI_CRC_Door_RR_Stat );
    }
    if( ( _Door_RR_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _Door_RR_Stat_AR_E2E_Armed == 1  )    )
    {
        _Door_RR_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mDoor_RR_Stat_AR );
        
    if( _Door_RR_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _Door_RR_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _Door_RR_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _Door_RR_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _Door_RR_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _Door_RR_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_Door_RR_Stat_State, 0 );
        }
    }
}

Door_RR_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Door_RR_Stat_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Door_RR_Stat_AR := %X\n", getValue( HMI__STMSG_Door_RR_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Door_RR_Stat_AR := %X\n", getValue( HMI__STMSGT_Door_RR_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_CLkS_Sw_RR_Psd := %X\n", getValue( HMI_CLkS_Sw_RR_Psd ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CSL_SeatOprtn_LHD_Actv := %X\n", getValue( HMI_CSL_SeatOprtn_LHD_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Door_RR_Stat := %X\n", getValue( HMI_CRC_Door_RR_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Door_RR_Stat_Auto := %X\n", getValue( HMI_CRC_Door_RR_Stat_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Door_RR_Stat_UB := %X\n", getValue( HMI_Door_RR_Stat_UB ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrPreLtch_RR_Engg := %X\n", getValue( HMI_DrPreLtch_RR_Engg ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrRLtch_RR_Stat := %X\n", getValue( HMI_DrRLtch_RR_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FtSeatAdj_RR_Actv := %X\n", getValue( HMI_FtSeatAdj_RR_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PwrCls_RR_Actv := %X\n", getValue( HMI_PwrCls_RR_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_Door_RR_Stat := %X\n", getValue( HMI_Rsrv1_Door_RR_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Door_RR_Stat := %X\n", getValue( HMI_SQC_Door_RR_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Door_RR_Stat_Auto := %X\n", getValue( HMI_SQC_Door_RR_Stat_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Tweeter_RR_Posn_Stat := %X\n", getValue( HMI_Tweeter_RR_Posn_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tDoor_RR_Stat_AR
{
    putValue( HMI__STMSG_Door_RR_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_Door_RR_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Door_RR_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tDoor_RR_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_Door_RR_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Door_RR_Stat_AR
{
    if( getValue( this ) )
        openPanel("Door_RR_Stat_AR");
}

on envVar HMI_E2E_Door_RR_Stat_Inject
{
    if( getValue( this ) )
    {
        _Door_RR_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_Door_RR_Stat_ErrorCount );
        _Door_RR_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_Door_RR_Stat_TriggerPosition );
        _Door_RR_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_Door_RR_Stat_WrongSeq );
        _Door_RR_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_Door_RR_Stat_Repeated );
        _Door_RR_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_Door_RR_Stat_MSG_DropCnt );
        putValue( HMI_E2E_Door_RR_Stat_State, 2 );
        _Door_RR_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_CLkS_Sw_RR_Psd
{
    _mDoor_RR_Stat_AR.CLkS_Sw_RR_Psd.phys = getValue(this);
    _Door_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_CSL_SeatOprtn_LHD_Actv
{
    _mDoor_RR_Stat_AR.CSL_SeatOprtn_LHD_Actv.phys = getValue(this);
    _Door_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Door_RR_Stat_UB
{
    _mDoor_RR_Stat_AR.Door_RR_Stat_UB.phys = getValue(this);
    _Door_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrPreLtch_RR_Engg
{
    _mDoor_RR_Stat_AR.DrPreLtch_RR_Engg.phys = getValue(this);
    _Door_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrRLtch_RR_Stat
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cRRDoorNMRequest );
        setTimer( t_DoorNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mDoor_RR_Stat_AR.DrRLtch_RR_Stat.phys = getValue(this);
    _Door_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FtSeatAdj_RR_Actv
{
    _mDoor_RR_Stat_AR.FtSeatAdj_RR_Actv.phys = getValue(this);
    _Door_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PwrCls_RR_Actv
{
    _mDoor_RR_Stat_AR.PwrCls_RR_Actv.phys = getValue(this);
    _Door_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_Door_RR_Stat
{
    _mDoor_RR_Stat_AR.Rsrv1_Door_RR_Stat.phys = getValue(this);
    _Door_RR_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Tweeter_RR_Posn_Stat
{
    _mDoor_RR_Stat_AR.Tweeter_RR_Posn_Stat.phys = getValue(this);
    _Door_RR_Stat_AR_SpontanFlag = 1;
}

DPC_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_DPC_Disp_Rq_AR ) )
    {
    //  message   DPC_Disp_Rq_AR ID: 629 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _DPC_Disp_Rq_AR_DelayCnt > 0) _DPC_Disp_Rq_AR_DelayCnt--; // Mindestsendeabstand
        _DPC_Disp_Rq_AR_Cnt--;
        if( _DPC_Disp_Rq_AR_Cnt < 1 )
        {
            if( _DPC_Disp_Rq_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                DPC_Disp_Rq_AR_output();
                 _DPC_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _DPC_Disp_Rq_AR_DelayCnt = _DPC_Disp_Rq_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _DPC_Disp_Rq_AR_SpontanFlag = 1;
            }
            _DPC_Disp_Rq_AR_Cnt = _DPC_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _DPC_Disp_Rq_AR_SpontanFlag)
        {
            if( _DPC_Disp_Rq_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                DPC_Disp_Rq_AR_output();
                _DPC_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _DPC_Disp_Rq_AR_DelayCnt = _DPC_Disp_Rq_AR_MinDelay;
            }
        }
    }
}

DPC_Disp_Rq_AR_init()
{   /* Botschaft DPC_Disp_Rq_AR ID: 629 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 629 0;
BA_ "NmAsrMessage" BO_ 629 0;
BA_ "GenMsgMinAcceptLength" BO_ 629 8;
BA_ "GenMsgILSupport" BO_ 629 1;
BA_ "DiagState" BO_ 629 0;
BA_ "DiagRequest" BO_ 629 0;
BA_ "DiagResponse" BO_ 629 0;
BA_ "GenMsgStartValue" BO_ 629 "0";
BA_ "GenMsgStartDelayTime" BO_ 629 0;
BA_ "GenMsgDelayTime" BO_ 629 20;
BA_ "GenMsgNrOfRepetitions" BO_ 629 0;
BA_ "GenMsgCycleTime" BO_ 629 100;
BA_ "GenMsgSendType" BO_ 629 5;
    */
    _DPC_Disp_Rq_AR_Timebase =            c_tDBKomTimer_20ms;
    _DPC_Disp_Rq_AR_CycleCount =        100 / _DPC_Disp_Rq_AR_Timebase;
    _DPC_Disp_Rq_AR_StartDelay =          0 / _DPC_Disp_Rq_AR_Timebase;
    _DPC_Disp_Rq_AR_MinDelay =           20 / _DPC_Disp_Rq_AR_Timebase;
    _DPC_Disp_Rq_AR_Cnt = _DPC_Disp_Rq_AR_StartDelay;
    _DPC_Disp_Rq_AR_SpontanFlag = 0;
    _DPC_Disp_Rq_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_DPC_Disp_Rq_AR, _DPC_Disp_Rq_AR_StartDelay * _DPC_Disp_Rq_AR_Timebase );

    _mDPC_Disp_Rq_AR.DPC_GlobalMd_Rs_HU.phys = getValue( HMI_DPC_GlobalMd_Rs_HU );
    _mDPC_Disp_Rq_AR.DPC_GlobalMd_TrgRq.phys = getValue( HMI_DPC_GlobalMd_TrgRq );
    _mDPC_Disp_Rq_AR.DPC_LastMd_Rq.phys = getValue( HMI_DPC_LastMd_Rq );
    _mDPC_Disp_Rq_AR.DPC_Md_ASX_Rq.phys = getValue( HMI_DPC_Md_ASX_Rq );
    _mDPC_Disp_Rq_AR.DPC_Md_Disp_Rq.phys = getValue( HMI_DPC_Md_Disp_Rq );
    _mDPC_Disp_Rq_AR.DPC_Md_ESP_Rs_HU.phys = getValue( HMI_DPC_Md_ESP_Rs_HU );
    _mDPC_Disp_Rq_AR.DPC_Offroad_Abort_Disp_Rq.phys = getValue( HMI_DPC_Offroad_Abort_Disp_Rq );
    _mDPC_Disp_Rq_AR.DPC_OnroadMd_Disp_Rq.phys = getValue( HMI_DPC_OnroadMd_Disp_Rq );
    _mDPC_Disp_Rq_AR.DPC_OnroadMd_Disp_TrgRq.phys = getValue( HMI_DPC_OnroadMd_Disp_TrgRq );
    _mDPC_Disp_Rq_AR.DPC_OnroadMd_Style.phys = getValue( HMI_DPC_OnroadMd_Style );
    _mDPC_Disp_Rq_AR.Rsrv1_DPC_Disp_Rq.phys = getValue( HMI_Rsrv1_DPC_Disp_Rq );
    _mDPC_Disp_Rq_AR.Rsrv2_DPC_Disp_Rq.phys = getValue( HMI_Rsrv2_DPC_Disp_Rq );
}

DPC_Disp_Rq_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_DPC_Disp_Rq ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_DPC_Disp_Rq_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _DPC_Disp_Rq_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _DPC_Disp_Rq_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_DPC_Disp_Rq_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _DPC_Disp_Rq_AR_SQC_WrongSeqJump != 0 ) &&
            ( _DPC_Disp_Rq_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _DPC_Disp_Rq_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _DPC_Disp_Rq_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _DPC_Disp_Rq_AR_SQC_RepeatedCnt ) &&
            ( _DPC_Disp_Rq_AR_E2E_Armed == 1  )    )
        {
            _DPC_Disp_Rq_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_DPC_Disp_Rq, SQC_help );
    }
    _mDPC_Disp_Rq_AR.SQC_DPC_Disp_Rq = SQC_help;

    if( getValue( HMI_CRC_DPC_Disp_Rq_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_DPC_Disp_Rq_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mDPC_Disp_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mDPC_Disp_Rq_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_Disp_Rq_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_Disp_Rq_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_Disp_Rq_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_Disp_Rq_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mDPC_Disp_Rq_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mDPC_Disp_Rq_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _DPC_Disp_Rq_AR_CRC_Offset[ _mDPC_Disp_Rq_AR.SQC_DPC_Disp_Rq ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _DPC_Disp_Rq_AR_CRC_ErrorCnt   && ( _DPC_Disp_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_DPC_Disp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _DPC_Disp_Rq_AR_CRC_ErrorCnt > 0 )
                    _DPC_Disp_Rq_AR_CRC_ErrorCnt--; 
            }
            _mDPC_Disp_Rq_AR.CRC_DPC_Disp_Rq = crc;
            putValue( HMI_CRC_DPC_Disp_Rq, crc );
        }
        else
            _mDPC_Disp_Rq_AR.CRC_DPC_Disp_Rq = getValue( HMI_CRC_DPC_Disp_Rq );
    }
    else
    {
        if( !getValue( HMI_CRC_DPC_Disp_Rq_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mDPC_Disp_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mDPC_Disp_Rq_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mDPC_Disp_Rq_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mDPC_Disp_Rq_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mDPC_Disp_Rq_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mDPC_Disp_Rq_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mDPC_Disp_Rq_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mDPC_Disp_Rq_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _DPC_Disp_Rq_AR_CRC_ErrorCnt   && ( _DPC_Disp_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_DPC_Disp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _DPC_Disp_Rq_AR_CRC_ErrorCnt > 0 )
                    _DPC_Disp_Rq_AR_CRC_ErrorCnt--; 
            }
            _mDPC_Disp_Rq_AR.CRC_DPC_Disp_Rq = crc;
            putValue( HMI_CRC_DPC_Disp_Rq, crc );
        }
        else
            _mDPC_Disp_Rq_AR.CRC_DPC_Disp_Rq = getValue( HMI_CRC_DPC_Disp_Rq );
    }
    if( ( _DPC_Disp_Rq_AR_MSG_DropCnt > 0 ) &&
        ( _DPC_Disp_Rq_AR_E2E_Armed == 1  )    )
    {
        _DPC_Disp_Rq_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mDPC_Disp_Rq_AR );
        
    if( _DPC_Disp_Rq_AR_E2E_Armed == 1 )
    {
        if ( ( _DPC_Disp_Rq_AR_MSG_DropCnt == 0      ) &&
             ( _DPC_Disp_Rq_AR_CRC_ErrorCnt == 0     ) &&
             ( _DPC_Disp_Rq_AR_SQC_RepeatedCnt == 0  ) &&
             ( _DPC_Disp_Rq_AR_SQC_WrongSeqJump == 0 )    )
        {
            _DPC_Disp_Rq_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_DPC_Disp_Rq_State, 0 );
        }
    }
}

DPC_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: DPC_Disp_Rq_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_DPC_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_DPC_Disp_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_DPC_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_DPC_Disp_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_DPC_Disp_Rq := %X\n", getValue( HMI_CRC_DPC_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_DPC_Disp_Rq_Auto := %X\n", getValue( HMI_CRC_DPC_Disp_Rq_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_GlobalMd_Rs_HU := %X\n", getValue( HMI_DPC_GlobalMd_Rs_HU ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_GlobalMd_TrgRq := %X\n", getValue( HMI_DPC_GlobalMd_TrgRq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_LastMd_Rq := %X\n", getValue( HMI_DPC_LastMd_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_ASX_Rq := %X\n", getValue( HMI_DPC_Md_ASX_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_Disp_Rq := %X\n", getValue( HMI_DPC_Md_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_ESP_Rs_HU := %X\n", getValue( HMI_DPC_Md_ESP_Rs_HU ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Offroad_Abort_Disp_Rq := %X\n", getValue( HMI_DPC_Offroad_Abort_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_OnroadMd_Disp_Rq := %X\n", getValue( HMI_DPC_OnroadMd_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_OnroadMd_Disp_TrgRq := %X\n", getValue( HMI_DPC_OnroadMd_Disp_TrgRq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_OnroadMd_Style := %X\n", getValue( HMI_DPC_OnroadMd_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_DPC_Disp_Rq := %X\n", getValue( HMI_Rsrv1_DPC_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_DPC_Disp_Rq := %X\n", getValue( HMI_Rsrv2_DPC_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_DPC_Disp_Rq := %X\n", getValue( HMI_SQC_DPC_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_DPC_Disp_Rq_Auto := %X\n", getValue( HMI_SQC_DPC_Disp_Rq_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tDPC_Disp_Rq_AR
{
    putValue( HMI__STMSG_DPC_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_DPC_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_DPC_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tDPC_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_DPC_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_DPC_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("DPC_Disp_Rq_AR");
}

on envVar HMI_E2E_DPC_Disp_Rq_Inject
{
    if( getValue( this ) )
    {
        _DPC_Disp_Rq_AR_CRC_ErrorCnt = getValue( HMI_CRC_DPC_Disp_Rq_ErrorCount );
        _DPC_Disp_Rq_AR_SQC_TriggPos = getValue( HMI_SQC_DPC_Disp_Rq_TriggerPosition );
        _DPC_Disp_Rq_AR_SQC_WrongSeqJump = getValue( HMI_SQC_DPC_Disp_Rq_WrongSeq );
        _DPC_Disp_Rq_AR_SQC_RepeatedCnt = getValue( HMI_SQC_DPC_Disp_Rq_Repeated );
        _DPC_Disp_Rq_AR_MSG_DropCnt = getValue( HMI_SQC_DPC_Disp_Rq_MSG_DropCnt );
        putValue( HMI_E2E_DPC_Disp_Rq_State, 2 );
        _DPC_Disp_Rq_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_DPC_GlobalMd_Rs_HU
{
    _mDPC_Disp_Rq_AR.DPC_GlobalMd_Rs_HU.phys = getValue(this);
    _DPC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_GlobalMd_TrgRq
{
    _mDPC_Disp_Rq_AR.DPC_GlobalMd_TrgRq.phys = getValue(this);
    _DPC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_LastMd_Rq
{
    _mDPC_Disp_Rq_AR.DPC_LastMd_Rq.phys = getValue(this);
    _DPC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_ASX_Rq
{
    _mDPC_Disp_Rq_AR.DPC_Md_ASX_Rq.phys = getValue(this);
    _DPC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_Disp_Rq
{
    _mDPC_Disp_Rq_AR.DPC_Md_Disp_Rq.phys = getValue(this);
    _DPC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_ESP_Rs_HU
{
    _mDPC_Disp_Rq_AR.DPC_Md_ESP_Rs_HU.phys = getValue(this);
    _DPC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Offroad_Abort_Disp_Rq
{
    _mDPC_Disp_Rq_AR.DPC_Offroad_Abort_Disp_Rq.phys = getValue(this);
    _DPC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_OnroadMd_Disp_Rq
{
    _mDPC_Disp_Rq_AR.DPC_OnroadMd_Disp_Rq.phys = getValue(this);
    _DPC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_OnroadMd_Disp_TrgRq
{
    _mDPC_Disp_Rq_AR.DPC_OnroadMd_Disp_TrgRq.phys = getValue(this);
    _DPC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_OnroadMd_Style
{
    _mDPC_Disp_Rq_AR.DPC_OnroadMd_Style.phys = getValue(this);
    _DPC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_DPC_Disp_Rq
{
    _mDPC_Disp_Rq_AR.Rsrv1_DPC_Disp_Rq.phys = getValue(this);
    _DPC_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv2_DPC_Disp_Rq
{
    _mDPC_Disp_Rq_AR.Rsrv2_DPC_Disp_Rq.phys = getValue(this);
    _DPC_Disp_Rq_AR_SpontanFlag = 1;
}



DPC_IndMd_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_DPC_IndMd_Stat_AR ) )
    {
    //  message   DPC_IndMd_Stat_AR ID: 633 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _DPC_IndMd_Stat_AR_DelayCnt > 0) _DPC_IndMd_Stat_AR_DelayCnt--; // Mindestsendeabstand
        _DPC_IndMd_Stat_AR_Cnt--;
        if( _DPC_IndMd_Stat_AR_Cnt < 1 )
        {
            if( _DPC_IndMd_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                DPC_IndMd_Stat_AR_output();
                 _DPC_IndMd_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _DPC_IndMd_Stat_AR_DelayCnt = _DPC_IndMd_Stat_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _DPC_IndMd_Stat_AR_SpontanFlag = 1;
            }
            _DPC_IndMd_Stat_AR_Cnt = _DPC_IndMd_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _DPC_IndMd_Stat_AR_SpontanFlag)
        {
            if( _DPC_IndMd_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                DPC_IndMd_Stat_AR_output();
                _DPC_IndMd_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _DPC_IndMd_Stat_AR_DelayCnt = _DPC_IndMd_Stat_AR_MinDelay;
            }
        }
    }
}

DPC_IndMd_Stat_AR_init()
{   /* Botschaft DPC_IndMd_Stat_AR ID: 633 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 633 0;
BA_ "NmAsrMessage" BO_ 633 0;
BA_ "GenMsgMinAcceptLength" BO_ 633 8;
BA_ "GenMsgILSupport" BO_ 633 1;
BA_ "DiagState" BO_ 633 0;
BA_ "DiagRequest" BO_ 633 0;
BA_ "DiagResponse" BO_ 633 0;
BA_ "GenMsgStartValue" BO_ 633 "0";
BA_ "GenMsgStartDelayTime" BO_ 633 0;
BA_ "GenMsgDelayTime" BO_ 633 20;
BA_ "GenMsgNrOfRepetitions" BO_ 633 0;
BA_ "GenMsgCycleTime" BO_ 633 100;
BA_ "GenMsgSendType" BO_ 633 5;
    */
    _DPC_IndMd_Stat_AR_Timebase =         c_tDBKomTimer_20ms;
    _DPC_IndMd_Stat_AR_CycleCount =     100 / _DPC_IndMd_Stat_AR_Timebase;
    _DPC_IndMd_Stat_AR_StartDelay =       0 / _DPC_IndMd_Stat_AR_Timebase;
    _DPC_IndMd_Stat_AR_MinDelay =        20 / _DPC_IndMd_Stat_AR_Timebase;
    _DPC_IndMd_Stat_AR_Cnt = _DPC_IndMd_Stat_AR_StartDelay;
    _DPC_IndMd_Stat_AR_SpontanFlag = 0;
    _DPC_IndMd_Stat_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_DPC_IndMd_Stat_AR, _DPC_IndMd_Stat_AR_StartDelay * _DPC_IndMd_Stat_AR_Timebase );

    _mDPC_IndMd_Stat_AR.DPC_IndMd_AC_Stat.phys = getValue( HMI_DPC_IndMd_AC_Stat );
    _mDPC_IndMd_Stat_AR.DPC_IndMd_DrvDyn_Stat.phys = getValue( HMI_DPC_IndMd_DrvDyn_Stat );
    _mDPC_IndMd_Stat_AR.DPC_IndMd_ECO_Assist_Stat.phys = getValue( HMI_DPC_IndMd_ECO_Assist_Stat );
    _mDPC_IndMd_Stat_AR.DPC_IndMd_eDrv_Stat.phys = getValue( HMI_DPC_IndMd_eDrv_Stat );
    _mDPC_IndMd_Stat_AR.DPC_IndMd_ESP_Stat.phys = getValue( HMI_DPC_IndMd_ESP_Stat );
    _mDPC_IndMd_Stat_AR.DPC_IndMd_ExhstFlap_Stat.phys = getValue( HMI_DPC_IndMd_ExhstFlap_Stat );
    _mDPC_IndMd_Stat_AR.DPC_IndMd_Ht_Stat.phys = getValue( HMI_DPC_IndMd_Ht_Stat );
    _mDPC_IndMd_Stat_AR.DPC_IndMd_PT_Stat.phys = getValue( HMI_DPC_IndMd_PT_Stat );
    _mDPC_IndMd_Stat_AR.DPC_IndMd_PwrFreeD_Plus_Stat.phys = getValue( HMI_DPC_IndMd_PwrFreeD_Plus_Stat );
    _mDPC_IndMd_Stat_AR.DPC_IndMd_SSA_Stat.phys = getValue( HMI_DPC_IndMd_SSA_Stat );
    _mDPC_IndMd_Stat_AR.DPC_IndMd_St_Stat.phys = getValue( HMI_DPC_IndMd_St_Stat );
    _mDPC_IndMd_Stat_AR.DPC_IndMd_Susp_Stat.phys = getValue( HMI_DPC_IndMd_Susp_Stat );
    _mDPC_IndMd_Stat_AR.DPC_IndMd_Tx_Stat.phys = getValue( HMI_DPC_IndMd_Tx_Stat );
    _mDPC_IndMd_Stat_AR.DPC_OffroadMd_Stat.phys = getValue( HMI_DPC_OffroadMd_Stat );
    _mDPC_IndMd_Stat_AR.Rsrv2_DPC_IndMd_Stat.phys = getValue( HMI_Rsrv2_DPC_IndMd_Stat );
    _mDPC_IndMd_Stat_AR.Rsrv3_DPC_IndMd_Stat.phys = getValue( HMI_Rsrv3_DPC_IndMd_Stat );
}

DPC_IndMd_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_DPC_IndMd_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_DPC_IndMd_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _DPC_IndMd_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _DPC_IndMd_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_DPC_IndMd_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _DPC_IndMd_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _DPC_IndMd_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _DPC_IndMd_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _DPC_IndMd_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _DPC_IndMd_Stat_AR_SQC_RepeatedCnt ) &&
            ( _DPC_IndMd_Stat_AR_E2E_Armed == 1  )    )
        {
            _DPC_IndMd_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_DPC_IndMd_Stat, SQC_help );
    }
    _mDPC_IndMd_Stat_AR.SQC_DPC_IndMd_Stat = SQC_help;

    if( getValue( HMI_CRC_DPC_IndMd_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_DPC_IndMd_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mDPC_IndMd_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Stat_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Stat_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Stat_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Stat_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Stat_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Stat_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _DPC_IndMd_Stat_AR_CRC_Offset[ _mDPC_IndMd_Stat_AR.SQC_DPC_IndMd_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _DPC_IndMd_Stat_AR_CRC_ErrorCnt   && ( _DPC_IndMd_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_DPC_IndMd_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _DPC_IndMd_Stat_AR_CRC_ErrorCnt > 0 )
                    _DPC_IndMd_Stat_AR_CRC_ErrorCnt--; 
            }
            _mDPC_IndMd_Stat_AR.CRC_DPC_IndMd_Stat = crc;
            putValue( HMI_CRC_DPC_IndMd_Stat, crc );
        }
        else
            _mDPC_IndMd_Stat_AR.CRC_DPC_IndMd_Stat = getValue( HMI_CRC_DPC_IndMd_Stat );
    }
    else
    {
        if( !getValue( HMI_CRC_DPC_IndMd_Stat_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mDPC_IndMd_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mDPC_IndMd_Stat_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mDPC_IndMd_Stat_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mDPC_IndMd_Stat_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mDPC_IndMd_Stat_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mDPC_IndMd_Stat_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mDPC_IndMd_Stat_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mDPC_IndMd_Stat_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _DPC_IndMd_Stat_AR_CRC_ErrorCnt   && ( _DPC_IndMd_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_DPC_IndMd_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _DPC_IndMd_Stat_AR_CRC_ErrorCnt > 0 )
                    _DPC_IndMd_Stat_AR_CRC_ErrorCnt--; 
            }
            _mDPC_IndMd_Stat_AR.CRC_DPC_IndMd_Stat = crc;
            putValue( HMI_CRC_DPC_IndMd_Stat, crc );
        }
        else
            _mDPC_IndMd_Stat_AR.CRC_DPC_IndMd_Stat = getValue( HMI_CRC_DPC_IndMd_Stat );
    }
    if( ( _DPC_IndMd_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _DPC_IndMd_Stat_AR_E2E_Armed == 1  )    )
    {
        _DPC_IndMd_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mDPC_IndMd_Stat_AR );
        
    if( _DPC_IndMd_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _DPC_IndMd_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _DPC_IndMd_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _DPC_IndMd_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _DPC_IndMd_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _DPC_IndMd_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_DPC_IndMd_Stat_State, 0 );
        }
    }
}

DPC_IndMd_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: DPC_IndMd_Stat_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_DPC_IndMd_Stat_AR := %X\n", getValue( HMI__STMSG_DPC_IndMd_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_DPC_IndMd_Stat_AR := %X\n", getValue( HMI__STMSGT_DPC_IndMd_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_DPC_IndMd_Stat := %X\n", getValue( HMI_CRC_DPC_IndMd_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_DPC_IndMd_Stat_Auto := %X\n", getValue( HMI_CRC_DPC_IndMd_Stat_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_ABC_Stat := %X\n", getValue( HMI_DPC_IndMd_ABC_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_AC_Stat := %X\n", getValue( HMI_DPC_IndMd_AC_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_DrvDyn_Stat := %X\n", getValue( HMI_DPC_IndMd_DrvDyn_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_ECO_Assist_Stat := %X\n", getValue( HMI_DPC_IndMd_ECO_Assist_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_eDrv_Stat := %X\n", getValue( HMI_DPC_IndMd_eDrv_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_ESP_Stat := %X\n", getValue( HMI_DPC_IndMd_ESP_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_ExhstFlap_Stat := %X\n", getValue( HMI_DPC_IndMd_ExhstFlap_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_Ht_Stat := %X\n", getValue( HMI_DPC_IndMd_Ht_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_PT_Stat := %X\n", getValue( HMI_DPC_IndMd_PT_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_PwrFreeD_Plus_Stat := %X\n", getValue( HMI_DPC_IndMd_PwrFreeD_Plus_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_SSA_Stat := %X\n", getValue( HMI_DPC_IndMd_SSA_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_St_Stat := %X\n", getValue( HMI_DPC_IndMd_St_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_Susp_Stat := %X\n", getValue( HMI_DPC_IndMd_Susp_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_Tx_Stat := %X\n", getValue( HMI_DPC_IndMd_Tx_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_OffroadMd_Stat := %X\n", getValue( HMI_DPC_OffroadMd_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_DPC_IndMd_Stat := %X\n", getValue( HMI_Rsrv2_DPC_IndMd_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv3_DPC_IndMd_Stat := %X\n", getValue( HMI_Rsrv3_DPC_IndMd_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_DPC_IndMd_Stat := %X\n", getValue( HMI_SQC_DPC_IndMd_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_DPC_IndMd_Stat_Auto := %X\n", getValue( HMI_SQC_DPC_IndMd_Stat_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tDPC_IndMd_Stat_AR
{
    putValue( HMI__STMSG_DPC_IndMd_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_DPC_IndMd_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_DPC_IndMd_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tDPC_IndMd_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_DPC_IndMd_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_DPC_IndMd_Stat_AR
{
    if( getValue( this ) )
        openPanel("DPC_IndMd_Stat_AR");
}

on envVar HMI_E2E_DPC_IndMd_Stat_Inject
{
    if( getValue( this ) )
    {
        _DPC_IndMd_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_DPC_IndMd_Stat_ErrorCount );
        _DPC_IndMd_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_DPC_IndMd_Stat_TriggerPosition );
        _DPC_IndMd_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_DPC_IndMd_Stat_WrongSeq );
        _DPC_IndMd_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_DPC_IndMd_Stat_Repeated );
        _DPC_IndMd_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_DPC_IndMd_Stat_MSG_DropCnt );
        putValue( HMI_E2E_DPC_IndMd_Stat_State, 2 );
        _DPC_IndMd_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_DPC_IndMd_ABC_Stat
{
    _mDPC_IndMd_Stat_AR.DPC_IndMd_ABC_Stat.phys = getValue(this);
    _DPC_IndMd_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_IndMd_AC_Stat
{
    _mDPC_IndMd_Stat_AR.DPC_IndMd_AC_Stat.phys = getValue(this);
    _DPC_IndMd_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_IndMd_DrvDyn_Stat
{
    _mDPC_IndMd_Stat_AR.DPC_IndMd_DrvDyn_Stat.phys = getValue(this);
    _DPC_IndMd_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_IndMd_ECO_Assist_Stat
{
    _mDPC_IndMd_Stat_AR.DPC_IndMd_ECO_Assist_Stat.phys = getValue(this);
    _DPC_IndMd_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_IndMd_eDrv_Stat
{
    _mDPC_IndMd_Stat_AR.DPC_IndMd_eDrv_Stat.phys = getValue(this);
    _DPC_IndMd_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_IndMd_ESP_Stat
{
    _mDPC_IndMd_Stat_AR.DPC_IndMd_ESP_Stat.phys = getValue(this);
    _DPC_IndMd_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_IndMd_ExhstFlap_Stat
{
    _mDPC_IndMd_Stat_AR.DPC_IndMd_ExhstFlap_Stat.phys = getValue(this);
    _DPC_IndMd_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_IndMd_Ht_Stat
{
    _mDPC_IndMd_Stat_AR.DPC_IndMd_Ht_Stat.phys = getValue(this);
    _DPC_IndMd_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_IndMd_PT_Stat
{
    _mDPC_IndMd_Stat_AR.DPC_IndMd_PT_Stat.phys = getValue(this);
    _DPC_IndMd_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_IndMd_PwrFreeD_Plus_Stat
{
    _mDPC_IndMd_Stat_AR.DPC_IndMd_PwrFreeD_Plus_Stat.phys = getValue(this);
    _DPC_IndMd_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_IndMd_SSA_Stat
{
    _mDPC_IndMd_Stat_AR.DPC_IndMd_SSA_Stat.phys = getValue(this);
    _DPC_IndMd_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_IndMd_St_Stat
{
    _mDPC_IndMd_Stat_AR.DPC_IndMd_St_Stat.phys = getValue(this);
    _DPC_IndMd_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_IndMd_Susp_Stat
{
    _mDPC_IndMd_Stat_AR.DPC_IndMd_Susp_Stat.phys = getValue(this);
    _DPC_IndMd_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_IndMd_Tx_Stat
{
    _mDPC_IndMd_Stat_AR.DPC_IndMd_Tx_Stat.phys = getValue(this);
    _DPC_IndMd_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_OffroadMd_Stat
{
    _mDPC_IndMd_Stat_AR.DPC_OffroadMd_Stat.phys = getValue(this);
    _DPC_IndMd_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv2_DPC_IndMd_Stat
{
    _mDPC_IndMd_Stat_AR.Rsrv2_DPC_IndMd_Stat.phys = getValue(this);
    _DPC_IndMd_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv3_DPC_IndMd_Stat
{
    _mDPC_IndMd_Stat_AR.Rsrv3_DPC_IndMd_Stat.phys = getValue(this);
    _DPC_IndMd_Stat_AR_SpontanFlag = 1;
}

DPC_IndMd_Style_AR_check_output()
{
    if( !getValue( HMI__STMSG_DPC_IndMd_Style_AR ) )
    {
    //  message   DPC_IndMd_Style_AR ID: 778 --- Sendeart 0 cyclic --- 
        _DPC_IndMd_Style_AR_Cnt--;
        if( _DPC_IndMd_Style_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            DPC_IndMd_Style_AR_output();
            // Zyklus-Z�hler zur�cksetzen
            _DPC_IndMd_Style_AR_Cnt = _DPC_IndMd_Style_AR_CycleCount;
        }
    }
}

DPC_IndMd_Style_AR_init()
{   /* Botschaft DPC_IndMd_Style_AR ID: 778 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 778 0;
BA_ "NmAsrMessage" BO_ 778 0;
BA_ "GenMsgMinAcceptLength" BO_ 778 8;
BA_ "GenMsgILSupport" BO_ 778 1;
BA_ "DiagState" BO_ 778 0;
BA_ "DiagRequest" BO_ 778 0;
BA_ "DiagResponse" BO_ 778 0;
BA_ "GenMsgStartValue" BO_ 778 "0";
BA_ "GenMsgStartDelayTime" BO_ 778 0;
BA_ "GenMsgCycleTime" BO_ 778 1000;
BA_ "GenMsgSendType" BO_ 778 0;
    */
    _DPC_IndMd_Style_AR_Timebase =         c_tDBKomTimer_20ms;
    _DPC_IndMd_Style_AR_CycleCount =     1000 / _DPC_IndMd_Style_AR_Timebase;
    _DPC_IndMd_Style_AR_StartDelay =        0 / _DPC_IndMd_Style_AR_Timebase;
    _DPC_IndMd_Style_AR_Cnt = _DPC_IndMd_Style_AR_StartDelay;
    _DPC_IndMd_Style_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_DPC_IndMd_Style_AR, _DPC_IndMd_Style_AR_StartDelay * _DPC_IndMd_Style_AR_Timebase );

    _mDPC_IndMd_Style_AR.DPC_IndMd_AC_Style.phys = getValue( HMI_DPC_IndMd_AC_Style );
    _mDPC_IndMd_Style_AR.DPC_IndMd_DrvDyn_Style.phys = getValue( HMI_DPC_IndMd_DrvDyn_Style );
    _mDPC_IndMd_Style_AR.DPC_IndMd_ECO_Assist_Style.phys = getValue( HMI_DPC_IndMd_ECO_Assist_Style );
    _mDPC_IndMd_Style_AR.DPC_IndMd_eDrv_Style.phys = getValue( HMI_DPC_IndMd_eDrv_Style );
    _mDPC_IndMd_Style_AR.DPC_IndMd_ESP_Style.phys = getValue( HMI_DPC_IndMd_ESP_Style );
    _mDPC_IndMd_Style_AR.DPC_IndMd_ExhstFlap_Style.phys = getValue( HMI_DPC_IndMd_ExhstFlap_Style );
    _mDPC_IndMd_Style_AR.DPC_IndMd_Ht_Style.phys = getValue( HMI_DPC_IndMd_Ht_Style );
    _mDPC_IndMd_Style_AR.DPC_IndMd_PT_Style.phys = getValue( HMI_DPC_IndMd_PT_Style );
    _mDPC_IndMd_Style_AR.DPC_IndMd_PwrFreeD_Plus_Style.phys = getValue( HMI_DPC_IndMd_PwrFreeD_Plus_Style );
    _mDPC_IndMd_Style_AR.DPC_IndMd_SSA_Style.phys = getValue( HMI_DPC_IndMd_SSA_Style );
    _mDPC_IndMd_Style_AR.DPC_IndMd_St_Style.phys = getValue( HMI_DPC_IndMd_St_Style );
    _mDPC_IndMd_Style_AR.DPC_IndMd_Susp_Style.phys = getValue( HMI_DPC_IndMd_Susp_Style );
    _mDPC_IndMd_Style_AR.DPC_IndMd_Tx_Style.phys = getValue( HMI_DPC_IndMd_Tx_Style );
    _mDPC_IndMd_Style_AR.DPC_OffroadMd_Style.phys = getValue( HMI_DPC_OffroadMd_Style );
}

DPC_IndMd_Style_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_DPC_IndMd_Style ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_DPC_IndMd_Style_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _DPC_IndMd_Style_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _DPC_IndMd_Style_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_DPC_IndMd_Style_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _DPC_IndMd_Style_AR_SQC_WrongSeqJump != 0 ) &&
            ( _DPC_IndMd_Style_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _DPC_IndMd_Style_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _DPC_IndMd_Style_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _DPC_IndMd_Style_AR_SQC_RepeatedCnt ) &&
            ( _DPC_IndMd_Style_AR_E2E_Armed == 1  )    )
        {
            _DPC_IndMd_Style_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_DPC_IndMd_Style, SQC_help );
    }
    _mDPC_IndMd_Style_AR.SQC_DPC_IndMd_Style = SQC_help;

    if( getValue( HMI_CRC_DPC_IndMd_Style_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_DPC_IndMd_Style_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mDPC_IndMd_Style_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Style_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Style_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Style_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Style_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Style_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Style_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Style_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _DPC_IndMd_Style_AR_CRC_Offset[ _mDPC_IndMd_Style_AR.SQC_DPC_IndMd_Style ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _DPC_IndMd_Style_AR_CRC_ErrorCnt   && ( _DPC_IndMd_Style_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_DPC_IndMd_Style_Invalid )                                         )    )
            {
                crc++;
                if( _DPC_IndMd_Style_AR_CRC_ErrorCnt > 0 )
                    _DPC_IndMd_Style_AR_CRC_ErrorCnt--; 
            }
            _mDPC_IndMd_Style_AR.CRC_DPC_IndMd_Style = crc;
            putValue( HMI_CRC_DPC_IndMd_Style, crc );
        }
        else
            _mDPC_IndMd_Style_AR.CRC_DPC_IndMd_Style = getValue( HMI_CRC_DPC_IndMd_Style );
    }
    else
    {
        if( !getValue( HMI_CRC_DPC_IndMd_Style_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mDPC_IndMd_Style_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mDPC_IndMd_Style_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mDPC_IndMd_Style_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mDPC_IndMd_Style_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mDPC_IndMd_Style_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mDPC_IndMd_Style_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mDPC_IndMd_Style_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mDPC_IndMd_Style_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _DPC_IndMd_Style_AR_CRC_ErrorCnt   && ( _DPC_IndMd_Style_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_DPC_IndMd_Style_Invalid )                                         )    )
            {
                crc++;
                if( _DPC_IndMd_Style_AR_CRC_ErrorCnt > 0 )
                    _DPC_IndMd_Style_AR_CRC_ErrorCnt--; 
            }
            _mDPC_IndMd_Style_AR.CRC_DPC_IndMd_Style = crc;
            putValue( HMI_CRC_DPC_IndMd_Style, crc );
        }
        else
            _mDPC_IndMd_Style_AR.CRC_DPC_IndMd_Style = getValue( HMI_CRC_DPC_IndMd_Style );
    }
    if( ( _DPC_IndMd_Style_AR_MSG_DropCnt > 0 ) &&
        ( _DPC_IndMd_Style_AR_E2E_Armed == 1  )    )
    {
        _DPC_IndMd_Style_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mDPC_IndMd_Style_AR );
        
    if( _DPC_IndMd_Style_AR_E2E_Armed == 1 )
    {
        if ( ( _DPC_IndMd_Style_AR_MSG_DropCnt == 0      ) &&
             ( _DPC_IndMd_Style_AR_CRC_ErrorCnt == 0     ) &&
             ( _DPC_IndMd_Style_AR_SQC_RepeatedCnt == 0  ) &&
             ( _DPC_IndMd_Style_AR_SQC_WrongSeqJump == 0 )    )
        {
            _DPC_IndMd_Style_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_DPC_IndMd_Style_State, 0 );
        }
    }
}

DPC_IndMd_Style_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: DPC_IndMd_Style_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_DPC_IndMd_Style_AR := %X\n", getValue( HMI__STMSG_DPC_IndMd_Style_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_DPC_IndMd_Style_AR := %X\n", getValue( HMI__STMSGT_DPC_IndMd_Style_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_DPC_IndMd_Style := %X\n", getValue( HMI_CRC_DPC_IndMd_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_DPC_IndMd_Style_Auto := %X\n", getValue( HMI_CRC_DPC_IndMd_Style_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_AC_Style := %X\n", getValue( HMI_DPC_IndMd_AC_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_DrvDyn_Style := %X\n", getValue( HMI_DPC_IndMd_DrvDyn_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_ECO_Assist_Style := %X\n", getValue( HMI_DPC_IndMd_ECO_Assist_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_eDrv_Style := %X\n", getValue( HMI_DPC_IndMd_eDrv_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_ESP_Style := %X\n", getValue( HMI_DPC_IndMd_ESP_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_ExhstFlap_Style := %X\n", getValue( HMI_DPC_IndMd_ExhstFlap_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_Ht_Style := %X\n", getValue( HMI_DPC_IndMd_Ht_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_PT_Style := %X\n", getValue( HMI_DPC_IndMd_PT_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_PwrFreeD_Plus_Style := %X\n", getValue( HMI_DPC_IndMd_PwrFreeD_Plus_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_SSA_Style := %X\n", getValue( HMI_DPC_IndMd_SSA_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_St_Style := %X\n", getValue( HMI_DPC_IndMd_St_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_Susp_Style := %X\n", getValue( HMI_DPC_IndMd_Susp_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_Tx_Style := %X\n", getValue( HMI_DPC_IndMd_Tx_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_OffroadMd_Style := %X\n", getValue( HMI_DPC_OffroadMd_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_DPC_IndMd_Style := %X\n", getValue( HMI_SQC_DPC_IndMd_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_DPC_IndMd_Style_Auto := %X\n", getValue( HMI_SQC_DPC_IndMd_Style_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tDPC_IndMd_Style_AR
{
    putValue( HMI__STMSG_DPC_IndMd_Style_AR, 0 );
}

on EnvVar HMI__STMSG_DPC_IndMd_Style_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_DPC_IndMd_Style_AR );
        if( tDelay > 0)    
            setTimer( _tDPC_IndMd_Style_AR, tDelay );
        else
            putValue( HMI__STMSG_DPC_IndMd_Style_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_DPC_IndMd_Style_AR
{
    if( getValue( this ) )
        openPanel("DPC_IndMd_Style_AR");
}

on envVar HMI_E2E_DPC_IndMd_Style_Inject
{
    if( getValue( this ) )
    {
        _DPC_IndMd_Style_AR_CRC_ErrorCnt = getValue( HMI_CRC_DPC_IndMd_Style_ErrorCount );
        _DPC_IndMd_Style_AR_SQC_TriggPos = getValue( HMI_SQC_DPC_IndMd_Style_TriggerPosition );
        _DPC_IndMd_Style_AR_SQC_WrongSeqJump = getValue( HMI_SQC_DPC_IndMd_Style_WrongSeq );
        _DPC_IndMd_Style_AR_SQC_RepeatedCnt = getValue( HMI_SQC_DPC_IndMd_Style_Repeated );
        _DPC_IndMd_Style_AR_MSG_DropCnt = getValue( HMI_SQC_DPC_IndMd_Style_MSG_DropCnt );
        putValue( HMI_E2E_DPC_IndMd_Style_State, 2 );
        _DPC_IndMd_Style_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_DPC_IndMd_AC_Style
{
    _mDPC_IndMd_Style_AR.DPC_IndMd_AC_Style.phys = getValue(this);
}

on EnvVar HMI_DPC_IndMd_DrvDyn_Style
{
    _mDPC_IndMd_Style_AR.DPC_IndMd_DrvDyn_Style.phys = getValue(this);
}

on EnvVar HMI_DPC_IndMd_ECO_Assist_Style
{
    _mDPC_IndMd_Style_AR.DPC_IndMd_ECO_Assist_Style.phys = getValue(this);
}

on EnvVar HMI_DPC_IndMd_eDrv_Style
{
    _mDPC_IndMd_Style_AR.DPC_IndMd_eDrv_Style.phys = getValue(this);
}

on EnvVar HMI_DPC_IndMd_ESP_Style
{
    _mDPC_IndMd_Style_AR.DPC_IndMd_ESP_Style.phys = getValue(this);
}

on EnvVar HMI_DPC_IndMd_ExhstFlap_Style
{
    _mDPC_IndMd_Style_AR.DPC_IndMd_ExhstFlap_Style.phys = getValue(this);
}

on EnvVar HMI_DPC_IndMd_Ht_Style
{
    _mDPC_IndMd_Style_AR.DPC_IndMd_Ht_Style.phys = getValue(this);
}

on EnvVar HMI_DPC_IndMd_PT_Style
{
    _mDPC_IndMd_Style_AR.DPC_IndMd_PT_Style.phys = getValue(this);
}

on EnvVar HMI_DPC_IndMd_SSA_Style
{
    _mDPC_IndMd_Style_AR.DPC_IndMd_SSA_Style.phys = getValue(this);
}

on EnvVar HMI_DPC_IndMd_St_Style
{
    _mDPC_IndMd_Style_AR.DPC_IndMd_St_Style.phys = getValue(this);
}

on EnvVar HMI_DPC_IndMd_Susp_Style
{
    _mDPC_IndMd_Style_AR.DPC_IndMd_Susp_Style.phys = getValue(this);
}

on EnvVar HMI_DPC_IndMd_Tx_Style
{
    _mDPC_IndMd_Style_AR.DPC_IndMd_Tx_Style.phys = getValue(this);
}

on EnvVar HMI_DPC_OffroadMd_Style
{
    _mDPC_IndMd_Style_AR.DPC_OffroadMd_Style.phys = getValue(this);
}

DPC_IndMd_Style2_AR_check_output()
{
    if( !getValue( HMI__STMSG_DPC_IndMd_Style2_AR ) )
    {
    //  message   DPC_IndMd_Style2_AR --- Sendeart 0 cyclicX
        _DPC_IndMd_Style2_AR_Cnt--;
        if( _DPC_IndMd_Style2_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            DPC_IndMd_Style2_AR_output();
            // Zyklus-Z�hler zur�cksetzen
            _DPC_IndMd_Style2_AR_Cnt = _DPC_IndMd_Style2_AR_CycleCount;
        }
    }
}

DPC_IndMd_Style2_AR_init()
{   /* Botschaft DPC_IndMd_Style2_AR ID: 790 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 790 0;
BA_ "NmAsrMessage" BO_ 790 0;
BA_ "GenMsgMinAcceptLength" BO_ 790 8;
BA_ "GenMsgILSupport" BO_ 790 1;
BA_ "DiagState" BO_ 790 0;
BA_ "DiagRequest" BO_ 790 0;
BA_ "DiagResponse" BO_ 790 0;
BA_ "GenMsgStartValue" BO_ 790 "0";
BA_ "GenMsgCycleTime" BO_ 790 1000;
BA_ "GenMsgSendType" BO_ 790 0;
    */
    _DPC_IndMd_Style2_AR_Timebase =          c_tDBKomTimer_20ms;
    _DPC_IndMd_Style2_AR_CycleCount =      1000 / _DPC_IndMd_Style2_AR_Timebase;
    _DPC_IndMd_Style2_AR_StartDelay =         0 / _DPC_IndMd_Style2_AR_Timebase;
    _DPC_IndMd_Style2_AR_Cnt = _DPC_IndMd_Style2_AR_StartDelay;

    putValue( HMI__STMSGSD_DPC_IndMd_Style2_AR, _DPC_IndMd_Style2_AR_StartDelay * _DPC_IndMd_Style2_AR_Timebase );

    _mDPC_IndMd_Style2_AR.DPC_IndMd_ABC_Style.phys = getValue( HMI_DPC_IndMd_ABC_Style );
    _mDPC_IndMd_Style2_AR.Rsrv1_DPC_IndMd_Style2.phys = getValue( HMI_Rsrv1_DPC_IndMd_Style2 );
    _mDPC_IndMd_Style2_AR.Rsrv2_DPC_IndMd_Style2.phys = getValue( HMI_Rsrv2_DPC_IndMd_Style2 );
    _mDPC_IndMd_Style2_AR.Rsrv3_DPC_IndMd_Style2.phys = getValue( HMI_Rsrv3_DPC_IndMd_Style2 );
    _mDPC_IndMd_Style2_AR.Rsrv4_DPC_IndMd_Style2.phys = getValue( HMI_Rsrv4_DPC_IndMd_Style2 );
    _mDPC_IndMd_Style2_AR.Rsrv5_DPC_IndMd_Style2.phys = getValue( HMI_Rsrv5_DPC_IndMd_Style2 );
    _mDPC_IndMd_Style2_AR.Rsrv6_DPC_IndMd_Style2.phys = getValue( HMI_Rsrv6_DPC_IndMd_Style2 );
}

DPC_IndMd_Style2_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_DPC_IndMd_Style2 ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_DPC_IndMd_Style2_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _DPC_IndMd_Style2_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _DPC_IndMd_Style2_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_DPC_IndMd_Style2_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _DPC_IndMd_Style2_AR_SQC_WrongSeqJump != 0 ) &&
            ( _DPC_IndMd_Style2_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _DPC_IndMd_Style2_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _DPC_IndMd_Style2_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _DPC_IndMd_Style2_AR_SQC_RepeatedCnt ) &&
            ( _DPC_IndMd_Style2_AR_E2E_Armed == 1  )    )
        {
            _DPC_IndMd_Style2_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_DPC_IndMd_Style2, SQC_help );
    }
    _mDPC_IndMd_Style2_AR.SQC_DPC_IndMd_Style2 = SQC_help;

    if( getValue( HMI_CRC_DPC_IndMd_Style2_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_DPC_IndMd_Style2_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mDPC_IndMd_Style2_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Style2_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Style2_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Style2_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Style2_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Style2_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Style2_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_IndMd_Style2_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _DPC_IndMd_Style2_AR_CRC_Offset[ _mDPC_IndMd_Style2_AR.SQC_DPC_IndMd_Style2 ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _DPC_IndMd_Style2_AR_CRC_ErrorCnt   && ( _DPC_IndMd_Style2_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_DPC_IndMd_Style2_Invalid )                                         )    )
            {
                crc++;
                if( _DPC_IndMd_Style2_AR_CRC_ErrorCnt > 0 )
                    _DPC_IndMd_Style2_AR_CRC_ErrorCnt--; 
            }
            _mDPC_IndMd_Style2_AR.CRC_DPC_IndMd_Style2 = crc;
            putValue( HMI_CRC_DPC_IndMd_Style2, crc );
        }
        else
            _mDPC_IndMd_Style2_AR.CRC_DPC_IndMd_Style2 = getValue( HMI_CRC_DPC_IndMd_Style2 );
    }
    else
    {
        if( !getValue( HMI_CRC_DPC_IndMd_Style2_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mDPC_IndMd_Style2_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mDPC_IndMd_Style2_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mDPC_IndMd_Style2_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mDPC_IndMd_Style2_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mDPC_IndMd_Style2_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mDPC_IndMd_Style2_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mDPC_IndMd_Style2_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mDPC_IndMd_Style2_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _DPC_IndMd_Style2_AR_CRC_ErrorCnt   && ( _DPC_IndMd_Style2_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_DPC_IndMd_Style2_Invalid )                                         )    )
            {
                crc++;
                if( _DPC_IndMd_Style2_AR_CRC_ErrorCnt > 0 )
                    _DPC_IndMd_Style2_AR_CRC_ErrorCnt--; 
            }
            _mDPC_IndMd_Style2_AR.CRC_DPC_IndMd_Style2 = crc;
            putValue( HMI_CRC_DPC_IndMd_Style2, crc );
        }
        else
            _mDPC_IndMd_Style2_AR.CRC_DPC_IndMd_Style2 = getValue( HMI_CRC_DPC_IndMd_Style2 );
    }
    if( ( _DPC_IndMd_Style2_AR_MSG_DropCnt > 0 ) &&
        ( _DPC_IndMd_Style2_AR_E2E_Armed == 1  )    )
    {
        _DPC_IndMd_Style2_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mDPC_IndMd_Style2_AR );
        
    if( _DPC_IndMd_Style2_AR_E2E_Armed == 1 )
    {
        if ( ( _DPC_IndMd_Style2_AR_MSG_DropCnt == 0      ) &&
             ( _DPC_IndMd_Style2_AR_CRC_ErrorCnt == 0     ) &&
             ( _DPC_IndMd_Style2_AR_SQC_RepeatedCnt == 0  ) &&
             ( _DPC_IndMd_Style2_AR_SQC_WrongSeqJump == 0 )    )
        {
            _DPC_IndMd_Style2_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_DPC_IndMd_Style2_State, 0 );
        }
    }
}

DPC_IndMd_Style2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: DPC_IndMd_Style2_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_DPC_IndMd_Style2_AR := %X\n", getValue( HMI__STMSG_DPC_IndMd_Style2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_DPC_IndMd_Style2_AR := %X\n", getValue( HMI__STMSGT_DPC_IndMd_Style2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_DPC_IndMd_Style2 := %X\n", getValue( HMI_CRC_DPC_IndMd_Style2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_DPC_IndMd_Style2_Auto := %X\n", getValue( HMI_CRC_DPC_IndMd_Style2_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_DPC_IndMd_Style2_Profile_02 := %X\n", getValue( HMI_CRC_DPC_IndMd_Style2_Profile_02 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_IndMd_ABC_Style := %X\n", getValue( HMI_DPC_IndMd_ABC_Style ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_DPC_IndMd_Style2 := %X\n", getValue( HMI_Rsrv1_DPC_IndMd_Style2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_DPC_IndMd_Style2 := %X\n", getValue( HMI_Rsrv2_DPC_IndMd_Style2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv3_DPC_IndMd_Style2 := %X\n", getValue( HMI_Rsrv3_DPC_IndMd_Style2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv4_DPC_IndMd_Style2 := %X\n", getValue( HMI_Rsrv4_DPC_IndMd_Style2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv5_DPC_IndMd_Style2 := %X\n", getValue( HMI_Rsrv5_DPC_IndMd_Style2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv6_DPC_IndMd_Style2 := %X\n", getValue( HMI_Rsrv6_DPC_IndMd_Style2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_DPC_IndMd_Style2 := %X\n", getValue( HMI_SQC_DPC_IndMd_Style2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_DPC_IndMd_Style2_Auto := %X\n", getValue( HMI_SQC_DPC_IndMd_Style2_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tDPC_IndMd_Style2_AR
{
    putValue( HMI__STMSG_DPC_IndMd_Style2_AR, 0 );
}

on EnvVar HMI__STMSG_DPC_IndMd_Style2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_DPC_IndMd_Style2_AR );
        if( tDelay > 0)    
            setTimer( _tDPC_IndMd_Style2_AR, tDelay );
        else
            putValue( HMI__STMSG_DPC_IndMd_Style2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_DPC_IndMd_Style2_AR
{
    if( getValue( this ) )
        openPanel("DPC_IndMd_Style2_AR");
}

on envVar HMI_E2E_DPC_IndMd_Style2_Inject
{
    if( getValue( this ) )
    {
        _DPC_IndMd_Style2_AR_CRC_ErrorCnt = getValue( HMI_CRC_DPC_IndMd_Style2_ErrorCount );
        _DPC_IndMd_Style2_AR_SQC_TriggPos = getValue( HMI_SQC_DPC_IndMd_Style2_TriggerPosition );
        _DPC_IndMd_Style2_AR_SQC_WrongSeqJump = getValue( HMI_SQC_DPC_IndMd_Style2_WrongSeq );
        _DPC_IndMd_Style2_AR_SQC_RepeatedCnt = getValue( HMI_SQC_DPC_IndMd_Style2_Repeated );
        _DPC_IndMd_Style2_AR_MSG_DropCnt = getValue( HMI_SQC_DPC_IndMd_Style2_MSG_DropCnt );
        putValue( HMI_E2E_DPC_IndMd_Style2_State, 2 );
        _DPC_IndMd_Style2_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_DPC_IndMd_ABC_Style
{
    _mDPC_IndMd_Style2_AR.DPC_IndMd_ABC_Style.phys = getValue(this);
}

on EnvVar HMI_Rsrv1_DPC_IndMd_Style2
{
    _mDPC_IndMd_Style2_AR.Rsrv1_DPC_IndMd_Style2.phys = getValue(this);
}

on EnvVar HMI_Rsrv2_DPC_IndMd_Style2
{
    _mDPC_IndMd_Style2_AR.Rsrv2_DPC_IndMd_Style2.phys = getValue(this);
}

on EnvVar HMI_Rsrv3_DPC_IndMd_Style2
{
    _mDPC_IndMd_Style2_AR.Rsrv3_DPC_IndMd_Style2.phys = getValue(this);
}

on EnvVar HMI_Rsrv4_DPC_IndMd_Style2
{
    _mDPC_IndMd_Style2_AR.Rsrv4_DPC_IndMd_Style2.phys = getValue(this);
}

on EnvVar HMI_Rsrv5_DPC_IndMd_Style2
{
    _mDPC_IndMd_Style2_AR.Rsrv5_DPC_IndMd_Style2.phys = getValue(this);
}

on EnvVar HMI_Rsrv6_DPC_IndMd_Style2
{
    _mDPC_IndMd_Style2_AR.Rsrv6_DPC_IndMd_Style2.phys = getValue(this);
}

DPC_Master_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_DPC_Master_Rq_AR ) )
    {
    //  message   DPC_Master_Rq_AR ID: 625 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _DPC_Master_Rq_AR_DelayCnt > 0) _DPC_Master_Rq_AR_DelayCnt--; // Mindestsendeabstand
        _DPC_Master_Rq_AR_Cnt--;
        if( _DPC_Master_Rq_AR_Cnt < 1 )
        {
            if( _DPC_Master_Rq_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                DPC_Master_Rq_AR_output();
                 _DPC_Master_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _DPC_Master_Rq_AR_DelayCnt = _DPC_Master_Rq_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _DPC_Master_Rq_AR_SpontanFlag = 1;
            }
            _DPC_Master_Rq_AR_Cnt = _DPC_Master_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _DPC_Master_Rq_AR_SpontanFlag)
        {
            if( _DPC_Master_Rq_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                DPC_Master_Rq_AR_output();
                _DPC_Master_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _DPC_Master_Rq_AR_DelayCnt = _DPC_Master_Rq_AR_MinDelay;
            }
        }
    }
}

DPC_Master_Rq_AR_init()
{   /* Botschaft DPC_Master_Rq_AR ID: 625 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 625 0;
BA_ "NmAsrMessage" BO_ 625 0;
BA_ "GenMsgMinAcceptLength" BO_ 625 8;
BA_ "GenMsgILSupport" BO_ 625 1;
BA_ "DiagState" BO_ 625 0;
BA_ "DiagRequest" BO_ 625 0;
BA_ "DiagResponse" BO_ 625 0;
BA_ "GenMsgStartValue" BO_ 625 "0";
BA_ "GenMsgStartDelayTime" BO_ 625 0;
BA_ "GenMsgDelayTime" BO_ 625 20;
BA_ "GenMsgNrOfRepetitions" BO_ 625 0;
BA_ "GenMsgCycleTime" BO_ 625 100;
BA_ "GenMsgSendType" BO_ 625 5;
    */
    _DPC_Master_Rq_AR_Timebase =            c_tDBKomTimer_20ms;
    _DPC_Master_Rq_AR_CycleCount =        100 / _DPC_Master_Rq_AR_Timebase;
    _DPC_Master_Rq_AR_StartDelay =          0 / _DPC_Master_Rq_AR_Timebase;
    _DPC_Master_Rq_AR_MinDelay =           20 / _DPC_Master_Rq_AR_Timebase;
    _DPC_Master_Rq_AR_Cnt = _DPC_Master_Rq_AR_StartDelay;
    _DPC_Master_Rq_AR_SpontanFlag = 0;
    _DPC_Master_Rq_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_DPC_Master_Rq_AR, _DPC_Master_Rq_AR_StartDelay * _DPC_Master_Rq_AR_Timebase );

    _mDPC_Master_Rq_AR.DPC_GlobalMd_Rq.phys = getValue( HMI_DPC_GlobalMd_Rq );
    _mDPC_Master_Rq_AR.DPC_Md_ABC_Carv_Rq.phys = getValue( HMI_DPC_Md_ABC_Carv_Rq );
    _mDPC_Master_Rq_AR.DPC_Md_ABC_Preview_Rq.phys = getValue( HMI_DPC_Md_ABC_Preview_Rq );
    _mDPC_Master_Rq_AR.DPC_Md_AC_Rq.phys = getValue( HMI_DPC_Md_AC_Master_Rq );
    _mDPC_Master_Rq_AR.DPC_Md_AS_Rq.phys = getValue( HMI_DPC_Md_AS_Master_Rq );
    _mDPC_Master_Rq_AR.DPC_Md_ECO_Assist_Rq.phys = getValue( HMI_DPC_Md_ECO_Assist_Master_Rq );
    _mDPC_Master_Rq_AR.DPC_Md_eDrv_Rq.phys = getValue( HMI_DPC_Md_eDrv_Master_Rq );
    _mDPC_Master_Rq_AR.DPC_Md_ESP_Rq.phys = getValue( HMI_DPC_Md_ESP_Rq );
    _mDPC_Master_Rq_AR.DPC_Md_ExhstFlap_Rq.phys = getValue( HMI_DPC_Md_ExhstFlap_Rq );
    _mDPC_Master_Rq_AR.DPC_Md_Ht_Rq.phys = getValue( HMI_DPC_Md_Ht_Master_Rq );
    _mDPC_Master_Rq_AR.DPC_Md_PT_Rq.phys = getValue( HMI_DPC_Md_PT_Master_Rq );
    _mDPC_Master_Rq_AR.DPC_Md_PwrFreeD_Plus_Rq.phys = getValue( HMI_DPC_Md_PwrFreeD_Plus_Master_Rq );
    _mDPC_Master_Rq_AR.DPC_Md_SSA_Rq.phys = getValue( HMI_DPC_Md_SSA_Master_Rq );
    _mDPC_Master_Rq_AR.DPC_Md_St_Rq.phys = getValue( HMI_DPC_Md_St_Master_Rq );
    _mDPC_Master_Rq_AR.DPC_Md_Susp_Rq_V2.phys = getValue( HMI_DPC_Md_Susp_Master_Rq_V2 );
    _mDPC_Master_Rq_AR.DPC_Md_SuspLvl_Rq.phys = getValue( HMI_DPC_Md_SuspLvl_Rq );
    _mDPC_Master_Rq_AR.DPC_Md_Tx_Rq.phys = getValue( HMI_DPC_Md_Tx_Rq );
    _mDPC_Master_Rq_AR.DPC_PopupDisp_Rq.phys = getValue( HMI_DPC_PopupDisp_Rq );
    _mDPC_Master_Rq_AR.DPC_PopupSupp_Rq.phys = getValue( HMI_DPC_PopupSupp_Rq );
    _mDPC_Master_Rq_AR.Rsrv2_DPC_Master_Rq.phys = getValue( HMI_Rsrv2_DPC_Master_Rq );
    _mDPC_Master_Rq_AR.Rsrv3_DPC_Master_Rq.phys = getValue( HMI_Rsrv3_DPC_Master_Rq );
}

DPC_Master_Rq_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_DPC_Master_Rq ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_DPC_Master_Rq_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _DPC_Master_Rq_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _DPC_Master_Rq_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_DPC_Master_Rq_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _DPC_Master_Rq_AR_SQC_WrongSeqJump != 0 ) &&
            ( _DPC_Master_Rq_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _DPC_Master_Rq_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _DPC_Master_Rq_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _DPC_Master_Rq_AR_SQC_RepeatedCnt ) &&
            ( _DPC_Master_Rq_AR_E2E_Armed == 1  )    )
        {
            _DPC_Master_Rq_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_DPC_Master_Rq, SQC_help );
    }
    _mDPC_Master_Rq_AR.SQC_DPC_Master_Rq = SQC_help;

    if( getValue( HMI_CRC_DPC_Master_Rq_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_DPC_Master_Rq_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mDPC_Master_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mDPC_Master_Rq_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_Master_Rq_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_Master_Rq_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_Master_Rq_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_Master_Rq_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_Master_Rq_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mDPC_Master_Rq_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _DPC_Master_Rq_AR_CRC_Offset[ _mDPC_Master_Rq_AR.SQC_DPC_Master_Rq ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _DPC_Master_Rq_AR_CRC_ErrorCnt   && ( _DPC_Master_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_DPC_Master_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _DPC_Master_Rq_AR_CRC_ErrorCnt > 0 )
                    _DPC_Master_Rq_AR_CRC_ErrorCnt--; 
            }
            _mDPC_Master_Rq_AR.CRC_DPC_Master_Rq = crc;
            putValue( HMI_CRC_DPC_Master_Rq, crc );
        }
        else
            _mDPC_Master_Rq_AR.CRC_DPC_Master_Rq = getValue( HMI_CRC_DPC_Master_Rq );
    }
    else
    {
        if( !getValue( HMI_CRC_DPC_Master_Rq_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mDPC_Master_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mDPC_Master_Rq_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mDPC_Master_Rq_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mDPC_Master_Rq_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mDPC_Master_Rq_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mDPC_Master_Rq_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mDPC_Master_Rq_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mDPC_Master_Rq_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _DPC_Master_Rq_AR_CRC_ErrorCnt   && ( _DPC_Master_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_DPC_Master_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _DPC_Master_Rq_AR_CRC_ErrorCnt > 0 )
                    _DPC_Master_Rq_AR_CRC_ErrorCnt--; 
            }
            _mDPC_Master_Rq_AR.CRC_DPC_Master_Rq = crc;
            putValue( HMI_CRC_DPC_Master_Rq, crc );
        }
        else
            _mDPC_Master_Rq_AR.CRC_DPC_Master_Rq = getValue( HMI_CRC_DPC_Master_Rq );
    }
    if( ( _DPC_Master_Rq_AR_MSG_DropCnt > 0 ) &&
        ( _DPC_Master_Rq_AR_E2E_Armed == 1  )    )
    {
        _DPC_Master_Rq_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mDPC_Master_Rq_AR );
        
    if( _DPC_Master_Rq_AR_E2E_Armed == 1 )
    {
        if ( ( _DPC_Master_Rq_AR_MSG_DropCnt == 0      ) &&
             ( _DPC_Master_Rq_AR_CRC_ErrorCnt == 0     ) &&
             ( _DPC_Master_Rq_AR_SQC_RepeatedCnt == 0  ) &&
             ( _DPC_Master_Rq_AR_SQC_WrongSeqJump == 0 )    )
        {
            _DPC_Master_Rq_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_DPC_Master_Rq_State, 0 );
        }
    }
}

DPC_Master_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: DPC_Master_Rq_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_DPC_Master_Rq_AR := %X\n", getValue( HMI__STMSG_DPC_Master_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_DPC_Master_Rq_AR := %X\n", getValue( HMI__STMSGT_DPC_Master_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_DPC_Master_Rq := %X\n", getValue( HMI_CRC_DPC_Master_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_DPC_Master_Rq_Auto := %X\n", getValue( HMI_CRC_DPC_Master_Rq_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_GlobalMd_Rq := %X\n", getValue( HMI_DPC_GlobalMd_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_ABC_Carv_Rq := %X\n", getValue( HMI_DPC_Md_ABC_Carv_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_ABC_Preview_Rq := %X\n", getValue( HMI_DPC_Md_ABC_Preview_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_AC_Rq := %X\n", getValue( HMI_DPC_Md_AC_Master_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_AS_Rq := %X\n", getValue( HMI_DPC_Md_AS_Master_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_ECO_Assist_Rq := %X\n", getValue( HMI_DPC_Md_ECO_Assist_Master_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_eDrv_Rq := %X\n", getValue( HMI_DPC_Md_eDrv_Master_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_ESP_Rq := %X\n", getValue( HMI_DPC_Md_ESP_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_ExhstFlap_Rq := %X\n", getValue( HMI_DPC_Md_ExhstFlap_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_Ht_Rq := %X\n", getValue( HMI_DPC_Md_Ht_Master_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_PT_Rq := %X\n", getValue( HMI_DPC_Md_PT_Master_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_PwrFreeD_Plus_Rq := %X\n", getValue( HMI_DPC_Md_PwrFreeD_Plus_Master_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_SSA_Rq := %X\n", getValue( HMI_DPC_Md_SSA_Master_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_St_Rq := %X\n", getValue( HMI_DPC_Md_St_Master_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_Susp_Rq_V2 := %X\n", getValue( HMI_DPC_Md_Susp_Master_Rq_V2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_SuspLvl_Rq := %X\n", getValue( HMI_DPC_Md_SuspLvl_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_Tx_Rq := %X\n", getValue( HMI_DPC_Md_Tx_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_PopupDisp_Rq := %X\n", getValue( HMI_DPC_PopupDisp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_PopupSupp_Rq := %X\n", getValue( HMI_DPC_PopupSupp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_DPC_Master_Rq := %X\n", getValue( HMI_Rsrv2_DPC_Master_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv3_DPC_Master_Rq := %X\n", getValue( HMI_Rsrv3_DPC_Master_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_DPC_Master_Rq := %X\n", getValue( HMI_SQC_DPC_Master_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_DPC_Master_Rq_Auto := %X\n", getValue( HMI_SQC_DPC_Master_Rq_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tDPC_Master_Rq_AR
{
    putValue( HMI__STMSG_DPC_Master_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_DPC_Master_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_DPC_Master_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tDPC_Master_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_DPC_Master_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_DPC_Master_Rq_AR
{
    if( getValue( this ) )
        openPanel("DPC_Master_Rq_AR");
}

on envVar HMI_E2E_DPC_Master_Rq_Inject
{
    if( getValue( this ) )
    {
        _DPC_Master_Rq_AR_CRC_ErrorCnt = getValue( HMI_CRC_DPC_Master_Rq_ErrorCount );
        _DPC_Master_Rq_AR_SQC_TriggPos = getValue( HMI_SQC_DPC_Master_Rq_TriggerPosition );
        _DPC_Master_Rq_AR_SQC_WrongSeqJump = getValue( HMI_SQC_DPC_Master_Rq_WrongSeq );
        _DPC_Master_Rq_AR_SQC_RepeatedCnt = getValue( HMI_SQC_DPC_Master_Rq_Repeated );
        _DPC_Master_Rq_AR_MSG_DropCnt = getValue( HMI_SQC_DPC_Master_Rq_MSG_DropCnt );
        putValue( HMI_E2E_DPC_Master_Rq_State, 2 );
        _DPC_Master_Rq_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_DPC_GlobalMd_Rq
{
    _mDPC_Master_Rq_AR.DPC_GlobalMd_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_ABC_Carv_Rq
{
    _mDPC_Master_Rq_AR.DPC_Md_ABC_Carv_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_ABC_Preview_Rq
{
    _mDPC_Master_Rq_AR.DPC_Md_ABC_Preview_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_AC_Master_Rq
{
    _mDPC_Master_Rq_AR.DPC_Md_AC_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_AS_Master_Rq
{
    _mDPC_Master_Rq_AR.DPC_Md_AS_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_ECO_Assist_Master_Rq
{
    _mDPC_Master_Rq_AR.DPC_Md_ECO_Assist_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_eDrv_Master_Rq
{
    _mDPC_Master_Rq_AR.DPC_Md_eDrv_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_ExhstFlap_Rq
{
    _mDPC_Master_Rq_AR.DPC_Md_ExhstFlap_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_ESP_Rq
{
    _mDPC_Master_Rq_AR.DPC_Md_ESP_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_Ht_Master_Rq
{
    _mDPC_Master_Rq_AR.DPC_Md_Ht_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_PT_Master_Rq
{
    _mDPC_Master_Rq_AR.DPC_Md_PT_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_PwrFreeD_Plus_Master_Rq
{
    _mDPC_Master_Rq_AR.DPC_Md_PwrFreeD_Plus_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_SSA_Master_Rq
{
    _mDPC_Master_Rq_AR.DPC_Md_SSA_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_St_Master_Rq
{
    _mDPC_Master_Rq_AR.DPC_Md_St_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_Susp_Master_Rq_V2
{
    _mDPC_Master_Rq_AR.DPC_Md_Susp_Rq_V2.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_SuspLvl_Rq
{
    _mDPC_Master_Rq_AR.DPC_Md_SuspLvl_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_Tx_Rq
{
    _mDPC_Master_Rq_AR.DPC_Md_Tx_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_PopupDisp_Rq
{
    _mDPC_Master_Rq_AR.DPC_PopupDisp_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_PopupSupp_Rq
{
    _mDPC_Master_Rq_AR.DPC_PopupSupp_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv2_DPC_Master_Rq
{
    _mDPC_Master_Rq_AR.Rsrv2_DPC_Master_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv3_DPC_Master_Rq
{
    _mDPC_Master_Rq_AR.Rsrv3_DPC_Master_Rq.phys = getValue(this);
    _DPC_Master_Rq_AR_SpontanFlag = 1;
}

DTQ_Traj_AR_check_output()
{
    if( !getValue( HMI__STMSG_DTQ_Traj_AR ) )
        {
        //  message   DTQ_Traj_AR ID: 388 --- Sendeart 0 cyclicX --- 
            _DTQ_Traj_AR_Cnt--;
            if( _DTQ_Traj_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                DTQ_Traj_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _DTQ_Traj_AR_Cnt = _DTQ_Traj_AR_CycleCount;
            }
        }
}

DTQ_Traj_AR_init()
{   /* Botschaft DTQ_Traj_AR ID: 388 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 388 0;
BA_ "NmAsrMessage" BO_ 388 0;
BA_ "GenMsgMinAcceptLength" BO_ 388 8;
BA_ "GenMsgILSupport" BO_ 388 1;
BA_ "DiagState" BO_ 388 0;
BA_ "DiagRequest" BO_ 388 0;
BA_ "DiagResponse" BO_ 388 0;
BA_ "GenMsgStartValue" BO_ 388 "0";
BA_ "GenMsgStartDelayTime" BO_ 388 0;
BA_ "GenMsgCycleTime" BO_ 388 40;
BA_ "GenMsgSendType" BO_ 388 0;
    */
    _DTQ_Traj_AR_Timebase =      c_tDBKomTimer_20ms;
    _DTQ_Traj_AR_CycleCount =   40 / _DTQ_Traj_AR_Timebase;
    _DTQ_Traj_AR_StartDelay =      0 / _DTQ_Traj_AR_Timebase;
    _DTQ_Traj_AR_Cnt = _DTQ_Traj_AR_StartDelay;
    _DTQ_Traj_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_DTQ_Traj_AR, _DTQ_Traj_AR_StartDelay * _DTQ_Traj_AR_Timebase );

    _mDTQ_Traj_AR.DTQ_LeadVeh_Idx.phys = getValue( HMI_DTQ_LeadVeh_Idx );
    _mDTQ_Traj_AR.DTQ_Traj_Hrzt_ClothoidPara_c0.phys = getValue( HMI_DTQ_Traj_Hrzt_ClothoidPara_c0 );
    _mDTQ_Traj_AR.DTQ_Traj_Hrzt_ClothoidPara_c1.phys = getValue( HMI_DTQ_Traj_Hrzt_ClothoidPara_c1 );
	_mDTQ_Traj_AR.DTQ_Traj_Offset_Y_Long_Axs.phys = getValue( HMI_DTQ_Traj_Offset_Y_Long_Axs );
    _mDTQ_Traj_AR.DTQ_Traj_YawAngl_Long_Axs.phys = getValue( HMI_DTQ_Traj_YawAngl_Long_Axs );
    _mDTQ_Traj_AR.DTQ_TrajQual.phys = getValue( HMI_DTQ_TrajQual );

}

DTQ_Traj_AR_output(void)
{
    output( _mDTQ_Traj_AR );
}

DTQ_Traj_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: DTQ_Traj_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_DTQ_Traj_AR := %X\n", getValue( HMI__STMSG_DTQ_Traj_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_DTQ_Traj_AR := %X\n", getValue( HMI__STMSGT_DTQ_Traj_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_LeadVeh_Idx  := %X\n", getValue( HMI_DTQ_LeadVeh_Idx ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_Traj_Hrzt_ClothoidPara_c0  := %X\n", getValue( HMI_DTQ_Traj_Hrzt_ClothoidPara_c0 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_Traj_Hrzt_ClothoidPara_c1  := %X\n", getValue( HMI_DTQ_Traj_Hrzt_ClothoidPara_c1 ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_Traj_Offset_Y_Long_Axs  := %X\n", getValue( HMI_DTQ_Traj_Offset_Y_Long_Axs ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_Traj_YawAngl_Long_Axs  := %X\n", getValue( HMI_DTQ_Traj_YawAngl_Long_Axs ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTQ_TrajQual  := %X\n", getValue( HMI_DTQ_TrajQual ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tDTQ_Traj_AR
{
    putValue( HMI__STMSG_DTQ_Traj_AR, 0 );
}

on EnvVar HMI__STMSG_DTQ_Traj_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_DTQ_Traj_AR );
        if( tDelay > 0)    
            setTimer( _tDTQ_Traj_AR, tDelay );
        else
            putValue( HMI__STMSG_DTQ_Traj_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_DTQ_Traj_AR
{
    if( getValue( this ) )
        openPanel("DTQ_Traj_AR");
}

on EnvVar HMI_DTQ_LeadVeh_Idx
{
    _mDTQ_Traj_AR.DTQ_LeadVeh_Idx.phys = getValue(this);
}

on EnvVar HMI_DTQ_Traj_Hrzt_ClothoidPara_c0
{
    _mDTQ_Traj_AR.DTQ_Traj_Hrzt_ClothoidPara_c0.phys = getValue(this);
}

on EnvVar HMI_DTQ_Traj_Hrzt_ClothoidPara_c1
{
    _mDTQ_Traj_AR.DTQ_Traj_Hrzt_ClothoidPara_c1.phys = getValue(this);
}

on EnvVar HMI_DTQ_Traj_Offset_Y_Long_Axs
{
    _mDTQ_Traj_AR.DTQ_Traj_Offset_Y_Long_Axs.phys = getValue(this);
}

on EnvVar HMI_DTQ_Traj_YawAngl_Long_Axs
{
    _mDTQ_Traj_AR.DTQ_Traj_YawAngl_Long_Axs.phys = getValue(this);
}

on EnvVar HMI_DTQ_TrajQual
{
    _mDTQ_Traj_AR.DTQ_TrajQual.phys = getValue(this);
}

DTR_Obj_Attr1_AR_check_output()
{
    if( !getValue( HMI__STMSG_DTR_Obj_Attr1_AR ) )
        {
        //  message   DTR_Obj_Attr1_AR ID: 390 --- Sendeart 0 cyclicX --- 
            _DTR_Obj_Attr1_AR_Cnt--;
            if( _DTR_Obj_Attr1_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                DTR_Obj_Attr1_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _DTR_Obj_Attr1_AR_Cnt = _DTR_Obj_Attr1_AR_CycleCount;
            }
        }
}

DTR_Obj_Attr1_AR_init()
{   /* Botschaft DTR_Obj_Attr1_AR ID: 390 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 390 0;
BA_ "NmAsrMessage" BO_ 390 0;
BA_ "GenMsgMinAcceptLength" BO_ 390 8;
BA_ "GenMsgILSupport" BO_ 390 1;
BA_ "DiagState" BO_ 390 0;
BA_ "DiagRequest" BO_ 390 0;
BA_ "DiagResponse" BO_ 390 0;
BA_ "GenMsgStartValue" BO_ 390 "0";
BA_ "GenMsgStartDelayTime" BO_ 390 0;
BA_ "GenMsgCycleTime" BO_ 390 40;
BA_ "GenMsgSendType" BO_ 390 0;
    */
    _DTR_Obj_Attr1_AR_Timebase =      c_tDBKomTimer_20ms;
    _DTR_Obj_Attr1_AR_CycleCount =   40 / _DTR_Obj_Attr1_AR_Timebase;
    _DTR_Obj_Attr1_AR_StartDelay =      0 / _DTR_Obj_Attr1_AR_Timebase;
    _DTR_Obj_Attr1_AR_Cnt = _DTR_Obj_Attr1_AR_StartDelay;
    _DTR_Obj_Attr1_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_DTR_Obj_Attr1_AR, _DTR_Obj_Attr1_AR_StartDelay * _DTR_Obj_Attr1_AR_Timebase );

    _mDTR_Obj_Attr1_AR.DTR_Obj_Ego_1st_AbsYPosn.phys = getValue( HMI_DTR_Obj_Ego_1st_AbsYPosn );
    _mDTR_Obj_Attr1_AR.DTR_Obj_Lead_Crit.phys = getValue( HMI_DTR_Obj_Lead_Crit );
    _mDTR_Obj_Attr1_AR.DTR_Obj_Lt_1st_AbsYPosn.phys = getValue( HMI_DTR_Obj_Lt_1st_AbsYPosn );
	_mDTR_Obj_Attr1_AR.DTR_Obj_Rt_1st_AbsYPosn.phys = getValue( HMI_DTR_Obj_Rt_1st_AbsYPosn );
    _mDTR_Obj_Attr1_AR.DTR_ObjTmDelay.phys = getValue( HMI_DTR_ObjTmDelay );
    _mDTR_Obj_Attr1_AR.DTR_VehPitch.phys = getValue( HMI_DTR_VehPitch );

}

DTR_Obj_Attr1_AR_output(void)
{
    output( _mDTR_Obj_Attr1_AR );
}

DTR_Obj_Attr1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: DTR_Obj_Attr1_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_DTR_Obj_Attr1_AR := %X\n", getValue( HMI__STMSG_DTR_Obj_Attr1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_DTR_Obj_Attr1_AR := %X\n", getValue( HMI__STMSGT_DTR_Obj_Attr1_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_Obj_Ego_1st_AbsYPosn  := %X\n", getValue( HMI_DTR_Obj_Ego_1st_AbsYPosn ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_Obj_Lead_Crit  := %X\n", getValue( HMI_DTR_Obj_Lead_Crit ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_Obj_Lt_1st_AbsYPosn  := %X\n", getValue( HMI_DTR_Obj_Lt_1st_AbsYPosn ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_Obj_Rt_1st_AbsYPosn  := %X\n", getValue( HMI_DTR_Obj_Rt_1st_AbsYPosn ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_ObjTmDelay  := %X\n", getValue( HMI_DTR_ObjTmDelay ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_VehPitch  := %X\n", getValue( HMI_DTR_VehPitch ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tDTR_Obj_Attr1_AR
{
    putValue( HMI__STMSG_DTR_Obj_Attr1_AR, 0 );
}

on EnvVar HMI__STMSG_DTR_Obj_Attr1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_DTR_Obj_Attr1_AR );
        if( tDelay > 0)    
            setTimer( _tDTR_Obj_Attr1_AR, tDelay );
        else
            putValue( HMI__STMSG_DTR_Obj_Attr1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_DTR_Obj_Attr1_AR
{
    if( getValue( this ) )
        openPanel("DTR_Obj_Attr1_AR");
}

on EnvVar HMI_DTR_Obj_Ego_1st_AbsYPosn
{
    _mDTR_Obj_Attr1_AR.DTR_Obj_Ego_1st_AbsYPosn.phys = getValue(this);
}

on EnvVar HMI_DTR_Obj_Lead_Crit
{
    _mDTR_Obj_Attr1_AR.DTR_Obj_Lead_Crit.phys = getValue(this);
}

on EnvVar HMI_DTR_Obj_Lt_1st_AbsYPosn
{
    _mDTR_Obj_Attr1_AR.DTR_Obj_Lt_1st_AbsYPosn.phys = getValue(this);
}

on EnvVar HMI_DTR_Obj_Rt_1st_AbsYPosn
{
    _mDTR_Obj_Attr1_AR.DTR_Obj_Rt_1st_AbsYPosn.phys = getValue(this);
}

on EnvVar HMI_DTR_ObjTmDelay
{
    _mDTR_Obj_Attr1_AR.DTR_ObjTmDelay.phys = getValue(this);
}

on EnvVar HMI_DTR_VehPitch
{
    _mDTR_Obj_Attr1_AR.DTR_VehPitch.phys = getValue(this);
}

DTR_Obj_Attr2_AR_check_output()
{
    if( !getValue( HMI__STMSG_DTR_Obj_Attr2_AR ) )
        {
        //  message   DTR_Obj_Attr2_AR ID: 394 --- Sendeart 0 cyclicX --- 
            _DTR_Obj_Attr2_AR_Cnt--;
            if( _DTR_Obj_Attr2_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                DTR_Obj_Attr2_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _DTR_Obj_Attr2_AR_Cnt = _DTR_Obj_Attr2_AR_CycleCount;
            }
        }
}

DTR_Obj_Attr2_AR_init()
{   /* Botschaft DTR_Obj_Attr2_AR ID: 394 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 394 0;
BA_ "NmAsrMessage" BO_ 394 0;
BA_ "GenMsgMinAcceptLength" BO_ 394 8;
BA_ "GenMsgILSupport" BO_ 394 1;
BA_ "DiagState" BO_ 394 0;
BA_ "DiagRequest" BO_ 394 0;
BA_ "DiagResponse" BO_ 394 0;
BA_ "GenMsgStartValue" BO_ 394 "0";
BA_ "GenMsgStartDelayTime" BO_ 394 0;
BA_ "GenMsgCycleTime" BO_ 394 40;
BA_ "GenMsgSendType" BO_ 394 0;
    */
    _DTR_Obj_Attr2_AR_Timebase =      c_tDBKomTimer_20ms;
    _DTR_Obj_Attr2_AR_CycleCount =   40 / _DTR_Obj_Attr2_AR_Timebase;
    _DTR_Obj_Attr2_AR_StartDelay =      0 / _DTR_Obj_Attr2_AR_Timebase;
    _DTR_Obj_Attr2_AR_Cnt = _DTR_Obj_Attr2_AR_StartDelay;
    _DTR_Obj_Attr2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_DTR_Obj_Attr2_AR, _DTR_Obj_Attr2_AR_StartDelay * _DTR_Obj_Attr2_AR_Timebase );

    _mDTR_Obj_Attr2_AR.DTR_Obj_Ego_1st_AbsXPosn.phys = getValue( HMI_DTR_Obj_Ego_1st_AbsXPosn );
    _mDTR_Obj_Attr2_AR.DTR_Obj_Ego_1st_VertAngl.phys = getValue( HMI_DTR_Obj_Ego_1st_VertAngl );
    _mDTR_Obj_Attr2_AR.DTR_Obj_Lt_1st_VertAngl.phys = getValue( HMI_DTR_Obj_Lt_1st_VertAngl );
	_mDTR_Obj_Attr2_AR.DTR_Obj_Rt_1st_AbsXPosn.phys = getValue( HMI_DTR_Obj_Rt_1st_AbsXPosn );
    _mDTR_Obj_Attr2_AR.DTR_Obj_Rt_1st_VertAngl.phys = getValue( HMI_DTR_Obj_Rt_1st_VertAngl );
    _mDTR_Obj_Attr2_AR.DTR_ObjFusionStat.phys = getValue( HMI_DTR_ObjFusionStat );

}

DTR_Obj_Attr2_AR_output(void)
{
    output( _mDTR_Obj_Attr2_AR );
}

DTR_Obj_Attr2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: DTR_Obj_Attr2_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_DTR_Obj_Attr2_AR := %X\n", getValue( HMI__STMSG_DTR_Obj_Attr2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_DTR_Obj_Attr2_AR := %X\n", getValue( HMI__STMSGT_DTR_Obj_Attr2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_Obj_Ego_1st_AbsXPosn  := %X\n", getValue( HMI_DTR_Obj_Ego_1st_AbsXPosn ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_Obj_Ego_1st_VertAngl  := %X\n", getValue( HMI_DTR_Obj_Ego_1st_VertAngl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_Obj_Lt_1st_VertAngl  := %X\n", getValue( HMI_DTR_Obj_Lt_1st_VertAngl ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_Obj_Rt_1st_AbsXPosn  := %X\n", getValue( HMI_DTR_Obj_Rt_1st_AbsXPosn ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_Obj_Rt_1st_VertAngl  := %X\n", getValue( HMI_DTR_Obj_Rt_1st_VertAngl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_ObjFusionStat  := %X\n", getValue( HMI_DTR_ObjFusionStat ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tDTR_Obj_Attr2_AR
{
    putValue( HMI__STMSG_DTR_Obj_Attr2_AR, 0 );
}

on EnvVar HMI__STMSG_DTR_Obj_Attr2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_DTR_Obj_Attr2_AR );
        if( tDelay > 0)    
            setTimer( _tDTR_Obj_Attr2_AR, tDelay );
        else
            putValue( HMI__STMSG_DTR_Obj_Attr2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_DTR_Obj_Attr2_AR
{
    if( getValue( this ) )
        openPanel("DTR_Obj_Attr2_AR");
}

on EnvVar HMI_DTR_Obj_Ego_1st_AbsXPosn
{
    _mDTR_Obj_Attr2_AR.DTR_Obj_Ego_1st_AbsXPosn.phys = getValue(this);
}

on EnvVar HMI_DTR_Obj_Ego_1st_VertAngl
{
    _mDTR_Obj_Attr2_AR.DTR_Obj_Ego_1st_VertAngl.phys = getValue(this);
}

on EnvVar HMI_DTR_Obj_Lt_1st_VertAngl
{
    _mDTR_Obj_Attr2_AR.DTR_Obj_Lt_1st_VertAngl.phys = getValue(this);
}

on EnvVar HMI_DTR_Obj_Rt_1st_AbsXPosn
{
    _mDTR_Obj_Attr2_AR.DTR_Obj_Rt_1st_AbsXPosn.phys = getValue(this);
}

on EnvVar HMI_DTR_Obj_Rt_1st_VertAngl
{
    _mDTR_Obj_Attr2_AR.DTR_Obj_Rt_1st_VertAngl.phys = getValue(this);
}

on EnvVar HMI_DTR_ObjFusionStat
{
    _mDTR_Obj_Attr2_AR.DTR_ObjFusionStat.phys = getValue(this);
}

DTR_Obj_Attr3_AR_check_output()
{
    if( !getValue( HMI__STMSG_DTR_Obj_Attr3_AR ) )
        {
        //  message   DTR_Obj_Attr3_AR ID: 396 --- Sendeart 0 cyclicX --- 
            _DTR_Obj_Attr3_AR_Cnt--;
            if( _DTR_Obj_Attr3_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                DTR_Obj_Attr3_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _DTR_Obj_Attr3_AR_Cnt = _DTR_Obj_Attr3_AR_CycleCount;
            }
        }
}

DTR_Obj_Attr3_AR_init()
{   /* Botschaft DTR_Obj_Attr3_AR ID: 396 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 396 0;
BA_ "NmAsrMessage" BO_ 396 0;
BA_ "GenMsgMinAcceptLength" BO_ 396 8;
BA_ "GenMsgILSupport" BO_ 396 1;
BA_ "DiagState" BO_ 396 0;
BA_ "DiagRequest" BO_ 396 0;
BA_ "DiagResponse" BO_ 396 0;
BA_ "GenMsgStartValue" BO_ 396 "0";
BA_ "GenMsgStartDelayTime" BO_ 396 0;
BA_ "GenMsgCycleTime" BO_ 396 80;
BA_ "GenMsgSendType" BO_ 396 0;
    */
    _DTR_Obj_Attr3_AR_Timebase =      c_tDBKomTimer_20ms;
    _DTR_Obj_Attr3_AR_CycleCount =   80 / _DTR_Obj_Attr3_AR_Timebase;
    _DTR_Obj_Attr3_AR_StartDelay =      0 / _DTR_Obj_Attr3_AR_Timebase;
    _DTR_Obj_Attr3_AR_Cnt = _DTR_Obj_Attr3_AR_StartDelay;
    _DTR_Obj_Attr3_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_DTR_Obj_Attr3_AR, _DTR_Obj_Attr3_AR_StartDelay * _DTR_Obj_Attr3_AR_Timebase );

    _mDTR_Obj_Attr3_AR.DTR_LeadVeh_Idx.phys = getValue( HMI_DTR_LeadVeh_Idx );
    _mDTR_Obj_Attr3_AR.DTR_Obj_Ego_1st_vRel.phys = getValue( HMI_DTR_Obj_Ego_1st_vRel );
    _mDTR_Obj_Attr3_AR.DTR_Obj_Ego_1st_width.phys = getValue( HMI_DTR_Obj_Ego_1st_width );
	_mDTR_Obj_Attr3_AR.DTR_Obj_Lt_1st_AbsXPosn.phys = getValue( HMI_DTR_Obj_Lt_1st_AbsXPosn );
    _mDTR_Obj_Attr3_AR.DTR_Obj_Lt_1st_vRel.phys = getValue( HMI_DTR_Obj_Lt_1st_vRel );
    _mDTR_Obj_Attr3_AR.DTR_Obj_Lt_1st_width.phys = getValue( HMI_DTR_Obj_Lt_1st_width );
	_mDTR_Obj_Attr3_AR.DTR_Obj_Rt_1st_vRel.phys = getValue( HMI_DTR_Obj_Rt_1st_vRel );
    _mDTR_Obj_Attr3_AR.DTR_Obj_Rt_1st_width.phys = getValue( HMI_DTR_Obj_Rt_1st_width );
    _mDTR_Obj_Attr3_AR.DTR_VelRsn.phys = getValue( HMI_DTR_VelRsn );

}

DTR_Obj_Attr3_AR_output(void)
{
    output( _mDTR_Obj_Attr3_AR );
}

DTR_Obj_Attr3_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: DTR_Obj_Attr3_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_DTR_Obj_Attr3_AR := %X\n", getValue( HMI__STMSG_DTR_Obj_Attr3_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_DTR_Obj_Attr3_AR := %X\n", getValue( HMI__STMSGT_DTR_Obj_Attr3_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_LeadVeh_Idx  := %X\n", getValue( HMI_DTR_LeadVeh_Idx ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_Obj_Ego_1st_vRel  := %X\n", getValue( HMI_DTR_Obj_Ego_1st_vRel ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_Obj_Ego_1st_width  := %X\n", getValue( HMI_DTR_Obj_Ego_1st_width ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_Obj_Lt_1st_AbsXPosn  := %X\n", getValue( HMI_DTR_Obj_Lt_1st_AbsXPosn ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_Obj_Lt_1st_vRel  := %X\n", getValue( HMI_DTR_Obj_Lt_1st_vRel ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_Obj_Lt_1st_width  := %X\n", getValue( HMI_DTR_Obj_Lt_1st_width ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_Obj_Rt_1st_vRel  := %X\n", getValue( HMI_DTR_Obj_Rt_1st_vRel ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_Obj_Rt_1st_width  := %X\n", getValue( HMI_DTR_Obj_Rt_1st_width ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DTR_VelRsn  := %X\n", getValue( HMI_DTR_VelRsn ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tDTR_Obj_Attr3_AR
{
    putValue( HMI__STMSG_DTR_Obj_Attr3_AR, 0 );
}

on EnvVar HMI__STMSG_DTR_Obj_Attr3_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_DTR_Obj_Attr3_AR );
        if( tDelay > 0)    
            setTimer( _tDTR_Obj_Attr3_AR, tDelay );
        else
            putValue( HMI__STMSG_DTR_Obj_Attr3_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_DTR_Obj_Attr3_AR
{
    if( getValue( this ) )
        openPanel("DTR_Obj_Attr3_AR");
}

on EnvVar HMI_DTR_LeadVeh_Idx
{
    _mDTR_Obj_Attr3_AR.DTR_LeadVeh_Idx.phys = getValue(this);
}

on EnvVar HMI_DTR_Obj_Ego_1st_vRel
{
    _mDTR_Obj_Attr3_AR.DTR_Obj_Ego_1st_vRel.phys = getValue(this);
}

on EnvVar HMI_DTR_Obj_Ego_1st_width
{
    _mDTR_Obj_Attr3_AR.DTR_Obj_Ego_1st_width.phys = getValue(this);
}

on EnvVar HMI_DTR_Obj_Lt_1st_AbsXPosn
{
    _mDTR_Obj_Attr3_AR.DTR_Obj_Lt_1st_AbsXPosn.phys = getValue(this);
}

on EnvVar HMI_DTR_Obj_Lt_1st_vRel
{
    _mDTR_Obj_Attr3_AR.DTR_Obj_Lt_1st_vRel.phys = getValue(this);
}

on EnvVar HMI_DTR_Obj_Lt_1st_width
{
    _mDTR_Obj_Attr3_AR.DTR_Obj_Lt_1st_width.phys = getValue(this);
}

on EnvVar HMI_DTR_Obj_Rt_1st_vRel
{
    _mDTR_Obj_Attr3_AR.DTR_Obj_Rt_1st_vRel.phys = getValue(this);
}

on EnvVar HMI_DTR_Obj_Rt_1st_width
{
    _mDTR_Obj_Attr3_AR.DTR_Obj_Rt_1st_width.phys = getValue(this);
}

on EnvVar HMI_DTR_VelRsn
{
    _mDTR_Obj_Attr3_AR.DTR_VelRsn.phys = getValue(this);
}

ECO_Score_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_ECO_Score_Disp_Rq_AR ) )
    {
    //  message   ECO_Score_Disp_Rq_AR ID: 1129 --- Sendeart 0 cyclic --- 
        _ECO_Score_Disp_Rq_AR_Cnt--;
        if( _ECO_Score_Disp_Rq_AR_Cnt < 1 )
        {
            ECO_Score_Disp_Rq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _ECO_Score_Disp_Rq_AR_Cnt = _ECO_Score_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

ECO_Score_Disp_Rq_AR_init()
{   /* Botschaft ECO_Score_Disp_Rq_AR ID: 1129 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 1129 0;
BA_ "NmAsrMessage" BO_ 1129 0;
BA_ "GenMsgMinAcceptLength" BO_ 1129 8;
BA_ "GenMsgILSupport" BO_ 1129 1;
BA_ "DiagState" BO_ 1129 0;
BA_ "DiagRequest" BO_ 1129 0;
BA_ "DiagResponse" BO_ 1129 0;
BA_ "GenMsgStartValue" BO_ 1129 "0";
BA_ "GenMsgStartDelayTime" BO_ 1129 0;
BA_ "GenMsgCycleTime" BO_ 1129 200;
BA_ "GenMsgSendType" BO_ 1129 0;
    */
    _ECO_Score_Disp_Rq_AR_Timebase =       c_tDBKomTimer_20ms;
    _ECO_Score_Disp_Rq_AR_CycleCount =   200 / _ECO_Score_Disp_Rq_AR_Timebase;
    _ECO_Score_Disp_Rq_AR_StartDelay =     0 / _ECO_Score_Disp_Rq_AR_Timebase;
    _ECO_Score_Disp_Rq_AR_Cnt = _ECO_Score_Disp_Rq_AR_StartDelay;
    _ECO_Score_Disp_Rq_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_ECO_Score_Disp_Rq_AR, _ECO_Score_Disp_Rq_AR_StartDelay * _ECO_Score_Disp_Rq_AR_Timebase );

    _mECO_Score_Disp_Rq_AR.ECO_Score_Accel_Disp_Rq.phys = getValue( HMI_ECO_Score_Accel_Disp_Rq );
    _mECO_Score_Disp_Rq_AR.ECO_Score_Accel_Trnd_Disp_Rq.phys = getValue( HMI_ECO_Score_Accel_Trnd_Disp_Rq );
    _mECO_Score_Disp_Rq_AR.ECO_Score_BonusRng_Disp_Rq.phys = getValue( HMI_ECO_Score_BonusRng_Disp_Rq );
    _mECO_Score_Disp_Rq_AR.ECO_Score_Const_Disp_Rq.phys = getValue( HMI_ECO_Score_Const_Disp_Rq );
    _mECO_Score_Disp_Rq_AR.ECO_Score_Const_Trnd_Disp_Rq.phys = getValue( HMI_ECO_Score_Const_Trnd_Disp_Rq );
    _mECO_Score_Disp_Rq_AR.ECO_Score_FreeWhl_Disp_Rq.phys = getValue( HMI_ECO_Score_FreeWhl_Disp_Rq );
    _mECO_Score_Disp_Rq_AR.ECO_Score_FreeWhl_Trnd_Disp_Rq.phys = getValue( HMI_ECO_Score_FreeWhl_Trnd_Disp_Rq );
    _mECO_Score_Disp_Rq_AR.ECO_Score_Total_Disp_Rq.phys = getValue( HMI_ECO_Score_Total_Disp_Rq );
}

ECO_Score_Disp_Rq_AR_output(void)
{
    output( _mECO_Score_Disp_Rq_AR );
}

ECO_Score_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: ECO_Score_Disp_Rq_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_ECO_Score_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_ECO_Score_Disp_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_ECO_Score_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_ECO_Score_Disp_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ECO_Score_Accel_Disp_Rq := %X\n", getValue( HMI_ECO_Score_Accel_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ECO_Score_Accel_Trnd_Disp_Rq := %X\n", getValue( HMI_ECO_Score_Accel_Trnd_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ECO_Score_BonusRng_Disp_Rq := %X\n", getValue( HMI_ECO_Score_BonusRng_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ECO_Score_Const_Disp_Rq := %X\n", getValue( HMI_ECO_Score_Const_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ECO_Score_Const_Trnd_Disp_Rq := %X\n", getValue( HMI_ECO_Score_Const_Trnd_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ECO_Score_FreeWhl_Disp_Rq := %X\n", getValue( HMI_ECO_Score_FreeWhl_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ECO_Score_FreeWhl_Trnd_Disp_Rq := %X\n", getValue( HMI_ECO_Score_FreeWhl_Trnd_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ECO_Score_Total_Disp_Rq := %X\n", getValue( HMI_ECO_Score_Total_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tECO_Score_Disp_Rq_AR
{
    putValue( HMI__STMSG_ECO_Score_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_ECO_Score_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_ECO_Score_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tECO_Score_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_ECO_Score_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_ECO_Score_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("ECO_Score_Disp_Rq_AR");
}

on EnvVar HMI_ECO_Score_Accel_Disp_Rq
{
    _mECO_Score_Disp_Rq_AR.ECO_Score_Accel_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_ECO_Score_Accel_Trnd_Disp_Rq
{
    _mECO_Score_Disp_Rq_AR.ECO_Score_Accel_Trnd_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_ECO_Score_BonusRng_Disp_Rq
{
    _mECO_Score_Disp_Rq_AR.ECO_Score_BonusRng_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_ECO_Score_Const_Disp_Rq
{
    _mECO_Score_Disp_Rq_AR.ECO_Score_Const_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_ECO_Score_Const_Trnd_Disp_Rq
{
    _mECO_Score_Disp_Rq_AR.ECO_Score_Const_Trnd_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_ECO_Score_FreeWhl_Disp_Rq
{
    _mECO_Score_Disp_Rq_AR.ECO_Score_FreeWhl_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_ECO_Score_FreeWhl_Trnd_Disp_Rq
{
    _mECO_Score_Disp_Rq_AR.ECO_Score_FreeWhl_Trnd_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_ECO_Score_Total_Disp_Rq
{
    _mECO_Score_Disp_Rq_AR.ECO_Score_Total_Disp_Rq.phys = getValue(this);
}

EL_Ft_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_EL_Ft_Disp_Rq_AR ) )
    {
    //  message   EL_Ft_Disp_Rq_AR ID: 827 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _EL_Ft_Disp_Rq_AR_Cnt--;
        if( _EL_Ft_Disp_Rq_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            EL_Ft_Disp_Rq_AR_output();
            _EL_Ft_Disp_Rq_AR_Cnt = _EL_Ft_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _EL_Ft_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _EL_Ft_Disp_Rq_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            EL_Ft_Disp_Rq_AR_output();
            _EL_Ft_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

EL_Ft_Disp_Rq_AR_init()
{   /* Botschaft EL_Ft_Disp_Rq_AR ID: 827 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 827 0;
BA_ "NmAsrMessage" BO_ 827 0;
BA_ "GenMsgMinAcceptLength" BO_ 827 8;
BA_ "GenMsgILSupport" BO_ 827 1;
BA_ "DiagState" BO_ 827 0;
BA_ "DiagRequest" BO_ 827 0;
BA_ "DiagResponse" BO_ 827 0;
BA_ "GenMsgStartValue" BO_ 827 "0";
BA_ "GenMsgStartDelayTime" BO_ 827 0;
BA_ "GenMsgDelayTime" BO_ 827 5;
BA_ "GenMsgNrOfRepetitions" BO_ 827 0;
BA_ "GenMsgCycleTime" BO_ 827 1000;
BA_ "GenMsgSendType" BO_ 827 5;
    */
    _EL_Ft_Disp_Rq_AR_Timebase =          c_tDBKomTimer_20ms;
    _EL_Ft_Disp_Rq_AR_CycleCount =      1000 / _EL_Ft_Disp_Rq_AR_Timebase;
    _EL_Ft_Disp_Rq_AR_StartDelay =         0 / _EL_Ft_Disp_Rq_AR_Timebase;
    _EL_Ft_Disp_Rq_AR_Cnt = _EL_Ft_Disp_Rq_AR_StartDelay;
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_EL_Ft_Disp_Rq_AR, _EL_Ft_Disp_Rq_AR_StartDelay * _EL_Ft_Disp_Rq_AR_Timebase );

    _mEL_Ft_Disp_Rq_AR.DRL_Lt_Flt.phys = getValue( HMI_DRL_Lt_Flt );
    _mEL_Ft_Disp_Rq_AR.DRL_Rt_Flt.phys = getValue( HMI_DRL_Rt_Flt );
    _mEL_Ft_Disp_Rq_AR.EF_Flt.phys = getValue( HMI_EF_Flt );
    _mEL_Ft_Disp_Rq_AR.EmgLgtPath_Flt_BC_F.phys = getValue( HMI_EmgLgtPath_Flt_BC_F );
    _mEL_Ft_Disp_Rq_AR.ExtLmp_IC_Disp_On_Rq.phys = getValue( HMI_ExtLmp_IC_Disp_On_Rq );
    _mEL_Ft_Disp_Rq_AR.ExtLmp_RLS_Warn_Rq.phys = getValue( HMI_ExtLmp_RLS_Warn_Rq );
    _mEL_Ft_Disp_Rq_AR.FogLmp_FL_Flt.phys = getValue( HMI_FogLmp_FL_Flt );
    _mEL_Ft_Disp_Rq_AR.FogLmp_FR_Flt.phys = getValue( HMI_FogLmp_FR_Flt );
    _mEL_Ft_Disp_Rq_AR.HiBm_Lt_Flt.phys = getValue( HMI_HiBm_Lt_Flt );
    _mEL_Ft_Disp_Rq_AR.HiBm_Rt_Flt.phys = getValue( HMI_HiBm_Rt_Flt );
    _mEL_Ft_Disp_Rq_AR.IHC_Actv.phys = getValue( HMI_IHC_Actv );
    _mEL_Ft_Disp_Rq_AR.IHC_FltDisp_Rq.phys = getValue( HMI_IHC_FltDisp_Rq );
    _mEL_Ft_Disp_Rq_AR.IHC_Menu_Rq.phys = getValue( HMI_IHC_Menu_Rq );
    _mEL_Ft_Disp_Rq_AR.IrLmp_Lt_Flt.phys = getValue( HMI_IrLmp_Lt_Flt );
    _mEL_Ft_Disp_Rq_AR.IrLmp_Rt_Flt.phys = getValue( HMI_IrLmp_Rt_Flt );
    _mEL_Ft_Disp_Rq_AR.LoBm_Lt_Flt.phys = getValue( HMI_LoBm_Lt_Flt );
    _mEL_Ft_Disp_Rq_AR.LoBm_Rt_Flt.phys = getValue( HMI_LoBm_Rt_Flt );
    _mEL_Ft_Disp_Rq_AR.NS_IllDur_Cfg_Stat.phys = getValue( HMI_NS_IllDur_Cfg_Stat );
    _mEL_Ft_Disp_Rq_AR.PkLmp_FL_Flt.phys = getValue( HMI_PkLmp_FL_Flt );
    _mEL_Ft_Disp_Rq_AR.PkLmp_FR_Flt.phys = getValue( HMI_PkLmp_FR_Flt );
    _mEL_Ft_Disp_Rq_AR.Rsrv1_EL_Ft_FltDisp_Rq.phys = getValue( HMI_Rsrv1_EL_Ft_FltDisp_Rq );
    _mEL_Ft_Disp_Rq_AR.SM_FL_Flt.phys = getValue( HMI_SM_FL_Flt );
    _mEL_Ft_Disp_Rq_AR.SM_FR_Flt.phys = getValue( HMI_SM_FR_Flt );
    _mEL_Ft_Disp_Rq_AR.SurrIll_Cfg_Stat.phys = getValue( HMI_SurrIll_Cfg_Stat );
    _mEL_Ft_Disp_Rq_AR.TM_Timeout_Flt.phys = getValue( HMI_TM_Timeout_Flt );
    _mEL_Ft_Disp_Rq_AR.TurnLmp_FL_Flt.phys = getValue( HMI_TurnLmp_FL_Flt );
    _mEL_Ft_Disp_Rq_AR.TurnLmp_FR_Flt.phys = getValue( HMI_TurnLmp_FR_Flt );
    _mEL_Ft_Disp_Rq_AR.TurnLmp_R_Flt.phys = getValue( HMI_TurnLmp_R_Flt );
    _mEL_Ft_Disp_Rq_AR.TurnLmp_R_Flt_TM.phys = getValue( HMI_TurnLmp_R_Flt_TM );
    _mEL_Ft_Disp_Rq_AR.VCS_Flt.phys = getValue( HMI_VCS_Flt );
    _mEL_Ft_Disp_Rq_AR.BltLineIll_Stat.phys = getValue( HMI_BltLineIll_Stat );
    _mEL_Ft_Disp_Rq_AR.EmbIll_Stat.phys = getValue( HMI_EmbIll_Stat );
    _mEL_Ft_Disp_Rq_AR.NightLineIll_Stat.phys = getValue( HMI_NightLineIll_Stat );
    _mEL_Ft_Disp_Rq_AR.RunBrdIll_Stat.phys = getValue( HMI_RunBrdIll_Stat );

}

EL_Ft_Disp_Rq_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_EL_Ft_FltDisp_Rq ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_EL_Ft_FltDisp_Rq_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _EL_Ft_Disp_Rq_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _EL_Ft_Disp_Rq_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_EL_Ft_FltDisp_Rq_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _EL_Ft_Disp_Rq_AR_SQC_WrongSeqJump != 0 ) &&
            ( _EL_Ft_Disp_Rq_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _EL_Ft_Disp_Rq_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _EL_Ft_Disp_Rq_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _EL_Ft_Disp_Rq_AR_SQC_RepeatedCnt ) &&
            ( _EL_Ft_Disp_Rq_AR_E2E_Armed == 1  )    )
        {
            _EL_Ft_Disp_Rq_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_EL_Ft_FltDisp_Rq, SQC_help );
    }
    _mEL_Ft_Disp_Rq_AR.SQC_EL_Ft_FltDisp_Rq = SQC_help;

    if( getValue( HMI_CRC_EL_Ft_FltDisp_Rq_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_EL_Ft_FltDisp_Rq_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mEL_Ft_Disp_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mEL_Ft_Disp_Rq_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mEL_Ft_Disp_Rq_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mEL_Ft_Disp_Rq_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mEL_Ft_Disp_Rq_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mEL_Ft_Disp_Rq_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mEL_Ft_Disp_Rq_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mEL_Ft_Disp_Rq_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _EL_Ft_Disp_Rq_AR_CRC_Offset[ _mEL_Ft_Disp_Rq_AR.SQC_EL_Ft_FltDisp_Rq ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _EL_Ft_Disp_Rq_AR_CRC_ErrorCnt   && ( _EL_Ft_Disp_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EL_Ft_FltDisp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _EL_Ft_Disp_Rq_AR_CRC_ErrorCnt > 0 )
                    _EL_Ft_Disp_Rq_AR_CRC_ErrorCnt--; 
            }
            _mEL_Ft_Disp_Rq_AR.CRC_EL_Ft_FltDisp_Rq = crc;
            putValue( HMI_CRC_EL_Ft_FltDisp_Rq, crc );
        }
        else
            _mEL_Ft_Disp_Rq_AR.CRC_EL_Ft_FltDisp_Rq = getValue( HMI_CRC_EL_Ft_FltDisp_Rq );
    }
    // no CRC for W222 / 205

    if( ( _EL_Ft_Disp_Rq_AR_MSG_DropCnt > 0 ) &&
        ( _EL_Ft_Disp_Rq_AR_E2E_Armed == 1  )    )
    {
        _EL_Ft_Disp_Rq_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mEL_Ft_Disp_Rq_AR );
        
    if( _EL_Ft_Disp_Rq_AR_E2E_Armed == 1 )
    {
        if ( ( _EL_Ft_Disp_Rq_AR_MSG_DropCnt == 0      ) &&
             ( _EL_Ft_Disp_Rq_AR_CRC_ErrorCnt == 0     ) &&
             ( _EL_Ft_Disp_Rq_AR_SQC_RepeatedCnt == 0  ) &&
             ( _EL_Ft_Disp_Rq_AR_SQC_WrongSeqJump == 0 )    )
        {
            _EL_Ft_Disp_Rq_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_EL_Ft_FltDisp_Rq_State, 0 );
        }
    }
}

EL_Ft_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: EL_Ft_Disp_Rq_AR\n", 30, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_EL_Ft_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_EL_Ft_Disp_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_EL_Ft_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_EL_Ft_Disp_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EL_Ft_FltDisp_Rq := %X\n", getValue( HMI_CRC_EL_Ft_FltDisp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EL_Ft_FltDisp_Rq_Auto := %X\n", getValue( HMI_CRC_EL_Ft_FltDisp_Rq_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EL_Ft_FltDisp_Rq_Profile_02 := %X\n", getValue( HMI_CRC_EL_Ft_FltDisp_Rq_Profile_02 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DRL_Lt_Flt := %X\n", getValue( HMI_DRL_Lt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DRL_Rt_Flt := %X\n", getValue( HMI_DRL_Rt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EF_Flt := %X\n", getValue( HMI_EF_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EmgLgtPath_Flt_BC_F := %X\n", getValue( HMI_EmgLgtPath_Flt_BC_F ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ExtLmp_IC_Disp_On_Rq := %X\n", getValue( HMI_ExtLmp_IC_Disp_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ExtLmp_RLS_Warn_Rq := %X\n", getValue( HMI_ExtLmp_RLS_Warn_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FogLmp_FL_Flt := %X\n", getValue( HMI_FogLmp_FL_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FogLmp_FR_Flt := %X\n", getValue( HMI_FogLmp_FR_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HiBm_Lt_Flt := %X\n", getValue( HMI_HiBm_Lt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HiBm_Rt_Flt := %X\n", getValue( HMI_HiBm_Rt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_Actv := %X\n", getValue( HMI_IHC_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_FltDisp_Rq := %X\n", getValue( HMI_IHC_FltDisp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_Menu_Rq := %X\n", getValue( HMI_IHC_Menu_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IrLmp_Lt_Flt := %X\n", getValue( HMI_IrLmp_Lt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IrLmp_Rt_Flt := %X\n", getValue( HMI_IrLmp_Rt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LoBm_Lt_Flt := %X\n", getValue( HMI_LoBm_Lt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LoBm_Rt_Flt := %X\n", getValue( HMI_LoBm_Rt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_NS_IllDur_Cfg_Stat := %X\n", getValue( HMI_NS_IllDur_Cfg_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PkLmp_FL_Flt := %X\n", getValue( HMI_PkLmp_FL_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PkLmp_FR_Flt := %X\n", getValue( HMI_PkLmp_FR_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_EL_Ft_FltDisp_Rq := %X\n", getValue( HMI_Rsrv1_EL_Ft_FltDisp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SM_FL_Flt := %X\n", getValue( HMI_SM_FL_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SM_FR_Flt := %X\n", getValue( HMI_SM_FR_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EL_Ft_FltDisp_Rq := %X\n", getValue( HMI_SQC_EL_Ft_FltDisp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EL_Ft_FltDisp_Rq_Auto := %X\n", getValue( HMI_SQC_EL_Ft_FltDisp_Rq_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SurrIll_Cfg_Stat := %X\n", getValue( HMI_SurrIll_Cfg_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TM_Timeout_Flt := %X\n", getValue( HMI_TM_Timeout_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TurnLmp_FL_Flt := %X\n", getValue( HMI_TurnLmp_FL_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TurnLmp_FR_Flt := %X\n", getValue( HMI_TurnLmp_FR_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TurnLmp_R_Flt := %X\n", getValue( HMI_TurnLmp_R_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TurnLmp_R_Flt_TM := %X\n", getValue( HMI_TurnLmp_R_Flt_TM ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VCS_Flt := %X\n", getValue( HMI_VCS_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BltLineIll_Stat := %X\n", getValue( HMI_BltLineIll_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EmbIll_Stat := %X\n", getValue( HMI_EmbIll_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_NightLineIll_Stat := %X\n", getValue( HMI_NightLineIll_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RunBrdIll_Stat := %X\n", getValue( HMI_RunBrdIll_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tEL_Ft_Disp_Rq_AR
{
    putValue( HMI__STMSG_EL_Ft_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_EL_Ft_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_EL_Ft_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tEL_Ft_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_EL_Ft_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_EL_Ft_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("EL_Ft_Disp_Rq_AR");
}

on envVar HMI_E2E_EL_Ft_FltDisp_Rq_Inject
{
    if( getValue( this ) )
    {
        _EL_Ft_Disp_Rq_AR_CRC_ErrorCnt = getValue( HMI_CRC_EL_Ft_FltDisp_Rq_ErrorCount );
        _EL_Ft_Disp_Rq_AR_SQC_TriggPos = getValue( HMI_SQC_EL_Ft_FltDisp_Rq_TriggerPosition );
        _EL_Ft_Disp_Rq_AR_SQC_WrongSeqJump = getValue( HMI_SQC_EL_Ft_FltDisp_Rq_WrongSeq );
        _EL_Ft_Disp_Rq_AR_SQC_RepeatedCnt = getValue( HMI_SQC_EL_Ft_FltDisp_Rq_Repeated );
        _EL_Ft_Disp_Rq_AR_MSG_DropCnt = getValue( HMI_SQC_EL_Ft_FltDisp_Rq_MSG_DropCnt );
        putValue( HMI_E2E_EL_Ft_FltDisp_Rq_State, 2 );
        _EL_Ft_Disp_Rq_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_DRL_Lt_Flt
{
    _mEL_Ft_Disp_Rq_AR.DRL_Lt_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DRL_Rt_Flt
{
    _mEL_Ft_Disp_Rq_AR.DRL_Rt_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EF_Flt
{
    _mEL_Ft_Disp_Rq_AR.EF_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EmgLgtPath_Flt_BC_F
{
    _mEL_Ft_Disp_Rq_AR.EmgLgtPath_Flt_BC_F.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ExtLmp_IC_Disp_On_Rq
{
    _mEL_Ft_Disp_Rq_AR.ExtLmp_IC_Disp_On_Rq.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ExtLmp_RLS_Warn_Rq
{
    _mEL_Ft_Disp_Rq_AR.ExtLmp_RLS_Warn_Rq.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FogLmp_FL_Flt
{
    _mEL_Ft_Disp_Rq_AR.FogLmp_FL_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FogLmp_FR_Flt
{
    _mEL_Ft_Disp_Rq_AR.FogLmp_FR_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_HiBm_Lt_Flt
{
    _mEL_Ft_Disp_Rq_AR.HiBm_Lt_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_HiBm_Rt_Flt
{
    _mEL_Ft_Disp_Rq_AR.HiBm_Rt_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_IHC_Actv
{
    _mEL_Ft_Disp_Rq_AR.IHC_Actv.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_IHC_FltDisp_Rq
{
    _mEL_Ft_Disp_Rq_AR.IHC_FltDisp_Rq.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_IHC_Menu_Rq
{
    _mEL_Ft_Disp_Rq_AR.IHC_Menu_Rq.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_IrLmp_Lt_Flt
{
    _mEL_Ft_Disp_Rq_AR.IrLmp_Lt_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_IrLmp_Rt_Flt
{
    _mEL_Ft_Disp_Rq_AR.IrLmp_Rt_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LoBm_Lt_Flt
{
    _mEL_Ft_Disp_Rq_AR.LoBm_Lt_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LoBm_Rt_Flt
{
    _mEL_Ft_Disp_Rq_AR.LoBm_Rt_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_NS_IllDur_Cfg_Stat
{
    _mEL_Ft_Disp_Rq_AR.NS_IllDur_Cfg_Stat.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PkLmp_FL_Flt
{
    _mEL_Ft_Disp_Rq_AR.PkLmp_FL_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_PkLmp_FR_Flt
{
    _mEL_Ft_Disp_Rq_AR.PkLmp_FR_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SM_FL_Flt
{
    _mEL_Ft_Disp_Rq_AR.SM_FL_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SM_FR_Flt
{
    _mEL_Ft_Disp_Rq_AR.SM_FR_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SurrIll_Cfg_Stat
{
    _mEL_Ft_Disp_Rq_AR.SurrIll_Cfg_Stat.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TM_Timeout_Flt
{
    _mEL_Ft_Disp_Rq_AR.TM_Timeout_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TurnLmp_FL_Flt
{
    _mEL_Ft_Disp_Rq_AR.TurnLmp_FL_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TurnLmp_FR_Flt
{
    _mEL_Ft_Disp_Rq_AR.TurnLmp_FR_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TurnLmp_R_Flt
{
    _mEL_Ft_Disp_Rq_AR.TurnLmp_R_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TurnLmp_R_Flt_TM
{
    _mEL_Ft_Disp_Rq_AR.TurnLmp_R_Flt_TM.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_VCS_Flt
{
    _mEL_Ft_Disp_Rq_AR.VCS_Flt.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BltLineIll_Stat
{
    _mEL_Ft_Disp_Rq_AR.BltLineIll_Stat.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EmbIll_Stat
{
    _mEL_Ft_Disp_Rq_AR.EmbIll_Stat.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_NightLineIll_Stat
{
    _mEL_Ft_Disp_Rq_AR.NightLineIll_Stat.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_RunBrdIll_Stat
{
    _mEL_Ft_Disp_Rq_AR.RunBrdIll_Stat.phys = getValue(this);
    _EL_Ft_Disp_Rq_AR_SpontanFlag = 1;
}

EL_R_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_EL_R_Disp_Rq_AR ) )
    {
    //  message   EL_R_Disp_Rq_AR ID: 897 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _EL_R_Disp_Rq_AR_Cnt--;
        if( _EL_R_Disp_Rq_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            EL_R_Disp_Rq_AR_output();
            _EL_R_Disp_Rq_AR_Cnt = _EL_R_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _EL_R_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _EL_R_Disp_Rq_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            EL_R_Disp_Rq_AR_output();
            _EL_R_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

EL_R_Disp_Rq_AR_init()
{   /* Botschaft EL_R_Disp_Rq_AR ID: 897 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 897 0;
BA_ "NmAsrMessage" BO_ 897 0;
BA_ "GenMsgMinAcceptLength" BO_ 897 8;
BA_ "GenMsgILSupport" BO_ 897 1;
BA_ "DiagState" BO_ 897 0;
BA_ "DiagRequest" BO_ 897 0;
BA_ "DiagResponse" BO_ 897 0;
BA_ "GenMsgStartValue" BO_ 897 "0";
BA_ "GenMsgStartDelayTime" BO_ 897 0;
BA_ "GenMsgDelayTime" BO_ 897 5;
BA_ "GenMsgNrOfRepetitions" BO_ 897 0;
BA_ "GenMsgCycleTime" BO_ 897 200;
BA_ "GenMsgSendType" BO_ 897 5;
    */
    _EL_R_Disp_Rq_AR_Timebase =          c_tDBKomTimer_20ms;
    _EL_R_Disp_Rq_AR_CycleCount =       200 / _EL_R_Disp_Rq_AR_Timebase;
    _EL_R_Disp_Rq_AR_StartDelay =         0 / _EL_R_Disp_Rq_AR_Timebase;
    _EL_R_Disp_Rq_AR_Cnt = _EL_R_Disp_Rq_AR_StartDelay;
    _EL_R_Disp_Rq_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_EL_R_Disp_Rq_AR, _EL_R_Disp_Rq_AR_StartDelay * _EL_R_Disp_Rq_AR_Timebase );

    _mEL_R_Disp_Rq_AR.BrkLmp3_Flt.phys = getValue( HMI_BrkLmp3_Flt );
    _mEL_R_Disp_Rq_AR.BrkLmp_Lt_Flt.phys = getValue( HMI_BrkLmp_Lt_Flt );
    _mEL_R_Disp_Rq_AR.BrkLmp_Rt_Flt.phys = getValue( HMI_BrkLmp_Rt_Flt );
    _mEL_R_Disp_Rq_AR.BrkTlLmp_Lt_Flt.phys = getValue( HMI_BrkTlLmp_Lt_Flt );
    _mEL_R_Disp_Rq_AR.BrkTlLmp_Rt_Flt.phys = getValue( HMI_BrkTlLmp_Rt_Flt );
    _mEL_R_Disp_Rq_AR.BuLmp_Lt_Flt.phys = getValue( HMI_BuLmp_Lt_Flt );
    _mEL_R_Disp_Rq_AR.BuLmp_Rt_Flt.phys = getValue( HMI_BuLmp_Rt_Flt );
    _mEL_R_Disp_Rq_AR.EmgLgtPath_Flt_SAM_R.phys = getValue( HMI_EmgLgtPath_Flt_SAM_R );
    _mEL_R_Disp_Rq_AR.FogLmp_RL_Flt.phys = getValue( HMI_FogLmp_RL_Flt );
    _mEL_R_Disp_Rq_AR.FogLmp_RR_Flt.phys = getValue( HMI_FogLmp_RR_Flt );
    _mEL_R_Disp_Rq_AR.LP_Lmp_Lt_Flt.phys = getValue( HMI_LP_Lmp_Lt_Flt );
    _mEL_R_Disp_Rq_AR.LP_Lmp_Rt_Flt.phys = getValue( HMI_LP_Lmp_Rt_Flt );
    _mEL_R_Disp_Rq_AR.Rsrv1_EL_R_FltDisp_Rq.phys = getValue( HMI_Rsrv1_EL_R_FltDisp_Rq );
    _mEL_R_Disp_Rq_AR.SM_RL_Flt.phys = getValue( HMI_SM_RL_Flt );
    _mEL_R_Disp_Rq_AR.SM_RR_Flt.phys = getValue( HMI_SM_RR_Flt );
    _mEL_R_Disp_Rq_AR.SVS_ExtLmp_Stat.phys = getValue( HMI_SVS_ExtLmp_Stat );
    _mEL_R_Disp_Rq_AR.Term54_Flt_BC_R.phys = getValue( HMI_Term54_Flt_BC_R );
    _mEL_R_Disp_Rq_AR.TlLmp_Lt_Flt.phys = getValue( HMI_TlLmp_Lt_Flt );
    _mEL_R_Disp_Rq_AR.TlLmp_Rt_Flt.phys = getValue( HMI_TlLmp_Rt_Flt );
    _mEL_R_Disp_Rq_AR.TurnLmp_RL_Flt.phys = getValue( HMI_TurnLmp_RL_Flt );
    _mEL_R_Disp_Rq_AR.TurnLmp_RR_Flt.phys = getValue( HMI_TurnLmp_RR_Flt );
}

EL_R_Disp_Rq_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_EL_R_FltDisp_Rq ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_EL_R_FltDisp_Rq_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _EL_R_Disp_Rq_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _EL_R_Disp_Rq_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_EL_R_FltDisp_Rq_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _EL_R_Disp_Rq_AR_SQC_WrongSeqJump != 0 ) &&
            ( _EL_R_Disp_Rq_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _EL_R_Disp_Rq_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _EL_R_Disp_Rq_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _EL_R_Disp_Rq_AR_SQC_RepeatedCnt ) &&
            ( _EL_R_Disp_Rq_AR_E2E_Armed == 1  )    )
        {
            _EL_R_Disp_Rq_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_EL_R_FltDisp_Rq, SQC_help );
    }
    _mEL_R_Disp_Rq_AR.SQC_EL_R_FltDisp_Rq = SQC_help;

    if( getValue( HMI_CRC_EL_R_FltDisp_Rq_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_EL_R_FltDisp_Rq_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mEL_R_Disp_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mEL_R_Disp_Rq_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mEL_R_Disp_Rq_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mEL_R_Disp_Rq_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mEL_R_Disp_Rq_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mEL_R_Disp_Rq_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mEL_R_Disp_Rq_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mEL_R_Disp_Rq_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _EL_R_Disp_Rq_AR_CRC_Offset[ _mEL_R_Disp_Rq_AR.SQC_EL_R_FltDisp_Rq ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _EL_R_Disp_Rq_AR_CRC_ErrorCnt   && ( _EL_R_Disp_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EL_R_FltDisp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _EL_R_Disp_Rq_AR_CRC_ErrorCnt > 0 )
                    _EL_R_Disp_Rq_AR_CRC_ErrorCnt--; 
            }
            _mEL_R_Disp_Rq_AR.CRC_EL_R_FltDisp_Rq = crc;
            putValue( HMI_CRC_EL_R_FltDisp_Rq, crc );
        }
        else
            _mEL_R_Disp_Rq_AR.CRC_EL_R_FltDisp_Rq = getValue( HMI_CRC_EL_R_FltDisp_Rq );
    }
    else
    {
        if( !getValue( HMI_CRC_EL_R_FltDisp_Rq_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mEL_R_Disp_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mEL_R_Disp_Rq_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mEL_R_Disp_Rq_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mEL_R_Disp_Rq_AR.byte( 3 ) ];
//            crc = crctable[ crc ^ _mEL_R_Disp_Rq_AR.byte( 4 ) ];
//            crc = crctable[ crc ^ _mEL_R_Disp_Rq_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mEL_R_Disp_Rq_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mEL_R_Disp_Rq_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _EL_R_Disp_Rq_AR_CRC_ErrorCnt   && ( _EL_R_Disp_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EL_R_FltDisp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _EL_R_Disp_Rq_AR_CRC_ErrorCnt > 0 )
                    _EL_R_Disp_Rq_AR_CRC_ErrorCnt--; 
            }
            _mEL_R_Disp_Rq_AR.CRC_EL_R_FltDisp_Rq = crc;
            putValue( HMI_CRC_EL_R_FltDisp_Rq, crc );
        }
        else
            _mEL_R_Disp_Rq_AR.CRC_EL_R_FltDisp_Rq = getValue( HMI_CRC_EL_R_FltDisp_Rq );
    }
    if( ( _EL_R_Disp_Rq_AR_MSG_DropCnt > 0 ) &&
        ( _EL_R_Disp_Rq_AR_E2E_Armed == 1  )    )
    {
        _EL_R_Disp_Rq_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mEL_R_Disp_Rq_AR );
        
    if( _EL_R_Disp_Rq_AR_E2E_Armed == 1 )
    {
        if ( ( _EL_R_Disp_Rq_AR_MSG_DropCnt == 0      ) &&
             ( _EL_R_Disp_Rq_AR_CRC_ErrorCnt == 0     ) &&
             ( _EL_R_Disp_Rq_AR_SQC_RepeatedCnt == 0  ) &&
             ( _EL_R_Disp_Rq_AR_SQC_WrongSeqJump == 0 )    )
        {
            _EL_R_Disp_Rq_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_EL_R_FltDisp_Rq_State, 0 );
        }
    }
}

EL_R_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: EL_R_Disp_Rq_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_EL_R_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_EL_R_Disp_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_EL_R_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_EL_R_Disp_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkLmp3_Flt := %X\n", getValue( HMI_BrkLmp3_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkLmp_Lt_Flt := %X\n", getValue( HMI_BrkLmp_Lt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkLmp_Rt_Flt := %X\n", getValue( HMI_BrkLmp_Rt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkTlLmp_Lt_Flt := %X\n", getValue( HMI_BrkTlLmp_Lt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkTlLmp_Rt_Flt := %X\n", getValue( HMI_BrkTlLmp_Rt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BuLmp_Lt_Flt := %X\n", getValue( HMI_BuLmp_Lt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BuLmp_Rt_Flt := %X\n", getValue( HMI_BuLmp_Rt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EL_R_FltDisp_Rq := %X\n", getValue( HMI_CRC_EL_R_FltDisp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EL_R_FltDisp_Rq_Auto := %X\n", getValue( HMI_CRC_EL_R_FltDisp_Rq_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EL_R_FltDisp_Rq_Profilr_02 := %X\n", getValue( HMI_CRC_EL_R_FltDisp_Rq_Profile_02 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EmgLgtPath_Flt_SAM_R := %X\n", getValue( HMI_EmgLgtPath_Flt_SAM_R ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FogLmp_RL_Flt := %X\n", getValue( HMI_FogLmp_RL_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FogLmp_RR_Flt := %X\n", getValue( HMI_FogLmp_RR_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LP_Lmp_Lt_Flt := %X\n", getValue( HMI_LP_Lmp_Lt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LP_Lmp_Rt_Flt := %X\n", getValue( HMI_LP_Lmp_Rt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_EL_R_FltDisp_Rq := %X\n", getValue( HMI_Rsrv1_EL_R_FltDisp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SM_RL_Flt := %X\n", getValue( HMI_SM_RL_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SM_RR_Flt := %X\n", getValue( HMI_SM_RR_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EL_R_FltDisp_Rq := %X\n", getValue( HMI_SQC_EL_R_FltDisp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EL_R_FltDisp_Rq_Auto := %X\n", getValue( HMI_SQC_EL_R_FltDisp_Rq_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SVS_ExtLmp_Stat := %X\n", getValue( HMI_SVS_ExtLmp_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Term54_Flt_BC_R := %X\n", getValue( HMI_Term54_Flt_BC_R ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TlLmp_Lt_Flt := %X\n", getValue( HMI_TlLmp_Lt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TlLmp_Rt_Flt := %X\n", getValue( HMI_TlLmp_Rt_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TurnLmp_RL_Flt := %X\n", getValue( HMI_TurnLmp_RL_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TurnLmp_RR_Flt := %X\n", getValue( HMI_TurnLmp_RR_Flt ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tEL_R_Disp_Rq_AR
{
    putValue( HMI__STMSG_EL_R_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_EL_R_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_EL_R_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tEL_R_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_EL_R_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_EL_R_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("EL_R_Disp_Rq_AR");
}

on envVar HMI_E2E_EL_R_FltDisp_Rq_Inject
{
    if( getValue( this ) )
    {
        _EL_R_Disp_Rq_AR_CRC_ErrorCnt = getValue( HMI_CRC_EL_R_FltDisp_Rq_ErrorCount );
        _EL_R_Disp_Rq_AR_SQC_TriggPos = getValue( HMI_SQC_EL_R_FltDisp_Rq_TriggerPosition );
        _EL_R_Disp_Rq_AR_SQC_WrongSeqJump = getValue( HMI_SQC_EL_R_FltDisp_Rq_WrongSeq );
        _EL_R_Disp_Rq_AR_SQC_RepeatedCnt = getValue( HMI_SQC_EL_R_FltDisp_Rq_Repeated );
        _EL_R_Disp_Rq_AR_MSG_DropCnt = getValue( HMI_SQC_EL_R_FltDisp_Rq_MSG_DropCnt );
        putValue( HMI_E2E_EL_R_FltDisp_Rq_State, 2 );
        _EL_R_Disp_Rq_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_BrkLmp3_Flt
{
    _mEL_R_Disp_Rq_AR.BrkLmp3_Flt.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BrkLmp_Lt_Flt
{
    _mEL_R_Disp_Rq_AR.BrkLmp_Lt_Flt.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BrkLmp_Rt_Flt
{
    _mEL_R_Disp_Rq_AR.BrkLmp_Rt_Flt.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BrkTlLmp_Lt_Flt
{
    _mEL_R_Disp_Rq_AR.BrkTlLmp_Lt_Flt.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BrkTlLmp_Rt_Flt
{
    _mEL_R_Disp_Rq_AR.BrkTlLmp_Rt_Flt.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BuLmp_Lt_Flt
{
    _mEL_R_Disp_Rq_AR.BuLmp_Lt_Flt.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BuLmp_Rt_Flt
{
    _mEL_R_Disp_Rq_AR.BuLmp_Rt_Flt.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EmgLgtPath_Flt_SAM_R
{
    _mEL_R_Disp_Rq_AR.EmgLgtPath_Flt_SAM_R.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FogLmp_RL_Flt
{
    _mEL_R_Disp_Rq_AR.FogLmp_RL_Flt.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FogLmp_RR_Flt
{
    _mEL_R_Disp_Rq_AR.FogLmp_RR_Flt.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LP_Lmp_Lt_Flt
{
    _mEL_R_Disp_Rq_AR.LP_Lmp_Lt_Flt.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_LP_Lmp_Rt_Flt
{
    _mEL_R_Disp_Rq_AR.LP_Lmp_Rt_Flt.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_EL_R_FltDisp_Rq
{
    _mEL_R_Disp_Rq_AR.Rsrv1_EL_R_FltDisp_Rq.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SM_RL_Flt
{
    _mEL_R_Disp_Rq_AR.SM_RL_Flt.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SM_RR_Flt
{
    _mEL_R_Disp_Rq_AR.SM_RR_Flt.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SVS_ExtLmp_Stat
{
    _mEL_R_Disp_Rq_AR.SVS_ExtLmp_Stat.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Term54_Flt_BC_R
{
    _mEL_R_Disp_Rq_AR.Term54_Flt_BC_R.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TlLmp_Lt_Flt
{
    _mEL_R_Disp_Rq_AR.TlLmp_Lt_Flt.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TlLmp_Rt_Flt
{
    _mEL_R_Disp_Rq_AR.TlLmp_Rt_Flt.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TurnLmp_RL_Flt
{
    _mEL_R_Disp_Rq_AR.TurnLmp_RL_Flt.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TurnLmp_RR_Flt
{
    _mEL_R_Disp_Rq_AR.TurnLmp_RR_Flt.phys = getValue(this);
    _EL_R_Disp_Rq_AR_SpontanFlag = 1;
}

EL_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_EL_Stat_AR ) )
    {
    //  message   EL_Stat_AR ID: 829 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _EL_Stat_AR_Cnt--;
        if( _EL_Stat_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            EL_Stat_AR_output();
            _EL_Stat_AR_Cnt = _EL_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _EL_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _EL_Stat_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            EL_Stat_AR_output();
            _EL_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

EL_Stat_AR_init()
{   /* Botschaft EL_Stat_AR ID: 829 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 829 0;
BA_ "NmAsrMessage" BO_ 829 0;
BA_ "GenMsgMinAcceptLength" BO_ 829 8;
BA_ "GenMsgILSupport" BO_ 829 1;
BA_ "DiagState" BO_ 829 0;
BA_ "DiagRequest" BO_ 829 0;
BA_ "DiagResponse" BO_ 829 0;
BA_ "GenMsgStartValue" BO_ 829 "0";
BA_ "GenMsgStartDelayTime" BO_ 829 0;
BA_ "GenMsgDelayTime" BO_ 829 5;
BA_ "GenMsgNrOfRepetitions" BO_ 829 0;
BA_ "GenMsgCycleTime" BO_ 829 200;
BA_ "GenMsgSendType" BO_ 829 5;
    */
    _EL_Stat_AR_Timebase =              c_tDBKomTimer_20ms;
    _EL_Stat_AR_CycleCount =          200 / _EL_Stat_AR_Timebase;
    _EL_Stat_AR_StartDelay =            0 / _EL_Stat_AR_Timebase;
    _EL_Stat_AR_Cnt = _EL_Stat_AR_StartDelay;
    _EL_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_EL_Stat_AR, _EL_Stat_AR_StartDelay * _EL_Stat_AR_Timebase );

    _mEL_Stat_AR.BuLmp_Lt_On_Rq.phys = getValue( HMI_BuLmp_Lt_On_Rq );
    _mEL_Stat_AR.BuLmp_Rt_On_Rq.phys = getValue( HMI_BuLmp_Rt_On_Rq );
    _mEL_Stat_AR.DrHdlRecLgt_On_Rq.phys = getValue( HMI_DrHdlRecLgt_On_Rq );
    _mEL_Stat_AR.DRL_Dim_Actv.phys = getValue( HMI_DRL_Dim_Actv );
    _mEL_Stat_AR.DRL_LT_On_Rq.phys = getValue( HMI_DRL_LT_On_Rq );
    _mEL_Stat_AR.DRL_RT_On_Rq.phys = getValue( HMI_DRL_RT_On_Rq );
    _mEL_Stat_AR.ElecPwr_Inc_Rq.phys = getValue( HMI_ElecPwr_Inc_Rq );
    _mEL_Stat_AR.EntrLmp_Front_LT_On_Rq.phys = getValue( HMI_EntrLmp_Front_LT_On_Rq );
    _mEL_Stat_AR.EntrLmp_Front_RT_On_Rq.phys = getValue( HMI_EntrLmp_Front_RT_On_Rq );
    _mEL_Stat_AR.EntrLmp_Rear_Lt_On_Rq.phys = getValue( HMI_EntrLmp_Rear_Lt_On_Rq );
    _mEL_Stat_AR.EntrLmp_Rear_Rt_On_Rq.phys = getValue( HMI_EntrLmp_Rear_Rt_On_Rq );
    _mEL_Stat_AR.ExtLmp_AcustWarn_On_Rq.phys = getValue( HMI_ExtLmp_AcustWarn_On_Rq );
    _mEL_Stat_AR.FogLmp_Ft_IndLmp_On_Rq.phys = getValue( HMI_FogLmp_Ft_IndLmp_On_Rq );
    _mEL_Stat_AR.FogLmp_Ft_On_Rq.phys = getValue( HMI_FogLmp_Ft_On_Rq );
    _mEL_Stat_AR.FogLmp_R_IndLmp_On_Rq.phys = getValue( HMI_FogLmp_R_IndLmp_On_Rq );
    _mEL_Stat_AR.FogLmp_R_On_Rq.phys = getValue( HMI_FogLmp_R_On_Rq );
    _mEL_Stat_AR.FogLmp_RL_On_Rq.phys = getValue( HMI_FogLmp_RL_On_Rq );
    _mEL_Stat_AR.FogLmp_RR_On_Rq.phys = getValue( HMI_FogLmp_RR_On_Rq );
    _mEL_Stat_AR.HiBm_IndLmp_On_Rq.phys = getValue( HMI_HiBm_IndLmp_On_Rq );
    _mEL_Stat_AR.HiBm_Md_On_Rq.phys = getValue( HMI_HiBm_Md_On_Rq );
    _mEL_Stat_AR.HiBm_On.phys = getValue( HMI_HiBm_On );
    _mEL_Stat_AR.IHC_Sys_Stat.phys = getValue( HMI_IHC_Sys_Stat );
    _mEL_Stat_AR.IrLmp_Stat.phys = getValue( HMI_IrLmp_Stat );
    _mEL_Stat_AR.LoBm_IndLmp_On_Rq.phys = getValue( HMI_LoBm_IndLmp_On_Rq );
    _mEL_Stat_AR.LoBm_On_Rq.phys = getValue( HMI_LoBm_On_Rq );
    _mEL_Stat_AR.LP_Lmp_Lt_On_Rq.phys = getValue( HMI_LP_Lmp_Lt_On_Rq );
    _mEL_Stat_AR.NS_Ill_Actv.phys = getValue( HMI_NS_Ill_Actv );
    _mEL_Stat_AR.PkLmp_Lt_On_Rq.phys = getValue( HMI_PkLmp_Lt_On_Rq );
    _mEL_Stat_AR.PkLmp_Rt_On_Rq.phys = getValue( HMI_PkLmp_Rt_On_Rq );
    _mEL_Stat_AR.PosnLmp_IndLmp_On_Rq.phys = getValue( HMI_PosnLmp_IndLmp_On_Rq );
    _mEL_Stat_AR.PosnLmp_On_Rq.phys = getValue( HMI_PosnLmp_On_Rq );
    _mEL_Stat_AR.Rsrv1_ExtLgt_Lmp_On_Rq.phys = getValue( HMI_Rsrv1_ExtLgt_Lmp_On_Rq );
    _mEL_Stat_AR.SM_RL_On_Rq.phys = getValue( HMI_SM_RL_On_Rq );
    _mEL_Stat_AR.SM_RR_On_Rq.phys = getValue( HMI_SM_RR_On_Rq );
    _mEL_Stat_AR.SurrIll_Stat.phys = getValue( HMI_SurrIll_Stat );
    _mEL_Stat_AR.SVS_ExtLmp_Actv_V2.phys = getValue( HMI_SVS_ExtLmp_Actv_V2 );
    _mEL_Stat_AR.TlLmp_Lt_On_Rq.phys = getValue( HMI_TlLmp_Lt_On_Rq );
    _mEL_Stat_AR.TlLmp_Rt_On_Rq.phys = getValue( HMI_TlLmp_Rt_On_Rq );
    _mEL_Stat_AR.TlLmp_Rt_On_Rq.phys = getValue( HMI_TlLmp_Rt_On_Rq );
    _mEL_Stat_AR.DRLt_On_Stat.phys = getValue( HMI_DRLt_On_Stat );
}

EL_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_ExtLgt_Lmp_On_Rq ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_ExtLgt_Lmp_On_Rq_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _EL_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _EL_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_ExtLgt_Lmp_On_Rq_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _EL_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _EL_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _EL_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _EL_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _EL_Stat_AR_SQC_RepeatedCnt ) &&
            ( _EL_Stat_AR_E2E_Armed == 1  )    )
        {
            _EL_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_ExtLgt_Lmp_On_Rq, SQC_help );
    }
    _mEL_Stat_AR.SQC_ExtLgt_Lmp_On_Rq = SQC_help;

    if( getValue( HMI_CRC_ExtLgt_Lmp_On_Rq_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_ExtLgt_Lmp_On_Rq_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mEL_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mEL_Stat_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mEL_Stat_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mEL_Stat_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mEL_Stat_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mEL_Stat_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mEL_Stat_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mEL_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _EL_Stat_AR_CRC_Offset[ _mEL_Stat_AR.SQC_ExtLgt_Lmp_On_Rq ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _EL_Stat_AR_CRC_ErrorCnt   && ( _EL_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_ExtLgt_Lmp_On_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _EL_Stat_AR_CRC_ErrorCnt > 0 )
                    _EL_Stat_AR_CRC_ErrorCnt--; 
            }
            _mEL_Stat_AR.CRC_ExtLgt_Lmp_On_Rq = crc;
            putValue( HMI_CRC_ExtLgt_Lmp_On_Rq, crc );
        }
        else
            _mEL_Stat_AR.CRC_ExtLgt_Lmp_On_Rq = getValue( HMI_CRC_ExtLgt_Lmp_On_Rq );
    }
    else
    {
        if( !getValue( HMI_CRC_ExtLgt_Lmp_On_Rq_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mEL_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mEL_Stat_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mEL_Stat_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mEL_Stat_AR.byte( 3 ) ];
//            crc = crctable[ crc ^ _mEL_Stat_AR.byte( 4 ) ];
//            crc = crctable[ crc ^ _mEL_Stat_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mEL_Stat_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mEL_Stat_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _EL_Stat_AR_CRC_ErrorCnt   && ( _EL_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_ExtLgt_Lmp_On_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _EL_Stat_AR_CRC_ErrorCnt > 0 )
                    _EL_Stat_AR_CRC_ErrorCnt--; 
            }
            _mEL_Stat_AR.CRC_ExtLgt_Lmp_On_Rq = crc;
            putValue( HMI_CRC_ExtLgt_Lmp_On_Rq, crc );
        }
        else
            _mEL_Stat_AR.CRC_ExtLgt_Lmp_On_Rq = getValue( HMI_CRC_ExtLgt_Lmp_On_Rq );
    }
    if( ( _EL_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _EL_Stat_AR_E2E_Armed == 1  )    )
    {
        _EL_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mEL_Stat_AR );
        
    if( _EL_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _EL_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _EL_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _EL_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _EL_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _EL_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_ExtLgt_Lmp_On_Rq_State, 0 );
        }
    }
}

EL_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: EL_Stat_AR\n", 24, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_EL_Stat_AR := %X\n", getValue( HMI__STMSG_EL_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_EL_Stat_AR := %X\n", getValue( HMI__STMSGT_EL_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BuLmp_Lt_On_Rq := %X\n", getValue( HMI_BuLmp_Lt_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BuLmp_Rt_On_Rq := %X\n", getValue( HMI_BuLmp_Rt_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ExtLgt_Lmp_On_Rq := %X\n", getValue( HMI_CRC_ExtLgt_Lmp_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ExtLgt_Lmp_On_Rq_Auto := %X\n", getValue( HMI_CRC_ExtLgt_Lmp_On_Rq_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrHdlRecLgt_On_Rq := %X\n", getValue( HMI_DrHdlRecLgt_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DRL_Dim_Actv := %X\n", getValue( HMI_DRL_Dim_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DRL_LT_On_Rq := %X\n", getValue( HMI_DRL_LT_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DRL_RT_On_Rq := %X\n", getValue( HMI_DRL_RT_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ElecPwr_Inc_Rq := %X\n", getValue( HMI_ElecPwr_Inc_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EntrLmp_Front_LT_On_Rq := %X\n", getValue( HMI_EntrLmp_Front_LT_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EntrLmp_Front_RT_On_Rq := %X\n", getValue( HMI_EntrLmp_Front_RT_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EntrLmp_Rear_Lt_On_Rq := %X\n", getValue( HMI_EntrLmp_Rear_Lt_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EntrLmp_Rear_Rt_On_Rq := %X\n", getValue( HMI_EntrLmp_Rear_Rt_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ExtLmp_AcustWarn_On_Rq := %X\n", getValue( HMI_ExtLmp_AcustWarn_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FogLmp_Ft_IndLmp_On_Rq := %X\n", getValue( HMI_FogLmp_Ft_IndLmp_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FogLmp_Ft_On_Rq := %X\n", getValue( HMI_FogLmp_Ft_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FogLmp_R_IndLmp_On_Rq := %X\n", getValue( HMI_FogLmp_R_IndLmp_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FogLmp_R_On_Rq := %X\n", getValue( HMI_FogLmp_R_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FogLmp_RL_On_Rq := %X\n", getValue( HMI_FogLmp_RL_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FogLmp_RR_On_Rq := %X\n", getValue( HMI_FogLmp_RR_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HiBm_IndLmp_On_Rq := %X\n", getValue( HMI_HiBm_IndLmp_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HiBm_Md_On_Rq := %X\n", getValue( HMI_HiBm_Md_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HiBm_On := %X\n", getValue( HMI_HiBm_On ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IHC_Sys_Stat := %X\n", getValue( HMI_IHC_Sys_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IrLmp_Stat := %X\n", getValue( HMI_IrLmp_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LoBm_IndLmp_On_Rq := %X\n", getValue( HMI_LoBm_IndLmp_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LoBm_On_Rq := %X\n", getValue( HMI_LoBm_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_LP_Lmp_Lt_On_Rq := %X\n", getValue( HMI_LP_Lmp_Lt_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_NS_Ill_Actv := %X\n", getValue( HMI_NS_Ill_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PkLmp_Lt_On_Rq := %X\n", getValue( HMI_PkLmp_Lt_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PkLmp_Rt_On_Rq := %X\n", getValue( HMI_PkLmp_Rt_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PosnLmp_IndLmp_On_Rq := %X\n", getValue( HMI_PosnLmp_IndLmp_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PosnLmp_On_Rq := %X\n", getValue( HMI_PosnLmp_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_ExtLgt_Lmp_On_Rq := %X\n", getValue( HMI_Rsrv1_ExtLgt_Lmp_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SM_RL_On_Rq := %X\n", getValue( HMI_SM_RL_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SM_RR_On_Rq := %X\n", getValue( HMI_SM_RR_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_ExtLgt_Lmp_On_Rq := %X\n", getValue( HMI_SQC_ExtLgt_Lmp_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_ExtLgt_Lmp_On_Rq_Auto := %X\n", getValue( HMI_SQC_ExtLgt_Lmp_On_Rq_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SurrIll_Stat := %X\n", getValue( HMI_SurrIll_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SVS_ExtLmp_Actv_V2 := %X\n", getValue( HMI_SVS_ExtLmp_Actv_V2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TlLmp_Lt_On_Rq := %X\n", getValue( HMI_TlLmp_Lt_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TlLmp_Rt_On_Rq := %X\n", getValue( HMI_TlLmp_Rt_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DRLt_On_Stat := %X\n", getValue( HMI_DRLt_On_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    
}

on timer _tEL_Stat_AR
{
    putValue( HMI__STMSG_EL_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_EL_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_EL_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tEL_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_EL_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_EL_Stat_AR
{
    if( getValue( this ) )
        openPanel("EL_Stat_AR");
}

on envVar HMI_E2E_ExtLgt_Lmp_On_Rq_Inject
{
    if( getValue( this ) )
    {
        _EL_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_ExtLgt_Lmp_On_Rq_ErrorCount );
        _EL_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_ExtLgt_Lmp_On_Rq_TriggerPosition );
        _EL_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_ExtLgt_Lmp_On_Rq_WrongSeq );
        _EL_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_ExtLgt_Lmp_On_Rq_Repeated );
        _EL_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_ExtLgt_Lmp_On_Rq_MSG_DropCnt );
        putValue( HMI_E2E_ExtLgt_Lmp_On_Rq_State, 2 );
        _EL_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_BuLmp_Lt_On_Rq
{
    _mEL_Stat_AR.BuLmp_Lt_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_BuLmp_Rt_On_Rq
{
    _mEL_Stat_AR.BuLmp_Rt_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrHdlRecLgt_On_Rq
{
    _mEL_Stat_AR.DrHdlRecLgt_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DRL_Dim_Actv
{
    _mEL_Stat_AR.DRL_Dim_Actv.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DRL_LT_On_Rq
{
    _mEL_Stat_AR.DRL_LT_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DRL_RT_On_Rq
{
    _mEL_Stat_AR.DRL_RT_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DRLt_On_Stat
{
    _mEL_Stat_AR.DRLt_On_Stat.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ElecPwr_Inc_Rq
{
    _mEL_Stat_AR.ElecPwr_Inc_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_EntrLmp_Front_LT_On_Rq
{
    _mEL_Stat_AR.EntrLmp_Front_LT_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_EntrLmp_Front_RT_On_Rq
{
    _mEL_Stat_AR.EntrLmp_Front_RT_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_EntrLmp_Rear_Lt_On_Rq
{
    _mEL_Stat_AR.EntrLmp_Rear_Lt_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_EntrLmp_Rear_Rt_On_Rq
{
    _mEL_Stat_AR.EntrLmp_Rear_Rt_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ExtLmp_AcustWarn_On_Rq
{
    _mEL_Stat_AR.ExtLmp_AcustWarn_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FogLmp_Ft_IndLmp_On_Rq
{
    _mEL_Stat_AR.FogLmp_Ft_IndLmp_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FogLmp_Ft_On_Rq
{
    _mEL_Stat_AR.FogLmp_Ft_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FogLmp_R_IndLmp_On_Rq
{
    _mEL_Stat_AR.FogLmp_R_IndLmp_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FogLmp_R_On_Rq
{
    _mEL_Stat_AR.FogLmp_R_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FogLmp_RL_On_Rq
{
    _mEL_Stat_AR.FogLmp_RL_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FogLmp_RR_On_Rq
{
    _mEL_Stat_AR.FogLmp_RR_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_HiBm_IndLmp_On_Rq
{
    _mEL_Stat_AR.HiBm_IndLmp_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_HiBm_Md_On_Rq
{
    _mEL_Stat_AR.HiBm_Md_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_HiBm_On
{
    _mEL_Stat_AR.HiBm_On.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_IHC_Sys_Stat
{
    _mEL_Stat_AR.IHC_Sys_Stat.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_IrLmp_Stat
{
    _mEL_Stat_AR.IrLmp_Stat.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LoBm_IndLmp_On_Rq
{
	
    if( ( getValue( HMI__STMSG_EL_Stat_AR ) == 1) ) // TO on panel is active
    {
	//do nothing
	_ReleaseCommRequest( cLowBeamNMRequest );//make sure commReq is released
    }
    else
    {//there is no TO
    	if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   && ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    	{
		_SetCommRequest( cLowBeamNMRequest );
        	setTimer( t_LowBeamNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    	}
    	_mEL_Stat_AR.LoBm_IndLmp_On_Rq.phys = getValue(this);
    	_EL_Stat_AR_SpontanFlag = 1;
    }
}

on EnvVar HMI_LoBm_On_Rq
{
    _mEL_Stat_AR.LoBm_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_LP_Lmp_Lt_On_Rq
{
    _mEL_Stat_AR.LP_Lmp_Lt_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_NS_Ill_Actv
{
    _mEL_Stat_AR.NS_Ill_Actv.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PkLmp_Lt_On_Rq
{
    _mEL_Stat_AR.PkLmp_Lt_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PkLmp_Rt_On_Rq
{
    _mEL_Stat_AR.PkLmp_Rt_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PosnLmp_IndLmp_On_Rq
{
	if( ( getValue( HMI__STMSG_EL_Stat_AR ) == 1) ) // TO on panel is active
	{
	//do nothing
	}
	else
	{//there is no TO
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cIlluNMRequest );
        setTimer( t_IlluNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mEL_Stat_AR.PosnLmp_IndLmp_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
	}
}

on EnvVar HMI_PosnLmp_On_Rq
{
	if( ( getValue( HMI__STMSG_EL_Stat_AR ) == 1) ) // TO on panel is active
	{
	//do nothing
	}
	else
	{//there is no TO
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cIlluNMRequest );
        setTimer( t_IlluNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mEL_Stat_AR.PosnLmp_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
	}
}

on EnvVar HMI_Rsrv1_ExtLgt_Lmp_On_Rq
{
    _mEL_Stat_AR.Rsrv1_ExtLgt_Lmp_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SM_RL_On_Rq
{
    _mEL_Stat_AR.SM_RL_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SM_RR_On_Rq
{
    _mEL_Stat_AR.SM_RR_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SurrIll_Stat
{
    _mEL_Stat_AR.SurrIll_Stat.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SVS_ExtLmp_Actv_V2
{
    _mEL_Stat_AR.SVS_ExtLmp_Actv_V2.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_TlLmp_Lt_On_Rq
{
    _mEL_Stat_AR.TlLmp_Lt_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_TlLmp_Rt_On_Rq
{
    _mEL_Stat_AR.TlLmp_Rt_On_Rq.phys = getValue(this);
    _EL_Stat_AR_SpontanFlag = 1;
}

EL_TurnInd_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_EL_TurnInd_Rq_AR ) )
    {
    //  message   EL_TurnInd_Rq_AR ID: 287 --- Sendeart 1 spontanX --- 
        if( _EL_TurnInd_Rq_AR_SpontanFlag)
        {
            EL_TurnInd_Rq_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _EL_TurnInd_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

EL_TurnInd_Rq_AR_init()
{   /* Botschaft EL_TurnInd_Rq_AR ID: 287 --- Sendeart 1 spontanX --- 
BA_ "ApplMessage" BO_ 287 0;
BA_ "NmAsrMessage" BO_ 287 0;
BA_ "GenMsgMinAcceptLength" BO_ 287 4;
BA_ "GenMsgILSupport" BO_ 287 1;
BA_ "DiagState" BO_ 287 0;
BA_ "DiagRequest" BO_ 287 0;
BA_ "DiagResponse" BO_ 287 0;
BA_ "GenMsgStartValue" BO_ 287 "0";
BA_ "GenMsgDelayTime" BO_ 287 5;
BA_ "GenMsgNrOfRepetitions" BO_ 287 0;
BA_ "GenMsgSendType" BO_ 287 1;
    */
    _EL_TurnInd_Rq_AR_Timebase =         c_tDBKomTimer_5ms ;
    _EL_TurnInd_Rq_AR_SpontanFlag = 0;

    putValue( HMI_TurnLmpOnDur, 600 );
    _mEL_TurnInd_Rq_AR.EF_Actv.phys = getValue( HMI_EF_Actv );
    _mEL_TurnInd_Rq_AR.Rsrv1_EL_TurnInd_On_Rq.phys = getValue( HMI_Rsrv1_EL_TurnInd_On_Rq );
    _mEL_TurnInd_Rq_AR.TurnInd_FL_On_Rq.phys = getValue( HMI_TurnInd_FL_On_Rq );
    _mEL_TurnInd_Rq_AR.TurnInd_FR_On_Rq.phys = getValue( HMI_TurnInd_FR_On_Rq );
    _mEL_TurnInd_Rq_AR.TurnInd_Lt_On.phys = getValue( HMI_TurnInd_Lt_On );
    _mEL_TurnInd_Rq_AR.TurnInd_RL_On_Rq.phys = getValue( HMI_TurnInd_RL_On_Rq );
    _mEL_TurnInd_Rq_AR.TurnInd_RR_On_Rq.phys = getValue( HMI_TurnInd_RR_On_Rq );
    _mEL_TurnInd_Rq_AR.TurnInd_Rt_On.phys = getValue( HMI_TurnInd_Rt_On );
    _mEL_TurnInd_Rq_AR.TurnLmpOnDur.phys = getValue( HMI_TurnLmpOnDur );
}

EL_TurnInd_Rq_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_EL_TurnInd_On_Rq ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_EL_TurnInd_On_Rq_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _EL_TurnInd_Rq_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _EL_TurnInd_Rq_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_EL_TurnInd_On_Rq_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _EL_TurnInd_Rq_AR_SQC_WrongSeqJump != 0 ) &&
            ( _EL_TurnInd_Rq_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _EL_TurnInd_Rq_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _EL_TurnInd_Rq_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _EL_TurnInd_Rq_AR_SQC_RepeatedCnt ) &&
            ( _EL_TurnInd_Rq_AR_E2E_Armed == 1  )    )
        {
            _EL_TurnInd_Rq_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_EL_TurnInd_On_Rq, SQC_help );
    }
    _mEL_TurnInd_Rq_AR.SQC_EL_TurnInd_On_Rq = SQC_help;

    if( getValue( HMI_CRC_EL_TurnInd_On_Rq_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_EL_TurnInd_On_Rq_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mEL_TurnInd_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mEL_TurnInd_Rq_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mEL_TurnInd_Rq_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mEL_TurnInd_Rq_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mEL_TurnInd_Rq_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mEL_TurnInd_Rq_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mEL_TurnInd_Rq_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mEL_TurnInd_Rq_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _EL_TurnInd_Rq_AR_CRC_Offset[ _mEL_TurnInd_Rq_AR.SQC_EL_TurnInd_On_Rq ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _EL_TurnInd_Rq_AR_CRC_ErrorCnt   && ( _EL_TurnInd_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EL_TurnInd_On_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _EL_TurnInd_Rq_AR_CRC_ErrorCnt > 0 )
                    _EL_TurnInd_Rq_AR_CRC_ErrorCnt--; 
            }
            _mEL_TurnInd_Rq_AR.CRC_EL_TurnInd_On_Rq = crc;
            putValue( HMI_CRC_EL_TurnInd_On_Rq, crc );
        }
        else
            _mEL_TurnInd_Rq_AR.CRC_EL_TurnInd_On_Rq = getValue( HMI_CRC_EL_TurnInd_On_Rq );
    }
    if( ( _EL_TurnInd_Rq_AR_MSG_DropCnt > 0 ) &&
        ( _EL_TurnInd_Rq_AR_E2E_Armed == 1  )    )
    {
        _EL_TurnInd_Rq_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mEL_TurnInd_Rq_AR );
        
    if( _EL_TurnInd_Rq_AR_E2E_Armed == 1 )
    {
        if ( ( _EL_TurnInd_Rq_AR_MSG_DropCnt == 0      ) &&
             ( _EL_TurnInd_Rq_AR_CRC_ErrorCnt == 0     ) &&
             ( _EL_TurnInd_Rq_AR_SQC_RepeatedCnt == 0  ) &&
             ( _EL_TurnInd_Rq_AR_SQC_WrongSeqJump == 0 )    )
        {
            _EL_TurnInd_Rq_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_EL_TurnInd_On_Rq_State, 0 );
        }
    }
}

EL_TurnInd_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: EL_TurnInd_Rq_AR\n", 30, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_EL_TurnInd_Rq_AR := %X\n", getValue( HMI__STMSG_EL_TurnInd_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_EL_TurnInd_Rq_AR := %X\n", getValue( HMI__STMSGT_EL_TurnInd_Rq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EL_TurnInd_On_Rq := %X\n", getValue( HMI_CRC_EL_TurnInd_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EL_TurnInd_On_Rq_Auto := %X\n", getValue( HMI_CRC_EL_TurnInd_On_Rq_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EL_TurnInd_On_Rq_Profile_02 := %X\n", getValue( HMI_CRC_EL_TurnInd_On_Rq_Profile_02 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EF_Actv := %X\n", getValue( HMI_EF_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_EL_TurnInd_On_Rq := %X\n", getValue( HMI_Rsrv1_EL_TurnInd_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EL_TurnInd_On_Rq := %X\n", getValue( HMI_SQC_EL_TurnInd_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EL_TurnInd_On_Rq_Auto := %X\n", getValue( HMI_SQC_EL_TurnInd_On_Rq_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TurnInd_FL_On_Rq := %X\n", getValue( HMI_TurnInd_FL_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TurnInd_FR_On_Rq := %X\n", getValue( HMI_TurnInd_FR_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TurnInd_Lt_On := %X\n", getValue( HMI_TurnInd_Lt_On ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TurnInd_RL_On_Rq := %X\n", getValue( HMI_TurnInd_RL_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TurnInd_RR_On_Rq := %X\n", getValue( HMI_TurnInd_RR_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TurnInd_Rt_On := %X\n", getValue( HMI_TurnInd_Rt_On ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TurnLmpOnDur := %X\n", getValue( HMI_TurnLmpOnDur ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tEL_TurnInd_Rq_AR
{
    putValue( HMI__STMSG_EL_TurnInd_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_EL_TurnInd_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_EL_TurnInd_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tEL_TurnInd_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_EL_TurnInd_Rq_AR, 0 );
    }
}

on EnvVar HMI__STMSP_EL_TurnInd_Rq_AR
{
/* HJH inserted VDO */
    _EL_TurnInd_Rq_AR_SpontanFlag = 1;
    if( getValue( this ) )
        putValue( this, 0 );
}

on envVar HMI__STMSG_PO_EL_TurnInd_Rq_AR
{
    if( getValue( this ) )
        openPanel("EL_TurnInd_Rq_AR");
}

on envVar HMI_E2E_EL_TurnInd_On_Rq_Inject
{
    if( getValue( this ) )
    {
        _EL_TurnInd_Rq_AR_CRC_ErrorCnt = getValue( HMI_CRC_EL_TurnInd_On_Rq_ErrorCount );
        _EL_TurnInd_Rq_AR_SQC_TriggPos = getValue( HMI_SQC_EL_TurnInd_On_Rq_TriggerPosition );
        _EL_TurnInd_Rq_AR_SQC_WrongSeqJump = getValue( HMI_SQC_EL_TurnInd_On_Rq_WrongSeq );
        _EL_TurnInd_Rq_AR_SQC_RepeatedCnt = getValue( HMI_SQC_EL_TurnInd_On_Rq_Repeated );
        _EL_TurnInd_Rq_AR_MSG_DropCnt = getValue( HMI_SQC_EL_TurnInd_On_Rq_MSG_DropCnt );
        putValue( HMI_E2E_EL_TurnInd_On_Rq_State, 2 );
        _EL_TurnInd_Rq_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_EF_Actv
{
    _mEL_TurnInd_Rq_AR.EF_Actv.phys = getValue(this);
//    _EL_TurnInd_Rq_AR_SpontanFlag = 1; use HMI__STMSP_EL_TurnInd_Rq_AR for transmission
}

on EnvVar HMI_Rsrv1_EL_TurnInd_On_Rq
{
    _mEL_TurnInd_Rq_AR.Rsrv1_EL_TurnInd_On_Rq.phys = getValue(this);
//    _EL_TurnInd_Rq_AR_SpontanFlag = 1; use HMI__STMSP_EL_TurnInd_Rq_AR for transmission
}

on EnvVar HMI_TurnInd_FL_On_Rq
{
    _mEL_TurnInd_Rq_AR.TurnInd_FL_On_Rq.phys = getValue(this);
//    _EL_TurnInd_Rq_AR_SpontanFlag = 1; use HMI__STMSP_EL_TurnInd_Rq_AR for transmission
}

on EnvVar HMI_TurnInd_FR_On_Rq
{
    _mEL_TurnInd_Rq_AR.TurnInd_FR_On_Rq.phys = getValue(this);
//    _EL_TurnInd_Rq_AR_SpontanFlag = 1; use HMI__STMSP_EL_TurnInd_Rq_AR for transmission
}

on EnvVar HMI_TurnInd_Lt_On
{
    _mEL_TurnInd_Rq_AR.TurnInd_Lt_On.phys = getValue(this);
//    _EL_TurnInd_Rq_AR_SpontanFlag = 1; use HMI__STMSP_EL_TurnInd_Rq_AR for transmission
}

on EnvVar HMI_TurnInd_RL_On_Rq
{
    _mEL_TurnInd_Rq_AR.TurnInd_RL_On_Rq.phys = getValue(this);
//    _EL_TurnInd_Rq_AR_SpontanFlag = 1; use HMI__STMSP_EL_TurnInd_Rq_AR for transmission
}

on EnvVar HMI_TurnInd_RR_On_Rq
{
    _mEL_TurnInd_Rq_AR.TurnInd_RR_On_Rq.phys = getValue(this);
//    _EL_TurnInd_Rq_AR_SpontanFlag = 1; use HMI__STMSP_EL_TurnInd_Rq_AR for transmission
}

on EnvVar HMI_TurnInd_Rt_On
{
    _mEL_TurnInd_Rq_AR.TurnInd_Rt_On.phys = getValue(this);
//    _EL_TurnInd_Rq_AR_SpontanFlag = 1; use HMI__STMSP_EL_TurnInd_Rq_AR for transmission
}

on EnvVar HMI_TurnLmpOnDur
{
    _mEL_TurnInd_Rq_AR.TurnLmpOnDur.phys = getValue(this);
//    _EL_TurnInd_Rq_AR_SpontanFlag = 1; use HMI__STMSP_EL_TurnInd_Rq_AR for transmission
}

Eng_Data_VAN_AR_check_output()
{
    if( !getValue( HMI__STMSG_Eng_Data_VAN_AR ) )
    {
    //  message   Eng_Data_VAN_AR ID: 1158 --- Sendeart 0 cyclicX --- 
        _Eng_Data_VAN_AR_Cnt--;
        if( _Eng_Data_VAN_AR_Cnt < 1 )
        {
            Eng_Data_VAN_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _Eng_Data_VAN_AR_Cnt = _Eng_Data_VAN_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

Eng_Data_VAN_AR_init()
{   /* Botschaft Eng_Data_VAN_AR ID: 1158 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 1158 0;
BA_ "NmAsrMessage" BO_ 1158 0;
BA_ "GenMsgMinAcceptLength" BO_ 1158 8;
BA_ "GenMsgILSupport" BO_ 1158 1;
BA_ "DiagState" BO_ 1158 0;
BA_ "DiagRequest" BO_ 1158 0;
BA_ "DiagResponse" BO_ 1158 0;
BA_ "GenMsgStartValue" BO_ 1158 "0";
BA_ "GenMsgCycleTime" BO_ 1158 1000;
BA_ "GenMsgSendType" BO_ 1158 0;
*/
    _Eng_Data_VAN_AR_Timebase =         c_tDBKomTimer_20ms;
    _Eng_Data_VAN_AR_CycleCount =   1000 / _Eng_Data_VAN_AR_Timebase;
    _Eng_Data_VAN_AR_StartDelay =      0 / _Eng_Data_VAN_AR_Timebase;
    _Eng_Data_VAN_AR_Cnt = _Eng_Data_VAN_AR_StartDelay;

    putValue( HMI__STMSGSD_Eng_Data_VAN_AR, _Eng_Data_VAN_AR_StartDelay * _Eng_Data_VAN_AR_Timebase );

    _mEng_Data_VAN_AR.DPF_ManRgnrt_Stat.phys = getValue( HMI_DPF_ManRgnrt_Stat );
    _mEng_Data_VAN_AR.DPF_SootLoad_Disp_Rq.phys = getValue( HMI_DPF_SootLoad_Disp_Rq );
}

Eng_Data_VAN_AR_output()
{
    output( _mEng_Data_VAN_AR );
}

Eng_Data_VAN_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Eng_Data_VAN_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Eng_Data_VAN_AR := %X\n", getValue( HMI__STMSG_Eng_Data_VAN_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Eng_Data_VAN_AR := %X\n", getValue( HMI__STMSGT_Eng_Data_VAN_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPF_ManRgnrt_Stat := %X\n", getValue( HMI_DPF_ManRgnrt_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPF_SootLoad_Disp_Rq := %X\n", getValue( HMI_DPF_SootLoad_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tEng_Data_VAN_AR
{
    putValue( HMI__STMSG_Eng_Data_VAN_AR, 0 );
}

on EnvVar HMI__STMSG_Eng_Data_VAN_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Eng_Data_VAN_AR );
        if( tDelay > 0)    
            setTimer( _tEng_Data_VAN_AR, tDelay );
        else
            putValue( HMI__STMSG_Eng_Data_VAN_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Eng_Data_VAN_AR
{
    if( getValue( this ) )
        openPanel("Eng_Data_VAN_AR");
}

on EnvVar HMI_DPF_ManRgnrt_Stat
{
    _mEng_Data_VAN_AR.DPF_ManRgnrt_Stat.phys = getValue(this);
}

on EnvVar HMI_DPF_SootLoad_Disp_Rq
{
    _mEng_Data_VAN_AR.DPF_SootLoad_Disp_Rq.phys = getValue(this);
}

Eng_Rs_EngCtrl_AR_check_output()
{
    if( !getValue( HMI__STMSG_Eng_Rs_EngCtrl_AR ) )
    {
    //  message   Eng_Rs_EngCtrl_AR ID: 177 --- Sendeart 0 cyclicX --- 
        _Eng_Rs_EngCtrl_AR_Cnt--;
        if( _Eng_Rs_EngCtrl_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            Eng_Rs_EngCtrl_AR_output();
            // Zyklus-Z�hler zur�cksetzen
            _Eng_Rs_EngCtrl_AR_Cnt = _Eng_Rs_EngCtrl_AR_CycleCount;
        }
    }
}

Eng_Rs_EngCtrl_AR_init()
{   /* Botschaft Eng_Rs_EngCtrl_AR ID: 177 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 177 0;
BA_ "NmAsrMessage" BO_ 177 0;
BA_ "GenMsgMinAcceptLength" BO_ 177 8;
BA_ "GenMsgILSupport" BO_ 177 1;
BA_ "DiagState" BO_ 177 0;
BA_ "DiagRequest" BO_ 177 0;
BA_ "DiagResponse" BO_ 177 0;
BA_ "GenMsgStartValue" BO_ 177 "0";
BA_ "GenMsgStartDelayTime" BO_ 177 0;
BA_ "GenMsgCycleTime" BO_ 177 10;
BA_ "GenMsgSendType" BO_ 177 0;
    */
    _Eng_Rs_EngCtrl_AR_Timebase =         c_tDBKomTimer_5ms;
    _Eng_Rs_EngCtrl_AR_CycleCount =     10 / _Eng_Rs_EngCtrl_AR_Timebase;
    _Eng_Rs_EngCtrl_AR_StartDelay =      0 / _Eng_Rs_EngCtrl_AR_Timebase;
    _Eng_Rs_EngCtrl_AR_Cnt = _Eng_Rs_EngCtrl_AR_StartDelay;

    putValue( HMI__STMSGSD_Eng_Rs_EngCtrl_AR, _Eng_Rs_EngCtrl_AR_StartDelay * _Eng_Rs_EngCtrl_AR_Timebase );

    _mEng_Rs_EngCtrl_AR.AddPwrCnsmr_On_Rq.phys = getValue( HMI_AddPwrCnsmr_On_Rq );
    _mEng_Rs_EngCtrl_AR.CRC_Eng_Rs_EngCtrl.phys = getValue( HMI_CRC_Eng_Rs_EngCtrl );
    _mEng_Rs_EngCtrl_AR.EngRPM.phys = getValue( HMI_EngRPM );
    _mEng_Rs_EngCtrl_AR.EngRPM_Sens_LHOM.phys = getValue( HMI_EngRPM_Sens_LHOM );
    _mEng_Rs_EngCtrl_AR.EngRun_Stat.phys = getValue( HMI_EngRun_Stat );
    _mEng_Rs_EngCtrl_AR.EngStyle.phys = getValue( HMI_EngStyle );
    _mEng_Rs_EngCtrl_AR.EngTrq.phys = getValue( HMI_EngTrq );
    _mEng_Rs_EngCtrl_AR.EngTrqLmtd_Misfire.phys = getValue( HMI_EngTrqLmtd_Misfire );
    _mEng_Rs_EngCtrl_AR.EngTrqMaxCorrFctr.phys = getValue( HMI_EngTrqMaxCorrFctr );
    _mEng_Rs_EngCtrl_AR.OFC_Stat_PT.phys = getValue( HMI_OFC_Stat_PT );
    _mEng_Rs_EngCtrl_AR.Rsrv2_Eng_Rs_EngCtrl.phys = getValue( HMI_Rsrv2_Eng_Rs_EngCtrl );
    _mEng_Rs_EngCtrl_AR.SQC_Eng_Rs_EngCtrl.phys = getValue( HMI_SQC_Eng_Rs_EngCtrl );
}

Eng_Rs_EngCtrl_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_Eng_Rs_EngCtrl ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_Eng_Rs_EngCtrl_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _Eng_Rs_EngCtrl_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _Eng_Rs_EngCtrl_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_Eng_Rs_EngCtrl_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _Eng_Rs_EngCtrl_AR_SQC_WrongSeqJump != 0 ) &&
            ( _Eng_Rs_EngCtrl_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _Eng_Rs_EngCtrl_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _Eng_Rs_EngCtrl_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _Eng_Rs_EngCtrl_AR_SQC_RepeatedCnt ) &&
            ( _Eng_Rs_EngCtrl_AR_E2E_Armed == 1  )    )
        {
            _Eng_Rs_EngCtrl_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_Eng_Rs_EngCtrl, SQC_help );
    }
    _mEng_Rs_EngCtrl_AR.SQC_Eng_Rs_EngCtrl = SQC_help;

    if( getValue( HMI_CRC_Eng_Rs_EngCtrl_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_Eng_Rs_EngCtrl_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mEng_Rs_EngCtrl_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mEng_Rs_EngCtrl_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mEng_Rs_EngCtrl_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mEng_Rs_EngCtrl_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mEng_Rs_EngCtrl_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mEng_Rs_EngCtrl_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mEng_Rs_EngCtrl_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mEng_Rs_EngCtrl_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _Eng_Rs_EngCtrl_AR_CRC_Offset[ _mEng_Rs_EngCtrl_AR.SQC_Eng_Rs_EngCtrl ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _Eng_Rs_EngCtrl_AR_CRC_ErrorCnt   && ( _Eng_Rs_EngCtrl_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Eng_Rs_EngCtrl_Invalid )                                         )    )
            {
                crc++;
                if( _Eng_Rs_EngCtrl_AR_CRC_ErrorCnt > 0 )
                    _Eng_Rs_EngCtrl_AR_CRC_ErrorCnt--; 
            }
            _mEng_Rs_EngCtrl_AR.CRC_Eng_Rs_EngCtrl = crc;
            putValue( HMI_CRC_Eng_Rs_EngCtrl, crc );
        }
        else
            _mEng_Rs_EngCtrl_AR.CRC_Eng_Rs_EngCtrl = getValue( HMI_CRC_Eng_Rs_EngCtrl );
    }
    else
    {
        if( !getValue( HMI_CRC_Eng_Rs_EngCtrl_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mEng_Rs_EngCtrl_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mEng_Rs_EngCtrl_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mEng_Rs_EngCtrl_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mEng_Rs_EngCtrl_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mEng_Rs_EngCtrl_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mEng_Rs_EngCtrl_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mEng_Rs_EngCtrl_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mEng_Rs_EngCtrl_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _Eng_Rs_EngCtrl_AR_CRC_ErrorCnt   && ( _Eng_Rs_EngCtrl_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Eng_Rs_EngCtrl_Invalid )                                         )    )
            {
                crc++;
                if( _Eng_Rs_EngCtrl_AR_CRC_ErrorCnt > 0 )
                    _Eng_Rs_EngCtrl_AR_CRC_ErrorCnt--; 
            }
            _mEng_Rs_EngCtrl_AR.CRC_Eng_Rs_EngCtrl = crc;
            putValue( HMI_CRC_Eng_Rs_EngCtrl, crc );
        }
        else
            _mEng_Rs_EngCtrl_AR.CRC_Eng_Rs_EngCtrl = getValue( HMI_CRC_Eng_Rs_EngCtrl );
    }
    if( ( _Eng_Rs_EngCtrl_AR_MSG_DropCnt > 0 ) &&
        ( _Eng_Rs_EngCtrl_AR_E2E_Armed == 1  )    )
    {
        _Eng_Rs_EngCtrl_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mEng_Rs_EngCtrl_AR );
        
    if( _Eng_Rs_EngCtrl_AR_E2E_Armed == 1 )
    {
        if ( ( _Eng_Rs_EngCtrl_AR_MSG_DropCnt == 0      ) &&
             ( _Eng_Rs_EngCtrl_AR_CRC_ErrorCnt == 0     ) &&
             ( _Eng_Rs_EngCtrl_AR_SQC_RepeatedCnt == 0  ) &&
             ( _Eng_Rs_EngCtrl_AR_SQC_WrongSeqJump == 0 )    )
        {
            _Eng_Rs_EngCtrl_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_Eng_Rs_EngCtrl_State, 0 );
        }
    }
}

Eng_Rs_EngCtrl_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Eng_Rs_EngCtrl_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Eng_Rs_EngCtrl_AR := %X\n", getValue( HMI__STMSG_Eng_Rs_EngCtrl_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Eng_Rs_EngCtrl_AR := %X\n", getValue( HMI__STMSGT_Eng_Rs_EngCtrl_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AddPwrCnsmr_On_Rq := %X\n", getValue( HMI_AddPwrCnsmr_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Eng_Rs_EngCtrl := %X\n", getValue( HMI_CRC_Eng_Rs_EngCtrl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Eng_Rs_EngCtrl_Auto := %X\n", getValue( HMI_CRC_Eng_Rs_EngCtrl_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngRPM := %X\n", getValue( HMI_EngRPM ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngRPM_Sens_LHOM := %X\n", getValue( HMI_EngRPM_Sens_LHOM ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngRun_Stat := %X\n", getValue( HMI_EngRun_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngStyle := %X\n", getValue( HMI_EngStyle ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngTrq := %X\n", getValue( HMI_EngTrq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngTrqLmtd_Misfire := %X\n", getValue( HMI_EngTrqLmtd_Misfire ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngTrqMaxCorrFctr := %X\n", getValue( HMI_EngTrqMaxCorrFctr ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_OFC_Stat_PT := %X\n", getValue( HMI_OFC_Stat_PT ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_Eng_Rs_EngCtrl := %X\n", getValue( HMI_Rsrv2_Eng_Rs_EngCtrl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Eng_Rs_EngCtrl := %X\n", getValue( HMI_SQC_Eng_Rs_EngCtrl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Eng_Rs_EngCtrl_Auto := %X\n", getValue( HMI_SQC_Eng_Rs_EngCtrl_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tEng_Rs_EngCtrl_AR
{
    putValue( HMI__STMSG_Eng_Rs_EngCtrl_AR, 0 );
}

on EnvVar HMI__STMSG_Eng_Rs_EngCtrl_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Eng_Rs_EngCtrl_AR );
        if( tDelay > 0)    
            setTimer( _tEng_Rs_EngCtrl_AR, tDelay );
        else
            putValue( HMI__STMSG_Eng_Rs_EngCtrl_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Eng_Rs_EngCtrl_AR
{
    if( getValue( this ) )
        openPanel("Eng_Rs_EngCtrl_AR");
}

on envVar HMI_E2E_Eng_Rs_EngCtrl_Inject
{
    if( getValue( this ) )
    {
        _Eng_Rs_EngCtrl_AR_CRC_ErrorCnt = getValue( HMI_CRC_Eng_Rs_EngCtrl_ErrorCount );
        _Eng_Rs_EngCtrl_AR_SQC_TriggPos = getValue( HMI_SQC_Eng_Rs_EngCtrl_TriggerPosition );
        _Eng_Rs_EngCtrl_AR_SQC_WrongSeqJump = getValue( HMI_SQC_Eng_Rs_EngCtrl_WrongSeq );
        _Eng_Rs_EngCtrl_AR_SQC_RepeatedCnt = getValue( HMI_SQC_Eng_Rs_EngCtrl_Repeated );
        _Eng_Rs_EngCtrl_AR_MSG_DropCnt = getValue( HMI_SQC_Eng_Rs_EngCtrl_MSG_DropCnt );
        putValue( HMI_E2E_Eng_Rs_EngCtrl_State, 2 );
        _Eng_Rs_EngCtrl_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_AddPwrCnsmr_On_Rq
{
    _mEng_Rs_EngCtrl_AR.AddPwrCnsmr_On_Rq.phys = getValue(this);
}

on EnvVar HMI_EngRPM
{
    _mEng_Rs_EngCtrl_AR.EngRPM.phys = getValue(this);
}

on EnvVar HMI_EngRPM_Sens_LHOM
{
    _mEng_Rs_EngCtrl_AR.EngRPM_Sens_LHOM.phys = getValue(this);
}

on EnvVar HMI_EngRun_Stat
{
    _mEng_Rs_EngCtrl_AR.EngRun_Stat.phys = getValue(this);
}

on EnvVar HMI_EngStyle
{
    _mEng_Rs_EngCtrl_AR.EngStyle.phys = getValue(this);
}

on EnvVar HMI_EngTrq
{
    _mEng_Rs_EngCtrl_AR.EngTrq.phys = getValue(this);
}

on EnvVar HMI_EngTrqLmtd_Misfire
{
    _mEng_Rs_EngCtrl_AR.EngTrqLmtd_Misfire.phys = getValue(this);
}

on EnvVar HMI_EngTrqMaxCorrFctr
{
    _mEng_Rs_EngCtrl_AR.EngTrqMaxCorrFctr.phys = getValue(this);
}

on EnvVar HMI_OFC_Stat_PT
{
    _mEng_Rs_EngCtrl_AR.OFC_Stat_PT.phys = getValue(this);
}

on EnvVar HMI_Rsrv2_Eng_Rs_EngCtrl
{
    _mEng_Rs_EngCtrl_AR.Rsrv2_Eng_Rs_EngCtrl.phys = getValue(this);
}

Eng_Rs2_AR_check_output()
{
    if( !getValue( HMI__STMSG_Eng_Rs2_AR ) )
    {
    //  message   Eng_Rs2_AR ID: 119 --- Sendeart 0 cyclicX --- 
        _Eng_Rs2_AR_Cnt--;
        if( _Eng_Rs2_AR_Cnt < 1 )
        {
            Eng_Rs2_AR_output();  // Nachricht wg. abgelaufenem Zyklus ausgeben
            _Eng_Rs2_AR_Cnt = _Eng_Rs2_AR_CycleCount;  // Zyklus-Z�hler zur�cksetzen
        }
    }
}

Eng_Rs2_AR_init()
{   /* Botschaft Eng_Rs2_AR ID: 119 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 119 0;
BA_ "NmAsrMessage" BO_ 119 0;
BA_ "GenMsgMinAcceptLength" BO_ 119 8;
BA_ "GenMsgILSupport" BO_ 119 1;
BA_ "DiagState" BO_ 119 0;
BA_ "DiagRequest" BO_ 119 0;
BA_ "DiagResponse" BO_ 119 0;
BA_ "GenMsgStartValue" BO_ 119 "0";
BA_ "GenMsgStartDelayTime" BO_ 119 0;
BA_ "GenMsgCycleTime" BO_ 119 20;
BA_ "GenMsgSendType" BO_ 119 0;
    */
    _Eng_Rs2_AR_Timebase =          c_tDBKomTimer_20ms;
    _Eng_Rs2_AR_CycleCount =       20 / _Eng_Rs2_AR_Timebase;
    _Eng_Rs2_AR_StartDelay =        0 / _Eng_Rs2_AR_Timebase;
    _Eng_Rs2_AR_Cnt = _Eng_Rs2_AR_StartDelay;

    putValue( HMI__STMSGSD_Eng_Rs2_AR, _Eng_Rs2_AR_StartDelay * _Eng_Rs2_AR_Timebase );

    _mEng_Rs2_AR.EngTrqMax.phys = getValue( HMI_EngTrqMax );
    _mEng_Rs2_AR.EngTrqMin.phys = getValue( HMI_EngTrqMin );
    _mEng_Rs2_AR.EngTrqStatic.phys = getValue( HMI_EngTrqStatic );
    _mEng_Rs2_AR.Rsrv1_Eng_Rs2.phys = getValue( HMI_Rsrv1_Eng_Rs2 );
    _mEng_Rs2_AR.Rsrv2_Eng_Rs2.phys = getValue( HMI_Rsrv2_Eng_Rs2 );
    _mEng_Rs2_AR.Rsrv3_Eng_Rs2.phys = getValue( HMI_Rsrv3_Eng_Rs2 );
    _mEng_Rs2_AR.Rsrv4_Eng_Rs2.phys = getValue( HMI_Rsrv4_Eng_Rs2 );
}

Eng_Rs2_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_Eng_Rs2 ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_Eng_Rs2_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _Eng_Rs2_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _Eng_Rs2_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_Eng_Rs2_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _Eng_Rs2_AR_SQC_WrongSeqJump != 0 ) &&
            ( _Eng_Rs2_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _Eng_Rs2_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _Eng_Rs2_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _Eng_Rs2_AR_SQC_RepeatedCnt ) &&
            ( _Eng_Rs2_AR_E2E_Armed == 1  )    )
        {
            _Eng_Rs2_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_Eng_Rs2, SQC_help );
    }
    _mEng_Rs2_AR.SQC_Eng_Rs2 = SQC_help;

    if( getValue( HMI_CRC_Eng_Rs2_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_Eng_Rs2_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mEng_Rs2_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mEng_Rs2_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mEng_Rs2_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mEng_Rs2_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mEng_Rs2_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mEng_Rs2_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mEng_Rs2_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mEng_Rs2_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _Eng_Rs2_AR_CRC_Offset[ _mEng_Rs2_AR.SQC_Eng_Rs2 ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _Eng_Rs2_AR_CRC_ErrorCnt   && ( _Eng_Rs2_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Eng_Rs2_Invalid )                                         )    )
            {
                crc++;
                if( _Eng_Rs2_AR_CRC_ErrorCnt > 0 )
                    _Eng_Rs2_AR_CRC_ErrorCnt--; 
            }
            _mEng_Rs2_AR.CRC_Eng_Rs2 = crc;
            putValue( HMI_CRC_Eng_Rs2, crc );
        }
        else
            _mEng_Rs2_AR.CRC_Eng_Rs2 = getValue( HMI_CRC_Eng_Rs2 );
    }
    else
    {
        if( !getValue( HMI_CRC_Eng_Rs2_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mEng_Rs2_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mEng_Rs2_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mEng_Rs2_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mEng_Rs2_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mEng_Rs2_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mEng_Rs2_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mEng_Rs2_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mEng_Rs2_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _Eng_Rs2_AR_CRC_ErrorCnt   && ( _Eng_Rs2_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Eng_Rs2_Invalid )                                         )    )
            {
                crc++;
                if( _Eng_Rs2_AR_CRC_ErrorCnt > 0 )
                    _Eng_Rs2_AR_CRC_ErrorCnt--; 
            }
            _mEng_Rs2_AR.CRC_Eng_Rs2 = crc;
            putValue( HMI_CRC_Eng_Rs2, crc );
        }
        else
            _mEng_Rs2_AR.CRC_Eng_Rs2 = getValue( HMI_CRC_Eng_Rs2 );
    }
    if( ( _Eng_Rs2_AR_MSG_DropCnt > 0 ) &&
        ( _Eng_Rs2_AR_E2E_Armed == 1  )    )
    {
        _Eng_Rs2_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mEng_Rs2_AR );
        
    if( _Eng_Rs2_AR_E2E_Armed == 1 )
    {
        if ( ( _Eng_Rs2_AR_MSG_DropCnt == 0      ) &&
             ( _Eng_Rs2_AR_CRC_ErrorCnt == 0     ) &&
             ( _Eng_Rs2_AR_SQC_RepeatedCnt == 0  ) &&
             ( _Eng_Rs2_AR_SQC_WrongSeqJump == 0 )    )
        {
            _Eng_Rs2_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_Eng_Rs2_State, 0 );
        }
    }
}

Eng_Rs2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Eng_Rs2_AR\n", 24, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Eng_Rs2_AR := %X\n", getValue( HMI__STMSG_Eng_Rs2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Eng_Rs2_AR := %X\n", getValue( HMI__STMSGT_Eng_Rs2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Eng_Rs2 := %X\n", getValue( HMI_CRC_Eng_Rs2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Eng_Rs2_Auto := %X\n", getValue( HMI_CRC_Eng_Rs2_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngTrqMax := %X\n", getValue( HMI_EngTrqMax ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngTrqMin := %X\n", getValue( HMI_EngTrqMin ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngTrqStatic := %X\n", getValue( HMI_EngTrqStatic ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_Eng_Rs2 := %X\n", getValue( HMI_Rsrv1_Eng_Rs2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_Eng_Rs2 := %X\n", getValue( HMI_Rsrv2_Eng_Rs2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv3_Eng_Rs2 := %X\n", getValue( HMI_Rsrv3_Eng_Rs2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv4_Eng_Rs2 := %X\n", getValue( HMI_Rsrv4_Eng_Rs2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Eng_Rs2 := %X\n", getValue( HMI_SQC_Eng_Rs2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Eng_Rs2_Auto := %X\n", getValue( HMI_SQC_Eng_Rs2_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tEng_Rs2_AR
{
    putValue( HMI__STMSG_Eng_Rs2_AR, 0 );
}

on EnvVar HMI__STMSG_Eng_Rs2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Eng_Rs2_AR );
        if( tDelay > 0)    
            setTimer( _tEng_Rs2_AR, tDelay );
        else
            putValue( HMI__STMSG_Eng_Rs2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Eng_Rs2_AR
{
    if( getValue( this ) )
        openPanel("Eng_Rs2_AR");
}

on envVar HMI_E2E_Eng_Rs2_Inject
{
    if( getValue( this ) )
    {
        _Eng_Rs2_AR_CRC_ErrorCnt = getValue( HMI_CRC_Eng_Rs2_ErrorCount );
        _Eng_Rs2_AR_SQC_TriggPos = getValue( HMI_SQC_Eng_Rs2_TriggerPosition );
        _Eng_Rs2_AR_SQC_WrongSeqJump = getValue( HMI_SQC_Eng_Rs2_WrongSeq );
        _Eng_Rs2_AR_SQC_RepeatedCnt = getValue( HMI_SQC_Eng_Rs2_Repeated );
        _Eng_Rs2_AR_MSG_DropCnt = getValue( HMI_SQC_Eng_Rs2_MSG_DropCnt );
        putValue( HMI_E2E_Eng_Rs2_State, 2 );
        _Eng_Rs2_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_EngTrqMax
{
    _mEng_Rs2_AR.EngTrqMax.phys = getValue(this);
}

on EnvVar HMI_EngTrqMin
{
    _mEng_Rs2_AR.EngTrqMin.phys = getValue(this);
}

on EnvVar HMI_EngTrqStatic
{
    _mEng_Rs2_AR.EngTrqStatic.phys = getValue(this);
}

on EnvVar HMI_Rsrv1_Eng_Rs2
{
    _mEng_Rs2_AR.Rsrv1_Eng_Rs2.phys = getValue(this);
}

on EnvVar HMI_Rsrv2_Eng_Rs2
{
    _mEng_Rs2_AR.Rsrv2_Eng_Rs2.phys = getValue(this);
}

on EnvVar HMI_Rsrv3_Eng_Rs2
{
    _mEng_Rs2_AR.Rsrv3_Eng_Rs2.phys = getValue(this);
}

on EnvVar HMI_Rsrv4_Eng_Rs2
{
    _mEng_Rs2_AR.Rsrv4_Eng_Rs2.phys = getValue(this);
}

EngCtrl_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_EngCtrl_Disp_Rq_AR ) )
    {
    //  message   EngCtrl_Disp_Rq_AR ID: 327 --- Sendeart 0 cyclicX --- 
        _EngCtrl_Disp_Rq_AR_Cnt--;
        if( _EngCtrl_Disp_Rq_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            EngCtrl_Disp_Rq_AR_output();
            // Zyklus-Z�hler zur�cksetzen
            _EngCtrl_Disp_Rq_AR_Cnt = _EngCtrl_Disp_Rq_AR_CycleCount;
        }
    }
}

EngCtrl_Disp_Rq_AR_init()
{   /* Botschaft EngCtrl_Disp_Rq_AR ID: 327 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 327 0;
BA_ "NmAsrMessage" BO_ 327 0;
BA_ "GenMsgMinAcceptLength" BO_ 327 8;
BA_ "GenMsgILSupport" BO_ 327 1;
BA_ "DiagState" BO_ 327 0;
BA_ "DiagRequest" BO_ 327 0;
BA_ "DiagResponse" BO_ 327 0;
BA_ "GenMsgStartValue" BO_ 327 "0";
BA_ "GenMsgStartDelayTime" BO_ 327 0;
BA_ "GenMsgCycleTime" BO_ 327 100;
BA_ "GenMsgSendType" BO_ 327 0;
    */
    _EngCtrl_Disp_Rq_AR_Timebase =        c_tDBKomTimer_20ms;
    _EngCtrl_Disp_Rq_AR_CycleCount =    100 / _EngCtrl_Disp_Rq_AR_Timebase;
    _EngCtrl_Disp_Rq_AR_StartDelay =      0 / _EngCtrl_Disp_Rq_AR_Timebase;
    _EngCtrl_Disp_Rq_AR_Cnt = _EngCtrl_Disp_Rq_AR_StartDelay;

    putValue( HMI__STMSGSD_EngCtrl_Disp_Rq_AR, _EngCtrl_Disp_Rq_AR_StartDelay * _EngCtrl_Disp_Rq_AR_Timebase );

    _mEngCtrl_Disp_Rq_AR.AirStrIndLmp_On_Rq.phys = getValue( HMI_AirStrIndLmp_On_Rq );
    _mEngCtrl_Disp_Rq_AR.BoostPress_Disp_Rq.phys = getValue( HMI_BoostPress_Disp_Rq );
    _mEngCtrl_Disp_Rq_AR.DAC_StErr.phys = getValue( HMI_DAC_StErr );
    _mEngCtrl_Disp_Rq_AR.EngCoolTemp_Disp_Rq.phys = getValue( HMI_EngCoolTemp_Disp_Rq );
    _mEngCtrl_Disp_Rq_AR.EngIdleRPM_Dsr.phys = getValue( HMI_EngIdleRPM_Dsr );
    _mEngCtrl_Disp_Rq_AR.EngOilIndLmp_On_Rq.phys = getValue( HMI_EngOilIndLmp_On_Rq );
    _mEngCtrl_Disp_Rq_AR.EngOilLvl_Sens_Foam_Dtct.phys = getValue( HMI_EngOilLvl_Sens_Foam_Dtct );
    _mEngCtrl_Disp_Rq_AR.EngOilLvl_Sens_LowTemp_Dtct.phys = getValue( HMI_EngOilLvl_Sens_LowTemp_Dtct );
    _mEngCtrl_Disp_Rq_AR.EngOilLvl_V2.phys = getValue( HMI_EngOilLvl_V2 );
    _mEngCtrl_Disp_Rq_AR.EngOilPress_Disp_Rq.phys = getValue( HMI_EngOilPress_Disp_Rq );
    _mEngCtrl_Disp_Rq_AR.EngOilTemp_Above_Max.phys = getValue( HMI_EngOilTemp_Above_Max );
    _mEngCtrl_Disp_Rq_AR.MIL_On_Rq.phys = getValue( HMI_MIL_On_Rq );
    _mEngCtrl_Disp_Rq_AR.OvrRPM_Actv.phys = getValue( HMI_OvrRPM_Actv );
    _mEngCtrl_Disp_Rq_AR.ParticleFltrWarn.phys = getValue( HMI_ParticleFltrWarn );
    _mEngCtrl_Disp_Rq_AR.PreHtIndLmp_On_Rq.phys = getValue( HMI_PreHtIndLmp_On_Rq );
    _mEngCtrl_Disp_Rq_AR.TankCapIndLmp_On_Rq.phys = getValue( HMI_TankCapIndLmp_On_Rq );
    _mEngCtrl_Disp_Rq_AR.TankPressCtrlDisp_Rq.phys = getValue( HMI_TankPressCtrlDisp_Rq );
    _mEngCtrl_Disp_Rq_AR.WtrFuelIndLmp_On_Rq.phys = getValue( HMI_WtrFuelIndLmp_On_Rq );  
    _mEngCtrl_Disp_Rq_AR.EngFlt_Warn_Disp_Rq.phys = getValue( HMI_EngFlt_Warn_Disp_Rq );
    _mEngCtrl_Disp_Rq_AR.EngStop_Warn_Disp_Rq.phys = getValue( HMI_EngStop_Warn_Disp_Rq );
}

EngCtrl_Disp_Rq_AR_output(void)
{
    output( _mEngCtrl_Disp_Rq_AR );
}

EngCtrl_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: EngCtrl_Disp_Rq_AR\n", 32, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_EngCtrl_Disp_Rq := %X\n", getValue( HMI__STMSG_EngCtrl_Disp_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_EngCtrl_Disp_Rq := %X\n", getValue( HMI__STMSGT_EngCtrl_Disp_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AirStrIndLmp_On_Rq := %X\n", getValue( HMI_AirStrIndLmp_On_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BoostPress_Disp_Rq := %X\n", getValue( HMI_BoostPress_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DAC_StErr := %X\n", getValue( HMI_DAC_StErr ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngCoolTemp_Disp_Rq := %X\n", getValue( HMI_EngCoolTemp_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngIdleRPM_Dsr := %X\n", getValue( HMI_EngIdleRPM_Dsr ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngOilIndLmp_On_Rq := %X\n", getValue( HMI_EngOilIndLmp_On_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngOilLvl_Sens_Foam_Dtct := %X\n", getValue( HMI_EngOilLvl_Sens_Foam_Dtct ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngOilLvl_Sens_LowTemp_Dtct := %X\n", getValue( HMI_EngOilLvl_Sens_LowTemp_Dtct ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngOilLvl_V2 := %X\n", getValue( HMI_EngOilLvl_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngOilPress_Disp_Rq := %X\n", getValue( HMI_EngOilPress_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngOilTemp_Above_Max := %X\n", getValue( HMI_EngOilTemp_Above_Max ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MIL_On_Rq := %X\n", getValue( HMI_MIL_On_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_OvrRPM_Actv := %X\n", getValue( HMI_OvrRPM_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ParticleFltrWarn := %X\n", getValue( HMI_ParticleFltrWarn ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PreHtIndLmp_On_Rq := %X\n", getValue( HMI_PreHtIndLmp_On_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TankCapIndLmp_On_Rq := %X\n", getValue( HMI_TankCapIndLmp_On_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TankPressCtrlDisp_Rq := %X\n", getValue( HMI_TankPressCtrlDisp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WtrFuelIndLmp_On_Rq := %X\n", getValue( HMI_WtrFuelIndLmp_On_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );

    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngFlt_Warn_Disp_Rq := %X\n", getValue( HMI_EngFlt_Warn_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngStop_Warn_Disp_Rq := %X\n", getValue( HMI_EngStop_Warn_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tEngCtrl_Disp_Rq_AR
{
    putValue( HMI__STMSG_EngCtrl_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_EngCtrl_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_EngCtrl_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tEngCtrl_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_EngCtrl_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_EngCtrl_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("EngCtrl_Disp_Rq_AR");
}

on EnvVar HMI_AirStrIndLmp_On_Rq
{
    _mEngCtrl_Disp_Rq_AR.AirStrIndLmp_On_Rq.phys = getValue(this);
}

on EnvVar HMI_BoostPress_Disp_Rq
{
    _mEngCtrl_Disp_Rq_AR.BoostPress_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_DAC_StErr
{
    _mEngCtrl_Disp_Rq_AR.DAC_StErr.phys = getValue(this);
}

on EnvVar HMI_EngCoolTemp_Disp_Rq
{
    _mEngCtrl_Disp_Rq_AR.EngCoolTemp_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_EngIdleRPM_Dsr
{
    _mEngCtrl_Disp_Rq_AR.EngIdleRPM_Dsr.phys = getValue(this);
}

on EnvVar HMI_EngOilIndLmp_On_Rq
{
    _mEngCtrl_Disp_Rq_AR.EngOilIndLmp_On_Rq.phys = getValue(this);
}

on EnvVar HMI_EngOilLvl_Sens_Foam_Dtct
{
    _mEngCtrl_Disp_Rq_AR.EngOilLvl_Sens_Foam_Dtct.phys = getValue(this);
}

on EnvVar HMI_EngOilLvl_Sens_LowTemp_Dtct
{
    _mEngCtrl_Disp_Rq_AR.EngOilLvl_Sens_LowTemp_Dtct.phys = getValue(this);
}

on EnvVar HMI_EngOilLvl_V2
{
    _mEngCtrl_Disp_Rq_AR.EngOilLvl_V2.phys = getValue(this);
}

on EnvVar HMI_EngOilPress_Disp_Rq
{
    _mEngCtrl_Disp_Rq_AR.EngOilPress_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_EngOilTemp_Above_Max
{
    _mEngCtrl_Disp_Rq_AR.EngOilTemp_Above_Max.phys = getValue(this);
}

on EnvVar HMI_MIL_On_Rq
{
    _mEngCtrl_Disp_Rq_AR.MIL_On_Rq.phys = getValue(this);
}

on EnvVar HMI_OvrRPM_Actv
{
    _mEngCtrl_Disp_Rq_AR.OvrRPM_Actv.phys = getValue(this);
}

on EnvVar HMI_ParticleFltrWarn
{
    _mEngCtrl_Disp_Rq_AR.ParticleFltrWarn.phys = getValue(this);
}

on EnvVar HMI_PreHtIndLmp_On_Rq
{
    _mEngCtrl_Disp_Rq_AR.PreHtIndLmp_On_Rq.phys = getValue(this);
}

on EnvVar HMI_TankCapIndLmp_On_Rq
{
    _mEngCtrl_Disp_Rq_AR.TankCapIndLmp_On_Rq.phys = getValue(this);
}

on EnvVar HMI_TankPressCtrlDisp_Rq
{
    _mEngCtrl_Disp_Rq_AR.TankPressCtrlDisp_Rq.phys = getValue(this);
}

on EnvVar HMI_WtrFuelIndLmp_On_Rq
{
    _mEngCtrl_Disp_Rq_AR.WtrFuelIndLmp_On_Rq.phys = getValue(this);
}

on EnvVar HMI_EngFlt_Warn_Disp_Rq
{
    _mEngCtrl_Disp_Rq_AR.EngFlt_Warn_Disp_Rq.phys = getValue(this);
}

on EnvVar HMI_EngStop_Warn_Disp_Rq
{
    _mEngCtrl_Disp_Rq_AR.EngStop_Warn_Disp_Rq.phys = getValue(this);
}

EngCtrl_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_EngCtrl_Stat_AR ) )
    {
    //  message   EngCtrl_Stat_AR ID: 697 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _EngCtrl_Stat_AR_Cnt--;
        if( _EngCtrl_Stat_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            EngCtrl_Stat_AR_output();
            _EngCtrl_Stat_AR_Cnt = _EngCtrl_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _EngCtrl_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _EngCtrl_Stat_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            EngCtrl_Stat_AR_output();
            _EngCtrl_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

EngCtrl_Stat_AR_init()
{   /* Botschaft EngCtrl_Stat_AR ID: 697 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 697 0;
BA_ "NmAsrMessage" BO_ 697 0;
BA_ "GenMsgMinAcceptLength" BO_ 697 8;
BA_ "GenMsgILSupport" BO_ 697 1;
BA_ "DiagState" BO_ 697 0;
BA_ "DiagRequest" BO_ 697 0;
BA_ "DiagResponse" BO_ 697 0;
BA_ "GenMsgStartValue" BO_ 697 "0";
BA_ "GenMsgDelayTime" BO_ 697 20;
BA_ "GenMsgNrOfRepetitions" BO_ 697 0;
BA_ "GenMsgCycleTime" BO_ 697 100;
BA_ "GenMsgSendType" BO_ 697 5;
    */
    _EngCtrl_Stat_AR_Timebase =           c_tDBKomTimer_20ms;
    _EngCtrl_Stat_AR_CycleCount =       100 / _EngCtrl_Stat_AR_Timebase;
    _EngCtrl_Stat_AR_StartDelay =         0 / _EngCtrl_Stat_AR_Timebase;
    _EngCtrl_Stat_AR_Cnt = _EngCtrl_Stat_AR_StartDelay;
    _EngCtrl_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_EngCtrl_Stat_AR, _EngCtrl_Stat_AR_StartDelay * _EngCtrl_Stat_AR_Timebase );

    _mEngCtrl_Stat_AR.AirPress_Outsd.phys = getValue( HMI_AirPress_Outsd );
    _mEngCtrl_Stat_AR.CylCutoff_Stat.phys = getValue( HMI_CylCutoff_Stat );
    _mEngCtrl_Stat_AR.EngCoolTemp.phys = getValue( HMI_EngCoolTemp );
    _mEngCtrl_Stat_AR.EngOilQual.phys = getValue( HMI_EngOilQual );
    _mEngCtrl_Stat_AR.FuelCons.phys = getValue( HMI_FuelCons );
    _mEngCtrl_Stat_AR.IntkAirTemp.phys = getValue( HMI_IntkAirTemp );
    _mEngCtrl_Stat_AR.PN14_EHC_Prio_Rq.phys = getValue( HMI_PN14_EHC_Prio_Rq );
    _mEngCtrl_Stat_AR.PreHt_Stat.phys = getValue( HMI_PreHt_Stat );
    _mEngCtrl_Stat_AR.Eng_CrkCsVent_Stat.phys = getValue( HMI_Eng_CrkCsVent_Stat );
    _mEngCtrl_Stat_AR.Eng_OprtnMd_V2.phys = getValue( HMI_Eng_OprtnMd_V2 );
    _mEngCtrl_Stat_AR.ECM_OBD_ErrMemClr_Trgr.phys = getValue( HMI_ECM_OBD_ErrMemClr_Trgr );
}

EngCtrl_Stat_AR_output(void)
{
    output( _mEngCtrl_Stat_AR );
}

EngCtrl_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: EngCtrl_Stat_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_EngCtrl_Stat := %X\n", getValue( HMI__STMSG_EngCtrl_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_EngCtrl_Stat := %X\n", getValue( HMI__STMSGT_EngCtrl_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AirPress_Outsd := %X\n", getValue( HMI_AirPress_Outsd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CylCutoff_Stat := %X\n", getValue( HMI_CylCutoff_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngCoolTemp := %X\n", getValue( HMI_EngCoolTemp ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EngOilQual := %X\n", getValue( HMI_EngOilQual ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FuelCons := %X\n", getValue( HMI_FuelCons ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IntkAirTemp := %X\n", getValue( HMI_IntkAirTemp ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_EHC_Prio_Rq := %X\n", getValue( HMI_PN14_EHC_Prio_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PreHt_Stat := %X\n", getValue( HMI_PreHt_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Eng_CrkCsVent_Stat := %X\n", getValue( HMI_Eng_CrkCsVent_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_Eng_OprtnMd_V2 := %X\n", getValue( HMI_Eng_OprtnMd_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ECM_OBD_ErrMemClr_Trgr := %X\n", getValue( HMI_ECM_OBD_ErrMemClr_Trgr ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tEngCtrl_Stat_AR
{
    putValue( HMI__STMSG_EngCtrl_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_EngCtrl_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_EngCtrl_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tEngCtrl_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_EngCtrl_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_EngCtrl_Stat_AR
{
    if( getValue( this ) )
        openPanel("EngCtrl_Stat_AR");
}

on EnvVar HMI_AirPress_Outsd
{
    _mEngCtrl_Stat_AR.AirPress_Outsd.phys = getValue(this);
    _EngCtrl_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_CylCutoff_Stat
{
    _mEngCtrl_Stat_AR.CylCutoff_Stat.phys = getValue(this);
    _EngCtrl_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_EngCoolTemp
{
    _mEngCtrl_Stat_AR.EngCoolTemp.phys = getValue(this);
    _EngCtrl_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_EngOilQual
{
    _mEngCtrl_Stat_AR.EngOilQual.phys = getValue(this);
    _EngCtrl_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FuelCons
{
    _mEngCtrl_Stat_AR.FuelCons.phys = getValue(this);
    _EngCtrl_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_IntkAirTemp
{
    _mEngCtrl_Stat_AR.IntkAirTemp.phys = getValue(this);
    _EngCtrl_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_EHC_Prio_Rq
{
    _mEngCtrl_Stat_AR.PN14_EHC_Prio_Rq.phys = getValue(this);
    _EngCtrl_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PreHt_Stat
{
    _mEngCtrl_Stat_AR.PreHt_Stat.phys = getValue(this);
    _EngCtrl_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Eng_CrkCsVent_Stat
{
    _mEngCtrl_Stat_AR.Eng_CrkCsVent_Stat.phys = getValue(this);
    _EngCtrl_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Eng_OprtnMd_V2
{
    _mEngCtrl_Stat_AR.Eng_OprtnMd_V2.phys = getValue(this);
    _EngCtrl_Stat_AR_SpontanFlag = 1;
}



on EnvVar HMI_ECM_OBD_ErrMemClr_Trgr
{
    _mEngCtrl_Stat_AR.ECM_OBD_ErrMemClr_Trgr.phys = getValue(this);
    _EngCtrl_Stat_AR_SpontanFlag = 1;
}
EPKB_Disp_IndLmp_Rq_2_AR_check_output()
{
    if( !getValue( HMI__STMSG_EPKB_Disp_IndLmp_Rq_2_AR ) )
    {
    //  message   EPKB_Disp_IndLmp_Rq_2_AR ID: 1041 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _EPKB_Disp_IndLmp_Rq_2_AR_Cnt--;
        if( _EPKB_Disp_IndLmp_Rq_2_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
             EPKB_Disp_IndLmp_Rq_2_AR_output();
            _EPKB_Disp_IndLmp_Rq_2_AR_Cnt = _EPKB_Disp_IndLmp_Rq_2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _EPKB_Disp_IndLmp_Rq_2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _EPKB_Disp_IndLmp_Rq_2_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            EPKB_Disp_IndLmp_Rq_2_AR_output();
            _EPKB_Disp_IndLmp_Rq_2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

EPKB_Disp_IndLmp_Rq_2_AR_init()
{   /* Botschaft EPKB_Disp_IndLmp_Rq_2_AR ID: 1041 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1041 0;
BA_ "NmAsrMessage" BO_ 1041 0;
BA_ "GenMsgMinAcceptLength" BO_ 1041 4;
BA_ "GenMsgILSupport" BO_ 1041 1;
BA_ "DiagState" BO_ 1041 0;
BA_ "DiagRequest" BO_ 1041 0;
BA_ "DiagResponse" BO_ 1041 0;
BA_ "GenMsgStartValue" BO_ 1041 "0";
BA_ "GenMsgStartDelayTime" BO_ 1041 0;
BA_ "GenMsgDelayTime" BO_ 1041 5;
BA_ "GenMsgNrOfRepetitions" BO_ 1041 0;
BA_ "GenMsgCycleTime" BO_ 1041 200;
BA_ "GenMsgSendType" BO_ 1041 5;
    */
    _EPKB_Disp_IndLmp_Rq_2_AR_Timebase =        c_tDBKomTimer_20ms;
    _EPKB_Disp_IndLmp_Rq_2_AR_CycleCount =    200 / _EPKB_Disp_IndLmp_Rq_2_AR_Timebase;
    _EPKB_Disp_IndLmp_Rq_2_AR_StartDelay =      0 / _EPKB_Disp_IndLmp_Rq_2_AR_Timebase;
    _EPKB_Disp_IndLmp_Rq_2_AR_Cnt = _EPKB_Disp_IndLmp_Rq_2_AR_StartDelay;
    _EPKB_Disp_IndLmp_Rq_2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_EPKB_Disp_IndLmp_Rq_2_AR, _EPKB_Disp_IndLmp_Rq_2_AR_StartDelay * _EPKB_Disp_IndLmp_Rq_2_AR_Timebase );

    _mEPKB_Disp_IndLmp_Rq_2_AR.BrkIndLmp_On_Rq_EPkB.phys = getValue( HMI_BrkIndLmp_On_Rq_EPkB );
    _mEPKB_Disp_IndLmp_Rq_2_AR.BrkLnServMd_MsgDisp_Rq.phys = getValue( HMI_BrkLnServMd_MsgDisp_Rq );
    _mEPKB_Disp_IndLmp_Rq_2_AR.EPKB_Msg_Disp_Rq.phys = getValue( HMI_EPKB_Msg_Disp_Rq );
    _mEPKB_Disp_IndLmp_Rq_2_AR.EPKB_Msg_Disp_TrgrRq.phys = getValue( HMI_EPKB_Msg_Disp_TrgrRq );
    _mEPKB_Disp_IndLmp_Rq_2_AR.PkBrkIndLmp_On_Rq.phys = getValue( HMI_PkBrkIndLmp_On_Rq );
    _mEPKB_Disp_IndLmp_Rq_2_AR.Rsrv1_EPKB_Disp_IndLmp_Rq.phys = getValue( HMI_Rsrv1_EPKB_Disp_IndLmp_Rq );
}

EPKB_Disp_IndLmp_Rq_2_AR_output()
{
    byte crc;
    byte SQC_help;
    byte dataId = 0x1F;

    SQC_help = getValue( HMI_SQC_EPKB_Disp_IndLmp_Rq ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_EPKB_Disp_IndLmp_Rq_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _EPKB_Disp_IndLmp_Rq_2_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _EPKB_Disp_IndLmp_Rq_2_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_EPKB_Disp_IndLmp_Rq_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _EPKB_Disp_IndLmp_Rq_2_AR_SQC_WrongSeqJump != 0 ) &&
            ( _EPKB_Disp_IndLmp_Rq_2_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _EPKB_Disp_IndLmp_Rq_2_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _EPKB_Disp_IndLmp_Rq_2_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _EPKB_Disp_IndLmp_Rq_2_AR_SQC_RepeatedCnt ) &&
            ( _EPKB_Disp_IndLmp_Rq_2_AR_E2E_Armed == 1  )    )
        {
            _EPKB_Disp_IndLmp_Rq_2_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_EPKB_Disp_IndLmp_Rq, SQC_help );
    }
    _mEPKB_Disp_IndLmp_Rq_2_AR.SQC_EPKB_Disp_IndLmp_Rq = SQC_help;

    if( getValue( HMI_CRC_EPKB_Disp_IndLmp_Rq_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_EPKB_Disp_IndLmp_Rq_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mEPKB_Disp_IndLmp_Rq_2_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mEPKB_Disp_IndLmp_Rq_2_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mEPKB_Disp_IndLmp_Rq_2_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mEPKB_Disp_IndLmp_Rq_2_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mEPKB_Disp_IndLmp_Rq_2_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mEPKB_Disp_IndLmp_Rq_2_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mEPKB_Disp_IndLmp_Rq_2_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mEPKB_Disp_IndLmp_Rq_2_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _EPKB_Disp_IndLmp_Rq_2_AR_CRC_Offset[ _mEPKB_Disp_IndLmp_Rq_2_AR.SQC_EPKB_Disp_IndLmp_Rq ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _EPKB_Disp_IndLmp_Rq_2_AR_CRC_ErrorCnt   && ( _EPKB_Disp_IndLmp_Rq_2_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EPKB_Disp_IndLmp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _EPKB_Disp_IndLmp_Rq_2_AR_CRC_ErrorCnt > 0 )
                    _EPKB_Disp_IndLmp_Rq_2_AR_CRC_ErrorCnt--; 
            }
            _mEPKB_Disp_IndLmp_Rq_2_AR.CRC_EPKB_Disp_IndLmp_Rq = crc;
            putValue( HMI_CRC_EPKB_Disp_IndLmp_Rq, crc );
        }
        else
            _mEPKB_Disp_IndLmp_Rq_2_AR.CRC_EPKB_Disp_IndLmp_Rq = getValue( HMI_CRC_EPKB_Disp_IndLmp_Rq );
    }
    else
    {
        if( !getValue( HMI_CRC_EPKB_Disp_IndLmp_Rq_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mEPKB_Disp_IndLmp_Rq_2_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mEPKB_Disp_IndLmp_Rq_2_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mEPKB_Disp_IndLmp_Rq_2_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mEPKB_Disp_IndLmp_Rq_2_AR.byte( 3 ) ];
//            crc = crctable[ crc ^ _mEPKB_Disp_IndLmp_Rq_2_AR.byte( 4 ) ];
//            crc = crctable[ crc ^ _mEPKB_Disp_IndLmp_Rq_2_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mEPKB_Disp_IndLmp_Rq_2_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mEPKB_Disp_IndLmp_Rq_2_AR.byte( 7 ) ];
            crc = crctable[ crc ^ dataId ];
            crc = (crc ^ 0xFF);
            if( ( _EPKB_Disp_IndLmp_Rq_2_AR_CRC_ErrorCnt   && ( _EPKB_Disp_IndLmp_Rq_2_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EPKB_Disp_IndLmp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _EPKB_Disp_IndLmp_Rq_2_AR_CRC_ErrorCnt > 0 )
                    _EPKB_Disp_IndLmp_Rq_2_AR_CRC_ErrorCnt--; 
            }
            _mEPKB_Disp_IndLmp_Rq_2_AR.CRC_EPKB_Disp_IndLmp_Rq = crc;
            putValue( HMI_CRC_EPKB_Disp_IndLmp_Rq, crc );
        }
        else
            _mEPKB_Disp_IndLmp_Rq_2_AR.CRC_EPKB_Disp_IndLmp_Rq = getValue( HMI_CRC_EPKB_Disp_IndLmp_Rq );
    }
    if( ( _EPKB_Disp_IndLmp_Rq_2_AR_MSG_DropCnt > 0 ) &&
        ( _EPKB_Disp_IndLmp_Rq_2_AR_E2E_Armed == 1  )    )
    {
        _EPKB_Disp_IndLmp_Rq_2_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mEPKB_Disp_IndLmp_Rq_2_AR );
        
    if( _EPKB_Disp_IndLmp_Rq_2_AR_E2E_Armed == 1 )
    {
        if ( ( _EPKB_Disp_IndLmp_Rq_2_AR_MSG_DropCnt == 0      ) &&
             ( _EPKB_Disp_IndLmp_Rq_2_AR_CRC_ErrorCnt == 0     ) &&
             ( _EPKB_Disp_IndLmp_Rq_2_AR_SQC_RepeatedCnt == 0  ) &&
             ( _EPKB_Disp_IndLmp_Rq_2_AR_SQC_WrongSeqJump == 0 )    )
        {
            _EPKB_Disp_IndLmp_Rq_2_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_EPKB_Disp_IndLmp_Rq_State, 0 );
        }
    }
}

EPKB_Disp_IndLmp_Rq_2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: EPKB_Disp_IndLmp_Rq_AR \n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_EPKB_Disp_IndLmp_Rq_2_AR := %X\n", getValue( HMI__STMSG_EPKB_Disp_IndLmp_Rq_2_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_EPKB_Disp_IndLmp_Rq_2_AR := %X\n", getValue( HMI__STMSGT_EPKB_Disp_IndLmp_Rq_2_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkIndLmp_On_Rq_EPkB := %X\n", getValue( HMI_BrkIndLmp_On_Rq_EPkB ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkLnServMd_MsgDisp_Rq := %X\n", getValue( HMI_BrkLnServMd_MsgDisp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EPKB_Msg_Disp_Rq := %X\n", getValue( HMI_EPKB_Msg_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EPKB_Msg_Disp_TrgrRq := %X\n", getValue( HMI_EPKB_Msg_Disp_TrgrRq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PkBrkIndLmp_On_Rq := %X\n", getValue( HMI_PkBrkIndLmp_On_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tEPKB_Disp_IndLmp_Rq_2_AR
{
    putValue( HMI__STMSG_EPKB_Disp_IndLmp_Rq_2_AR, 0 );
}

on EnvVar HMI__STMSG_EPKB_Disp_IndLmp_Rq_2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_EPKB_Disp_IndLmp_Rq_2_AR );
        if( tDelay > 0)    
            setTimer( _tEPKB_Disp_IndLmp_Rq_2_AR, tDelay );
        else
            putValue( HMI__STMSG_EPKB_Disp_IndLmp_Rq_2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_EPKB_Disp_IndLmp_Rq_2_AR
{
    if( getValue( this ) )
        openPanel( "EPKB_Disp_IndLmp_Rq_2_AR" );
}

on envVar HMI_E2E_EPKB_Disp_IndLmp_Rq_Inject
{
    if( getValue( this ) )
    {
        _EPKB_Disp_IndLmp_Rq_2_AR_CRC_ErrorCnt = getValue( HMI_CRC_EPKB_Disp_IndLmp_Rq_ErrorCount );
        _EPKB_Disp_IndLmp_Rq_2_AR_SQC_TriggPos = getValue( HMI_SQC_EPKB_Disp_IndLmp_Rq_TriggerPosition );
        _EPKB_Disp_IndLmp_Rq_2_AR_SQC_WrongSeqJump = getValue( HMI_SQC_EPKB_Disp_IndLmp_Rq_WrongSeq );
        _EPKB_Disp_IndLmp_Rq_2_AR_SQC_RepeatedCnt = getValue( HMI_SQC_EPKB_Disp_IndLmp_Rq_Repeated );
        _EPKB_Disp_IndLmp_Rq_2_AR_MSG_DropCnt = getValue( HMI_SQC_EPKB_Disp_IndLmp_Rq_MSG_DropCnt );
        putValue( HMI_E2E_EPKB_Disp_IndLmp_Rq_State, 2 );
        _EPKB_Disp_IndLmp_Rq_2_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_BrkIndLmp_On_Rq_EPkB
{
    _mEPKB_Disp_IndLmp_Rq_2_AR.BrkIndLmp_On_Rq_EPkB.phys = getValue(this);
    _EPKB_Disp_IndLmp_Rq_2_AR_SpontanFlag = 1;
}

on EnvVar HMI_BrkLnServMd_MsgDisp_Rq
{
    _mEPKB_Disp_IndLmp_Rq_2_AR.BrkLnServMd_MsgDisp_Rq.phys = getValue(this);
    _EPKB_Disp_IndLmp_Rq_2_AR_SpontanFlag = 1;
}

on EnvVar HMI_EPKB_Msg_Disp_Rq
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cEPKBWarningNMRequest );
        setTimer( t_EPKBWarningNMCancelTimer, c_NMCancelTimer_05sec ); // 30 seconds for auto-shut-off
    }
    _mEPKB_Disp_IndLmp_Rq_2_AR.EPKB_Msg_Disp_Rq.phys = getValue(this);
    _EPKB_Disp_IndLmp_Rq_2_AR_SpontanFlag = 1;
}

on EnvVar HMI_EPKB_Msg_Disp_TrgrRq
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cEPKBWarningNMRequest );
        setTimer( t_EPKBWarningNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mEPKB_Disp_IndLmp_Rq_2_AR.EPKB_Msg_Disp_TrgrRq.phys = getValue(this);
    _EPKB_Disp_IndLmp_Rq_2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PkBrkIndLmp_On_Rq
{
    _mEPKB_Disp_IndLmp_Rq_2_AR.PkBrkIndLmp_On_Rq.phys = getValue(this);
    _EPKB_Disp_IndLmp_Rq_2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_EPKB_Disp_IndLmp_Rq
{
    _mEPKB_Disp_IndLmp_Rq_2_AR.Rsrv1_EPKB_Disp_IndLmp_Rq.phys = getValue(this);
    _EPKB_Disp_IndLmp_Rq_2_AR_SpontanFlag = 1;
}

EPS_Stat_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_EPS_Stat_Disp_Rq_AR ) )
    {
    //  message   EPS_Stat_Disp_Rq_AR ID: 1069 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _EPS_Stat_Disp_Rq_AR_Cnt--;
        if( _EPS_Stat_Disp_Rq_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            EPS_Stat_Disp_Rq_AR_output();
            _EPS_Stat_Disp_Rq_AR_Cnt = _EPS_Stat_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _EPS_Stat_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _EPS_Stat_Disp_Rq_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            EPS_Stat_Disp_Rq_AR_output();
            _EPS_Stat_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

EPS_Stat_Disp_Rq_AR_init()
{   /* Botschaft EPS_Stat_Disp_Rq_AR ID: 1069 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1069 0;
BA_ "NmAsrMessage" BO_ 1069 0;
BA_ "GenMsgMinAcceptLength" BO_ 1069 8;
BA_ "GenMsgILSupport" BO_ 1069 1;
BA_ "DiagState" BO_ 1069 0;
BA_ "DiagRequest" BO_ 1069 0;
BA_ "DiagResponse" BO_ 1069 0;
BA_ "GenMsgStartValue" BO_ 1069 "0";
BA_ "GenMsgStartDelayTime" BO_ 1069 0;
BA_ "GenMsgDelayTime" BO_ 1069 5;
BA_ "GenMsgNrOfRepetitions" BO_ 1069 0;
BA_ "GenMsgCycleTime" BO_ 1069 200;
BA_ "GenMsgSendType" BO_ 1069 5;
    */
    _EPS_Stat_Disp_Rq_AR_Timebase =            c_tDBKomTimer_20ms;
    _EPS_Stat_Disp_Rq_AR_CycleCount =         200 / _EPS_Stat_Disp_Rq_AR_Timebase;
    _EPS_Stat_Disp_Rq_AR_StartDelay =           0 / _EPS_Stat_Disp_Rq_AR_Timebase;
    _EPS_Stat_Disp_Rq_AR_Cnt = _EPS_Stat_Disp_Rq_AR_StartDelay;
    _EPS_Stat_Disp_Rq_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_EPS_Stat_Disp_Rq_AR, _EPS_Stat_Disp_Rq_AR_StartDelay * _EPS_Stat_Disp_Rq_AR_Timebase );

    _mEPS_Stat_Disp_Rq_AR.ASM_Stat_EPS.phys = getValue( HMI_ASM_Stat_EPS );
    _mEPS_Stat_Disp_Rq_AR.DPC_Md_St_Rs.phys = getValue( HMI_DPC_Md_St_Rs );
    _mEPS_Stat_Disp_Rq_AR.EPS_ALDW_Warn_Stat.phys = getValue( HMI_EPS_ALDW_Warn_Stat );
    _mEPS_Stat_Disp_Rq_AR.EPS_IndLmp_On_Rq.phys = getValue( HMI_EPS_IndLmp_On_Rq );
    _mEPS_Stat_Disp_Rq_AR.EPS_Stat_Maneuv.phys = getValue( HMI_EPS_Stat_Maneuv );
    _mEPS_Stat_Disp_Rq_AR.EPS_WarnDisp_Rq.phys = getValue( HMI_EPS_WarnDisp_Rq );
    _mEPS_Stat_Disp_Rq_AR.Rsrv1_EPS_CtrlLmp_Disp_Rq.phys = getValue( HMI_Rsrv1_EPS_CtrlLmp_Disp_Rq );
    _mEPS_Stat_Disp_Rq_AR.Rsrv2_EPS_CtrlLmp_Disp_Rq.phys = getValue( HMI_Rsrv2_EPS_CtrlLmp_Disp_Rq );
    _mEPS_Stat_Disp_Rq_AR.Rsrv3_EPS_CtrlLmp_Disp_Rq.phys = getValue( HMI_Rsrv3_EPS_CtrlLmp_Disp_Rq );
}

EPS_Stat_Disp_Rq_AR_output()
{
    byte crc;
    byte SQC_help;
    byte dataId = 0x2D;

    SQC_help = getValue( HMI_SQC_EPS_CtrlLmp_Disp_Rq ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_EPS_CtrlLmp_Disp_Rq_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _EPS_Stat_Disp_Rq_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _EPS_Stat_Disp_Rq_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_EPS_CtrlLmp_Disp_Rq_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _EPS_Stat_Disp_Rq_AR_SQC_WrongSeqJump != 0 ) &&
            ( _EPS_Stat_Disp_Rq_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _EPS_Stat_Disp_Rq_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _EPS_Stat_Disp_Rq_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _EPS_Stat_Disp_Rq_AR_SQC_RepeatedCnt ) &&
            ( _EPS_Stat_Disp_Rq_AR_E2E_Armed == 1  )    )
        {
            _EPS_Stat_Disp_Rq_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_EPS_CtrlLmp_Disp_Rq, SQC_help );
    }
    _mEPS_Stat_Disp_Rq_AR.SQC_EPS_CtrlLmp_Disp_Rq = SQC_help;

    if( getValue( HMI_CRC_EPS_CtrlLmp_Disp_Rq_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_EPS_CtrlLmp_Disp_Rq_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mEPS_Stat_Disp_Rq_AR.byte( 0 ) ];
//            crc = crctable_profile02[ crc ^ _mEPS_Stat_Disp_Rq_AR.byte( 1 ) ];
//            crc = crctable_profile02[ crc ^ _mEPS_Stat_Disp_Rq_AR.byte( 2 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mEPS_Stat_Disp_Rq_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mEPS_Stat_Disp_Rq_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mEPS_Stat_Disp_Rq_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mEPS_Stat_Disp_Rq_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mEPS_Stat_Disp_Rq_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _EPS_Stat_Disp_Rq_AR_CRC_Offset[ _mEPS_Stat_Disp_Rq_AR.SQC_EPS_CtrlLmp_Disp_Rq ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _EPS_Stat_Disp_Rq_AR_CRC_ErrorCnt   && ( _EPS_Stat_Disp_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EPS_CtrlLmp_Disp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _EPS_Stat_Disp_Rq_AR_CRC_ErrorCnt > 0 )
                    _EPS_Stat_Disp_Rq_AR_CRC_ErrorCnt--; 
            }
            _mEPS_Stat_Disp_Rq_AR.CRC_EPS_CtrlLmp_Disp_Rq = crc;
            putValue( HMI_CRC_EPS_CtrlLmp_Disp_Rq, crc );
        }
        else
            _mEPS_Stat_Disp_Rq_AR.CRC_EPS_CtrlLmp_Disp_Rq = getValue( HMI_CRC_EPS_CtrlLmp_Disp_Rq );
    }
    else
    {
        if( !getValue( HMI_CRC_EPS_CtrlLmp_Disp_Rq_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mEPS_Stat_Disp_Rq_AR.byte( 0 ) ];
//            crc = crctable[ crc ^ _mEPS_Stat_Disp_Rq_AR.byte( 1 ) ];
//            crc = crctable[ crc ^ _mEPS_Stat_Disp_Rq_AR.byte( 2 ) ];  CRC
            crc = crctable[ crc ^ _mEPS_Stat_Disp_Rq_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mEPS_Stat_Disp_Rq_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mEPS_Stat_Disp_Rq_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mEPS_Stat_Disp_Rq_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mEPS_Stat_Disp_Rq_AR.byte( 7 ) ];
            crc = crctable[ crc ^ dataId ];
            crc = (crc ^ 0xFF);
            if( ( _EPS_Stat_Disp_Rq_AR_CRC_ErrorCnt   && ( _EPS_Stat_Disp_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EPS_CtrlLmp_Disp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _EPS_Stat_Disp_Rq_AR_CRC_ErrorCnt > 0 )
                    _EPS_Stat_Disp_Rq_AR_CRC_ErrorCnt--; 
            }
            _mEPS_Stat_Disp_Rq_AR.CRC_EPS_CtrlLmp_Disp_Rq = crc;
            putValue( HMI_CRC_EPS_CtrlLmp_Disp_Rq, crc );
        }
        else
            _mEPS_Stat_Disp_Rq_AR.CRC_EPS_CtrlLmp_Disp_Rq = getValue( HMI_CRC_EPS_CtrlLmp_Disp_Rq );
    }
    if( ( _EPS_Stat_Disp_Rq_AR_MSG_DropCnt > 0 ) &&
        ( _EPS_Stat_Disp_Rq_AR_E2E_Armed == 1  )    )
    {
        _EPS_Stat_Disp_Rq_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mEPS_Stat_Disp_Rq_AR );
        
    if( _EPS_Stat_Disp_Rq_AR_E2E_Armed == 1 )
    {
        if ( ( _EPS_Stat_Disp_Rq_AR_MSG_DropCnt == 0      ) &&
             ( _EPS_Stat_Disp_Rq_AR_CRC_ErrorCnt == 0     ) &&
             ( _EPS_Stat_Disp_Rq_AR_SQC_RepeatedCnt == 0  ) &&
             ( _EPS_Stat_Disp_Rq_AR_SQC_WrongSeqJump == 0 )    )
        {
            _EPS_Stat_Disp_Rq_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_EPS_CtrlLmp_Disp_Rq_State, 0 );
        }
    }
}

EPS_Stat_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: EPS_Stat_Disp_Rq_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_EPS_Stat_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_EPS_Stat_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_EPS_Stat_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_EPS_Stat_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ASM_Stat_EPS := %X\n", getValue( HMI_ASM_Stat_EPS ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EPS_CtrlLmp_Disp_Rq := %X\n", getValue( HMI_CRC_EPS_CtrlLmp_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EPS_CtrlLmp_Disp_Rq_Auto := %X\n", getValue( HMI_CRC_EPS_CtrlLmp_Disp_Rq_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_St_Rs := %X\n", getValue( HMI_DPC_Md_St_Rs ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EPS_ALDW_Warn_Stat := %X\n", getValue( HMI_EPS_ALDW_Warn_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EPS_IndLmp_On_Rq := %X\n", getValue( HMI_EPS_IndLmp_On_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EPS_Stat_Maneuv := %X\n", getValue( HMI_EPS_Stat_Maneuv ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EPS_WarnDisp_Rq := %X\n", getValue( HMI_EPS_WarnDisp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_EPS_CtrlLmp_Disp_Rq := %X\n", getValue( HMI_Rsrv1_EPS_CtrlLmp_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_EPS_CtrlLmp_Disp_Rq := %X\n", getValue( HMI_Rsrv2_EPS_CtrlLmp_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv3_EPS_CtrlLmp_Disp_Rq := %X\n", getValue( HMI_Rsrv3_EPS_CtrlLmp_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EPS_CtrlLmp_Disp_Rq := %X\n", getValue( HMI_SQC_EPS_CtrlLmp_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EPS_CtrlLmp_Disp_Rq_Auto := %X\n", getValue( HMI_SQC_EPS_CtrlLmp_Disp_Rq_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tEPS_Stat_Disp_Rq_AR
{
    putValue( HMI__STMSG_EPS_Stat_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_EPS_Stat_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_EPS_Stat_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tEPS_Stat_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_EPS_Stat_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_EPS_Stat_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("EPS_Stat_Disp_Rq_AR");
}

on envVar HMI_E2E_EPS_CtrlLmp_Disp_Rq_Inject
{
    if( getValue( this ) )
    {
        _EPS_Stat_Disp_Rq_AR_CRC_ErrorCnt = getValue( HMI_CRC_EPS_CtrlLmp_Disp_Rq_ErrorCount );
        _EPS_Stat_Disp_Rq_AR_SQC_TriggPos = getValue( HMI_SQC_EPS_CtrlLmp_Disp_Rq_TriggerPosition );
        _EPS_Stat_Disp_Rq_AR_SQC_WrongSeqJump = getValue( HMI_SQC_EPS_CtrlLmp_Disp_Rq_WrongSeq );
        _EPS_Stat_Disp_Rq_AR_SQC_RepeatedCnt = getValue( HMI_SQC_EPS_CtrlLmp_Disp_Rq_Repeated );
        _EPS_Stat_Disp_Rq_AR_MSG_DropCnt = getValue( HMI_SQC_EPS_CtrlLmp_Disp_Rq_MSG_DropCnt );
        putValue( HMI_E2E_EPS_CtrlLmp_Disp_Rq_State, 2 );
        _EPS_Stat_Disp_Rq_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_ASM_Stat_EPS
{
    _mEPS_Stat_Disp_Rq_AR.ASM_Stat_EPS.phys = getValue(this);
    _EPS_Stat_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_DPC_Md_St_Rs
{
    _mEPS_Stat_Disp_Rq_AR.DPC_Md_St_Rs.phys = getValue(this);
    _EPS_Stat_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EPS_ALDW_Warn_Stat
{
    _mEPS_Stat_Disp_Rq_AR.EPS_ALDW_Warn_Stat.phys = getValue(this);
    _EPS_Stat_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EPS_IndLmp_On_Rq
{
    _mEPS_Stat_Disp_Rq_AR.EPS_IndLmp_On_Rq.phys = getValue(this);
    _EPS_Stat_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EPS_Stat_Maneuv
{
    _mEPS_Stat_Disp_Rq_AR.EPS_Stat_Maneuv.phys = getValue(this);
    _EPS_Stat_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_EPS_WarnDisp_Rq
{
    _mEPS_Stat_Disp_Rq_AR.EPS_WarnDisp_Rq.phys = getValue(this);
    _EPS_Stat_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_EPS_CtrlLmp_Disp_Rq
{
    _mEPS_Stat_Disp_Rq_AR.Rsrv1_EPS_CtrlLmp_Disp_Rq.phys = getValue(this);
    _EPS_Stat_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv2_EPS_CtrlLmp_Disp_Rq
{
    _mEPS_Stat_Disp_Rq_AR.Rsrv2_EPS_CtrlLmp_Disp_Rq.phys = getValue(this);
    _EPS_Stat_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv3_EPS_CtrlLmp_Disp_Rq
{
    _mEPS_Stat_Disp_Rq_AR.Rsrv3_EPS_CtrlLmp_Disp_Rq.phys = getValue(this);
    _EPS_Stat_Disp_Rq_AR_SpontanFlag = 1;
}

ESP_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_ESP_Disp_Rq_AR ) )
    {
    //  message   ESP_Disp_Rq_AR ID: 555 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _ESP_Disp_Rq_AR_Cnt--;
        if( _ESP_Disp_Rq_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            ESP_Disp_Rq_AR_output();
            _ESP_Disp_Rq_AR_Cnt = _ESP_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _ESP_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _ESP_Disp_Rq_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            ESP_Disp_Rq_AR_output();
            _ESP_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

ESP_ATC_Stat_AMG_AR_check_output()
{
    if( !getValue( HMI__STMSG_ESP_ATC_Stat_AMG_AR ) )
    {
    //  message   ESP_ATC_Stat_AMG_AR ID: 2345140224 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _ESP_ATC_Stat_AMG_AR_Cnt--;
        if( _ESP_ATC_Stat_AMG_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            ESP_ATC_Stat_AMG_AR_output();
            _ESP_ATC_Stat_AMG_AR_Cnt = _ESP_ATC_Stat_AMG_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _ESP_ATC_Stat_AMG_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _ESP_ATC_Stat_AMG_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            ESP_ATC_Stat_AMG_AR_output();
            _ESP_ATC_Stat_AMG_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

ESP_ATC_Stat_AMG_AR_init()
{   /* Botschaft ESP_ATC_Stat_AMG_AR ID: 555 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 2345140224 0;
BA_ "NmAsrMessage" BO_ 2345140224 0;
BA_ "GenMsgMinAcceptLength" BO_ 2345140224 8;
BA_ "GenMsgILSupport" BO_ 2345140224 1;
BA_ "DiagState" BO_ 2345140224 0;
BA_ "DiagRequest" BO_ 2345140224 0;
BA_ "DiagResponse" BO_ 2345140224 0;
BA_ "GenMsgStartValue" BO_ 2345140224 "0";
BA_ "GenMsgStartDelayTime" BO_ 2345140224 0;
BA_ "GenMsgDelayTime" BO_ 2345140224 20;
BA_ "GenMsgNrOfRepetition" BO_ 2345140224 0;
BA_ "GenMsgCycleTime" BO_ 2345140224 500;
BA_ "GenMsgSendType" BO_ 2345140224 5;
    */
    _ESP_ATC_Stat_AMG_AR_Timebase =            c_tDBKomTimer_20ms;
    _ESP_ATC_Stat_AMG_AR_CycleCount =         500 / _ESP_ATC_Stat_AMG_AR_Timebase;
    _ESP_ATC_Stat_AMG_AR_StartDelay =           0 / _ESP_ATC_Stat_AMG_AR_Timebase;
    _ESP_ATC_Stat_AMG_AR_Cnt = _ESP_ATC_Stat_AMG_AR_StartDelay;
    _ESP_ATC_Stat_AMG_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_ESP_ATC_Stat_AMG_AR, _ESP_ATC_Stat_AMG_AR_StartDelay * _ESP_ATC_Stat_AMG_AR_Timebase );

    _mESP_ATC_Stat_AMG_AR.ATC_IndLmp_Rq.phys = getValue( HMI_ATC_IndLmp_Rq );
    _mESP_ATC_Stat_AMG_AR.ATC_Level_Stat.phys = getValue( HMI_ATC_Level_Stat );
    _mESP_ATC_Stat_AMG_AR.ATC_Md_Stat.phys = getValue( HMI_ATC_Md_Stat );
    _mESP_ATC_Stat_AMG_AR.ATC_MsgDisp_Rq.phys = getValue( HMI_ATC_MsgDisp_Rq );
    _mESP_ATC_Stat_AMG_AR.Rsrv1_ESP_ATC_Stat_AMG.phys = getValue( HMI_Rsrv1_ESP_ATC_Stat_AMG );
}

ESP_ATC_Stat_AMG_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_ESP_ATC_Stat_AMG ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_ESP_ATC_Stat_AMG_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _ESP_ATC_Stat_AMG_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _ESP_ATC_Stat_AMG_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_ESP_ATC_Stat_AMG_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _ESP_ATC_Stat_AMG_AR_SQC_WrongSeqJump != 0 ) &&
            ( _ESP_ATC_Stat_AMG_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _ESP_ATC_Stat_AMG_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _ESP_ATC_Stat_AMG_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _ESP_ATC_Stat_AMG_AR_SQC_RepeatedCnt ) &&
            ( _ESP_ATC_Stat_AMG_AR_E2E_Armed == 1  )    )
        {
            _ESP_ATC_Stat_AMG_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_ESP_ATC_Stat_AMG, SQC_help );
    }
    _mESP_ATC_Stat_AMG_AR.SQC_ESP_ATC_Stat_AMG = SQC_help;

    if( getValue( HMI_CRC_ESP_ATC_Stat_AMG_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_ESP_ATC_Stat_AMG_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mESP_ATC_Stat_AMG_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mESP_ATC_Stat_AMG_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mESP_ATC_Stat_AMG_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mESP_ATC_Stat_AMG_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mESP_ATC_Stat_AMG_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mESP_ATC_Stat_AMG_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mESP_ATC_Stat_AMG_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mESP_ATC_Stat_AMG_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _ESP_ATC_Stat_AMG_AR_CRC_Offset[ _mESP_ATC_Stat_AMG_AR.SQC_ESP_ATC_Stat_AMG ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _ESP_ATC_Stat_AMG_AR_CRC_ErrorCnt   && ( _ESP_ATC_Stat_AMG_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_ESP_ATC_Stat_AMG_Invalid )                                         )    )
            {
                crc++;
                if( _ESP_ATC_Stat_AMG_AR_CRC_ErrorCnt > 0 )
                    _ESP_ATC_Stat_AMG_AR_CRC_ErrorCnt--; 
            }
            _mESP_ATC_Stat_AMG_AR.CRC_ESP_ATC_Stat_AMG = crc;
            putValue( HMI_CRC_ESP_ATC_Stat_AMG, crc );
        }
        else
            _mESP_ATC_Stat_AMG_AR.CRC_ESP_ATC_Stat_AMG = getValue( HMI_CRC_ESP_ATC_Stat_AMG );
    }
    else
    {
        if( !getValue( HMI_CRC_ESP_ATC_Stat_AMG_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mESP_ATC_Stat_AMG_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mESP_ATC_Stat_AMG_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mESP_ATC_Stat_AMG_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mESP_ATC_Stat_AMG_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mESP_ATC_Stat_AMG_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mESP_ATC_Stat_AMG_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mESP_ATC_Stat_AMG_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mESP_ATC_Stat_AMG_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _ESP_ATC_Stat_AMG_AR_CRC_ErrorCnt   && ( _ESP_ATC_Stat_AMG_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_ESP_ATC_Stat_AMG_Invalid )                                         )    )
            {
                crc++;
                if( _ESP_ATC_Stat_AMG_AR_CRC_ErrorCnt > 0 )
                    _ESP_ATC_Stat_AMG_AR_CRC_ErrorCnt--; 
            }
            _mESP_ATC_Stat_AMG_AR.CRC_ESP_ATC_Stat_AMG = crc;
            putValue( HMI_CRC_ESP_ATC_Stat_AMG, crc );
        }
        else
            _mESP_ATC_Stat_AMG_AR.CRC_ESP_ATC_Stat_AMG = getValue( HMI_CRC_ESP_ATC_Stat_AMG );
    }
    if( ( _ESP_ATC_Stat_AMG_AR_MSG_DropCnt > 0 ) &&
        ( _ESP_ATC_Stat_AMG_AR_E2E_Armed == 1  )    )
    {
        _ESP_ATC_Stat_AMG_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mESP_ATC_Stat_AMG_AR );
        
    if( _ESP_ATC_Stat_AMG_AR_E2E_Armed == 1 )
    {
        if ( ( _ESP_ATC_Stat_AMG_AR_MSG_DropCnt == 0      ) &&
             ( _ESP_ATC_Stat_AMG_AR_CRC_ErrorCnt == 0     ) &&
             ( _ESP_ATC_Stat_AMG_AR_SQC_RepeatedCnt == 0  ) &&
             ( _ESP_ATC_Stat_AMG_AR_SQC_WrongSeqJump == 0 )    )
        {
            _ESP_ATC_Stat_AMG_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_ESP_ATC_Stat_AMG_State, 0 );
        }
    }
}

ESP_ATC_Stat_AMG_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: ESP_ATC_Stat_AMG_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_ESP_ATC_Stat_AMG_AR := %X\n", getValue( HMI__STMSG_ESP_ATC_Stat_AMG_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_ESP_ATC_Stat_AMG_AR := %X\n", getValue( HMI__STMSGT_ESP_ATC_Stat_AMG_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ATC_IndLmp_Rq := %X\n", getValue( HMI_ATC_IndLmp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ATC_Level_Stat := %X\n", getValue( HMI_ATC_Level_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ESP_ATC_Stat_AMG := %X\n", getValue( HMI_CRC_ESP_ATC_Stat_AMG ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ESP_ATC_Stat_AMG_Auto := %X\n", getValue( HMI_CRC_ESP_ATC_Stat_AMG_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ATC_Md_Stat := %X\n", getValue( HMI_ATC_Md_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ATC_MsgDisp_Rq := %X\n", getValue( HMI_ATC_MsgDisp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_ESP_ATC_Stat_AMG := %X\n", getValue( HMI_Rsrv1_ESP_ATC_Stat_AMG ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_ESP_ATC_Stat_AMG := %X\n", getValue( HMI_SQC_ESP_ATC_Stat_AMG ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_ESP_ATC_Stat_AMG_Auto := %X\n", getValue( HMI_SQC_ESP_ATC_Stat_AMG_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tESP_ATC_Stat_AMG_AR
{
    putValue( HMI__STMSG_ESP_ATC_Stat_AMG_AR, 0 );
}

on EnvVar HMI__STMSG_ESP_ATC_Stat_AMG_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_ESP_ATC_Stat_AMG_AR );
        if( tDelay > 0)    
            setTimer( _tESP_ATC_Stat_AMG_AR, tDelay );
        else
            putValue( HMI__STMSG_ESP_ATC_Stat_AMG_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_ESP_ATC_Stat_AMG_AR
{
    if( getValue( this ) )
        openPanel("ESP_ATC_Stat_AMG_AR");
}

on envVar HMI_E2E_ESP_ATC_Stat_AMG_Inject
{
    if( getValue( this ) )
    {
        _ESP_ATC_Stat_AMG_AR_CRC_ErrorCnt = getValue( HMI_CRC_ESP_ATC_Stat_AMG_ErrorCount );
        _ESP_ATC_Stat_AMG_AR_SQC_TriggPos = getValue( HMI_SQC_ESP_ATC_Stat_AMG_TriggerPosition );
        _ESP_ATC_Stat_AMG_AR_SQC_WrongSeqJump = getValue( HMI_SQC_ESP_ATC_Stat_AMG_WrongSeq );
        _ESP_ATC_Stat_AMG_AR_SQC_RepeatedCnt = getValue( HMI_SQC_ESP_ATC_Stat_AMG_Repeated );
        _ESP_ATC_Stat_AMG_AR_MSG_DropCnt = getValue( HMI_SQC_ESP_ATC_Stat_AMG_MSG_DropCnt );
        putValue( HMI_E2E_ESP_ATC_Stat_AMG_State, 2 );
        _ESP_ATC_Stat_AMG_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_ATC_IndLmp_Rq
{
    _mESP_ATC_Stat_AMG_AR.ATC_IndLmp_Rq.phys = getValue(this);
    _ESP_ATC_Stat_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_ATC_Level_Stat
{
    _mESP_ATC_Stat_AMG_AR.ATC_Level_Stat.phys = getValue(this);
    _ESP_ATC_Stat_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_ATC_Md_Stat
{
    _mESP_ATC_Stat_AMG_AR.ATC_Md_Stat.phys = getValue(this);
    _ESP_ATC_Stat_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_ATC_MsgDisp_Rq
{
    _mESP_ATC_Stat_AMG_AR.ATC_MsgDisp_Rq.phys = getValue(this);
    _ESP_ATC_Stat_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_ESP_ATC_Stat_AMG
{
    _mESP_ATC_Stat_AMG_AR.Rsrv1_ESP_ATC_Stat_AMG.phys = getValue(this);
    _ESP_ATC_Stat_AMG_AR_SpontanFlag = 1;
}

ESP_Disp_Rq_AR_init()
{   /* Botschaft ESP_Disp_Rq_AR ID: 555 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 555 0;
BA_ "NmAsrMessage" BO_ 555 0;
BA_ "GenMsgMinAcceptLength" BO_ 555 8;
BA_ "GenMsgILSupport" BO_ 555 1;
BA_ "DiagState" BO_ 555 0;
BA_ "DiagRequest" BO_ 555 0;
BA_ "DiagResponse" BO_ 555 0;
BA_ "GenMsgStartValue" BO_ 555 "0";
BA_ "GenMsgStartDelayTime" BO_ 555 0;
BA_ "GenMsgDelayTime" BO_ 555 5;
BA_ "GenMsgNrOfRepetitions" BO_ 555 0;
BA_ "GenMsgCycleTime" BO_ 555 100;
BA_ "GenMsgSendType" BO_ 555 5;
    */
    _ESP_Disp_Rq_AR_Timebase =            c_tDBKomTimer_20ms;
    _ESP_Disp_Rq_AR_CycleCount =         100 / _ESP_Disp_Rq_AR_Timebase;
    _ESP_Disp_Rq_AR_StartDelay =           0 / _ESP_Disp_Rq_AR_Timebase;
    _ESP_Disp_Rq_AR_Cnt = _ESP_Disp_Rq_AR_StartDelay;
    _ESP_Disp_Rq_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_ESP_Disp_Rq_AR, _ESP_Disp_Rq_AR_StartDelay * _ESP_Disp_Rq_AR_Timebase );

    _mESP_Disp_Rq_AR.ABS_IndLmp_On_Rq.phys = getValue( HMI_ABS_IndLmp_On_Rq );
    _mESP_Disp_Rq_AR.BrkIndLmp_On_Rq_ESP.phys = getValue( HMI_BrkIndLmp_On_Rq_ESP );
    _mESP_Disp_Rq_AR.ESP_BrkMsg_Disp_Rq.phys = getValue( HMI_ESP_BrkMsg_Disp_Rq );
    _mESP_Disp_Rq_AR.ESP_BrkMsg_Disp_TrgRq.phys = getValue( HMI_ESP_BrkMsg_Disp_TrgRq );
    _mESP_Disp_Rq_AR.ESP_CtrlLmp_Info.phys = getValue( HMI_ESP_CtrlLmp_Info );
    _mESP_Disp_Rq_AR.ESP_Md_Disp_Rq.phys = getValue( HMI_ESP_Md_Disp_Rq );
    _mESP_Disp_Rq_AR.ESP_Md_Rq_Ack.phys = getValue( HMI_ESP_Md_Rq_Ack );
    _mESP_Disp_Rq_AR.ESP_Off_IndLmp_On_Rq.phys = getValue( HMI_ESP_Off_IndLmp_On_Rq );
    _mESP_Disp_Rq_AR.ESP_VDC_Msg_Disp_Rq.phys = getValue( HMI_ESP_VDC_Msg_Disp_Rq );
    _mESP_Disp_Rq_AR.ESP_VDC_Msg_Disp_TrgRq.phys = getValue( HMI_ESP_VDC_Msg_Disp_TrgRq );
    _mESP_Disp_Rq_AR.FTW_Msg_Disp_Rq.phys = getValue( HMI_FTW_Msg_Disp_Rq );
    _mESP_Disp_Rq_AR.FTW_Stat.phys = getValue( HMI_FTW_Stat );
    _mESP_Disp_Rq_AR.MIL_On_Rq_ESP.phys = getValue( HMI_MIL_On_Rq_ESP );
    _mESP_Disp_Rq_AR.RBS_AcustWarn_Rq.phys = getValue( HMI_RBS_AcustWarn_Rq );
    _mESP_Disp_Rq_AR.RBS_IndLmp_On_Rq.phys = getValue( HMI_RBS_IndLmp_On_Rq );
    _mESP_Disp_Rq_AR.RollTestMd_Rq_Ack.phys = getValue( HMI_RollTestMd_Rq_Ack );
    _mESP_Disp_Rq_AR.Rsrv1_ESP_Disp_Rq.phys = getValue( HMI_Rsrv1_ESP_Disp_Rq );
    _mESP_Disp_Rq_AR.SPCR_Stat.phys = getValue( HMI_SPCR_Stat );
    _mESP_Disp_Rq_AR.SPCR_StatMsg_Disp_Rq.phys = getValue( HMI_SPCR_StatMsg_Disp_Rq );
    _mESP_Disp_Rq_AR.SQC_ESP_Disp_Rq.phys = 15;
    putValue( HMI_SPCR_StatMsg_Disp_Rq, 15 );
}

ESP_Disp_Rq_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_ESP_Disp_Rq ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_ESP_Disp_Rq_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _ESP_Disp_Rq_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _ESP_Disp_Rq_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_ESP_Disp_Rq_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _ESP_Disp_Rq_AR_SQC_WrongSeqJump != 0 ) &&
            ( _ESP_Disp_Rq_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _ESP_Disp_Rq_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _ESP_Disp_Rq_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _ESP_Disp_Rq_AR_SQC_RepeatedCnt ) &&
            ( _ESP_Disp_Rq_AR_E2E_Armed == 1  )    )
        {
            _ESP_Disp_Rq_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_ESP_Disp_Rq, SQC_help );
    }
    _mESP_Disp_Rq_AR.SQC_ESP_Disp_Rq = SQC_help;

    if( getValue( HMI_CRC_ESP_Disp_Rq_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_ESP_Disp_Rq_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mESP_Disp_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mESP_Disp_Rq_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mESP_Disp_Rq_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mESP_Disp_Rq_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mESP_Disp_Rq_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mESP_Disp_Rq_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mESP_Disp_Rq_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mESP_Disp_Rq_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _ESP_Disp_Rq_AR_CRC_Offset[ _mESP_Disp_Rq_AR.SQC_ESP_Disp_Rq ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _ESP_Disp_Rq_AR_CRC_ErrorCnt   && ( _ESP_Disp_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_ESP_Disp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _ESP_Disp_Rq_AR_CRC_ErrorCnt > 0 )
                    _ESP_Disp_Rq_AR_CRC_ErrorCnt--; 
            }
            _mESP_Disp_Rq_AR.CRC_ESP_Disp_Rq = crc;
            putValue( HMI_CRC_ESP_Disp_Rq, crc );
        }
        else
            _mESP_Disp_Rq_AR.CRC_ESP_Disp_Rq = getValue( HMI_CRC_ESP_Disp_Rq );
    }
    else
    {
        if( !getValue( HMI_CRC_ESP_Disp_Rq_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mESP_Disp_Rq_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mESP_Disp_Rq_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mESP_Disp_Rq_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mESP_Disp_Rq_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mESP_Disp_Rq_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mESP_Disp_Rq_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mESP_Disp_Rq_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mESP_Disp_Rq_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _ESP_Disp_Rq_AR_CRC_ErrorCnt   && ( _ESP_Disp_Rq_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_ESP_Disp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _ESP_Disp_Rq_AR_CRC_ErrorCnt > 0 )
                    _ESP_Disp_Rq_AR_CRC_ErrorCnt--; 
            }
            _mESP_Disp_Rq_AR.CRC_ESP_Disp_Rq = crc;
            putValue( HMI_CRC_ESP_Disp_Rq, crc );
        }
        else
            _mESP_Disp_Rq_AR.CRC_ESP_Disp_Rq = getValue( HMI_CRC_ESP_Disp_Rq );
    }
    if( ( _ESP_Disp_Rq_AR_MSG_DropCnt > 0 ) &&
        ( _ESP_Disp_Rq_AR_E2E_Armed == 1  )    )
    {
        _ESP_Disp_Rq_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mESP_Disp_Rq_AR );
        
    if( _ESP_Disp_Rq_AR_E2E_Armed == 1 )
    {
        if ( ( _ESP_Disp_Rq_AR_MSG_DropCnt == 0      ) &&
             ( _ESP_Disp_Rq_AR_CRC_ErrorCnt == 0     ) &&
             ( _ESP_Disp_Rq_AR_SQC_RepeatedCnt == 0  ) &&
             ( _ESP_Disp_Rq_AR_SQC_WrongSeqJump == 0 )    )
        {
            _ESP_Disp_Rq_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_ESP_Disp_Rq_State, 0 );
        }
    }
}

ESP_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: ESP_Disp_Rq_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_ESP_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_ESP_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_ESP_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_ESP_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ABS_IndLmp_On_Rq := %X\n", getValue( HMI_ABS_IndLmp_On_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkIndLmp_On_Rq_ESP := %X\n", getValue( HMI_BrkIndLmp_On_Rq_ESP ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ESP_Disp_Rq := %X\n", getValue( HMI_CRC_ESP_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ESP_Disp_Rq_Auto := %X\n", getValue( HMI_CRC_ESP_Disp_Rq_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ESP_BrkMsg_Disp_Rq := %X\n", getValue( HMI_ESP_BrkMsg_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ESP_BrkMsg_Disp_TrgRq := %X\n", getValue( HMI_ESP_BrkMsg_Disp_TrgRq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ESP_CtrlLmp_Info := %X\n", getValue( HMI_ESP_CtrlLmp_Info ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ESP_Md_Disp_Rq := %X\n", getValue( HMI_ESP_Md_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ESP_Md_Rq_Ack := %X\n", getValue( HMI_ESP_Md_Rq_Ack ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ESP_Off_IndLmp_On_Rq := %X\n", getValue( HMI_ESP_Off_IndLmp_On_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ESP_VDC_Msg_Disp_Rq := %X\n", getValue( HMI_ESP_VDC_Msg_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ESP_VDC_Msg_Disp_TrgRq := %X\n", getValue( HMI_ESP_VDC_Msg_Disp_TrgRq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FTW_Msg_Disp_Rq := %X\n", getValue( HMI_FTW_Msg_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FTW_Stat := %X\n", getValue( HMI_FTW_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MIL_On_Rq_ESP := %X\n", getValue( HMI_MIL_On_Rq_ESP ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RBS_AcustWarn_Rq := %X\n", getValue( HMI_RBS_AcustWarn_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RBS_IndLmp_On_Rq := %X\n", getValue( HMI_RBS_IndLmp_On_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RollTestMd_Rq_Ack := %X\n", getValue( HMI_RollTestMd_Rq_Ack ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_ESP_Disp_Rq := %X\n", getValue( HMI_Rsrv1_ESP_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPCR_Stat := %X\n", getValue( HMI_SPCR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPCR_StatMsg_Disp_Rq := %X\n", getValue( HMI_SPCR_StatMsg_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_ESP_Disp_Rq := %X\n", getValue( HMI_SQC_ESP_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_ESP_Disp_Rq_Auto := %X\n", getValue( HMI_SQC_ESP_Disp_Rq_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tESP_Disp_Rq_AR
{
    putValue( HMI__STMSG_ESP_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_ESP_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_ESP_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tESP_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_ESP_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_ESP_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("ESP_Disp_Rq_AR");
}

on envVar HMI_E2E_ESP_Disp_Rq_Inject
{
    if( getValue( this ) )
    {
        _ESP_Disp_Rq_AR_CRC_ErrorCnt = getValue( HMI_CRC_ESP_Disp_Rq_ErrorCount );
        _ESP_Disp_Rq_AR_SQC_TriggPos = getValue( HMI_SQC_ESP_Disp_Rq_TriggerPosition );
        _ESP_Disp_Rq_AR_SQC_WrongSeqJump = getValue( HMI_SQC_ESP_Disp_Rq_WrongSeq );
        _ESP_Disp_Rq_AR_SQC_RepeatedCnt = getValue( HMI_SQC_ESP_Disp_Rq_Repeated );
        _ESP_Disp_Rq_AR_MSG_DropCnt = getValue( HMI_SQC_ESP_Disp_Rq_MSG_DropCnt );
        putValue( HMI_E2E_ESP_Disp_Rq_State, 2 );
        _ESP_Disp_Rq_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_ABS_IndLmp_On_Rq
{
    _mESP_Disp_Rq_AR.ABS_IndLmp_On_Rq.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_BrkIndLmp_On_Rq_ESP
{
    _mESP_Disp_Rq_AR.BrkIndLmp_On_Rq_ESP.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ESP_BrkMsg_Disp_Rq
{
    _mESP_Disp_Rq_AR.ESP_BrkMsg_Disp_Rq.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ESP_BrkMsg_Disp_TrgRq
{
    _mESP_Disp_Rq_AR.ESP_BrkMsg_Disp_TrgRq.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ESP_CtrlLmp_Info
{
    _mESP_Disp_Rq_AR.ESP_CtrlLmp_Info.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ESP_Md_Disp_Rq
{
    _mESP_Disp_Rq_AR.ESP_Md_Disp_Rq.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ESP_Md_Rq_Ack
{
    _mESP_Disp_Rq_AR.ESP_Md_Rq_Ack.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ESP_Off_IndLmp_On_Rq
{
    _mESP_Disp_Rq_AR.ESP_Off_IndLmp_On_Rq.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ESP_VDC_Msg_Disp_Rq
{
    _mESP_Disp_Rq_AR.ESP_VDC_Msg_Disp_Rq.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_ESP_VDC_Msg_Disp_TrgRq
{
    _mESP_Disp_Rq_AR.ESP_VDC_Msg_Disp_TrgRq.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FTW_Msg_Disp_Rq
{
    _mESP_Disp_Rq_AR.FTW_Msg_Disp_Rq.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_FTW_Stat
{
    _mESP_Disp_Rq_AR.FTW_Stat.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_MIL_On_Rq_ESP
{
    _mESP_Disp_Rq_AR.MIL_On_Rq_ESP.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_RBS_AcustWarn_Rq
{
    _mESP_Disp_Rq_AR.RBS_AcustWarn_Rq.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_RBS_IndLmp_On_Rq
{
    _mESP_Disp_Rq_AR.RBS_IndLmp_On_Rq.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_RollTestMd_Rq_Ack
{
    _mESP_Disp_Rq_AR.RollTestMd_Rq_Ack.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_ESP_Disp_Rq
{
    _mESP_Disp_Rq_AR.Rsrv1_ESP_Disp_Rq.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPCR_Stat
{
    _mESP_Disp_Rq_AR.SPCR_Stat.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPCR_StatMsg_Disp_Rq
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cWakeWarningNMRequest );
        setTimer( t_WakeWarningNMCancelTimer, c_NMCancelTimer_05sec ); // 30 seconds for auto-shut-off
    }
    _mESP_Disp_Rq_AR.SPCR_StatMsg_Disp_Rq.phys = getValue(this);
    _ESP_Disp_Rq_AR_SpontanFlag = 1;
}

ESP_Disp_Rq2_AR_check_output()
{
    if( !getValue( HMI__STMSG_ESP_Disp_Rq2_AR ) )
    {
    //  message   ESP_Disp_Rq2_AR ID: 1177 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _ESP_Disp_Rq2_AR_Cnt--;
        if( _ESP_Disp_Rq2_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            ESP_Disp_Rq2_AR_output();
            _ESP_Disp_Rq2_AR_Cnt = _ESP_Disp_Rq2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _ESP_Disp_Rq2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _ESP_Disp_Rq2_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            ESP_Disp_Rq2_AR_output();
            _ESP_Disp_Rq2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

ESP_Disp_Rq2_AR_init()
{   /* Botschaft ESP_Disp_Rq2_AR ID: 1177 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1177 0;
BA_ "NmAsrMessage" BO_ 1177 0;
BA_ "GenMsgMinAcceptLength" BO_ 1177 8;
BA_ "GenMsgILSupport" BO_ 1177 1;
BA_ "DiagState" BO_ 1177 0;
BA_ "DiagRequest" BO_ 1177 0;
BA_ "DiagResponse" BO_ 1177 0;
BA_ "GenMsgStartValue" BO_ 1177 "0";
BA_ "GenMsgStartDelayTime" BO_ 1177 0;
BA_ "GenMsgDelayTime" BO_ 1177 20;
BA_ "GenMsgNrOfRepetitions" BO_ 1177 0;
BA_ "GenMsgCycleTime" BO_ 1177 100;
BA_ "GenMsgSendType" BO_ 1177 5;
    */
    _ESP_Disp_Rq2_AR_Timebase =            c_tDBKomTimer_20ms;
    _ESP_Disp_Rq2_AR_CycleCount =         100 / _ESP_Disp_Rq2_AR_Timebase;
    _ESP_Disp_Rq2_AR_StartDelay =           0 / _ESP_Disp_Rq2_AR_Timebase;
    _ESP_Disp_Rq2_AR_Cnt = _ESP_Disp_Rq2_AR_StartDelay;
    _ESP_Disp_Rq2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_ESP_Disp_Rq2_AR, _ESP_Disp_Rq2_AR_StartDelay * _ESP_Disp_Rq2_AR_Timebase );

    _mESP_Disp_Rq2_AR.ABS_Actv_Stat_EDR.phys = getValue( HMI_ABS_Actv_Stat_EDR );
    _mESP_Disp_Rq2_AR.CRC_DSR_Disp_Rq.phys = getValue( HMI_CRC_DSR_Disp_Rq );
    _mESP_Disp_Rq2_AR.DrowDtct_Actv.phys = getValue( HMI_DrowDtct_Actv );
    _mESP_Disp_Rq2_AR.DrowDtct_DrvTmHour_Disp_Rq.phys = getValue( HMI_DrowDtct_DrvTmHour_Disp_Rq );
    _mESP_Disp_Rq2_AR.DrowDtct_DrvTmMinute_Disp_Rq.phys = getValue( HMI_DrowDtct_DrvTmMinute_Disp_Rq );
    _mESP_Disp_Rq2_AR.DrowDtctIndLmp_On_Rq.phys = getValue( HMI_DrowDtctIndLmp_On_Rq );
    _mESP_Disp_Rq2_AR.DrowLvl_Disp_Rq.phys = getValue( HMI_DrowLvl_Disp_Rq );
    _mESP_Disp_Rq2_AR.DrowLvlDisp_Md_Rq.phys = getValue( HMI_DrowLvlDisp_Md_Rq );
    _mESP_Disp_Rq2_AR.DrowWarn_Rq.phys = getValue( HMI_DrowWarn_Rq );
    _mESP_Disp_Rq2_AR.DSR_Disp_Rq1.phys = getValue( HMI_DSR_Disp_Rq1 );
    _mESP_Disp_Rq2_AR.DSR_Disp_Rq2.phys = getValue( HMI_DSR_Disp_Rq2 );
    _mESP_Disp_Rq2_AR.DSR_Disp_TrgrRq.phys = getValue( HMI_DSR_Disp_TrgrRq );
    _mESP_Disp_Rq2_AR.DSR_SpdUnit_Rs.phys = getValue( HMI_DSR_SpdUnit_Rs );
    _mESP_Disp_Rq2_AR.DSR_Sw_LED_On_Rq.phys = getValue( HMI_DSR_Sw_LED_On_Rq );
    _mESP_Disp_Rq2_AR.ESP_Actv_Stat_EDR.phys = getValue( HMI_ESP_Actv_Stat_EDR );
    _mESP_Disp_Rq2_AR.ESP_LastMd_Disp_Rq.phys = getValue( HMI_ESP_LastMd_Disp_Rq );
    _mESP_Disp_Rq2_AR.RoofLuggMd_MenuSubs_Rq.phys = getValue( HMI_RoofLuggMd_MenuSubs_Rq );
    putValue( HMI_SQC_DSR_Disp_Rq, 15 );
    _mESP_Disp_Rq2_AR.SQC_DSR_Disp_Rq.phys = getValue( HMI_SQC_DSR_Disp_Rq );
}

ESP_Disp_Rq2_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_DSR_Disp_Rq ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_DSR_Disp_Rq_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _ESP_Disp_Rq2_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _ESP_Disp_Rq2_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_DSR_Disp_Rq_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _ESP_Disp_Rq2_AR_SQC_WrongSeqJump != 0 ) &&
            ( _ESP_Disp_Rq2_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _ESP_Disp_Rq2_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _ESP_Disp_Rq2_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _ESP_Disp_Rq2_AR_SQC_RepeatedCnt ) &&
            ( _ESP_Disp_Rq2_AR_E2E_Armed == 1  )    )
        {
            _ESP_Disp_Rq2_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_DSR_Disp_Rq, SQC_help );
    }
    _mESP_Disp_Rq2_AR.SQC_DSR_Disp_Rq = SQC_help;

    if( getValue( HMI_CRC_DSR_Disp_Rq_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_DSR_Disp_Rq_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mESP_Disp_Rq2_AR.byte( 0 ) ];
//            crc = crctable_profile02[ crc ^ _mESP_Disp_Rq2_AR.byte( 1 ) ];
//            crc = crctable_profile02[ crc ^ _mESP_Disp_Rq2_AR.byte( 2 ) ];
//            crc = crctable_profile02[ crc ^ _mESP_Disp_Rq2_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mESP_Disp_Rq2_AR.byte( 4 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mESP_Disp_Rq2_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mESP_Disp_Rq2_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mESP_Disp_Rq2_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _ESP_Disp_Rq2_AR_CRC_Offset[ _mESP_Disp_Rq2_AR.SQC_DSR_Disp_Rq ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _ESP_Disp_Rq2_AR_CRC_ErrorCnt   && ( _ESP_Disp_Rq2_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_DSR_Disp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _ESP_Disp_Rq2_AR_CRC_ErrorCnt > 0 )
                    _ESP_Disp_Rq2_AR_CRC_ErrorCnt--; 
            }
            _mESP_Disp_Rq2_AR.CRC_DSR_Disp_Rq = crc;
            putValue( HMI_CRC_DSR_Disp_Rq, crc );
        }
        else
            _mESP_Disp_Rq2_AR.CRC_DSR_Disp_Rq = getValue( HMI_CRC_DSR_Disp_Rq );
    }
    else
    {
        if( !getValue( HMI_CRC_DSR_Disp_Rq_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mESP_Disp_Rq2_AR.byte( 0 ) ];
//            crc = crctable[ crc ^ _mESP_Disp_Rq2_AR.byte( 1 ) ];
//            crc = crctable[ crc ^ _mESP_Disp_Rq2_AR.byte( 2 ) ];
//            crc = crctable[ crc ^ _mESP_Disp_Rq2_AR.byte( 3 ) ];
//            crc = crctable[ crc ^ _mESP_Disp_Rq2_AR.byte( 4 ) ];  CRC
            crc = crctable[ crc ^ _mESP_Disp_Rq2_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mESP_Disp_Rq2_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mESP_Disp_Rq2_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _ESP_Disp_Rq2_AR_CRC_ErrorCnt   && ( _ESP_Disp_Rq2_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_DSR_Disp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _ESP_Disp_Rq2_AR_CRC_ErrorCnt > 0 )
                    _ESP_Disp_Rq2_AR_CRC_ErrorCnt--; 
            }
            _mESP_Disp_Rq2_AR.CRC_DSR_Disp_Rq = crc;
            putValue( HMI_CRC_DSR_Disp_Rq, crc );
        }
        else
            _mESP_Disp_Rq2_AR.CRC_DSR_Disp_Rq = getValue( HMI_CRC_DSR_Disp_Rq );
    }
    if( ( _ESP_Disp_Rq2_AR_MSG_DropCnt > 0 ) &&
        ( _ESP_Disp_Rq2_AR_E2E_Armed == 1  )    )
    {
        _ESP_Disp_Rq2_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mESP_Disp_Rq2_AR );
        
    if( _ESP_Disp_Rq2_AR_E2E_Armed == 1 )
    {
        if ( ( _ESP_Disp_Rq2_AR_MSG_DropCnt == 0      ) &&
             ( _ESP_Disp_Rq2_AR_CRC_ErrorCnt == 0     ) &&
             ( _ESP_Disp_Rq2_AR_SQC_RepeatedCnt == 0  ) &&
             ( _ESP_Disp_Rq2_AR_SQC_WrongSeqJump == 0 )    )
        {
            _ESP_Disp_Rq2_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_DSR_Disp_Rq_State, 0 );
        }
    }
}

ESP_Disp_Rq2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: ESP_Disp_Rq2_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_ESP_Disp_Rq2_AR := %X\n", getValue( HMI__STMSG_ESP_Disp_Rq2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_ESP_Disp_Rq2_AR := %X\n", getValue( HMI__STMSGT_ESP_Disp_Rq2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ABS_Actv_Stat_EDR := %X\n", getValue( HMI_ABS_Actv_Stat_EDR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_DSR_Disp_Rq := %X\n", getValue( HMI_CRC_DSR_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_DSR_Disp_Rq_Auto := %X\n", getValue( HMI_CRC_DSR_Disp_Rq_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrowDtct_Actv := %X\n", getValue( HMI_DrowDtct_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrowDtct_DrvTmHour_Disp_Rq := %X\n", getValue( HMI_DrowDtct_DrvTmHour_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrowDtct_DrvTmMinute_Disp_Rq := %X\n", getValue( HMI_DrowDtct_DrvTmMinute_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrowDtctIndLmp_On_Rq := %X\n", getValue( HMI_DrowDtctIndLmp_On_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrowLvl_Disp_Rq := %X\n", getValue( HMI_DrowLvl_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrowLvlDisp_Md_Rq := %X\n", getValue( HMI_DrowLvlDisp_Md_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrowWarn_Rq := %X\n", getValue( HMI_DrowWarn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DSR_Disp_Rq1 := %X\n", getValue( HMI_DSR_Disp_Rq1 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DSR_Disp_Rq2 := %X\n", getValue( HMI_DSR_Disp_Rq2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DSR_Disp_TrgrRq := %X\n", getValue( HMI_DSR_Disp_TrgrRq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DSR_SpdUnit_Rs := %X\n", getValue( HMI_DSR_SpdUnit_Rs ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DSR_Sw_LED_On_Rq := %X\n", getValue( HMI_DSR_Sw_LED_On_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ESP_Actv_Stat_EDR := %X\n", getValue( HMI_ESP_Actv_Stat_EDR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ESP_LastMd_Disp_Rq := %X\n", getValue( HMI_ESP_LastMd_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RoofLuggMd_MenuSubs_Rq := %X\n", getValue( HMI_RoofLuggMd_MenuSubs_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_DSR_Disp_Rq := %X\n", getValue( HMI_SQC_DSR_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_DSR_Disp_Rq_Auto := %X\n", getValue( HMI_SQC_DSR_Disp_Rq_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tESP_Disp_Rq2_AR
{
    putValue( HMI__STMSG_ESP_Disp_Rq2_AR, 0 );
}

on EnvVar HMI__STMSG_ESP_Disp_Rq2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_ESP_Disp_Rq2_AR );
        if( tDelay > 0)    
            setTimer( _tESP_Disp_Rq2_AR, tDelay );
        else
            putValue( HMI__STMSG_ESP_Disp_Rq2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_ESP_Disp_Rq2_AR
{
    if( getValue( this ) )
        openPanel("ESP_Disp_Rq2_AR");
}

on envVar HMI_E2E_DSR_Disp_Rq_Inject
{
    if( getValue( this ) )
    {
        _ESP_Disp_Rq2_AR_CRC_ErrorCnt = getValue( HMI_CRC_DSR_Disp_Rq_ErrorCount );
        _ESP_Disp_Rq2_AR_SQC_TriggPos = getValue( HMI_SQC_DSR_Disp_Rq_TriggerPosition );
        _ESP_Disp_Rq2_AR_SQC_WrongSeqJump = getValue( HMI_SQC_DSR_Disp_Rq_WrongSeq );
        _ESP_Disp_Rq2_AR_SQC_RepeatedCnt = getValue( HMI_SQC_DSR_Disp_Rq_Repeated );
        _ESP_Disp_Rq2_AR_MSG_DropCnt = getValue( HMI_SQC_DSR_Disp_Rq_MSG_DropCnt );
        putValue( HMI_E2E_DSR_Disp_Rq_State, 2 );
        _ESP_Disp_Rq2_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_ABS_Actv_Stat_EDR
{
    _mESP_Disp_Rq2_AR.ABS_Actv_Stat_EDR.phys = getValue(this);
    _ESP_Disp_Rq2_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrowDtct_Actv
{
    _mESP_Disp_Rq2_AR.DrowDtct_Actv.phys = getValue(this);
    _ESP_Disp_Rq2_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrowDtct_DrvTmHour_Disp_Rq
{
    _mESP_Disp_Rq2_AR.DrowDtct_DrvTmHour_Disp_Rq.phys = getValue(this);
    _ESP_Disp_Rq2_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrowDtct_DrvTmMinute_Disp_Rq
{
    _mESP_Disp_Rq2_AR.DrowDtct_DrvTmMinute_Disp_Rq.phys = getValue(this);
    _ESP_Disp_Rq2_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrowDtctIndLmp_On_Rq
{
    _mESP_Disp_Rq2_AR.DrowDtctIndLmp_On_Rq.phys = getValue(this);
    _ESP_Disp_Rq2_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrowLvl_Disp_Rq
{
    _mESP_Disp_Rq2_AR.DrowLvl_Disp_Rq.phys = getValue(this);
    _ESP_Disp_Rq2_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrowLvlDisp_Md_Rq
{
    _mESP_Disp_Rq2_AR.DrowLvlDisp_Md_Rq.phys = getValue(this);
    _ESP_Disp_Rq2_AR_SpontanFlag = 1;
}

on EnvVar HMI_DrowWarn_Rq
{
    _mESP_Disp_Rq2_AR.DrowWarn_Rq.phys = getValue(this);
    _ESP_Disp_Rq2_AR_SpontanFlag = 1;
}

on EnvVar HMI_DSR_Disp_Rq1
{
    _mESP_Disp_Rq2_AR.DSR_Disp_Rq1.phys = getValue(this);
    _ESP_Disp_Rq2_AR_SpontanFlag = 1;
}

on EnvVar HMI_DSR_Disp_Rq2
{
    _mESP_Disp_Rq2_AR.DSR_Disp_Rq2.phys = getValue(this);
    _ESP_Disp_Rq2_AR_SpontanFlag = 1;
}

on EnvVar HMI_DSR_Disp_TrgrRq
{
    _mESP_Disp_Rq2_AR.DSR_Disp_TrgrRq.phys = getValue(this);
    _ESP_Disp_Rq2_AR_SpontanFlag = 1;
}

on EnvVar HMI_DSR_SpdUnit_Rs
{
    _mESP_Disp_Rq2_AR.DSR_SpdUnit_Rs.phys = getValue(this);
    _ESP_Disp_Rq2_AR_SpontanFlag = 1;
}

on EnvVar HMI_DSR_Sw_LED_On_Rq
{
    _mESP_Disp_Rq2_AR.DSR_Sw_LED_On_Rq.phys = getValue(this);
	_mESP_Stat1_VAN_AR.DSR_Sw_LED_On_Rq.phys = getValue(this);
	
    _ESP_Disp_Rq2_AR_SpontanFlag = 1;
	_ESP_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_ESP_Actv_Stat_EDR
{
    _mESP_Disp_Rq2_AR.ESP_Actv_Stat_EDR.phys = getValue(this);
    _ESP_Disp_Rq2_AR_SpontanFlag = 1;
}

on EnvVar HMI_ESP_LastMd_Disp_Rq
{
    _mESP_Disp_Rq2_AR.ESP_LastMd_Disp_Rq.phys = getValue(this);
    _ESP_Disp_Rq2_AR_SpontanFlag = 1;
}

on EnvVar HMI_RoofLuggMd_MenuSubs_Rq
{
    _mESP_Disp_Rq2_AR.RoofLuggMd_MenuSubs_Rq.phys = getValue(this);
    _ESP_Disp_Rq2_AR_SpontanFlag = 1;
}

ESP_Disp_Rq3_AR_check_output()
{
    if( !getValue( HMI__STMSG_ESP_Disp_Rq3_AR ) )
    {
    //  message   ESP_Disp_Rq3_AR ID: 920 --- Sendeart 0 cyclicX --- 
        _ESP_Disp_Rq3_AR_Cnt--;
        if( _ESP_Disp_Rq3_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            ESP_Disp_Rq3_AR_output();
            // Zyklus-Z�hler zur�cksetzen
            _ESP_Disp_Rq3_AR_Cnt = _ESP_Disp_Rq3_AR_CycleCount;
        }
    }
}

ESP_Disp_Rq3_AR_init()
{   /* Botschaft ESP_Disp_Rq3_AR ID: 920 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 920 0;
BA_ "NmAsrMessage" BO_ 920 0;
BA_ "GenMsgMinAcceptLength" BO_ 920 8;
BA_ "GenMsgILSupport" BO_ 920 1;
BA_ "DiagState" BO_ 920 0;
BA_ "DiagRequest" BO_ 920 0;
BA_ "DiagResponse" BO_ 920 0;
BA_ "GenMsgStartValue" BO_ 920 "0";
BA_ "GenMsgCycleTime" BO_ 920 200;
BA_ "GenMsgSendType" BO_ 920 0;
    */
    _ESP_Disp_Rq3_AR_Timebase =            c_tDBKomTimer_20ms;
    _ESP_Disp_Rq3_AR_CycleCount =         200 / _ESP_Disp_Rq3_AR_Timebase;
    _ESP_Disp_Rq3_AR_StartDelay =           0 / _ESP_Disp_Rq3_AR_Timebase;
    _ESP_Disp_Rq3_AR_Cnt = _ESP_Disp_Rq3_AR_StartDelay;

    putValue( HMI__STMSGSD_ESP_Disp_Rq3_AR, _ESP_Disp_Rq3_AR_StartDelay * _ESP_Disp_Rq3_AR_Timebase );

    _mESP_Disp_Rq3_AR.DrowDtct_Md_Stat.phys = getValue( HMI_DrowDtct_Md_Stat );	
	_mESP_Disp_Rq3_AR.DrvTrq_FL_Disp_Rq_ESP.phys = getValue( HMI_DrvTrq_FL_Disp_Rq_ESP );
	_mESP_Disp_Rq3_AR.DrvTrq_FR_Disp_Rq_ESP.phys = getValue( HMI_DrvTrq_FR_Disp_Rq_ESP );
	_mESP_Disp_Rq3_AR.DrvTrq_RL_Disp_Rq_ESP.phys = getValue( HMI_DrvTrq_RL_Disp_Rq_ESP );
	_mESP_Disp_Rq3_AR.DrvTrq_RR_Disp_Rq_ESP.phys = getValue( HMI_DrvTrq_RR_Disp_Rq_ESP );	
    _mESP_Disp_Rq3_AR.Incl_X_Graph.phys = getValue( HMI_Incl_X_Graph );
    _mESP_Disp_Rq3_AR.Incl_X_Num.phys = getValue( HMI_Incl_X_Num );
    _mESP_Disp_Rq3_AR.Incl_Y_Graph.phys = getValue( HMI_Incl_Y_Graph );
    _mESP_Disp_Rq3_AR.Incl_Y_Num.phys = getValue( HMI_Incl_Y_Num );
    _mESP_Disp_Rq3_AR.ESP_OBD_ErrMemClr_Trgr.phys = getValue( HMI_ESP_OBD_ErrMemClr_Trgr );
}

ESP_Disp_Rq3_AR_output(void)
{
    output( _mESP_Disp_Rq3_AR );
}

ESP_Disp_Rq3_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: ESP_Disp_Rq3_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_ESP_Disp_Rq3_AR := %X\n", getValue( HMI__STMSG_ESP_Disp_Rq3_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_ESP_Disp_Rq3_AR := %X\n", getValue( HMI__STMSGT_ESP_Disp_Rq3_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrowDtct_Md_Stat := %X\n", getValue( HMI_DrowDtct_Md_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );	
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrvTrq_FL_Disp_Rq_ESP := %X\n", getValue( HMI_DrvTrq_FL_Disp_Rq_ESP ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrvTrq_FR_Disp_Rq_ESP := %X\n", getValue( HMI_DrvTrq_FR_Disp_Rq_ESP ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrvTrq_RL_Disp_Rq_ESP := %X\n", getValue( HMI_DrvTrq_RL_Disp_Rq_ESP ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_DrvTrq_RR_Disp_Rq_ESP := %X\n", getValue( HMI_DrvTrq_RR_Disp_Rq_ESP ) );    filePutString( buffer, elcount( buffer ), hFile );	
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Incl_X_Graph := %X\n", getValue( HMI_Incl_X_Graph ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Incl_X_Num := %X\n", getValue( HMI_Incl_X_Num ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Incl_Y_Graph := %X\n", getValue( HMI_Incl_Y_Graph ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Incl_Y_Num := %X\n", getValue( HMI_Incl_Y_Num ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tESP_Disp_Rq3_AR
{
    putValue( HMI__STMSG_ESP_Disp_Rq3_AR, 0 );
}

on EnvVar HMI__STMSG_ESP_Disp_Rq3_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_ESP_Disp_Rq3_AR );
        if( tDelay > 0)    
            setTimer( _tESP_Disp_Rq3_AR, tDelay );
        else
            putValue( HMI__STMSG_ESP_Disp_Rq3_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_ESP_Disp_Rq3_AR
{
    if( getValue( this ) )
        openPanel("ESP_Disp_Rq3_AR");
}

on EnvVar HMI_DrowDtct_Md_Stat
{
    _mESP_Disp_Rq3_AR.DrowDtct_Md_Stat.phys = getValue(this);
}

on EnvVar HMI_DrvTrq_FL_Disp_Rq_ESP
{
    _mESP_Disp_Rq3_AR.DrvTrq_FL_Disp_Rq_ESP.phys = getValue(this);
}

on EnvVar HMI_DrvTrq_FR_Disp_Rq_ESP
{
    _mESP_Disp_Rq3_AR.DrvTrq_FR_Disp_Rq_ESP.phys = getValue(this);
}

on EnvVar HMI_DrvTrq_RL_Disp_Rq_ESP
{
    _mESP_Disp_Rq3_AR.DrvTrq_RL_Disp_Rq_ESP.phys = getValue(this);
}

on EnvVar HMI_DrvTrq_RR_Disp_Rq_ESP
{
    _mESP_Disp_Rq3_AR.DrvTrq_RR_Disp_Rq_ESP.phys = getValue(this);
}

on EnvVar HMI_Incl_X_Graph
{
    _mESP_Disp_Rq3_AR.Incl_X_Graph.phys = getValue(this);
}

on EnvVar HMI_Incl_X_Num
{
    _mESP_Disp_Rq3_AR.Incl_X_Num.phys = getValue(this);
}

on EnvVar HMI_Incl_Y_Graph
{
    _mESP_Disp_Rq3_AR.Incl_Y_Graph.phys = getValue(this);
}

on EnvVar HMI_Incl_Y_Num
{
    _mESP_Disp_Rq3_AR.Incl_Y_Num.phys = getValue(this);
}

on EnvVar HMI_ESP_OBD_ErrMemClr_Trgr
{
    _mESP_Disp_Rq3_AR.ESP_OBD_ErrMemClr_Trgr.phys = getValue(this);
}

ESP_Disp_Rq_AMG_AR_check_output()
{
    if( !getValue( HMI__STMSG_ESP_Disp_Rq3_AR ) )
    {
    //  message   ESP_Disp_Rq_AMG_AR ID: 365 --- Sendeart 0 cyclicX --- 
        _ESP_Disp_Rq_AMG_AR_Cnt--;
        if( _ESP_Disp_Rq_AMG_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            ESP_Disp_Rq_AMG_AR_output();
            // Zyklus-Z�hler zur�cksetzen
            _ESP_Disp_Rq_AMG_AR_Cnt = _ESP_Disp_Rq_AMG_AR_CycleCount;
        }
    }
}

ESP_Disp_Rq_AMG_AR_init()
{   /* Botschaft ESP_Disp_Rq_AMG_AR ID: 365 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 365 0;
BA_ "NmAsrMessage" BO_ 365 0;
BA_ "GenMsgMinAcceptLength" BO_ 365 2;
BA_ "GenMsgILSupport" BO_ 365 1;
BA_ "DiagState" BO_ 365 0;
BA_ "DiagRequest" BO_ 365 0;
BA_ "DiagResponse" BO_ 365 0;
BA_ "GenMsgStartValue" BO_ 365 "0";
BA_ "GenMsgStartDelayTime" BO_ 365 35;
BA_ "GenMsgCycleTime" BO_ 365 40;
BA_ "GenMsgSendType" BO_ 365 0;
    */
    _ESP_Disp_Rq_AMG_AR_Timebase =            c_tDBKomTimer_20ms;
    _ESP_Disp_Rq_AMG_AR_CycleCount =          40 / _ESP_Disp_Rq_AMG_AR_Timebase;
    _ESP_Disp_Rq_AMG_AR_StartDelay =          35 / _ESP_Disp_Rq_AMG_AR_Timebase;
    _ESP_Disp_Rq_AMG_AR_Cnt = _ESP_Disp_Rq_AMG_AR_StartDelay;

    putValue( HMI__STMSGSD_ESP_Disp_Rq_AMG_AR, _ESP_Disp_Rq_AMG_AR_StartDelay * _ESP_Disp_Rq_AMG_AR_Timebase );

    _mESP_Disp_Rq_AMG_AR.VehAccel_Y_V3.phys = getValue( HMI_VehAccel_Y_V3 );
}

ESP_Disp_Rq_AMG_AR_output(void)
{
    output( _mESP_Disp_Rq_AMG_AR );
}

ESP_Disp_Rq_AMG_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: ESP_Disp_Rq_AMG_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_ESP_Disp_Rq_AMG_AR := %X\n", getValue( HMI__STMSG_ESP_Disp_Rq_AMG_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_ESP_Disp_Rq_AMG_AR := %X\n", getValue( HMI__STMSGT_ESP_Disp_Rq_AMG_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehAccel_Y_V3 := %X\n", getValue( HMI_VehAccel_Y_V3 ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tESP_Disp_Rq_AMG_AR
{
    putValue( HMI__STMSG_ESP_Disp_Rq_AMG_AR, 0 );
}

on EnvVar HMI__STMSG_ESP_Disp_Rq_AMG_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_ESP_Disp_Rq_AMG_AR );
        if( tDelay > 0)    
            setTimer( _tESP_Disp_Rq_AMG_AR, tDelay );
        else
            putValue( HMI__STMSG_ESP_Disp_Rq_AMG_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_ESP_Disp_Rq_AMG_AR
{
    if( getValue( this ) )
        openPanel("ESP_Disp_Rq_AMG_AR");
}

on EnvVar HMI_VehAccel_Y_V3
{
    _mESP_Disp_Rq_AMG_AR.VehAccel_Y_V3.phys = getValue(this);
}

ESP_Stat1_VAN_AR_check_output()
{
    if( !getValue( HMI__STMSG_ESP_Stat1_VAN_AR ) )
    {
    //  message   ESP_Stat1_VAN_AR ID: 628 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _ESP_Stat1_VAN_AR_DelayCnt > 0) _ESP_Stat1_VAN_AR_DelayCnt--; // Mindestsendeabstand
        _ESP_Stat1_VAN_AR_Cnt--;
        if( _ESP_Stat1_VAN_AR_Cnt < 1 )
        {
            if( _ESP_Stat1_VAN_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                ESP_Stat1_VAN_AR_output();
                 _ESP_Stat1_VAN_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _ESP_Stat1_VAN_AR_DelayCnt = _ESP_Stat1_VAN_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _ESP_Stat1_VAN_AR_SpontanFlag = 1;
            }
            _ESP_Stat1_VAN_AR_Cnt = _ESP_Stat1_VAN_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _ESP_Stat1_VAN_AR_SpontanFlag)
        {
            if( _ESP_Stat1_VAN_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                ESP_Stat1_VAN_AR_output();
                _ESP_Stat1_VAN_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _ESP_Stat1_VAN_AR_DelayCnt = _ESP_Stat1_VAN_AR_MinDelay;
            }
        }
    }
}

ESP_Stat1_VAN_AR_init()
{   /* Botschaft ESP_Stat1_VAN_AR  ID: 628 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 628 0;
BA_ "NmAsrMessage" BO_ 628 0;
BA_ "GenMsgMinAcceptLength" BO_ 628 8;
BA_ "GenMsgILSupport" BO_ 628 1;
BA_ "DiagState" BO_ 628 0;
BA_ "DiagRequest" BO_ 628 0;
BA_ "DiagResponse" BO_ 628 0;
BA_ "GenMsgStartValue" BO_ 628 "0";
BA_ "GenMsgDelayTime" BO_ 628 5;
BA_ "GenMsgNrOfRepetition" BO_ 628 0;
BA_ "GenMsgCycleTime" BO_ 628 100;
BA_ "GenMsgSendType" BO_ 628 5;
    */
    _ESP_Stat1_VAN_AR_Timebase =             c_tDBKomTimer_20ms;
    _ESP_Stat1_VAN_AR_CycleCount =          100 / _ESP_Stat1_VAN_AR_Timebase;
    _ESP_Stat1_VAN_AR_StartDelay =            0 / _ESP_Stat1_VAN_AR_Timebase;
    _ESP_Stat1_VAN_AR_MinDelay =              5 / _ESP_Stat1_VAN_AR_Timebase;
    _ESP_Stat1_VAN_AR_Cnt = _ESP_Stat1_VAN_AR_StartDelay;
    _ESP_Stat1_VAN_AR_SpontanFlag = 0;
    _ESP_Stat1_VAN_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_ESP_Stat1_VAN_AR, _ESP_Stat1_VAN_AR_StartDelay * _ESP_Stat1_VAN_AR_Timebase);
    
    _mESP_Stat1_VAN_AR.ABS_Dstrb.phys = getValue( HMI_ABS_Dstrb );
    _mESP_Stat1_VAN_AR.BrkIntrvntn_Actv_CWA_Disp_Rq_VAN.phys = getValue( HMI_BrkIntrvntn_Actv_CWA_Disp_Rq_VAN );
    _mESP_Stat1_VAN_AR.BrkSys_Stat_VAN.phys = getValue( HMI_BrkSys_Stat_VAN );
    _mESP_Stat1_VAN_AR.BrkTrq_ABH.phys = getValue( HMI_BrkTrq_ABH );
    _mESP_Stat1_VAN_AR.DSR_Sw_LED_On_Rq.phys = getValue( HMI_DSR_Sw_LED_On_Rq_ );
    _mESP_Stat1_VAN_AR.Retarder_Off_Rq.phys = getValue( HMI_Retarder_Off_Rq );
    _mESP_Stat1_VAN_AR.Rsrv2_ESP_Stat_VAN.phys = getValue( HMI_Rsrv2_ESP_Stat_VAN );
    _mESP_Stat1_VAN_AR.Rsrv3_ESP_Stat_VAN.phys = getValue( HMI_Rsrv3_ESP_Stat_VAN );
    _mESP_Stat1_VAN_AR.ABH_Veh_Stbl.phys = getValue( HMI_ABH_Veh_Stbl );
    _mESP_Stat1_VAN_AR.AnaSwInStat1_Rs.phys = getValue( HMI_AnaSwInStat1_Rs );
}

ESP_Stat1_VAN_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_ESP_Stat1_VAN ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_ESP_Stat1_VAN_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _ESP_Stat1_VAN_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _ESP_Stat1_VAN_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_ESP_Stat1_VAN_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _ESP_Stat1_VAN_AR_SQC_WrongSeqJump != 0 ) &&
            ( _ESP_Stat1_VAN_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _ESP_Stat1_VAN_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _ESP_Stat1_VAN_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _ESP_Stat1_VAN_AR_SQC_RepeatedCnt ) &&
            ( _ESP_Stat1_VAN_AR_E2E_Armed == 1  )    )
        {
            _ESP_Stat1_VAN_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_ESP_Stat1_VAN, SQC_help );
    }
    _mESP_Stat1_VAN_AR.SQC_ESP_Stat1_VAN = SQC_help;

    if( getValue( HMI_CRC_ESP_Stat1_VAN_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_ESP_Stat1_VAN_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable_profile02[ crc ^ _mESP_Stat1_VAN_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mESP_Stat1_VAN_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mESP_Stat1_VAN_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mESP_Stat1_VAN_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mESP_Stat1_VAN_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mESP_Stat1_VAN_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mESP_Stat1_VAN_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mESP_Stat1_VAN_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _ESP_Stat1_VAN_AR_CRC_Offset[ _mESP_Stat1_VAN_AR.SQC_ESP_Stat1_VAN ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _ESP_Stat1_VAN_AR_CRC_ErrorCnt   && ( _ESP_Stat1_VAN_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_ESP_Stat1_VAN_Invalid )                                         )    )
            {
                crc++;
                if( _ESP_Stat1_VAN_AR_CRC_ErrorCnt > 0 )
                    _ESP_Stat1_VAN_AR_CRC_ErrorCnt--; 
            }
            _mESP_Stat1_VAN_AR.CRC_ESP_Stat1_VAN = crc;
            putValue( HMI_CRC_ESP_Stat1_VAN, crc );
        }
        else
            _mESP_Stat1_VAN_AR.CRC_ESP_Stat1_VAN = getValue( HMI_CRC_ESP_Stat1_VAN );
    }
    else
    {
        if( !getValue( HMI_CRC_ESP_Stat1_VAN_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mESP_Stat1_VAN_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mESP_Stat1_VAN_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mESP_Stat1_VAN_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mESP_Stat1_VAN_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mESP_Stat1_VAN_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mESP_Stat1_VAN_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mESP_Stat1_VAN_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mESP_Stat1_VAN_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _ESP_Stat1_VAN_AR_CRC_ErrorCnt   && ( _ESP_Stat1_VAN_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_ESP_Stat1_VAN_Invalid )                                         )    )
            {
                crc++;
                if( _ESP_Stat1_VAN_AR_CRC_ErrorCnt > 0 )
                    _ESP_Stat1_VAN_AR_CRC_ErrorCnt--; 
            }
            _mESP_Stat1_VAN_AR.CRC_ESP_Stat1_VAN = crc;
            putValue( HMI_CRC_ESP_Stat1_VAN, crc );
        }
        else
            _mESP_Stat1_VAN_AR.CRC_ESP_Stat1_VAN = getValue( HMI_CRC_ESP_Stat1_VAN );
    }
    if( ( _ESP_Stat1_VAN_AR_MSG_DropCnt > 0 ) &&
        ( _ESP_Stat1_VAN_AR_E2E_Armed == 1  )    )
    {
        _ESP_Stat1_VAN_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mESP_Stat1_VAN_AR );
        
    if( _ESP_Stat1_VAN_AR_E2E_Armed == 1 )
    {
        if ( ( _ESP_Stat1_VAN_AR_MSG_DropCnt == 0      ) &&
             ( _ESP_Stat1_VAN_AR_CRC_ErrorCnt == 0     ) &&
             ( _ESP_Stat1_VAN_AR_SQC_RepeatedCnt == 0  ) &&
             ( _ESP_Stat1_VAN_AR_SQC_WrongSeqJump == 0 )    )
        {
            _ESP_Stat1_VAN_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_ESP_Stat1_VAN_State, 0 );
        }
    }
}

ESP_Stat1_VAN_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: ESP_Stat1_VAN_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_ESP_Stat1_VAN_AR := %X\n", getValue( HMI__STMSG_ESP_Stat1_VAN_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_ESP_Stat1_VAN_AR := %X\n", getValue( HMI__STMSGT_ESP_Stat1_VAN_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ESP_Stat1_VAN := %X\n", getValue( HMI_CRC_ESP_Stat1_VAN ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ESP_Stat1_VAN_Auto := %X\n", getValue( HMI_CRC_ESP_Stat1_VAN_Auto ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ESP_Stat1_VAN_Profile_02 := %X\n", getValue( HMI_CRC_ESP_Stat1_VAN_Profile_02 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ABS_Dstrb := %X\n", getValue( HMI_ABS_Dstrb ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkIntrvntn_Actv_CWA_Disp_Rq_VAN_ := %X\n", getValue( HMI_BrkIntrvntn_Actv_CWA_Disp_Rq_VAN ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkSys_Stat_VAN_ := %X\n", getValue( HMI_BrkSys_Stat_VAN ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkTrq_ABH := %X\n", getValue( HMI_BrkTrq_ABH ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DSR_Sw_LED_On_Rq := %X\n", getValue( HMI_DSR_Sw_LED_On_Rq_ ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Retarder_Off_Rq := %X\n", getValue( HMI_Retarder_Off_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_ESP_Stat_VAN := %X\n", getValue( HMI_Rsrv2_ESP_Stat_VAN ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv3_ESP_Stat_VAN := %X\n", getValue( HMI_Rsrv3_ESP_Stat_VAN ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_ESP_Stat1_VAN := %X\n", getValue( HMI_SQC_ESP_Stat1_VAN ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_ESP_Stat1_VAN_Auto := %X\n", getValue( HMI_SQC_ESP_Stat1_VAN_Auto ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ABH_Veh_Stbl := %X\n", getValue( HMI_ABH_Veh_Stbl ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AnaSwInStat1_Rs := %X\n", getValue( HMI_AnaSwInStat1_Rs ) );    filePutString ( buffer, elcount( buffer ), hFile );
    }

on timer _tESP_Stat1_VAN_AR
{
    putValue( HMI__STMSG_ESP_Stat1_VAN_AR, 0 );
}

on EnvVar HMI__STMSG_ESP_Stat1_VAN_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_ESP_Stat1_VAN_AR );
        if( tDelay > 0)    
            setTimer( _tESP_Stat1_VAN_AR, tDelay );
        else
            putValue( HMI__STMSG_ESP_Stat1_VAN_AR, 0 );
    }
}

on envVar HMI_E2E_ESP_Stat1_VAN_Inject
{
    if( getValue( this ) )
    {
        _ESP_Stat1_VAN_AR_CRC_ErrorCnt = getValue( HMI_CRC_ESP_Stat1_VAN_ErrorCount );
        _ESP_Stat1_VAN_AR_SQC_TriggPos = getValue( HMI_SQC_ESP_Stat1_VAN_TriggerPosition );
        _ESP_Stat1_VAN_AR_SQC_WrongSeqJump = getValue( HMI_SQC_ESP_Stat1_VAN_WrongSeq );
        _ESP_Stat1_VAN_AR_SQC_RepeatedCnt = getValue( HMI_SQC_ESP_Stat1_VAN_Repeated );
        _ESP_Stat1_VAN_AR_MSG_DropCnt = getValue( HMI_SQC_ESP_Stat1_VAN_MSG_DropCnt );
        putValue( HMI_E2E_ESP_Stat1_VAN_State, 2 );
        _ESP_Stat1_VAN_AR_E2E_Armed = 2;  //armed
    }
}

on envVar HMI__STMSG_PO_ESP_Stat1_VAN_AR
{
    if( getValue( this ) )
        openPanel("ESP_Stat1_VAN_AR");
}

on EnvVar HMI_ABS_Dstrb
{
    _mESP_Stat1_VAN_AR.ABS_Dstrb.phys = getValue(this);
    _ESP_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_BrkIntrvntn_Actv_CWA_Disp_Rq_VAN
{
    _mESP_Stat1_VAN_AR.BrkIntrvntn_Actv_CWA_Disp_Rq_VAN.phys = getValue(this);
    _ESP_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_BrkSys_Stat_VAN
{
    _mESP_Stat1_VAN_AR.BrkSys_Stat_VAN.phys = getValue(this);
    _ESP_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_BrkTrq_ABH
{
    _mESP_Stat1_VAN_AR.BrkTrq_ABH.phys = getValue(this);
    _ESP_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Retarder_Off_Rq
{
    _mESP_Stat1_VAN_AR.Retarder_Off_Rq.phys = getValue(this);
    _ESP_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv2_ESP_Stat_VAN
{
    _mESP_Stat1_VAN_AR.Rsrv2_ESP_Stat_VAN.phys = getValue(this);
    _ESP_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv3_ESP_Stat_VAN
{
    _mESP_Stat1_VAN_AR.Rsrv3_ESP_Stat_VAN.phys = getValue(this);
    _ESP_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_ABH_Veh_Stbl
{
    _mESP_Stat1_VAN_AR.ABH_Veh_Stbl.phys = getValue(this);
    _ESP_Stat1_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_AnaSwInStat1_Rs
{
    _mESP_Stat1_VAN_AR.AnaSwInStat1_Rs.phys = getValue(this);
    _ESP_Stat1_VAN_AR_SpontanFlag = 1;
}

EVC_CfgBit_01_32_AR_check_output()
{
    if( !getValue( HMI__STMSG_EVC_CfgBit_01_32_AR ) )
    {
    //  message   EVC_CfgBit_01_32_AR ID: 753 --- Sendeart 0 cyclicX --- 
        _EVC_CfgBit_01_32_AR_Cnt--;
        if( _EVC_CfgBit_01_32_AR_Cnt < 1 )
        {
            EVC_CfgBit_01_32_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _EVC_CfgBit_01_32_AR_Cnt = _EVC_CfgBit_01_32_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

EVC_CfgBit_01_32_AR_init()
{   /* Botschaft EVC_CfgBit_01_32_AR ID: 753 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 753 0;
BA_ "NmAsrMessage" BO_ 753 0;
BA_ "GenMsgMinAcceptLength" BO_ 753 8;
BA_ "GenMsgILSupport" BO_ 753 1;
BA_ "DiagState" BO_ 753 0;
BA_ "DiagRequest" BO_ 753 0;
BA_ "DiagResponse" BO_ 753 0;
BA_ "GenMsgStartValue" BO_ 753 "0";
BA_ "GenMsgStartDelayTime" BO_ 753 225;
BA_ "GenMsgCycleTime" BO_ 753 1000;
BA_ "GenMsgSendType" BO_ 753 0;
    */
    _EVC_CfgBit_01_32_AR_Timebase =        c_tDBKomTimer_20ms;
    _EVC_CfgBit_01_32_AR_CycleCount =    1000 / _EVC_CfgBit_01_32_AR_Timebase;
    _EVC_CfgBit_01_32_AR_StartDelay =     225 / _EVC_CfgBit_01_32_AR_Timebase;
    _EVC_CfgBit_01_32_AR_Cnt = _EVC_CfgBit_01_32_AR_StartDelay;

    putValue( HMI__STMSGSD_EVC_CfgBit_01_32_AR, _EVC_CfgBit_01_32_AR_StartDelay * _EVC_CfgBit_01_32_AR_Timebase );

    _mEVC_CfgBit_01_32_AR.EVC_01_Ver_USA_Avl.phys = getValue( HMI_EVC_01_Ver_USA_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_02_Ver_Mexico_Avl.phys = getValue( HMI_EVC_02_Ver_Mexico_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_03_Ver_Japan_Avl.phys = getValue( HMI_EVC_03_Ver_Japan_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_04_Ver_GulfStates_Avl.phys = getValue( HMI_EVC_04_Ver_GulfStates_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_05_Ver_Australia_Avl.phys = getValue( HMI_EVC_05_Ver_Australia_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_06_Ver_China_Avl.phys = getValue( HMI_EVC_06_Ver_China_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_07_Ver_S_Korea_Avl.phys = getValue( HMI_EVC_07_Ver_S_Korea_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_08_Ver_Canada_Avl.phys = getValue( HMI_EVC_08_Ver_Canada_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_09_FullHyb_Avl.phys = getValue( HMI_EVC_09_FullHyb_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_0A_Hyb_20kW_Avl.phys = getValue( HMI_EVC_0A_Hyb_20kW_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_0B_PlugInHyb_80kW_Avl.phys = getValue( HMI_EVC_0B_PlugInHyb_80kW_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_0C_AllWheelDr_Avl.phys = getValue( HMI_EVC_0C_AllWheelDr_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_0D_4x2Drive_Avl.phys = getValue( HMI_EVC_0D_4x2Drive_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_0E_Presf_Avl.phys = getValue( HMI_EVC_0E_Presf_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_0F_TrlrHtch_Avl.phys = getValue( HMI_EVC_0F_TrlrHtch_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_10_KG_Avl.phys = getValue( HMI_EVC_10_KG_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_11_AutTrunkLid_Avl.phys = getValue( HMI_EVC_11_AutTrunkLid_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_12_AutRearDr_Avl.phys = getValue( HMI_EVC_12_AutRearDr_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_13_PwrCls_Avl.phys = getValue( HMI_EVC_13_PwrCls_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_14_RainSens_Avl.phys = getValue( HMI_EVC_14_RainSens_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_15_DRLt_Avl.phys = getValue( HMI_EVC_15_DRLt_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_16_FogLmp_Avl.phys = getValue( HMI_EVC_16_FogLmp_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_17_IL_Pk_Avl.phys = getValue( HMI_EVC_17_IL_Pk_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_18_AmbLgt_Avl.phys = getValue( HMI_EVC_18_AmbLgt_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_19_ElDrPosnSel_Avl.phys = getValue( HMI_EVC_19_ElDrPosnSel_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_1A_IntSfProt_Avl.phys = getValue( HMI_EVC_1A_IntSfProt_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_1B_VTA_Avl.phys = getValue( HMI_EVC_1B_VTA_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_1C_HghVTP_Avl.phys = getValue( HMI_EVC_1C_HghVTP_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_1D_SecurityVer_Avl.phys = getValue( HMI_EVC_1D_SecurityVer_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_1E_GuardLvl_B4_Avl.phys = getValue( HMI_EVC_1E_GuardLvl_B4_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_1F_GuardLvl_B6_Avl.phys = getValue( HMI_EVC_1F_GuardLvl_B6_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_20_GuardLvl_B7_Avl.phys = getValue( HMI_EVC_20_GuardLvl_B7_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_21_Pullman_Avl.phys = getValue( HMI_EVC_21_Pullman_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_22_SpecClos_Avl.phys = getValue( HMI_EVC_22_SpecClos_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_23_PASS_Avl.phys = getValue( HMI_EVC_23_PASS_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_24_ICH_Avl.phys = getValue( HMI_EVC_24_ICH_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_25_HVAC_R_Avl.phys = getValue( HMI_EVC_25_HVAC_R_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_26_SSA_Avl.phys = getValue( HMI_EVC_26_SSA_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_27_HandsFreeAcc_Avl.phys = getValue( HMI_EVC_27_HandsFreeAcc_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_28_PlugInHyb_50kW_Avl.phys = getValue( HMI_EVC_28_PlugInHyb_50kW_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_29_Hyb_30kW_Avl.phys = getValue( HMI_EVC_29_Hyb_30kW_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_2A_SeatElAdj_F_OprtnR_Avl.phys = getValue( HMI_EVC_2A_SeatElAdj_F_OprtnR_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_2B_DSI_Sel_Avl.phys = getValue( HMI_EVC_2B_DSI_Sel_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_2C_WC_VEDA_Avl.phys = getValue( HMI_EVC_2C_WC_VEDA_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_2D_AutoSpdCtrl_Avl.phys = getValue( HMI_EVC_2D_AutoSpdCtrl_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_2E_AddEquipBlock_Avl.phys = getValue( HMI_EVC_2E_AddEquipBlock_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_2F_RetrofitFuelcell_Avl.phys = getValue( HMI_EVC_2F_RetrofitFuelcell_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_30_RearStWhl_Avl.phys = getValue( HMI_EVC_30_RearStWhl_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_31_PlugInHyb_75_84kW_Avl.phys = getValue( HMI_EVC_31_PlugInHyb_75_84kW_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_32_Hyb_ME10_Avl.phys = getValue( HMI_EVC_32_Hyb_ME10_Avl );
    _mEVC_CfgBit_01_32_AR.EVC_CfgBit_01_32_Stat.phys = getValue( HMI_EVC_CfgBit_01_32_Stat );
}

EVC_CfgBit_01_32_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_EVC_CfgBit_01_32 ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_EVC_CfgBit_01_32_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _EVC_CfgBit_01_32_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _EVC_CfgBit_01_32_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_EVC_CfgBit_01_32_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _EVC_CfgBit_01_32_AR_SQC_WrongSeqJump != 0 ) &&
            ( _EVC_CfgBit_01_32_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _EVC_CfgBit_01_32_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _EVC_CfgBit_01_32_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _EVC_CfgBit_01_32_AR_SQC_RepeatedCnt ) &&
            ( _EVC_CfgBit_01_32_AR_E2E_Armed == 1  )    )
        {
            _EVC_CfgBit_01_32_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_EVC_CfgBit_01_32, SQC_help );
    }
    _mEVC_CfgBit_01_32_AR.SQC_EVC_CfgBit_01_32 = SQC_help;

    if( getValue( HMI_CRC_EVC_CfgBit_01_32_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_EVC_CfgBit_01_32_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mEVC_CfgBit_01_32_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_01_32_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_01_32_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_01_32_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_01_32_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_01_32_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_01_32_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_01_32_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _EVC_CfgBit_01_32_AR_CRC_Offset[ _mEVC_CfgBit_01_32_AR.SQC_EVC_CfgBit_01_32 ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _EVC_CfgBit_01_32_AR_CRC_ErrorCnt   && ( _EVC_CfgBit_01_32_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EVC_CfgBit_01_32_Invalid )                                         )    )
            {
                crc++;
                if( _EVC_CfgBit_01_32_AR_CRC_ErrorCnt > 0 )
                    _EVC_CfgBit_01_32_AR_CRC_ErrorCnt--; 
            }
            _mEVC_CfgBit_01_32_AR.CRC_EVC_CfgBit_01_32 = crc;
            putValue( HMI_CRC_EVC_CfgBit_01_32, crc );
        }
        else
            _mEVC_CfgBit_01_32_AR.CRC_EVC_CfgBit_01_32 = getValue( HMI_CRC_EVC_CfgBit_01_32 );
    }
    else
    {
        if( !getValue( HMI_CRC_EVC_CfgBit_01_32_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mEVC_CfgBit_01_32_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mEVC_CfgBit_01_32_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_01_32_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_01_32_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_01_32_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_01_32_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_01_32_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mEVC_CfgBit_01_32_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _EVC_CfgBit_01_32_AR_CRC_ErrorCnt   && ( _EVC_CfgBit_01_32_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EVC_CfgBit_01_32_Invalid )                                         )    )
            {
                crc++;
                if( _EVC_CfgBit_01_32_AR_CRC_ErrorCnt > 0 )
                    _EVC_CfgBit_01_32_AR_CRC_ErrorCnt--; 
            }
            _mEVC_CfgBit_01_32_AR.CRC_EVC_CfgBit_01_32 = crc;
            putValue( HMI_CRC_EVC_CfgBit_01_32, crc );
        }
        else
            _mEVC_CfgBit_01_32_AR.CRC_EVC_CfgBit_01_32 = getValue( HMI_CRC_EVC_CfgBit_01_32 );
    }
    if( ( _EVC_CfgBit_01_32_AR_MSG_DropCnt > 0 ) &&
        ( _EVC_CfgBit_01_32_AR_E2E_Armed == 1  )    )
    {
        _EVC_CfgBit_01_32_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mEVC_CfgBit_01_32_AR );
        
    if( _EVC_CfgBit_01_32_AR_E2E_Armed == 1 )
    {
        if ( ( _EVC_CfgBit_01_32_AR_MSG_DropCnt == 0      ) &&
             ( _EVC_CfgBit_01_32_AR_CRC_ErrorCnt == 0     ) &&
             ( _EVC_CfgBit_01_32_AR_SQC_RepeatedCnt == 0  ) &&
             ( _EVC_CfgBit_01_32_AR_SQC_WrongSeqJump == 0 )    )
        {
            _EVC_CfgBit_01_32_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_EVC_CfgBit_01_32_State, 0 );
        }
    }
}

EVC_CfgBit_01_32_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: EVC_CfgBit_01_32_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_EVC_CfgBit_01_32_AR := %X\n", getValue( HMI__STMSG_EVC_CfgBit_01_32_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_EVC_CfgBit_01_32_AR := %X\n", getValue( HMI__STMSGT_EVC_CfgBit_01_32_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EVC_CfgBit_01_32 := %X\n", getValue( HMI_CRC_EVC_CfgBit_01_32 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EVC_CfgBit_01_32_Auto := %X\n", getValue( HMI_CRC_EVC_CfgBit_01_32_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_01_Ver_USA_Avl := %X\n", getValue( HMI_EVC_01_Ver_USA_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_02_Ver_Mexico_Avl := %X\n", getValue( HMI_EVC_02_Ver_Mexico_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_03_Ver_Japan_Avl := %X\n", getValue( HMI_EVC_03_Ver_Japan_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_04_Ver_GulfStates_Avl := %X\n", getValue( HMI_EVC_04_Ver_GulfStates_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_05_Ver_Australia_Avl := %X\n", getValue( HMI_EVC_05_Ver_Australia_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_06_Ver_China_Avl := %X\n", getValue( HMI_EVC_06_Ver_China_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_07_Ver_S_Korea_Avl := %X\n", getValue( HMI_EVC_07_Ver_S_Korea_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_08_Ver_Canada_Avl := %X\n", getValue( HMI_EVC_08_Ver_Canada_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_09_FullHyb_Avl := %X\n", getValue( HMI_EVC_09_FullHyb_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_0A_Hyb_20kW_Avl := %X\n", getValue( HMI_EVC_0A_Hyb_20kW_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_0B_PlugInHyb_80kW_Avl := %X\n", getValue( HMI_EVC_0B_PlugInHyb_80kW_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_0C_AllWheelDr_Avl := %X\n", getValue( HMI_EVC_0C_AllWheelDr_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_0D_4x2Drive_Avl := %X\n", getValue( HMI_EVC_0D_4x2Drive_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_0E_Presf_Avl := %X\n", getValue( HMI_EVC_0E_Presf_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_0F_TrlrHtch_Avl := %X\n", getValue( HMI_EVC_0F_TrlrHtch_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_10_KG_Avl := %X\n", getValue( HMI_EVC_10_KG_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_11_AutTrunkLid_Avl := %X\n", getValue( HMI_EVC_11_AutTrunkLid_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_12_AutRearDr_Avl := %X\n", getValue( HMI_EVC_12_AutRearDr_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_13_PwrCls_Avl := %X\n", getValue( HMI_EVC_13_PwrCls_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_14_RainSens_Avl := %X\n", getValue( HMI_EVC_14_RainSens_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_15_DRLt_Avl := %X\n", getValue( HMI_EVC_15_DRLt_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_16_FogLmp_Avl := %X\n", getValue( HMI_EVC_16_FogLmp_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_17_IL_Pk_Avl := %X\n", getValue( HMI_EVC_17_IL_Pk_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_18_AmbLgt_Avl := %X\n", getValue( HMI_EVC_18_AmbLgt_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_19_ElDrPosnSel_Avl := %X\n", getValue( HMI_EVC_19_ElDrPosnSel_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_1A_IntSfProt_Avl := %X\n", getValue( HMI_EVC_1A_IntSfProt_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_1B_VTA_Avl := %X\n", getValue( HMI_EVC_1B_VTA_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_1C_HghVTP_Avl := %X\n", getValue( HMI_EVC_1C_HghVTP_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_1D_SecurityVer_Avl := %X\n", getValue( HMI_EVC_1D_SecurityVer_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_1E_GuardLvl_B4_Avl := %X\n", getValue( HMI_EVC_1E_GuardLvl_B4_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_1F_GuardLvl_B6_Avl := %X\n", getValue( HMI_EVC_1F_GuardLvl_B6_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_20_GuardLvl_B7_Avl := %X\n", getValue( HMI_EVC_20_GuardLvl_B7_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_21_Pullman_Avl := %X\n", getValue( HMI_EVC_21_Pullman_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_22_SpecClos_Avl := %X\n", getValue( HMI_EVC_22_SpecClos_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_23_PASS_Avl := %X\n", getValue( HMI_EVC_23_PASS_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_24_ICH_Avl := %X\n", getValue( HMI_EVC_24_ICH_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_25_HVAC_R_Avl := %X\n", getValue( HMI_EVC_25_HVAC_R_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_26_SSA_Avl := %X\n", getValue( HMI_EVC_26_SSA_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_27_HandsFreeAcc_Avl := %X\n", getValue( HMI_EVC_27_HandsFreeAcc_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_28_PlugInHyb_50kW_Avl := %X\n", getValue( HMI_EVC_28_PlugInHyb_50kW_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_29_Hyb_30kW_Avl := %X\n", getValue( HMI_EVC_29_Hyb_30kW_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_2A_SeatElAdj_F_OprtnR_Avl := %X\n", getValue( HMI_EVC_2A_SeatElAdj_F_OprtnR_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_2B_DSI_Sel_Avl := %X\n", getValue( HMI_EVC_2B_DSI_Sel_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_2C_WC_VEDA_Avl := %X\n", getValue( HMI_EVC_2C_WC_VEDA_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_2D_AutoSpdCtrl_Avl := %X\n", getValue( HMI_EVC_2D_AutoSpdCtrl_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_2E_AddEquipBlock_Avl := %X\n", getValue( HMI_EVC_2E_AddEquipBlock_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_2F_RetrofitFuelcell_Avl := %X\n", getValue( HMI_EVC_2F_RetrofitFuelcell_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_30_RearStWhl_Avl := %X\n", getValue( HMI_EVC_30_RearStWhl_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_31_PlugInHyb_75_84kW_Avl := %X\n", getValue( HMI_EVC_31_PlugInHyb_75_84kW_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_32_Hyb_ME10_Avl := %X\n", getValue( HMI_EVC_32_Hyb_ME10_Avl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EVC_CfgBit_01_32_Stat := %X\n", getValue( HMI_EVC_CfgBit_01_32_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EVC_CfgBit_01_32 := %X\n", getValue( HMI_SQC_EVC_CfgBit_01_32 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EVC_CfgBit_01_32_Auto := %X\n", getValue( HMI_SQC_EVC_CfgBit_01_32_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tEVC_CfgBit_01_32_AR
{
    putValue( HMI__STMSG_EVC_CfgBit_01_32_AR, 0 );
}

on EnvVar HMI__STMSG_EVC_CfgBit_01_32_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_EVC_CfgBit_01_32_AR );
        if( tDelay > 0)    
            setTimer( _tEVC_CfgBit_01_32_AR, tDelay );
        else
            putValue( HMI__STMSG_EVC_CfgBit_01_32_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_EVC_CfgBit_01_32_AR
{
    if( getValue( this ) )
        openPanel("EVC_CfgBit_01_32_AR");
}

on envVar HMI_E2E_EVC_CfgBit_01_32_Inject
{
    if( getValue( this ) )
    {
        _EVC_CfgBit_01_32_AR_CRC_ErrorCnt = getValue( HMI_CRC_EVC_CfgBit_01_32_ErrorCount );
        _EVC_CfgBit_01_32_AR_SQC_TriggPos = getValue( HMI_SQC_EVC_CfgBit_01_32_TriggerPosition );
        _EVC_CfgBit_01_32_AR_SQC_WrongSeqJump = getValue( HMI_SQC_EVC_CfgBit_01_32_WrongSeq );
        _EVC_CfgBit_01_32_AR_SQC_RepeatedCnt = getValue( HMI_SQC_EVC_CfgBit_01_32_Repeated );
        _EVC_CfgBit_01_32_AR_MSG_DropCnt = getValue( HMI_SQC_EVC_CfgBit_01_32_MSG_DropCnt );
        putValue( HMI_E2E_EVC_CfgBit_01_32_State, 2 );
        _EVC_CfgBit_01_32_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_EVC_01_Ver_USA_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_01_Ver_USA_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_02_Ver_Mexico_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_02_Ver_Mexico_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_03_Ver_Japan_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_03_Ver_Japan_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_04_Ver_GulfStates_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_04_Ver_GulfStates_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_05_Ver_Australia_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_05_Ver_Australia_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_06_Ver_China_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_06_Ver_China_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_07_Ver_S_Korea_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_07_Ver_S_Korea_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_08_Ver_Canada_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_08_Ver_Canada_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_09_FullHyb_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_09_FullHyb_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_0A_Hyb_20kW_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_0A_Hyb_20kW_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_0B_PlugInHyb_80kW_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_0B_PlugInHyb_80kW_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_0C_AllWheelDr_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_0C_AllWheelDr_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_0D_4x2Drive_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_0D_4x2Drive_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_0E_Presf_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_0E_Presf_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_0F_TrlrHtch_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_0F_TrlrHtch_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_10_KG_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_10_KG_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_11_AutTrunkLid_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_11_AutTrunkLid_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_12_AutRearDr_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_12_AutRearDr_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_13_PwrCls_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_13_PwrCls_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_14_RainSens_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_14_RainSens_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_15_DRLt_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_15_DRLt_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_16_FogLmp_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_16_FogLmp_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_17_IL_Pk_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_17_IL_Pk_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_18_AmbLgt_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_18_AmbLgt_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_19_ElDrPosnSel_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_19_ElDrPosnSel_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_1A_IntSfProt_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_1A_IntSfProt_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_1B_VTA_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_1B_VTA_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_1C_HghVTP_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_1C_HghVTP_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_1D_SecurityVer_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_1D_SecurityVer_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_1E_GuardLvl_B4_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_1E_GuardLvl_B4_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_1F_GuardLvl_B6_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_1F_GuardLvl_B6_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_20_GuardLvl_B7_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_20_GuardLvl_B7_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_21_Pullman_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_21_Pullman_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_22_SpecClos_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_22_SpecClos_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_23_PASS_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_23_PASS_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_24_ICH_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_24_ICH_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_25_HVAC_R_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_25_HVAC_R_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_26_SSA_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_26_SSA_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_27_HandsFreeAcc_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_27_HandsFreeAcc_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_28_PlugInHyb_50kW_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_28_PlugInHyb_50kW_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_29_Hyb_30kW_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_29_Hyb_30kW_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_2A_SeatElAdj_F_OprtnR_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_2A_SeatElAdj_F_OprtnR_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_2B_DSI_Sel_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_2B_DSI_Sel_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_2C_WC_VEDA_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_2C_WC_VEDA_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_2D_AutoSpdCtrl_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_2D_AutoSpdCtrl_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_2E_AddEquipBlock_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_2E_AddEquipBlock_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_2F_RetrofitFuelcell_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_2F_RetrofitFuelcell_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_30_RearStWhl_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_30_RearStWhl_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_31_PlugInHyb_75_84kW_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_31_PlugInHyb_75_84kW_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_32_Hyb_ME10_Avl
{
    _mEVC_CfgBit_01_32_AR.EVC_32_Hyb_ME10_Avl.phys = getValue(this);
}

on EnvVar HMI_EVC_CfgBit_01_32_Stat
{
    _mEVC_CfgBit_01_32_AR.EVC_CfgBit_01_32_Stat.phys = getValue(this);
}

EVC_CfgBit_33_64_AR_check_output()
{
    if( !getValue( HMI__STMSG_EVC_CfgBit_33_64_AR ) )
    {
    //  message   EVC_CfgBit_33_64_AR ID: 755 --- Sendeart 0 cyclicX --- 
        _EVC_CfgBit_33_64_AR_Cnt--;
        if( _EVC_CfgBit_33_64_AR_Cnt < 1 )
        {
            EVC_CfgBit_33_64_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _EVC_CfgBit_33_64_AR_Cnt = _EVC_CfgBit_33_64_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

EVC_CfgBit_33_64_AR_init()
{   /* Botschaft EVC_CfgBit_33_64_AR ID: 755 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 755 0;
BA_ "NmAsrMessage" BO_ 755 0;
BA_ "GenMsgMinAcceptLength" BO_ 755 8;
BA_ "GenMsgILSupport" BO_ 755 1;
BA_ "DiagState" BO_ 755 0;
BA_ "DiagRequest" BO_ 755 0;
BA_ "DiagResponse" BO_ 755 0;
BA_ "GenMsgStartValue" BO_ 755 "0";
BA_ "GenMsgStartDelayTime" BO_ 755 185;
BA_ "GenMsgCycleTime" BO_ 755 1000;
BA_ "GenMsgSendType" BO_ 755 0;
    */
    _EVC_CfgBit_33_64_AR_Timebase =        c_tDBKomTimer_20ms;
    _EVC_CfgBit_33_64_AR_CycleCount =    1000 / _EVC_CfgBit_33_64_AR_Timebase;
    _EVC_CfgBit_33_64_AR_StartDelay =     185 / _EVC_CfgBit_33_64_AR_Timebase;
    _EVC_CfgBit_33_64_AR_Cnt = _EVC_CfgBit_33_64_AR_StartDelay;

    putValue( HMI__STMSGSD_EVC_CfgBit_33_64_AR, _EVC_CfgBit_33_64_AR_StartDelay * _EVC_CfgBit_33_64_AR_Timebase );

    _mEVC_CfgBit_33_64_AR.EVC_33_EmgOpn_F_Avl.phys = getValue( HMI_EVC_33_EmgOpn_F_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_34_Curtain_F_Avl.phys = getValue( HMI_EVC_34_Curtain_F_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_35_EmgOpn_Inact.phys = getValue( HMI_EVC_35_EmgOpn_Inact );
    _mEVC_CfgBit_33_64_AR.EVC_36_SpecVehPW_FL_Avl.phys = getValue( HMI_EVC_36_SpecVehPW_FL_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_37_SpecVehPW_FR_Avl.phys = getValue( HMI_EVC_37_SpecVehPW_FR_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_38_SpecVehPW_RL_Avl.phys = getValue( HMI_EVC_38_SpecVehPW_RL_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_39_SpecVehPW_RR_Avl.phys = getValue( HMI_EVC_39_SpecVehPW_RR_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_3A_RB_F_Avl.phys = getValue( HMI_EVC_3A_RB_F_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_3B_RB_R_Avl.phys = getValue( HMI_EVC_3B_RB_R_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_3C_SeatDrvDyn_Ft_Avl.phys = getValue( HMI_EVC_3C_SeatDrvDyn_Ft_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_3D_ComfHdRst_Ft_Avl.phys = getValue( HMI_EVC_3D_ComfHdRst_Ft_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_3E_SeatMultiCont_Ft_Avl.phys = getValue( HMI_EVC_3E_SeatMultiCont_Ft_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_3F_SeatHt_Ft_Avl.phys = getValue( HMI_EVC_3F_SeatHt_Ft_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_40_SeatClim_Ft_Avl.phys = getValue( HMI_EVC_40_SeatClim_Ft_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_41_SeatMem_LHD_Avl.phys = getValue( HMI_EVC_41_SeatMem_LHD_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_42_SeatMem_RHD_Avl.phys = getValue( HMI_EVC_42_SeatMem_RHD_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_43_SeatMemPk_Avl.phys = getValue( HMI_EVC_43_SeatMemPk_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_44_ReclSeat_Avl.phys = getValue( HMI_EVC_44_ReclSeat_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_45_SeatMultiCont_R_Avl.phys = getValue( HMI_EVC_45_SeatMultiCont_R_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_46_SeatBkRstAdj_R_Avl.phys = getValue( HMI_EVC_46_SeatBkRstAdj_R_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_47_SeatHt_R_Avl.phys = getValue( HMI_EVC_47_SeatHt_R_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_48_SeatClim_R_Avl.phys = getValue( HMI_EVC_48_SeatClim_R_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_49_WShWashHt_Avl.phys = getValue( HMI_EVC_49_WShWashHt_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_4A_TaxiPwrSup_Avl.phys = getValue( HMI_EVC_4A_TaxiPwrSup_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_4B_TaxiRoofLmpCon_Avl.phys = getValue( HMI_EVC_4B_TaxiRoofLmpCon_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_4C_TaxiEmgAlm_Avl.phys = getValue( HMI_EVC_4C_TaxiEmgAlm_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_4D_RadioHdFree_Avl.phys = getValue( HMI_EVC_4D_RadioHdFree_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_4E_GAS_Avl.phys = getValue( HMI_EVC_4E_GAS_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_4F_CtrlU_MultiFunc_Avl.phys = getValue( HMI_EVC_4F_CtrlU_MultiFunc_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_50_TaxInMirr_Avl.phys = getValue( HMI_EVC_50_TaxInMirr_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_51_DistRecInMirr_Avl.phys = getValue( HMI_EVC_51_DistRecInMirr_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_52_PreInstRad_Avl.phys = getValue( HMI_EVC_52_PreInstRad_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_53_RetrofitRemCtrl_Avl.phys = getValue( HMI_EVC_53_VehHandi_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_54_PanelHt_Ft_Avl.phys = getValue( HMI_EVC_54_PanelHt_Ft_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_55_SeatComfHt_Ft_Avl.phys = getValue( HMI_EVC_55_SeatComfHt_Ft_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_56_SeatComfHt_R_Avl.phys = getValue( HMI_EVC_56_SeatComfHt_R_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_57_IntFoldHdRst_Ft_Avl.phys = getValue( HMI_EVC_57_IntFoldHdRst_Ft_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_58_SeatInd_R_Avl.phys = getValue( HMI_EVC_58_SeatInd_R_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_59_SeatChauffPos_P_Avl.phys = getValue( HMI_EVC_59_SeatChauffPos_P_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_5A_SeatMContMass_Ft_Avl.phys = getValue( HMI_EVC_5A_SeatMContMass_Ft_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_5B_PanelHt_R_Avl.phys = getValue( HMI_EVC_5B_PanelHt_R_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_5C_Airscarf_Ft_Avl.phys = getValue( HMI_EVC_5C_Airscarf_Ft_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_5D_SeatLimit_P_Avl.phys = getValue( HMI_EVC_5D_SeatLimit_P_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_5E_TaxiRoofLmp_Avl.phys = getValue( HMI_EVC_5E_TaxiRoofLmp_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_5F_SeatElAdj_LHD_Avl.phys = getValue( HMI_EVC_5F_SeatElAdj_LHD_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_60_SeatElAdj_RHD_Avl.phys = getValue( HMI_EVC_60_SeatElAdj_RHD_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_61_AMGPerfSusp_Avl.phys = getValue( HMI_EVC_61_AMGPerfSusp_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_62_ShiftExhstSys_Avl.phys = getValue( HMI_EVC_62_ShiftExhstSys_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_63_ActvLDA_MPC_Avl.phys = getValue( HMI_EVC_63_ActvLDA_MPC_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_64_EAS_Avl.phys = getValue( HMI_EVC_64_EAS_Avl );
    _mEVC_CfgBit_33_64_AR.EVC_CfgBit_33_64_Stat.phys = getValue( HMI_EVC_CfgBit_33_64_Stat );
}

EVC_CfgBit_33_64_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_EVC_CfgBit_33_64 ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_EVC_CfgBit_33_64_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _EVC_CfgBit_33_64_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _EVC_CfgBit_33_64_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_EVC_CfgBit_33_64_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _EVC_CfgBit_33_64_AR_SQC_WrongSeqJump != 0 ) &&
            ( _EVC_CfgBit_33_64_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _EVC_CfgBit_33_64_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _EVC_CfgBit_33_64_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _EVC_CfgBit_33_64_AR_SQC_RepeatedCnt ) &&
            ( _EVC_CfgBit_33_64_AR_E2E_Armed == 1  )    )
        {
            _EVC_CfgBit_33_64_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_EVC_CfgBit_33_64, SQC_help );
    }
    _mEVC_CfgBit_33_64_AR.SQC_EVC_CfgBit_33_64 = SQC_help;

    if( getValue( HMI_CRC_EVC_CfgBit_33_64_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_EVC_CfgBit_33_64_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mEVC_CfgBit_33_64_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_33_64_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_33_64_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_33_64_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_33_64_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_33_64_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mEVC_CfgBit_33_64_AR.byte( 6 ) ];
