    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg125_Disp_Rq := %X\n", getValue( HMI_MPM_Msg125_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg126_Disp_Rq := %X\n", getValue( HMI_MPM_Msg126_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg127_Disp_Rq := %X\n", getValue( HMI_MPM_Msg127_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_MPM_Msg128_Disp_Rq := %X\n", getValue( HMI_MPM_Msg128_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tSPV_Disp_Rq2_VAN_AR
{
    putValue( HMI__STMSG_SPV_Disp_Rq2_VAN_AR, 0 );
}

on EnvVar HMI__STMSG_SPV_Disp_Rq2_VAN_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SPV_Disp_Rq2_VAN_AR );
        if( tDelay > 0)    
            setTimer( _tSPV_Disp_Rq2_VAN_AR, tDelay );
        else
            putValue( HMI__STMSG_SPV_Disp_Rq2_VAN_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_SPV_Disp_Rq2_VAN_AR
{
    if( getValue( this ) )
        openPanel("SPV_Disp_Rq2_VAN_AR");
}

on EnvVar HMI_MPM_Msg65_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg65_Disp_Rq = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg66_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg66_Disp_Rq = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg67_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg67_Disp_Rq = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg68_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg68_Disp_Rq = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg69_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg69_Disp_Rq = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg70_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg70_Disp_Rq = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg71_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg71_Disp_Rq = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg72_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg72_Disp_Rq = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg73_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg73_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg74_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg74_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg75_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg75_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg76_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg76_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg77_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg77_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg78_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg78_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg79_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg79_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg80_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg80_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg81_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg81_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg82_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg82_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg83_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg83_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg84_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg84_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg85_Disp_Rq
{  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg85_Disp_Rq   = getValue(this);
   _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg86_Disp_Rq
{  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg86_Disp_Rq   = getValue(this);
   _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg87_Disp_Rq
{  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg87_Disp_Rq   = getValue(this);
   _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg88_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg88_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg89_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg89_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg90_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg90_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg91_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg91_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg92_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg92_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg93_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg93_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg94_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg94_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg95_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg95_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg96_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg96_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg97_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg97_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg98_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg98_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg99_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg99_Disp_Rq   = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg100_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg100_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg101_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg101_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg102_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg102_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg103_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg103_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg104_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg104_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg105_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg105_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg106_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg106_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg107_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg107_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg108_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg108_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg109_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg109_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg110_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg110_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg111_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg111_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg112_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg112_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg113_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg113_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg114_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg114_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg115_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg115_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg116_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg116_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg117_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg117_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg118_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg118_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg119_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg119_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg120_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg120_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg121_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg121_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg122_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg122_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg123_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg123_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg124_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg124_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg125_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg125_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg126_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg126_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg127_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg127_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

on EnvVar HMI_MPM_Msg128_Disp_Rq
{
  _mSPV_Disp_Rq2_VAN_AR.MPM_Msg128_Disp_Rq  = getValue(this);
  _SPV_Disp_Rq2_VAN_AR_SpontanFlag = 1; 
}

void SPV_Rq_AR_Activity(int active )
{
    if( active )
    {
        if( _SPV_Rq_AR_SigActivity == 0)
            _SPV_Rq_AR_Cnt = 1;
        _SPV_Rq_AR_SigActivity++;
    }
    else
    {
        _SPV_Rq_AR_SigActivity--;
    }
}

int SPV_Rq_AR_Change(int lastValue, int sigValue, int inActValue )
{
    bActiveHelper = (sigValue != inActValue );
      if( !lastValue && bActiveHelper )
        SPV_Rq_AR_Activity( 1 );
      else if( lastValue && !bActiveHelper )
        SPV_Rq_AR_Activity(0 );
    return bActiveHelper;
}

SPV_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_SPV_Rq_AR ) )
    {
    //  message   SPV_Rq_AR ID: 789 --- Sendeart 8 cyclicIfActiveFast --- 
        _SPV_Rq_AR_Cnt--;
        if( _SPV_Rq_AR_Cnt < 1 )
        {

            SPV_Rq_AR_output(); // Zyklus abgelaufen, Nachricht senden
            _SPV_Rq_AR_Cnt = _SPV_Rq_AR_SigActivity ? _SPV_Rq_AR_CycleCountFast : _SPV_Rq_AR_CycleCountSlow;
        }
    }
}

SPV_Rq_AR_init()
{   /* Botschaft SPV_Rq_AR ID: 789 --- Sendeart 8 cyclicIfActiveFast --- 
BA_ "ApplMessage" BO_ 789 0;
BA_ "NmAsrMessage" BO_ 789 0;
BA_ "GenMsgMinAcceptLength" BO_ 789 2;
BA_ "GenMsgILSupport" BO_ 789 1;
BA_ "DiagState" BO_ 789 0;
BA_ "DiagRequest" BO_ 789 0;
BA_ "DiagResponse" BO_ 789 0;
BA_ "GenMsgStartValue" BO_ 789 "0";
BA_ "GenMsgStartDelayTime" BO_ 789 0;
BA_ "GenMsgDelayTime" BO_ 789 5;
BA_ "GenMsgCycleTime" BO_ 789 1000;
BA_ "GenMsgCycleTimeActive" BO_ 789 100;
BA_ "GenMsgSendType" BO_ 789 8;
    */
    _SPV_Rq_AR_Timebase =                 c_tDBKomTimer_5ms;
    _SPV_Rq_AR_CycleCountSlow =         1000 / _SPV_Rq_AR_Timebase;
    _SPV_Rq_AR_CycleCountFast =          100 / _SPV_Rq_AR_Timebase;
    _SPV_Rq_AR_StartDelay =                0 / _SPV_Rq_AR_Timebase;
    _SPV_Rq_AR_Cnt = _SPV_Rq_AR_StartDelay;
    _SPV_Rq_AR_SigActivity = 0;

    putValue( HMI__STMSGSD_SPV_Rq_AR, _SPV_Rq_AR_StartDelay * _SPV_Rq_AR_Timebase );

    _mSPV_Rq_AR.AcustWarn_Rq_MPM.phys = getValue( HMI_AcustWarn_Rq_MPM );                  _SPV_Rq_AR_AcustWarn_Rq_MPM_LastState = SPV_Rq_AR_Change( _SPV_Rq_AR_AcustWarn_Rq_MPM_LastState, _mSPV_Rq_AR.AcustWarn_Rq_MPM, 0 );
    _mSPV_Rq_AR.AudioMute_1_Rq.phys = getValue( HMI_AudioMute_1_Rq );                  _SPV_Rq_AR_AudioMute_1_Rq_LastState = SPV_Rq_AR_Change( _SPV_Rq_AR_AudioMute_1_Rq_LastState, _mSPV_Rq_AR.AudioMute_1_Rq, 0 );
    _mSPV_Rq_AR.AudioMute_2_Rq.phys = getValue( HMI_AudioMute_2_Rq );                  _SPV_Rq_AR_AudioMute_2_Rq_LastState = SPV_Rq_AR_Change( _SPV_Rq_AR_AudioMute_2_Rq_LastState, _mSPV_Rq_AR.AudioMute_2_Rq, 0 );
    _mSPV_Rq_AR.AuthRadio_Actv.phys = getValue( HMI_AuthRadio_Actv );                  _SPV_Rq_AR_AuthRadio_Actv_LastState = SPV_Rq_AR_Change( _SPV_Rq_AR_AuthRadio_Actv_LastState, _mSPV_Rq_AR.AuthRadio_Actv, 0 );
    _mSPV_Rq_AR.FBAS_VideoIn_Rq.phys = getValue( HMI_FBAS_VideoIn_Rq );                  _SPV_Rq_AR_FBAS_VideoIn_Rq_LastState = SPV_Rq_AR_Change( _SPV_Rq_AR_FBAS_VideoIn_Rq_LastState, _mSPV_Rq_AR.FBAS_VideoIn_Rq, 0 );
    _mSPV_Rq_AR.Gas_Dr_Unlk_Rq_MPM.phys = getValue( HMI_Gas_Dr_Unlk_Rq_MPM );                  _SPV_Rq_AR_Gas_Dr_Unlk_Rq_MPM_LastState = SPV_Rq_AR_Change( _SPV_Rq_AR_Gas_Dr_Unlk_Rq_MPM_LastState, _mSPV_Rq_AR.Gas_Dr_Unlk_Rq_MPM, 0 );
    _mSPV_Rq_AR.Radio_NumPad_Rq.phys = getValue( HMI_Radio_NumPad_Rq );                  _SPV_Rq_AR_Radio_NumPad_Rq_LastState = SPV_Rq_AR_Change( _SPV_Rq_AR_Radio_NumPad_Rq_LastState, _mSPV_Rq_AR.Radio_NumPad_Rq, 0 );
    _mSPV_Rq_AR.RadioHdFree_Actv.phys = getValue( HMI_RadioHdFree_Actv );                  _SPV_Rq_AR_RadioHdFree_Actv_LastState = SPV_Rq_AR_Change( _SPV_Rq_AR_RadioHdFree_Actv_LastState, _mSPV_Rq_AR.RadioHdFree_Actv, 0 );
    _mSPV_Rq_AR.SPV_Rem_UI_Rq.phys = getValue( HMI_SPV_Rem_UI_Rq );                  _SPV_Rq_AR_SPV_Rem_UI_Rq_LastState = SPV_Rq_AR_Change( _SPV_Rq_AR_SPV_Rem_UI_Rq_LastState, _mSPV_Rq_AR.SPV_Rem_UI_Rq, 0 );
}

SPV_Rq_AR_output(void)
{
    output( _mSPV_Rq_AR );
}

SPV_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SPV_Rq_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SPV_Rq_AR := %X\n", getValue( HMI__STMSG_SPV_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SPV_Rq_AR := %X\n", getValue( HMI__STMSGT_SPV_Rq_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AcustWarn_Rq_MPM := %X\n", getValue( HMI_AcustWarn_Rq_MPM ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AudioMute_1_Rq := %X\n", getValue( HMI_AudioMute_1_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AudioMute_2_Rq := %X\n", getValue( HMI_AudioMute_2_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AuthRadio_Actv := %X\n", getValue( HMI_AuthRadio_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FBAS_VideoIn_Rq := %X\n", getValue( HMI_FBAS_VideoIn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Gas_Dr_Unlk_Rq_MPM := %X\n", getValue( HMI_Gas_Dr_Unlk_Rq_MPM ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Radio_NumPad_Rq := %X\n", getValue( HMI_Radio_NumPad_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RadioHdFree_Actv := %X\n", getValue( HMI_RadioHdFree_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPV_Rem_UI_Rq := %X\n", getValue( HMI_SPV_Rem_UI_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tSPV_Rq_AR
{
    putValue( HMI__STMSG_SPV_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_SPV_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SPV_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tSPV_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_SPV_Rq_AR, 0 );
    }
}

on EnvVar HMI__ALLDEF_SPV_Rq_AR
{
    if( getValue(this) )
    {
        // alle signale auf default einstellen
        putValue( HMI_AcustWarn_Rq_MPM, 0 );
        putValue( HMI_AudioMute_1_Rq, 0 );
        putValue( HMI_AuthRadio_Actv, 0 );
        putValue( HMI_FBAS_VideoIn_Rq, 0 );
        putValue( HMI_Gas_Dr_Unlk_Rq_MPM, 0 );
        putValue( HMI_Radio_NumPad_Rq, 0 );
        putValue( HMI_RadioHdFree_Actv, 0 );
        putValue( HMI_SPV_Rem_UI_Rq, 0 );
    }
}

on envVar HMI__STMSG_PO_SPV_Rq_AR
{
    if( getValue( this ) )
        openPanel("SPV_Rq_AR");
}

on EnvVar HMI_AcustWarn_Rq_MPM
{
    _mSPV_Rq_AR.AcustWarn_Rq_MPM.phys = getValue(this);
    _SPV_Rq_AR_AcustWarn_Rq_MPM_LastState = SPV_Rq_AR_Change( _SPV_Rq_AR_AcustWarn_Rq_MPM_LastState, _mSPV_Rq_AR.AcustWarn_Rq_MPM, 0 );
}

on EnvVar HMI_AudioMute_1_Rq
{
    _mSPV_Rq_AR.AudioMute_1_Rq.phys = getValue(this);
    _SPV_Rq_AR_AudioMute_1_Rq_LastState = SPV_Rq_AR_Change( _SPV_Rq_AR_AudioMute_1_Rq_LastState, _mSPV_Rq_AR.AudioMute_1_Rq, 0 );
}

on EnvVar HMI_AudioMute_2_Rq
{
    _mSPV_Rq_AR.AudioMute_2_Rq.phys = getValue(this);
    _SPV_Rq_AR_AudioMute_2_Rq_LastState = SPV_Rq_AR_Change( _SPV_Rq_AR_AudioMute_2_Rq_LastState, _mSPV_Rq_AR.AudioMute_2_Rq, 0 );
}

on EnvVar HMI_AuthRadio_Actv
{
    _mSPV_Rq_AR.AuthRadio_Actv.phys = getValue(this);
    _SPV_Rq_AR_AuthRadio_Actv_LastState = SPV_Rq_AR_Change( _SPV_Rq_AR_AuthRadio_Actv_LastState, _mSPV_Rq_AR.AuthRadio_Actv, 0 );
}

on EnvVar HMI_FBAS_VideoIn_Rq
{
    _mSPV_Rq_AR.FBAS_VideoIn_Rq.phys = getValue(this);
    _SPV_Rq_AR_FBAS_VideoIn_Rq_LastState = SPV_Rq_AR_Change( _SPV_Rq_AR_FBAS_VideoIn_Rq_LastState, _mSPV_Rq_AR.FBAS_VideoIn_Rq, 0 );
}

on EnvVar HMI_Gas_Dr_Unlk_Rq_MPM
{
    _mSPV_Rq_AR.Gas_Dr_Unlk_Rq_MPM.phys = getValue(this);
    _SPV_Rq_AR_Gas_Dr_Unlk_Rq_MPM_LastState = SPV_Rq_AR_Change( _SPV_Rq_AR_Gas_Dr_Unlk_Rq_MPM_LastState, _mSPV_Rq_AR.Gas_Dr_Unlk_Rq_MPM, 0 );
}

on EnvVar HMI_Radio_NumPad_Rq
{
    _mSPV_Rq_AR.Radio_NumPad_Rq.phys = getValue(this);
    _SPV_Rq_AR_Radio_NumPad_Rq_LastState = SPV_Rq_AR_Change( _SPV_Rq_AR_Radio_NumPad_Rq_LastState, _mSPV_Rq_AR.Radio_NumPad_Rq, 0 );
}

on EnvVar HMI_RadioHdFree_Actv
{
    _mSPV_Rq_AR.RadioHdFree_Actv.phys = getValue(this);
    _SPV_Rq_AR_RadioHdFree_Actv_LastState = SPV_Rq_AR_Change( _SPV_Rq_AR_RadioHdFree_Actv_LastState, _mSPV_Rq_AR.RadioHdFree_Actv, 0 );
}

on EnvVar HMI_SPV_Rem_UI_Rq
{
    _mSPV_Rq_AR.SPV_Rem_UI_Rq.phys = getValue(this);
    _SPV_Rq_AR_SPV_Rem_UI_Rq_LastState = SPV_Rq_AR_Change( _SPV_Rq_AR_SPV_Rem_UI_Rq_LastState, _mSPV_Rq_AR.SPV_Rem_UI_Rq, 0 );
}

SPV_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_SPV_Stat_AR ) )
    {
    //  message   SPV_Stat_AR ID: 791 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _SPV_Stat_AR_DelayCnt > 0) _SPV_Stat_AR_DelayCnt--; // Mindestsendeabstand
        _SPV_Stat_AR_Cnt--;
        if( _SPV_Stat_AR_Cnt < 1 )
        {
            if( _SPV_Stat_AR_DelayCnt < 1 )
            {
                SPV_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                 _SPV_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SPV_Stat_AR_DelayCnt = _SPV_Stat_AR_MinDelay;
            }
            else
            {
                 _SPV_Stat_AR_SpontanFlag = 1; // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
            }
            _SPV_Stat_AR_Cnt = _SPV_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _SPV_Stat_AR_SpontanFlag)
        {
            if( _SPV_Stat_AR_DelayCnt < 1 )
            {
                SPV_Stat_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _SPV_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SPV_Stat_AR_DelayCnt = _SPV_Stat_AR_MinDelay;
            }
        }
    }
}

SPV_Stat_AR_init()
{   /* Botschaft SPV_Stat_AR ID: 791 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 791 0;
BA_ "NmAsrMessage" BO_ 791 0;
BA_ "GenMsgMinAcceptLength" BO_ 791 4;
BA_ "GenMsgILSupport" BO_ 791 1;
BA_ "DiagState" BO_ 791 0;
BA_ "DiagRequest" BO_ 791 0;
BA_ "DiagResponse" BO_ 791 0;
BA_ "GenMsgStartValue" BO_ 791 "0";
BA_ "GenMsgStartDelayTime" BO_ 791 0;
BA_ "GenMsgDelayTime" BO_ 791 50;
BA_ "GenMsgNrOfRepetitions" BO_ 791 0;
BA_ "GenMsgCycleTime" BO_ 791 1000;
BA_ "GenMsgSendType" BO_ 791 5;
    */
    _SPV_Stat_AR_Timebase =               c_tDBKomTimer_5ms;
    _SPV_Stat_AR_CycleCount =            1000 / _SPV_Stat_AR_Timebase;
    _SPV_Stat_AR_StartDelay =               0 / _SPV_Stat_AR_Timebase;
    _SPV_Stat_AR_MinDelay =                50 / _SPV_Stat_AR_Timebase;
    _SPV_Stat_AR_Cnt = _SPV_Stat_AR_StartDelay;
    _SPV_Stat_AR_SpontanFlag = 0;
    _SPV_Stat_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_SPV_Stat_AR, _SPV_Stat_AR_StartDelay * _SPV_Stat_AR_Timebase );

    _mSPV_Stat_AR.Audio_TwoCabSnd_Stat.phys = getValue( HMI_Audio_TwoCabSnd_Stat );
    _mSPV_Stat_AR.Audio_TwoCabSrc_Rq.phys = getValue( HMI_Audio_TwoCabSrc_Rq );
    _mSPV_Stat_AR.C2X_Emg_Actv.phys = getValue( HMI_C2X_Emg_Actv );
    _mSPV_Stat_AR.CiA447_Flt.phys = getValue( HMI_CiA447_Flt );
    _mSPV_Stat_AR.ContEngRun_Sw_Psd.phys = getValue( HMI_ContEngRun_Sw_Psd );
    _mSPV_Stat_AR.EF_On_Rq_MPM.phys = getValue( HMI_EF_On_Rq_MPM );
    _mSPV_Stat_AR.EmgAlm_Flt.phys = getValue( HMI_EmgAlm_Flt );
    _mSPV_Stat_AR.ES_EmgVeh_Flt.phys = getValue( HMI_ES_EmgVeh_Flt );
    _mSPV_Stat_AR.ES_Taxi_Flt.phys = getValue( HMI_ES_Taxi_Flt );
    _mSPV_Stat_AR.ES_TaxiLim_Warn.phys = getValue( HMI_ES_TaxiLim_Warn );
    _mSPV_Stat_AR.FAS_Actv.phys = getValue( HMI_FAS_Actv );
    _mSPV_Stat_AR.FAS_Empty.phys = getValue( HMI_FAS_Empty );
    _mSPV_Stat_AR.FAS_Inact.phys = getValue( HMI_FAS_Inact );
    _mSPV_Stat_AR.FES_Actv.phys = getValue( HMI_FES_Actv );
    _mSPV_Stat_AR.FES_Empty.phys = getValue( HMI_FES_Empty );
    _mSPV_Stat_AR.FES_Flt.phys = getValue( HMI_FES_Flt );
    _mSPV_Stat_AR.FES_On.phys = getValue( HMI_FES_On );
    _mSPV_Stat_AR.Hrn_On_Rq_MPM.phys = getValue( HMI_Hrn_On_Rq_MPM );
    _mSPV_Stat_AR.IL_Dim_On_Rq.phys = getValue( HMI_IL_Dim_On_Rq );
    _mSPV_Stat_AR.PN14_SupBatCutSw_Rq.phys = getValue( HMI_PN14_SupBatCutSw_Rq );
    _mSPV_Stat_AR.RoofLmpChk_Rq.phys = getValue( HMI_RoofLmpChk_Rq );
    _mSPV_Stat_AR.RoofLmpIndLmp_On_Rq.phys = getValue( HMI_RoofLmpIndLmp_On_Rq );
    _mSPV_Stat_AR.SSA_Dsbl_Rq_MPM.phys = getValue( HMI_SSA_Dsbl_Rq_MPM );
    _mSPV_Stat_AR.TaxiRoofLmpMd_Stat.phys = getValue( HMI_TaxiRoofLmpMd_Stat );
    _mSPV_Stat_AR.Volt_Low_MPM.phys = getValue( HMI_Volt_Low_MPM );
}

SPV_Stat_AR_output(void)
{
    output( _mSPV_Stat_AR );
}

SPV_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SPV_Stat_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SPV_Stat := %X\n", getValue( HMI__STMSG_SPV_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SPV_Stat := %X\n", getValue( HMI__STMSGT_SPV_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Audio_TwoCabSnd_Stat := %X\n", getValue( HMI_Audio_TwoCabSnd_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Audio_TwoCabSrc_Rq := %X\n", getValue( HMI_Audio_TwoCabSrc_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_C2X_Emg_Actv := %X\n", getValue( HMI_C2X_Emg_Actv ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CiA447_Flt := %X\n", getValue( HMI_CiA447_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ContEngRun_Sw_Psd := %X\n", getValue( HMI_ContEngRun_Sw_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EF_On_Rq_MPM := %X\n", getValue( HMI_EF_On_Rq_MPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EmgAlm_Flt := %X\n", getValue( HMI_EmgAlm_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ES_EmgVeh_Flt := %X\n", getValue( HMI_ES_EmgVeh_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ES_Taxi_Flt := %X\n", getValue( HMI_ES_Taxi_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ES_TaxiLim_Warn := %X\n", getValue( HMI_ES_TaxiLim_Warn ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FAS_Actv := %X\n", getValue( HMI_FAS_Actv ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FAS_Empty := %X\n", getValue( HMI_FAS_Empty ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FAS_Inact := %X\n", getValue( HMI_FAS_Inact ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FES_Actv := %X\n", getValue( HMI_FES_Actv ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FES_Empty := %X\n", getValue( HMI_FES_Empty ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FES_Flt := %X\n", getValue( HMI_FES_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_FES_On := %X\n", getValue( HMI_FES_On ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Hrn_On_Rq_MPM := %X\n", getValue( HMI_Hrn_On_Rq_MPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IL_Dim_On_Rq := %X\n", getValue( HMI_IL_Dim_On_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PN14_SupBatCutSw_Rq := %X\n", getValue( HMI_PN14_SupBatCutSw_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RoofLmpChk_Rq := %X\n", getValue( HMI_RoofLmpChk_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RoofLmpIndLmp_On_Rq := %X\n", getValue( HMI_RoofLmpIndLmp_On_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SSA_Dsbl_Rq_MPM := %X\n", getValue( HMI_SSA_Dsbl_Rq_MPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TaxiRoofLmpMd_Stat := %X\n", getValue( HMI_TaxiRoofLmpMd_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Volt_Low_MPM := %X\n", getValue( HMI_Volt_Low_MPM ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tSPV_Stat_AR
{
    putValue( HMI__STMSG_SPV_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_SPV_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SPV_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tSPV_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_SPV_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_SPV_Stat_AR
{
    if( getValue( this ) )
        openPanel("SPV_Stat_AR");
}

on EnvVar HMI_Audio_TwoCabSnd_Stat
{
    _mSPV_Stat_AR.Audio_TwoCabSnd_Stat.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Audio_TwoCabSrc_Rq
{
    _mSPV_Stat_AR.Audio_TwoCabSrc_Rq.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_C2X_Emg_Actv
{
    _mSPV_Stat_AR.C2X_Emg_Actv.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_CiA447_Flt
{
    _mSPV_Stat_AR.CiA447_Flt.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ContEngRun_Sw_Psd
{
    _mSPV_Stat_AR.ContEngRun_Sw_Psd.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_EF_On_Rq_MPM
{
    _mSPV_Stat_AR.EF_On_Rq_MPM.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_EmgAlm_Flt
{
    _mSPV_Stat_AR.EmgAlm_Flt.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ES_EmgVeh_Flt
{
    _mSPV_Stat_AR.ES_EmgVeh_Flt.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ES_Taxi_Flt
{
    _mSPV_Stat_AR.ES_Taxi_Flt.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ES_TaxiLim_Warn
{
    _mSPV_Stat_AR.ES_TaxiLim_Warn.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FAS_Actv
{
    _mSPV_Stat_AR.FAS_Actv.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FAS_Empty
{
    _mSPV_Stat_AR.FAS_Empty.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FAS_Inact
{
    _mSPV_Stat_AR.FAS_Inact.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FES_Actv
{
    _mSPV_Stat_AR.FES_Actv.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FES_Empty
{
    _mSPV_Stat_AR.FES_Empty.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FES_Flt
{
    _mSPV_Stat_AR.FES_Flt.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_FES_On
{
    _mSPV_Stat_AR.FES_On.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Hrn_On_Rq_MPM
{
    _mSPV_Stat_AR.Hrn_On_Rq_MPM.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_IL_Dim_On_Rq
{
    _mSPV_Stat_AR.IL_Dim_On_Rq.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_PN14_SupBatCutSw_Rq
{
    _mSPV_Stat_AR.PN14_SupBatCutSw_Rq.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_RoofLmpChk_Rq
{
    _mSPV_Stat_AR.RoofLmpChk_Rq.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_RoofLmpIndLmp_On_Rq
{
    _mSPV_Stat_AR.RoofLmpIndLmp_On_Rq.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SSA_Dsbl_Rq_MPM
{
    _mSPV_Stat_AR.SSA_Dsbl_Rq_MPM.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_TaxiRoofLmpMd_Stat
{
    _mSPV_Stat_AR.TaxiRoofLmpMd_Stat.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Volt_Low_MPM
{
    _mSPV_Stat_AR.Volt_Low_MPM.phys = getValue(this);
    _SPV_Stat_AR_SpontanFlag = 1;
}

SPV_Stat_VAN_AR_check_output()
{
    if( !getValue( HMI__STMSG_SPV_Stat_VAN_AR ) )
    {
    //  message   SPV_Stat_VAN_AR ID: 630 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _SPV_Stat_VAN_AR_DelayCnt > 0) _SPV_Stat_VAN_AR_DelayCnt--; // Mindestsendeabstand
        _SPV_Stat_VAN_AR_Cnt--;
        if( _SPV_Stat_VAN_AR_Cnt < 1 )
        {
            if( _SPV_Stat_VAN_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                SPV_Stat_VAN_AR_output();
                 _SPV_Stat_VAN_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SPV_Stat_VAN_AR_DelayCnt = _SPV_Stat_VAN_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _SPV_Stat_VAN_AR_SpontanFlag = 1;
            }
            _SPV_Stat_VAN_AR_Cnt = _SPV_Stat_VAN_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _SPV_Stat_VAN_AR_SpontanFlag)
        {
            if( _SPV_Stat_VAN_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                SPV_Stat_VAN_AR_output();
                _SPV_Stat_VAN_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _SPV_Stat_VAN_AR_DelayCnt = _SPV_Stat_VAN_AR_MinDelay;
            }
        }
    }
}

SPV_Stat_VAN_AR_init()
{   /* Botschaft SPV_Stat_VAN_AR  ID: 630 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 630 0;
BA_ "NmAsrMessage" BO_ 630 0;
BA_ "GenMsgMinAcceptLength" BO_ 630 8;
BA_ "GenMsgILSupport" BO_ 630 1;
BA_ "DiagState" BO_ 630 0;
BA_ "DiagRequest" BO_ 630 0;
BA_ "DiagResponse" BO_ 630 0;
BA_ "GenMsgStartValue" BO_ 630 "0";
BA_ "GenMsgStartDelayTime" BO_ 630 0;
BA_ "GenMsgDelayTime" BO_ 630 20;
BA_ "GenMsgNrOfRepetition" BO_ 630 0;
BA_ "GenMsgCycleTime" BO_ 630 100;
BA_ "GenMsgSendType" BO_ 630 5;
    */
    _SPV_Stat_VAN_AR_Timebase =             c_tDBKomTimer_20ms;
    _SPV_Stat_VAN_AR_CycleCount =          100 / _SPV_Stat_VAN_AR_Timebase;
    _SPV_Stat_VAN_AR_StartDelay =            0 / _SPV_Stat_VAN_AR_Timebase;
    _SPV_Stat_VAN_AR_MinDelay =             20 / _SPV_Stat_VAN_AR_Timebase;
    _SPV_Stat_VAN_AR_Cnt = _SPV_Stat_VAN_AR_StartDelay;
    _SPV_Stat_VAN_AR_SpontanFlag = 0;
    _SPV_Stat_VAN_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_SPV_Stat_VAN_AR, _SPV_Stat_VAN_AR_StartDelay * _SPV_Stat_VAN_AR_Timebase );

    _mSPV_Stat_VAN_AR.AcustWarn_Rq_MPM_VAN.phys = getValue( HMI_AcustWarn_Rq_MPM_VAN );
    _mSPV_Stat_VAN_AR.AnaSwInStat1.phys = getValue( HMI_AnaSwInStat1 );
    _mSPV_Stat_VAN_AR.DSR_Sw_Psd_MPM.phys = getValue( HMI_DSR_Sw_Psd_MPM );
    _mSPV_Stat_VAN_AR.EStep_AcustWarn1_On_Rq.phys = getValue( HMI_EStep_AcustWarn1_On_Rq );
    _mSPV_Stat_VAN_AR.EStep_AcustWarn2_On_Rq.phys = getValue( HMI_EStep_AcustWarn2_On_Rq );
    _mSPV_Stat_VAN_AR.EStep_Disp_Rq.phys = getValue( HMI_EStep_Disp_Rq );
    _mSPV_Stat_VAN_AR.EStep_FL_Flt.phys = getValue( HMI_EStep_FL_Flt );
    _mSPV_Stat_VAN_AR.EStep_FR_Flt.phys = getValue( HMI_EStep_FR_Flt );
    _mSPV_Stat_VAN_AR.EStep_RL_Flt.phys = getValue( HMI_EStep_RL_Flt );
    _mSPV_Stat_VAN_AR.EStep_RR_Flt.phys = getValue( HMI_EStep_RR_Flt );
    _mSPV_Stat_VAN_AR.IL_F_Off_Rq_MPM.phys = getValue( HMI_IL_F_Off_Rq_MPM );
    _mSPV_Stat_VAN_AR.ExtPwrSup_Actv.phys = getValue( HMI_ExtPwrSup_Actv );
    _mSPV_Stat_VAN_AR.IL_F_On_Rq_MPM.phys = getValue( HMI_IL_F_On_Rq_MPM );
    _mSPV_Stat_VAN_AR.IL_R_Off_Rq_MPM.phys = getValue( HMI_IL_R_Off_Rq_MPM );
    _mSPV_Stat_VAN_AR.IL_R_On_Rq_MPM.phys = getValue( HMI_IL_R_On_Rq_MPM );
    _mSPV_Stat_VAN_AR.PSD_L_Rq_MPM.phys = getValue( HMI_PSD_L_Rq_MPM );
    _mSPV_Stat_VAN_AR.PSD_R_Rq_MPM.phys = getValue( HMI_PSD_R_Rq_MPM );
    _mSPV_Stat_VAN_AR.ExtLmp_Stat_MPM.phys = getValue( HMI_ExtLmp_Stat_MPM );
    _mSPV_Stat_VAN_AR.TDP_Prev_Reset_Rq_MPM.phys = getValue( HMI_TDP_Prev_Reset_Rq_MPM );
    _mSPV_Stat_VAN_AR.ContEngRun_Sw_LED_On_Rq.phys = getValue( HMI_ContEngRun_Sw_LED_On_Rq );
    _mSPV_Stat_VAN_AR.Rsrv5_SPV_Stat_VAN.phys = getValue( HMI_Rsrv5_SPV_Stat_VAN );
    _mSPV_Stat_VAN_AR.Rsrv6_SPV_Stat_VAN.phys = getValue( HMI_Rsrv6_SPV_Stat_VAN );
    _mSPV_Stat_VAN_AR.Wpr_Stat_MPM.phys = getValue( HMI_Wpr_Stat_MPM );
}

SPV_Stat_VAN_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_SPV_Stat_VAN ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_SPV_Stat_VAN_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _SPV_Stat_VAN_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _SPV_Stat_VAN_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_CamLane_Disp_Warn_Rq_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _SPV_Stat_VAN_AR_SQC_WrongSeqJump != 0 ) &&
            ( _SPV_Stat_VAN_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _SPV_Stat_VAN_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _SPV_Stat_VAN_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _SPV_Stat_VAN_AR_SQC_RepeatedCnt ) &&
            ( _SPV_Stat_VAN_AR_E2E_Armed == 1  )    )
        {
            _SPV_Stat_VAN_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_SPV_Stat_VAN, SQC_help );
    }
    _mSPV_Stat_VAN_AR.SQC_SPV_Stat_VAN = SQC_help;

    if( getValue( HMI_CRC_SPV_Stat_VAN_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_SPV_Stat_VAN_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable_profile02[ crc ^ _mSPV_Stat_VAN_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mSPV_Stat_VAN_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mSPV_Stat_VAN_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mSPV_Stat_VAN_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mSPV_Stat_VAN_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mSPV_Stat_VAN_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mSPV_Stat_VAN_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mSPV_Stat_VAN_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _SPV_Stat_VAN_AR_CRC_Offset[ _mSPV_Stat_VAN_AR.SQC_SPV_Stat_VAN ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _SPV_Stat_VAN_AR_CRC_ErrorCnt   && ( _SPV_Stat_VAN_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_SPV_Stat_VAN_Invalid )                                         )    )
            {
                crc++;
                if( _SPV_Stat_VAN_AR_CRC_ErrorCnt > 0 )
                    _SPV_Stat_VAN_AR_CRC_ErrorCnt--; 
            }
            _mSPV_Stat_VAN_AR.CRC_SPV_Stat_VAN = crc;
            putValue( HMI_CRC_SPV_Stat_VAN, crc );
        }
        else
            _mSPV_Stat_VAN_AR.CRC_SPV_Stat_VAN = getValue( HMI_CRC_SPV_Stat_VAN );
    }
    else
    {
        if( !getValue( HMI_CRC_SPV_Stat_VAN_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mSPV_Stat_VAN_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mSPV_Stat_VAN_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mSPV_Stat_VAN_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mSPV_Stat_VAN_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mSPV_Stat_VAN_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mSPV_Stat_VAN_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mSPV_Stat_VAN_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mSPV_Stat_VAN_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _SPV_Stat_VAN_AR_CRC_ErrorCnt   && ( _SPV_Stat_VAN_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_SPV_Stat_VAN_Invalid )                                         )    )
            {
                crc++;
                if( _SPV_Stat_VAN_AR_CRC_ErrorCnt > 0 )
                    _SPV_Stat_VAN_AR_CRC_ErrorCnt--; 
            }
            _mSPV_Stat_VAN_AR.CRC_SPV_Stat_VAN = crc;
            putValue( HMI_CRC_SPV_Stat_VAN, crc );
        }
        else
            _mSPV_Stat_VAN_AR.CRC_SPV_Stat_VAN = getValue( HMI_CRC_SPV_Stat_VAN );
    }
    if( ( _SPV_Stat_VAN_AR_MSG_DropCnt > 0 ) &&
        ( _SPV_Stat_VAN_AR_E2E_Armed == 1  )    )
    {
        _SPV_Stat_VAN_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mSPV_Stat_VAN_AR );
        
    if( _SPV_Stat_VAN_AR_E2E_Armed == 1 )
    {
        if ( ( _SPV_Stat_VAN_AR_MSG_DropCnt == 0      ) &&
             ( _SPV_Stat_VAN_AR_CRC_ErrorCnt == 0     ) &&
             ( _SPV_Stat_VAN_AR_SQC_RepeatedCnt == 0  ) &&
             ( _SPV_Stat_VAN_AR_SQC_WrongSeqJump == 0 )    )
        {
            _SPV_Stat_VAN_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_CamLane_Disp_Warn_Rq_State, 0 );
        }
    }
}

SPV_Stat_VAN_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: SPV_Stat_VAN_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SPV_Stat_VAN_AR := %X\n", getValue( HMI__STMSG_SPV_Stat_VAN_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SPV_Stat_VAN_AR := %X\n", getValue( HMI__STMSGT_SPV_Stat_VAN_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_SPV_Stat_VAN := %X\n", getValue( HMI_CRC_SPV_Stat_VAN ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_SPV_Stat_VAN_Auto := %X\n", getValue( HMI_CRC_SPV_Stat_VAN_Auto ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_SPV_Stat_VAN_Profile_02 := %X\n", getValue( HMI_CRC_SPV_Stat_VAN_Profile_02 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AcustWarn_Rq_MPM_VAN := %X\n", getValue( HMI_AcustWarn_Rq_MPM_VAN ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AnaSwInStat1 := %X\n", getValue( HMI_AnaSwInStat1 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DSR_Sw_Psd_MPM := %X\n", getValue( HMI_DSR_Sw_Psd_MPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EStep_AcustWarn1_On_Rq := %X\n", getValue( HMI_EStep_AcustWarn1_On_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EStep_AcustWarn2_On_Rq := %X\n", getValue( HMI_EStep_AcustWarn2_On_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EStep_Disp_Rq := %X\n", getValue( HMI_EStep_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EStep_FL_Flt := %X\n", getValue( HMI_EStep_FL_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EStep_FR_Flt := %X\n", getValue( HMI_EStep_FR_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EStep_RL_Flt := %X\n", getValue( HMI_EStep_RL_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EStep_RR_Flt := %X\n", getValue( HMI_EStep_RR_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IL_F_Off_Rq_MPM := %X\n", getValue( HMI_IL_F_Off_Rq_MPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ExtPwrSup_Actv := %X\n", getValue( HMI_ExtPwrSup_Actv ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IL_F_On_Rq_MPM := %X\n", getValue( HMI_IL_F_On_Rq_MPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IL_R_Off_Rq_MPM := %X\n", getValue( HMI_IL_R_Off_Rq_MPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IL_R_On_Rq_MPM := %X\n", getValue( HMI_IL_R_On_Rq_MPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PSD_L_Rq_MPM := %X\n", getValue( HMI_PSD_L_Rq_MPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PSD_R_Rq_MPM := %X\n", getValue( HMI_PSD_R_Rq_MPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ExtLmp_Stat_MPM := %X\n", getValue( HMI_ExtLmp_Stat_MPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TDP_Prev_Reset_Rq_MPM := %X\n", getValue( HMI_TDP_Prev_Reset_Rq_MPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ContEngRun_Sw_LED_On_Rq := %X\n", getValue( HMI_ContEngRun_Sw_LED_On_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv5_SPV_Stat_VAN := %X\n", getValue( HMI_Rsrv5_SPV_Stat_VAN ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv6_SPV_Stat_VAN := %X\n", getValue( HMI_Rsrv6_SPV_Stat_VAN ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Wpr_Stat_MPM := %X\n", getValue( HMI_Wpr_Stat_MPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_SPV_Stat_VAN := %X\n", getValue( HMI_SQC_SPV_Stat_VAN ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_SPV_Stat_VAN_Auto := %X\n", getValue( HMI_SQC_SPV_Stat_VAN_Auto ) );    filePutString ( buffer, elcount( buffer ), hFile );
	
	
}

on timer _tSPV_Stat_VAN_AR
{
    putValue( HMI__STMSG_SPV_Stat_VAN_AR, 0 );
}

on EnvVar HMI__STMSG_SPV_Stat_VAN_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_SPV_Stat_VAN_AR );
        if( tDelay > 0)    {
            setTimer( _tSPV_Stat_VAN_AR, tDelay );
            write("if: tDelay > 0");}
        else{
            putValue( HMI__STMSG_SPV_Stat_VAN_AR, 0 );
            write("else: tDelay > 0");}
    }
}

on envVar HMI_E2E_SPV_Stat_VAN_Inject
{
    if( getValue( this ) )
    {
        _SPV_Stat_VAN_AR_CRC_ErrorCnt = getValue( HMI_CRC_SPV_Stat_VAN_ErrorCount );
        _SPV_Stat_VAN_AR_SQC_TriggPos = getValue( HMI_SQC_SPV_Stat_VAN_TriggerPosition );
        _SPV_Stat_VAN_AR_SQC_WrongSeqJump = getValue( HMI_SQC_SPV_Stat_VAN_WrongSeq );
        _SPV_Stat_VAN_AR_SQC_RepeatedCnt = getValue( HMI_SQC_SPV_Stat_VAN_Repeated );
        _SPV_Stat_VAN_AR_MSG_DropCnt = getValue( HMI_SQC_SPV_Stat_VAN_MSG_DropCnt );
        putValue( HMI_E2E_CamLane_Disp_Warn_Rq_State, 2 );
        _SPV_Stat_VAN_AR_E2E_Armed = 2;  //armed
    }
}

on envVar HMI__STMSG_PO_SPV_Stat_VAN_AR
{
    if( getValue( this ) )
        openPanel("SPV_Stat_VAN_AR");
}

on EnvVar HMI_AcustWarn_Rq_MPM_VAN
{
    _mSPV_Stat_VAN_AR.AcustWarn_Rq_MPM_VAN.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_AnaSwInStat1
{
    _mSPV_Stat_VAN_AR.AnaSwInStat1.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_DSR_Sw_Psd_MPM
{
    _mSPV_Stat_VAN_AR.DSR_Sw_Psd_MPM.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_EStep_AcustWarn1_On_Rq
{
    _mSPV_Stat_VAN_AR.EStep_AcustWarn1_On_Rq.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_EStep_AcustWarn2_On_Rq
{
    _mSPV_Stat_VAN_AR.EStep_AcustWarn2_On_Rq.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_EStep_Disp_Rq
{
    _mSPV_Stat_VAN_AR.EStep_Disp_Rq.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_EStep_FL_Flt
{
    _mSPV_Stat_VAN_AR.EStep_FL_Flt.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_EStep_FR_Flt
{
    _mSPV_Stat_VAN_AR.EStep_FR_Flt.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_EStep_RL_Flt
{
    _mSPV_Stat_VAN_AR.EStep_RL_Flt.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_EStep_RR_Flt
{
    _mSPV_Stat_VAN_AR.EStep_RR_Flt.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_IL_F_Off_Rq_MPM
{
    _mSPV_Stat_VAN_AR.IL_F_Off_Rq_MPM.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_ExtPwrSup_Actv
{
    _mSPV_Stat_VAN_AR.ExtPwrSup_Actv.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_IL_F_On_Rq_MPM
{
    _mSPV_Stat_VAN_AR.IL_F_On_Rq_MPM.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_IL_R_Off_Rq_MPM
{
    _mSPV_Stat_VAN_AR.IL_R_Off_Rq_MPM.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_IL_R_On_Rq_MPM
{
    _mSPV_Stat_VAN_AR.IL_R_On_Rq_MPM.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PSD_L_Rq_MPM
{
    _mSPV_Stat_VAN_AR.PSD_L_Rq_MPM.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_PSD_R_Rq_MPM
{
    _mSPV_Stat_VAN_AR.PSD_R_Rq_MPM.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_ExtLmp_Stat_MPM
{
    _mSPV_Stat_VAN_AR.ExtLmp_Stat_MPM.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_TDP_Prev_Reset_Rq_MPM
{
    _mSPV_Stat_VAN_AR.TDP_Prev_Reset_Rq_MPM.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_ContEngRun_Sw_LED_On_Rq
{
    _mSPV_Stat_VAN_AR.ContEngRun_Sw_LED_On_Rq.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv5_SPV_Stat_VAN
{
    _mSPV_Stat_VAN_AR.Rsrv5_SPV_Stat_VAN.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Wpr_Stat_MPM
{
    _mSPV_Stat_VAN_AR.Wpr_Stat_MPM.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv6_SPV_Stat_VAN
{
    _mSPV_Stat_VAN_AR.Rsrv6_SPV_Stat_VAN.phys = getValue(this);
    _SPV_Stat_VAN_AR_SpontanFlag = 1;
}

StWhl_Angl_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_StWhl_Angl_Stat_AR ) )
    {
    //  message   StWhl_Angl_Stat_AR ID: 47 --- Sendeart 0 cyclicX --- 
        _StWhl_Angl_Stat_AR_Cnt--;
        if( _StWhl_Angl_Stat_AR_Cnt < 1 )
        {
            StWhl_Angl_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _StWhl_Angl_Stat_AR_Cnt = _StWhl_Angl_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

StWhl_Angl_Stat_AR_init()
{   /* Botschaft StWhl_Angl_Stat_AR ID: 47 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 47 0;
BA_ "NmAsrMessage" BO_ 47 0;
BA_ "GenMsgMinAcceptLength" BO_ 47 8;
BA_ "GenMsgILSupport" BO_ 47 1;
BA_ "DiagState" BO_ 47 0;
BA_ "DiagRequest" BO_ 47 0;
BA_ "DiagResponse" BO_ 47 0;
BA_ "GenMsgStartValue" BO_ 47 "0";
BA_ "GenMsgStartDelayTime" BO_ 47 0;
BA_ "GenMsgCycleTime" BO_ 47 10;
BA_ "GenMsgSendType" BO_ 47 0;
    */
    _StWhl_Angl_Stat_AR_Timebase =        c_tDBKomTimer_5ms;
    _StWhl_Angl_Stat_AR_CycleCount =      10 / _StWhl_Angl_Stat_AR_Timebase;
    _StWhl_Angl_Stat_AR_StartDelay =       0 / _StWhl_Angl_Stat_AR_Timebase;
    _StWhl_Angl_Stat_AR_Cnt = _StWhl_Angl_Stat_AR_StartDelay;

    putValue( HMI__STMSGSD_StWhl_Angl_Stat_AR, _StWhl_Angl_Stat_AR_StartDelay * _StWhl_Angl_Stat_AR_Timebase );

    _mStWhl_Angl_Stat_AR.Rsrv2_StWhl_Angl_Stat.phys = getValue( HMI_Rsrv2_StWhl_Angl_Stat );
    _mStWhl_Angl_Stat_AR.Rsrv3_StWhl_Angl_Stat.phys = getValue( HMI_Rsrv3_StWhl_Angl_Stat );
    _mStWhl_Angl_Stat_AR.StWhl_Angl.phys = getValue( HMI_StWhl_Angl );
    _mStWhl_Angl_Stat_AR.StWhl_AnglSens_Id.phys = getValue( HMI_StWhl_AnglSens_Id );
    _mStWhl_Angl_Stat_AR.StWhl_AnglSens_Stat.phys = getValue( HMI_StWhl_AnglSens_Stat );
    _mStWhl_Angl_Stat_AR.StWhl_AnglSensVld_Stat.phys = getValue( HMI_StWhl_AnglSensVld_Stat );
    _mStWhl_Angl_Stat_AR.StWhl_AnglSpd.phys = getValue( HMI_StWhl_AnglSpd );
}

StWhl_Angl_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_StWhl_Angl_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_StWhl_Angl_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _StWhl_Angl_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _StWhl_Angl_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_StWhl_Angl_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _StWhl_Angl_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _StWhl_Angl_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _StWhl_Angl_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _StWhl_Angl_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _StWhl_Angl_Stat_AR_SQC_RepeatedCnt ) &&
            ( _StWhl_Angl_Stat_AR_E2E_Armed == 1  )    )
        {
            _StWhl_Angl_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_StWhl_Angl_Stat, SQC_help );
    }
    _mStWhl_Angl_Stat_AR.SQC_StWhl_Angl_Stat = SQC_help;

    if( getValue( HMI_CRC_StWhl_Angl_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_StWhl_Angl_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mStWhl_Angl_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mStWhl_Angl_Stat_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mStWhl_Angl_Stat_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mStWhl_Angl_Stat_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mStWhl_Angl_Stat_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mStWhl_Angl_Stat_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mStWhl_Angl_Stat_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mStWhl_Angl_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _StWhl_Angl_Stat_AR_CRC_Offset[ _mStWhl_Angl_Stat_AR.SQC_StWhl_Angl_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _StWhl_Angl_Stat_AR_CRC_ErrorCnt   && ( _StWhl_Angl_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_StWhl_Angl_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _StWhl_Angl_Stat_AR_CRC_ErrorCnt > 0 )
                    _StWhl_Angl_Stat_AR_CRC_ErrorCnt--; 
            }
            _mStWhl_Angl_Stat_AR.CRC_StWhl_Angl_Stat = crc;
            putValue( HMI_CRC_StWhl_Angl_Stat, crc );
        }
        else
            _mStWhl_Angl_Stat_AR.CRC_StWhl_Angl_Stat = getValue( HMI_CRC_StWhl_Angl_Stat );
    }
    else
    {
        if( !getValue( HMI_CRC_StWhl_Angl_Stat_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mStWhl_Angl_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mStWhl_Angl_Stat_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mStWhl_Angl_Stat_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mStWhl_Angl_Stat_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mStWhl_Angl_Stat_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mStWhl_Angl_Stat_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mStWhl_Angl_Stat_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mStWhl_Angl_Stat_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _StWhl_Angl_Stat_AR_CRC_ErrorCnt   && ( _StWhl_Angl_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_StWhl_Angl_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _StWhl_Angl_Stat_AR_CRC_ErrorCnt > 0 )
                    _StWhl_Angl_Stat_AR_CRC_ErrorCnt--; 
            }
            _mStWhl_Angl_Stat_AR.CRC_StWhl_Angl_Stat = crc;
            putValue( HMI_CRC_StWhl_Angl_Stat, crc );
        }
        else
            _mStWhl_Angl_Stat_AR.CRC_StWhl_Angl_Stat = getValue( HMI_CRC_StWhl_Angl_Stat );
    }
    if( ( _StWhl_Angl_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _StWhl_Angl_Stat_AR_E2E_Armed == 1  )    )
    {
        _StWhl_Angl_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mStWhl_Angl_Stat_AR );
        
    if( _StWhl_Angl_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _StWhl_Angl_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _StWhl_Angl_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _StWhl_Angl_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _StWhl_Angl_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _StWhl_Angl_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_StWhl_Angl_Stat_State, 0 );
        }
    }
}

void StWhl_Angl_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: StWhl_Angl_Stat_AR\n", 32, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_StWhl_Angl_Stat_AR := %X\n", getValue( HMI__STMSG_StWhl_Angl_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_StWhl_Angl_Stat_AR := %X\n", getValue( HMI__STMSGT_StWhl_Angl_Stat_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_StWhl_Angl_Stat := %f\n", getValue( HMI_CRC_StWhl_Angl_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_StWhl_Angl_Stat_Auto := %f\n", getValue( HMI_CRC_StWhl_Angl_Stat_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_StWhl_Angl_Stat := %f\n", getValue( HMI_Rsrv2_StWhl_Angl_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv3_StWhl_Angl_Stat := %f\n", getValue( HMI_Rsrv3_StWhl_Angl_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_StWhl_Angl_Stat := %f\n", getValue( HMI_SQC_StWhl_Angl_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_StWhl_Angl_Stat_Auto := %f\n", getValue( HMI_SQC_StWhl_Angl_Stat_Auto ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Angl := %f\n", getValue( HMI_StWhl_Angl ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_AnglSens_Id := %f\n", getValue( HMI_StWhl_AnglSens_Id ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_AnglSens_Stat := %f\n", getValue( HMI_StWhl_AnglSens_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_AnglSensVld_Stat := %f\n", getValue( HMI_StWhl_AnglSensVld_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_AnglSpd := %f\n", getValue( HMI_StWhl_AnglSpd ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tStWhl_Angl_Stat_AR
{
    putValue( HMI__STMSG_StWhl_Angl_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_StWhl_Angl_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_StWhl_Angl_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tStWhl_Angl_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_StWhl_Angl_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_StWhl_Angl_Stat_AR
{
    if( getValue( this ) )
        openPanel("StWhl_Angl_Stat_AR");
}

on envVar HMI_E2E_StWhl_Angl_Stat_Inject
{
    if( getValue( this ) )
    {
        _StWhl_Angl_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_StWhl_Angl_Stat_ErrorCount );
        _StWhl_Angl_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_StWhl_Angl_Stat_TriggerPosition );
        _StWhl_Angl_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_StWhl_Angl_Stat_WrongSeq );
        _StWhl_Angl_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_StWhl_Angl_Stat_Repeated );
        _StWhl_Angl_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_StWhl_Angl_Stat_MSG_DropCnt );
        putValue( HMI_E2E_StWhl_Angl_Stat_State, 2 );
        _StWhl_Angl_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_Rsrv2_StWhl_Angl_Stat
{
    _mStWhl_Angl_Stat_AR.Rsrv2_StWhl_Angl_Stat.phys = getValue(this);
}

on EnvVar HMI_Rsrv3_StWhl_Angl_Stat
{
    _mStWhl_Angl_Stat_AR.Rsrv3_StWhl_Angl_Stat.phys = getValue(this);
}

on EnvVar HMI_StWhl_Angl
{
    _mStWhl_Angl_Stat_AR.StWhl_Angl.phys = getValue(this);
}

on EnvVar HMI_StWhl_AnglSens_Id
{
    _mStWhl_Angl_Stat_AR.StWhl_AnglSens_Id.phys = getValue(this);
}

on EnvVar HMI_StWhl_AnglSens_Stat
{
    _mStWhl_Angl_Stat_AR.StWhl_AnglSens_Stat.phys = getValue(this);
}

on EnvVar HMI_StWhl_AnglSensVld_Stat
{
    _mStWhl_Angl_Stat_AR.StWhl_AnglSensVld_Stat.phys = getValue(this);
}

on EnvVar HMI_StWhl_AnglSpd
{
    _mStWhl_Angl_Stat_AR.StWhl_AnglSpd.phys = getValue(this);
}

StWhl_OFN_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_StWhl_OFN_Stat_AR ) )
    {
    //  message   StWhl_OFN_Stat_AR ID: xxx --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _StWhl_OFN_Stat_AR_DelayCnt > 0) _StWhl_OFN_Stat_AR_DelayCnt--; // Mindestsendeabstand
        _StWhl_OFN_Stat_AR_Cnt--;
        if( _StWhl_OFN_Stat_AR_Cnt < 1 )
        {
            if( _StWhl_OFN_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                StWhl_OFN_Stat_AR_output();
                _StWhl_OFN_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _StWhl_OFN_Stat_AR_DelayCnt = _StWhl_OFN_Stat_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _StWhl_OFN_Stat_AR_SpontanFlag = 1;
            }
            _StWhl_OFN_Stat_AR_Cnt = _StWhl_OFN_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _StWhl_OFN_Stat_AR_SpontanFlag)
        {
            if( _StWhl_OFN_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                StWhl_OFN_Stat_AR_output();
                _StWhl_OFN_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _StWhl_OFN_Stat_AR_DelayCnt = _StWhl_OFN_Stat_AR_MinDelay;
            }
        }
    }
}

StWhl_OFN_Stat_AR_init()
{   /* Botschaft StWhl_OFN_Stat_AR ID: 621 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 621 0;
BA_ "NmAsrMessage" BO_ 621 0;
BA_ "GenMsgMinAcceptLength" BO_ 621 8;
BA_ "GenMsgILSupport" BO_ 621 1;
BA_ "DiagState" BO_ 621 0;
BA_ "DiagRequest" BO_ 621 0;
BA_ "DiagResponse" BO_ 621 0;
BA_ "GenMsgStartValue" BO_ 621 "0";
BA_ "GenMsgDelayTime" BO_ 621 20;
BA_ "GenMsgNrOfRepetitions" BO_ 621 0;
BA_ "GenMsgCycleTime" BO_ 621 100;
BA_ "GenMsgSendType" BO_ 621 5;
    */
    _StWhl_OFN_Stat_AR_Timebase =      c_tDBKomTimer_5ms;
    _StWhl_OFN_Stat_AR_CycleCount =    100 / _StWhl_OFN_Stat_AR_Timebase;
    _StWhl_OFN_Stat_AR_StartDelay =      0 / _StWhl_OFN_Stat_AR_Timebase;
    _StWhl_OFN_Stat_AR_MinDelay = 40 / _StWhl_OFN_Stat_AR_Timebase;
    _StWhl_OFN_Stat_AR_Cnt = _StWhl_OFN_Stat_AR_StartDelay;
    _StWhl_OFN_Stat_AR_SpontanFlag = 0;
    _StWhl_OFN_Stat_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_StWhl_OFN_Stat_AR, _StWhl_OFN_Stat_AR_StartDelay * _StWhl_OFN_Stat_AR_Timebase );

    _mStWhl_OFN_Stat_AR.StWhl_OFN_SnstyMd_Stat.phys = getValue( HMI_StWhl_OFN_SnstyMd_Stat );
    _mStWhl_OFN_Stat_AR.StWhl_OFN1_Mtn_X_Comp.phys = getValue( HMI_StWhl_OFN1_Mtn_X_Comp );
    _mStWhl_OFN_Stat_AR.StWhl_OFN1_Mtn_Y_Comp.phys = getValue( HMI_StWhl_OFN1_Mtn_Y_Comp );
    _mStWhl_OFN_Stat_AR.StWhl_OFN1_Stat.phys = getValue( HMI_StWhl_OFN1_Stat );
    _mStWhl_OFN_Stat_AR.StWhl_OFN1_TmStmp.phys = getValue( HMI_StWhl_OFN1_TmStmp );
    _mStWhl_OFN_Stat_AR.StWhl_OFN2_Mtn_X_Comp.phys = getValue( HMI_StWhl_OFN2_Mtn_X_Comp );
    _mStWhl_OFN_Stat_AR.StWhl_OFN2_Mtn_Y_Comp.phys = getValue( HMI_StWhl_OFN2_Mtn_Y_Comp );
    _mStWhl_OFN_Stat_AR.StWhl_OFN2_Stat.phys = getValue( HMI_StWhl_OFN2_Stat );
    _mStWhl_OFN_Stat_AR.StWhl_OFN2_TmStmp.phys = getValue( HMI_StWhl_OFN2_TmStmp );
    _mStWhl_OFN_Stat_AR.StWhl_AnyFNPAD_Psd.phys = getValue( HMI_StWhl_AnyFNPAD_Psd );
    _mStWhl_OFN_Stat_AR.StWhl_AnyMchSw_Psd.phys = getValue( HMI_StWhl_AnyMchSw_Psd );
    _mStWhl_OFN_Stat_AR.StWhl_FNPAD_Snsty_Md_Stat.phys = getValue( HMI_StWhl_FNPAD_Snsty_Md_Stat );
    _mStWhl_OFN_Stat_AR.StWhl_FNPAD_Tap_Md_Stat.phys = getValue( HMI_StWhl_FNPAD_Tap_Md_Stat );
    _mStWhl_OFN_Stat_AR.StWhl_Sw_Fav_Psd_V3.phys = getValue( HMI_StWhl_Sw_Fav_Psd_V3 );
    _mStWhl_OFN_Stat_AR.StWhl_Variant.phys = getValue( HMI_StWhl_Variant );
	
}

StWhl_OFN_Stat_AR_output()
{
    output( _mStWhl_OFN_Stat_AR );
}

StWhl_OFN_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: StWhl_OFN_Stat_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_StWhl_OFN_Stat_AR := %X\n", getValue( HMI__STMSG_StWhl_OFN_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_StWhl_OFN_Stat_AR := %X\n", getValue( HMI__STMSGT_StWhl_OFN_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_OFN_SnstyMd_Stat := %X\n", getValue( HMI_StWhl_OFN_SnstyMd_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_OFN1_Mtn_X_Comp := %X\n", getValue( HMI_StWhl_OFN1_Mtn_X_Comp ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_OFN1_Mtn_Y_Comp := %X\n", getValue( HMI_StWhl_OFN1_Mtn_Y_Comp ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_OFN1_Stat := %X\n", getValue( HMI_StWhl_OFN1_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_OFN1_TmStmp := %X\n", getValue( HMI_StWhl_OFN1_TmStmp ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_OFN2_Mtn_X_Comp := %X\n", getValue( HMI_StWhl_OFN2_Mtn_X_Comp ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_OFN2_Mtn_Y_Comp := %X\n", getValue( HMI_StWhl_OFN2_Mtn_Y_Comp ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_OFN2_Stat := %X\n", getValue( HMI_StWhl_OFN2_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_OFN2_TmStmp := %X\n", getValue( HMI_StWhl_OFN2_TmStmp ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_AnyFNPAD_Psd := %X\n", getValue( HMI_StWhl_AnyFNPAD_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_AnyMchSw_Psd := %X\n", getValue( HMI_StWhl_AnyMchSw_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_FNPAD_Snsty_Md_Stat := %X\n", getValue( HMI_StWhl_FNPAD_Snsty_Md_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_FNPAD_Tap_Md_Stat := %X\n", getValue( HMI_StWhl_FNPAD_Tap_Md_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Sw_Fav_Psd_V3 := %X\n", getValue( HMI_StWhl_Sw_Fav_Psd_V3 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Variant := %X\n", getValue( HMI_StWhl_Variant ) );        filePutString( buffer, elcount( buffer ), hFile );
}   

on timer _tStWhl_OFN_Stat_AR
{
    putValue( HMI__STMSG_StWhl_OFN_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_StWhl_OFN_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_StWhl_OFN_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tStWhl_OFN_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_StWhl_OFN_Stat_AR, 0 );
    }
}

on EnvVar HMI__TRIGMSG_StWhl_OFN_Stat_AR
{
    if( getValue( this ) )
    {
        _StWhl_OFN_Stat_AR_SpontanFlag = 1;
        putValue( this, 0 );
    }
}

on envVar HMI__STMSG_PO_StWhl_OFN_Stat_AR
{
    if( getValue( this ) )
        openPanel("StWhl_OFN_Stat_AR");
}

on EnvVar HMI_StWhl_OFN_SnstyMd_Stat
{
    _mStWhl_OFN_Stat_AR.StWhl_OFN_SnstyMd_Stat.phys = getValue(this);
//    _StWhl_OFN_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_OFN1_Mtn_X_Comp
{
    _mStWhl_OFN_Stat_AR.StWhl_OFN1_Mtn_X_Comp.phys = getValue(this);
//    _StWhl_OFN_Stat_AR_SpontanFlag = 1; // used by OFN-Simu, must not be set here!
}

on EnvVar HMI_StWhl_OFN1_Mtn_Y_Comp
{
    _mStWhl_OFN_Stat_AR.StWhl_OFN1_Mtn_Y_Comp.phys = getValue(this);
//    _StWhl_OFN_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_OFN1_Stat
{
    _mStWhl_OFN_Stat_AR.StWhl_OFN1_Stat.phys = getValue(this);
//    _StWhl_OFN_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_OFN1_TmStmp
{
    _mStWhl_OFN_Stat_AR.StWhl_OFN1_TmStmp.phys = getValue(this);
//    _StWhl_OFN_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_OFN2_Mtn_X_Comp
{
    _mStWhl_OFN_Stat_AR.StWhl_OFN2_Mtn_X_Comp.phys = getValue(this);
//    _StWhl_OFN_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_OFN2_Mtn_Y_Comp
{
    _mStWhl_OFN_Stat_AR.StWhl_OFN2_Mtn_Y_Comp.phys = getValue(this);
//    _StWhl_OFN_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_OFN2_Stat
{
    _mStWhl_OFN_Stat_AR.StWhl_OFN2_Stat.phys = getValue(this);
//    _StWhl_OFN_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_OFN2_TmStmp
{
    _mStWhl_OFN_Stat_AR.StWhl_OFN2_TmStmp.phys = getValue(this);
//    _StWhl_OFN_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_AnyFNPAD_Psd
{
    _mStWhl_OFN_Stat_AR.StWhl_AnyFNPAD_Psd.phys = getValue(this);
//    _StWhl_OFN_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_AnyMchSw_Psd
{
    _mStWhl_OFN_Stat_AR.StWhl_AnyMchSw_Psd.phys = getValue(this);
//    _StWhl_OFN_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_FNPAD_Snsty_Md_Stat
{
    _mStWhl_OFN_Stat_AR.StWhl_FNPAD_Snsty_Md_Stat.phys = getValue(this);
//    _StWhl_OFN_Stat_AR_SpontanFlag = 1;
}


on EnvVar HMI_StWhl_FNPAD_Tap_Md_Stat
{
    _mStWhl_OFN_Stat_AR.StWhl_FNPAD_Tap_Md_Stat.phys = getValue(this);
//    _StWhl_OFN_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Sw_Fav_Psd_V3
{
    _mStWhl_OFN_Stat_AR.StWhl_Sw_Fav_Psd_V3.phys = getValue(this);
//    _StWhl_OFN_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Variant
{
    _mStWhl_OFN_Stat_AR.StWhl_Variant.phys = getValue(this);
//    _StWhl_OFN_Stat_AR_SpontanFlag = 1;
}


StWhl_Sw_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_StWhl_Sw_Stat_AR ) )
    {
    //  message   StWhl_Sw_Stat_AR ID: 1025 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _StWhl_Sw_Stat_AR_Cnt--;
        if( _StWhl_Sw_Stat_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            StWhl_Sw_Stat_AR_output();
            _StWhl_Sw_Stat_AR_Cnt = _StWhl_Sw_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _StWhl_Sw_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _StWhl_Sw_Stat_AR_SpontanFlag )
        {
            // Nachricht wg. spontaner �nderung ausgeben
            StWhl_Sw_Stat_AR_output();
            _StWhl_Sw_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

StWhl_Sw_Stat_AR_init()
{   /* Botschaft StWhl_Sw_Stat_AR ID: 1025 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1025 0;
BA_ "NmAsrMessage" BO_ 1025 0;
BA_ "GenMsgMinAcceptLength" BO_ 1025 8;
BA_ "GenMsgILSupport" BO_ 1025 1;
BA_ "DiagState" BO_ 1025 0;
BA_ "DiagRequest" BO_ 1025 0;
BA_ "DiagResponse" BO_ 1025 0;
BA_ "GenMsgStartValue" BO_ 1025 "0";
BA_ "GenMsgStartDelayTime" BO_ 1025 0;
BA_ "GenMsgDelayTime" BO_ 1025 20;
BA_ "GenMsgNrOfRepetitions" BO_ 1025 0;
BA_ "GenMsgCycleTime" BO_ 1025 100;
BA_ "GenMsgSendType" BO_ 1025 5;
    */
    _StWhl_Sw_Stat_AR_Timebase =        c_tDBKomTimer_20ms;
    _StWhl_Sw_Stat_AR_CycleCount =     100 / _StWhl_Sw_Stat_AR_Timebase;
    _StWhl_Sw_Stat_AR_StartDelay =       0 / _StWhl_Sw_Stat_AR_Timebase;
    _StWhl_Sw_Stat_AR_Cnt = _StWhl_Sw_Stat_AR_StartDelay;
    _StWhl_Sw_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_StWhl_Sw_Stat_AR, _StWhl_Sw_Stat_AR_StartDelay * _StWhl_Sw_Stat_AR_Timebase );

    _mStWhl_Sw_Stat_AR.ALDW_VibMot_Avl.phys = getValue( HMI_ALDW_VibMot_Avl );
    _mStWhl_Sw_Stat_AR.ALDW_VibMot_Avl_UB.phys = getValue( HMI_ALDW_VibMot_Avl_UB );
    _mStWhl_Sw_Stat_AR.ALDW_VibMot_Stat.phys = getValue( HMI_ALDW_VibMot_Stat );
    _mStWhl_Sw_Stat_AR.ALDW_VibMot_Stat_UB.phys = getValue( HMI_ALDW_VibMot_Stat_UB );
    _mStWhl_Sw_Stat_AR.HrnSw_Psd_V2.phys = getValue( HMI_HrnSw_Psd_V2 );
    _mStWhl_Sw_Stat_AR.StWhl_Cond_ALDW_Sup.phys = getValue( HMI_StWhl_Cond_ALDW_Sup );
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Back1_Psd.phys = getValue( HMI_StWhl_Sw_Back1_Psd );
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Back2_Psd.phys = getValue( HMI_StWhl_Sw_Back2_Psd );
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Fav_Psd_V2.phys = getValue( HMI_StWhl_Sw_Fav_Psd_V2 );
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Home1_Psd.phys = getValue( HMI_StWhl_Sw_Home1_Psd );
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Home2_Psd.phys = getValue( HMI_StWhl_Sw_Home2_Psd );
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Minus_Psd.phys = getValue( HMI_StWhl_Sw_Minus_Psd );
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Mute_Psd.phys = getValue( HMI_StWhl_Sw_Mute_Psd );
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Ok1_Psd.phys = getValue( HMI_StWhl_Sw_Ok1_Psd );
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Ok2_Psd.phys = getValue( HMI_StWhl_Sw_Ok2_Psd );
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Plus_Psd.phys = getValue( HMI_StWhl_Sw_Plus_Psd );
    _mStWhl_Sw_Stat_AR.StWhl_Sw_PTT_Psd.phys = getValue( HMI_StWhl_Sw_PTT_Psd );
    _mStWhl_Sw_Stat_AR.StWhl_Sw_TelEnd_Psd.phys = getValue( HMI_StWhl_Sw_TelEnd_Psd );
    _mStWhl_Sw_Stat_AR.StWhl_Sw_TelSend_Psd.phys = getValue( HMI_StWhl_Sw_TelSend_Psd );
    _mStWhl_Sw_Stat_AR.Vol_Rq_SWSP.phys = getValue( HMI_Vol_Rq_SWSP );
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Mute_Psd_V2.phys = getValue( HMI_StWhl_Sw_Mute_Psd_V2 );
    _mStWhl_Sw_Stat_AR.StWhl_Sw_PTT_Psd_V2 = getValue( HMI_StWhl_Sw_PTT_Psd_V2 );
    _mStWhl_Sw_Stat_AR.StWhl_Sw_TelEnd_Psd_V2.phys = getValue( HMI_StWhl_Sw_TelEnd_Psd_V2 );
    _mStWhl_Sw_Stat_AR.StWhl_Sw_TelSend_Psd_V2.phys = getValue( HMI_StWhl_Sw_TelEnd_Psd_V2 );
}

StWhl_Sw_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_StWhl_Sw_Ok1_Ok2_Psd ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_StWhl_Sw_Ok1_Ok2_Psd_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _StWhl_Sw_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _StWhl_Sw_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_StWhl_Sw_Ok1_Ok2_Psd_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _StWhl_Sw_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _StWhl_Sw_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _StWhl_Sw_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _StWhl_Sw_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _StWhl_Sw_Stat_AR_SQC_RepeatedCnt ) &&
            ( _StWhl_Sw_Stat_AR_E2E_Armed == 1  )    )
        {
            _StWhl_Sw_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_StWhl_Sw_Ok1_Ok2_Psd, SQC_help );
    }
    _mStWhl_Sw_Stat_AR.SQC_StWhl_Sw_Ok1_Ok2_Psd = SQC_help;

    if( getValue( HMI_CRC_StWhl_Sw_Ok1_Ok2_Psd_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_StWhl_Sw_Ok1_Ok2_Psd_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mStWhl_Sw_Stat_AR.byte( 0 ) ];
//            crc = crctable_profile02[ crc ^ _mStWhl_Sw_Stat_AR.byte( 1 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mStWhl_Sw_Stat_AR.byte( 2 ) ];
//            crc = crctable_profile02[ crc ^ _mStWhl_Sw_Stat_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mStWhl_Sw_Stat_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mStWhl_Sw_Stat_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mStWhl_Sw_Stat_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mStWhl_Sw_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _StWhl_Sw_Stat_AR_CRC_Offset[ _mStWhl_Sw_Stat_AR.SQC_StWhl_Sw_Ok1_Ok2_Psd ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _StWhl_Sw_Stat_AR_CRC_ErrorCnt   && ( _StWhl_Sw_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_StWhl_Sw_Ok1_Ok2_Psd_Invalid )                                         )    )
            {
                crc++;
                if( _StWhl_Sw_Stat_AR_CRC_ErrorCnt > 0 )
                    _StWhl_Sw_Stat_AR_CRC_ErrorCnt--; 
            }
            _mStWhl_Sw_Stat_AR.CRC_StWhl_Sw_Ok1_Ok2_Psd = crc;
            putValue( HMI_CRC_StWhl_Sw_Ok1_Ok2_Psd, crc );
        }
        else
            _mStWhl_Sw_Stat_AR.CRC_StWhl_Sw_Ok1_Ok2_Psd = getValue( HMI_CRC_StWhl_Sw_Ok1_Ok2_Psd );
    }
    if( ( _StWhl_Sw_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _StWhl_Sw_Stat_AR_E2E_Armed == 1  )    )
    {
        _StWhl_Sw_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mStWhl_Sw_Stat_AR );
        
    if( _StWhl_Sw_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _StWhl_Sw_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _StWhl_Sw_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _StWhl_Sw_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _StWhl_Sw_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _StWhl_Sw_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_StWhl_Sw_Ok1_Ok2_Psd_State, 0 );
        }
    }
}

StWhl_Sw_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: StWhl_Sw_Stat_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_StWhl_Sw_Stat_AR := %X\n", getValue( HMI__STMSG_StWhl_Sw_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_StWhl_Sw_Stat_AR := %X\n", getValue( HMI__STMSGT_StWhl_Sw_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ALDW_VibMot_Avl := %X\n", getValue( HMI_ALDW_VibMot_Avl ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ALDW_VibMot_Avl_UB := %X\n", getValue( HMI_ALDW_VibMot_Avl_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ALDW_VibMot_Stat := %X\n", getValue( HMI_ALDW_VibMot_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ALDW_VibMot_Stat_UB := %X\n", getValue( HMI_ALDW_VibMot_Stat_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_StWhl_Sw_Ok1_Ok2_Psd := %X\n", getValue( HMI_CRC_StWhl_Sw_Ok1_Ok2_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_StWhl_Sw_Ok1_Ok2_Psd_Auto := %X\n", getValue( HMI_CRC_StWhl_Sw_Ok1_Ok2_Psd_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_StWhl_Sw_Ok1_Ok2_Psd_Profile_02 := %X\n", getValue( HMI_CRC_StWhl_Sw_Ok1_Ok2_Psd_Profile_02 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HrnSw_Psd_V2 := %X\n", getValue( HMI_HrnSw_Psd_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_StWhl_Sw_Ok1_Ok2_Psd := %X\n", getValue( HMI_Rsrv1_StWhl_Sw_Ok1_Ok2_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_StWhl_Sw_Ok1_Ok2_Psd := %X\n", getValue( HMI_SQC_StWhl_Sw_Ok1_Ok2_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_StWhl_Sw_Ok1_Ok2_Psd_Auto := %X\n", getValue( HMI_SQC_StWhl_Sw_Ok1_Ok2_Psd_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Cond_ALDW_Sup := %X\n", getValue( HMI_StWhl_Cond_ALDW_Sup ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Sw_Back1_Psd := %X\n", getValue( HMI_StWhl_Sw_Back1_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Sw_Back2_Psd := %X\n", getValue( HMI_StWhl_Sw_Back2_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Sw_Fav_Psd_V2 := %X\n", getValue( HMI_StWhl_Sw_Fav_Psd_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Sw_Home1_Psd := %X\n", getValue( HMI_StWhl_Sw_Home1_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Sw_Home2_Psd := %X\n", getValue( HMI_StWhl_Sw_Home2_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
     snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Sw_Minus_Psd := %X\n", getValue( HMI_StWhl_Sw_Minus_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Sw_Mute_Psd := %X\n", getValue( HMI_StWhl_Sw_Mute_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Sw_Ok1_Psd := %X\n", getValue( HMI_StWhl_Sw_Ok1_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Sw_Ok2_Psd := %X\n", getValue( HMI_StWhl_Sw_Ok2_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Sw_Plus_Psd := %X\n", getValue( HMI_StWhl_Sw_Plus_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Sw_PTT_Psd := %X\n", getValue( HMI_StWhl_Sw_PTT_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Sw_TelEnd_Psd := %X\n", getValue( HMI_StWhl_Sw_TelEnd_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Sw_TelSend_Psd := %X\n", getValue( HMI_StWhl_Sw_TelSend_Psd ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Vol_Rq_SWSP := %X\n", getValue( HMI_Vol_Rq_SWSP ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Sw_Mute_Psd_V2 := %X\n", getValue( HMI_StWhl_Sw_Mute_Psd_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Sw_PTT_Psd_V2 := %X\n", getValue( HMI_StWhl_Sw_PTT_Psd_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Sw_TelEnd_Psd_V2 := %X\n", getValue( HMI_StWhl_Sw_TelEnd_Psd_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Sw_TelSend_Psd_V2 := %X\n", getValue( HMI_StWhl_Sw_TelSend_Psd_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tStWhl_Sw_Stat_AR
{
    putValue( HMI__STMSG_StWhl_Sw_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_StWhl_Sw_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_StWhl_Sw_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tStWhl_Sw_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_StWhl_Sw_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_StWhl_Sw_Stat_AR
{
    if( getValue( this ) )
        openPanel("StWhl_Sw_Stat_AR");
}

on envVar HMI_E2E_StWhl_Sw_Ok1_Ok2_Psd_Inject
{
    if( getValue( this ) )
    {
        _StWhl_Sw_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_StWhl_Sw_Ok1_Ok2_Psd_ErrorCount );
        _StWhl_Sw_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_StWhl_Sw_Ok1_Ok2_Psd_TriggerPosition );
        _StWhl_Sw_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_StWhl_Sw_Ok1_Ok2_Psd_WrongSeq );
        _StWhl_Sw_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_StWhl_Sw_Ok1_Ok2_Psd_Repeated );
        _StWhl_Sw_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_StWhl_Sw_Ok1_Ok2_Psd_MSG_DropCnt );
        putValue( HMI_E2E_StWhl_Sw_Ok1_Ok2_Psd_State, 2 );
        _StWhl_Sw_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_ALDW_VibMot_Avl
{
    _mStWhl_Sw_Stat_AR.ALDW_VibMot_Avl.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ALDW_VibMot_Avl_UB
{
    _mStWhl_Sw_Stat_AR.ALDW_VibMot_Avl_UB.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ALDW_VibMot_Stat
{
    _mStWhl_Sw_Stat_AR.ALDW_VibMot_Stat.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ALDW_VibMot_Stat_UB
{
    _mStWhl_Sw_Stat_AR.ALDW_VibMot_Stat_UB.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_HrnSw_Psd_V2
{
    _mStWhl_Sw_Stat_AR.HrnSw_Psd_V2.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Cond_ALDW_Sup
{
    _mStWhl_Sw_Stat_AR.StWhl_Cond_ALDW_Sup.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Sw_Back1_Psd
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cStWhlButtonNMRequest );
        setTimer( t_StWhlButtonNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Back1_Psd.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Sw_Back2_Psd
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cStWhlButtonNMRequest );
        setTimer( t_StWhlButtonNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Back2_Psd.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Sw_Fav_Psd_V2
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cStWhlButtonNMRequest );
        setTimer( t_StWhlButtonNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Fav_Psd_V2.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Sw_Home1_Psd
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cStWhlButtonNMRequest );
        setTimer( t_StWhlButtonNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Home1_Psd.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Sw_Home2_Psd
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cStWhlButtonNMRequest );
        setTimer( t_StWhlButtonNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Home2_Psd.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Sw_Minus_Psd
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cStWhlButtonNMRequest );
        setTimer( t_StWhlButtonNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Minus_Psd.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Sw_Mute_Psd
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cStWhlButtonNMRequest );
        setTimer( t_StWhlButtonNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Mute_Psd.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Sw_Ok1_Psd
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cStWhlButtonNMRequest );
        setTimer( t_StWhlButtonNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Ok1_Psd.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Sw_Ok2_Psd
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cStWhlButtonNMRequest );
        setTimer( t_StWhlButtonNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Ok2_Psd.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Sw_Plus_Psd
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cStWhlButtonNMRequest );
        setTimer( t_StWhlButtonNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Plus_Psd.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Sw_PTT_Psd
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cStWhlButtonNMRequest );
        setTimer( t_StWhlButtonNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mStWhl_Sw_Stat_AR.StWhl_Sw_PTT_Psd.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Sw_TelEnd_Psd
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cStWhlButtonNMRequest );
        setTimer( t_StWhlButtonNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mStWhl_Sw_Stat_AR.StWhl_Sw_TelEnd_Psd.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Sw_TelSend_Psd
{
    if( ( getValue( Env_Stress__StresstestMainActiv ) == 0 )   &&
        ( getValue( HMI__NM_EIS_AutomaticNM_Switching ) == 0 )    )
    {
        _SetCommRequest( cStWhlButtonNMRequest );
        setTimer( t_StWhlButtonNMCancelTimer, c_NMCancelTimer_05sec ); // 5 seconds for auto-shut-off
    }
    _mStWhl_Sw_Stat_AR.StWhl_Sw_TelSend_Psd.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Vol_Rq_SWSP
{
    _mStWhl_Sw_Stat_AR.Vol_Rq_SWSP.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Sw_Mute_Psd_V2
{
    _mStWhl_Sw_Stat_AR.StWhl_Sw_Mute_Psd_V2.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Sw_PTT_Psd_V2
{
    _mStWhl_Sw_Stat_AR.StWhl_Sw_PTT_Psd_V2.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Sw_TelEnd_Psd_V2
{
    _mStWhl_Sw_Stat_AR.StWhl_Sw_TelEnd_Psd_V2.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_StWhl_Sw_TelSend_Psd_V2
{
    _mStWhl_Sw_Stat_AR.StWhl_Sw_TelSend_Psd_V2.phys = getValue(this);
    _StWhl_Sw_Stat_AR_SpontanFlag = 1;
}


TC_Disp_Rq_ECM_AR_check_output()
{
    if( !getValue( HMI__STMSG_TC_Disp_Rq_ECM_AR ) )
    {
    //  message   TC_Disp_Rq_ECM ID: 331 --- Sendeart 0 cyclicX --- 
        _TC_Disp_Rq_ECM_AR_Cnt--;
        if( _TC_Disp_Rq_ECM_AR_Cnt < 1 )
        {
            // Zyklus abgelaufen, Nachricht senden
            TC_Disp_Rq_ECM_AR_next_values();
            if( _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState == 0 )
            {
                putValue( HMI_TC_FuelType_TC_DISP_RQ, _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState );
                _mTC_Disp_Rq_ECM_AR.TC_FuelType_TC_DISP_RQ.phys = getValue( HMI_TC_FuelType_TC_DISP_RQ);
                _mTC_Disp_Rq_ECM_AR.TC_GasFuelCons.phys = getValue( HMI_TC_GasFuelCons);
                _mTC_Disp_Rq_ECM_AR.TC_GasFuelCons_Divsr.phys = getValue( HMI_TC_GasFuelCons_Divsr );
                _mTC_Disp_Rq_ECM_AR.TC_GasFuelCons_Reset.phys = getValue( HMI_TC_GasFuelCons_Reset );
                _mTC_Disp_Rq_ECM_AR.TC_GasFuelCons_Reset_Divsr.phys = getValue( HMI_TC_GasFuelCons_Reset_Divsr );
                _mTC_Disp_Rq_ECM_AR.TC_GasFuelCons_Start.phys = getValue( HMI_TC_GasFuelCons_Start );
                _mTC_Disp_Rq_ECM_AR.TC_GasFuelCons_Start_Divsr.phys = getValue( HMI_TC_GasFuelCons_Start_Divsr );
                _mTC_Disp_Rq_ECM_AR.TC_GasFuelTankLvl_Min_50.phys = getValue( HMI_TC_GasFuelTankLvl_Min_50 );
                _mTC_Disp_Rq_ECM_AR.TC_GasFuelTankRng.phys = getValue( HMI_TC_GasFuelTankRng);
                _mTC_Disp_Rq_ECM_AR.TC_GasFuelConsRecup.phys = getValue( HMI_TC_GasFuelConsRecup);
                //_mTC_Disp_Rq_ECM_AR.TC_SkipRng_Disp_Rq.phys = getValue( HMI_TC_SkipRng_Disp_Rq_Gas );
            }
            if( _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState == 1 )
            {
                putValue( HMI_TC_FuelType_TC_DISP_RQ, _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState );
                _mTC_Disp_Rq_ECM_AR.TC_FuelType_TC_DISP_RQ.phys = getValue( HMI_TC_FuelType_TC_DISP_RQ);
                _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons.phys = getValue( HMI_TC_LiquidFuelCons);
                _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons_Divsr.phys = getValue( HMI_TC_LiquidFuelCons_Divsr );
                _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons_Reset.phys = getValue( HMI_TC_LiquidFuelCons_Reset );
                _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons_Reset_Divsr.phys = getValue( HMI_TC_LiquidFuelCons_Reset_Divsr );
                _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons_Start.phys = getValue( HMI_TC_LiquidFuelCons_Start );
                _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons_Start_Divsr.phys = getValue( HMI_TC_LiquidFuelCons_Start_Divsr );
                _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelTankLvl_Min_50.phys = getValue( HMI_TC_LiquidFuelTankLvl_Min_50 );
                _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelTankRng.phys = getValue( HMI_TC_LiquidFuelTankRng);
                _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelConsRecup.phys = getValue( HMI_TC_LiquidFuelConsRecup);
                _mTC_Disp_Rq_ECM_AR.TC_SkipRng_Disp_Rq2.phys = getValue( HMI_TC_SkipRng_Disp_Rq_Liq);
            }
            if( _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState == 2 )
            {
                putValue( HMI_TC_FuelType_TC_DISP_RQ, _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState );
                _mTC_Disp_Rq_ECM_AR.TC_FuelType_TC_DISP_RQ.phys = getValue( HMI_TC_FuelType_TC_DISP_RQ);
                _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyCons.phys = getValue( HMI_TC_ElecEnergyCons );
                _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyCons_Divsr.phys = getValue( HMI_TC_ElecEnergyCons_Divsr );
                _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyCons_Reset.phys = getValue( HMI_TC_ElecEnergyCons_Reset );
                _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyCons_Reset_Divsr.phys = getValue( HMI_TC_ElecEnergyCons_Reset_Divsr );
                _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyCons_Start.phys = getValue( HMI_TC_ElecEnergyCons_Start );
                _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyCons_Start_Divsr.phys = getValue( HMI_TC_ElecEnergyCons_Start_Divsr );
                _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyLvl_Min_502.phys = getValue( HMI_TC_ElecEnergyLvl_Min_502 );
                _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyRng.phys = getValue( HMI_TC_ElecEnergyRng );
                _mTC_Disp_Rq_ECM_AR.TC_SkipRng_Disp_Rq1.phys = getValue( HMI_TC_SkipRng_Disp_Rq_Elec );
              
            }
            if( _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState == 3 )
            {
                putValue( HMI_TC_FuelType_TC_DISP_RQ, _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState );
                _mTC_Disp_Rq_ECM_AR.TC_FuelType_TC_DISP_RQ.phys = getValue( HMI_TC_FuelType_TC_DISP_RQ );
                _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelTankLvl_Min_50.phys = 0;
                _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelTankRng.phys = 2047;
                _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons_Reset.phys = 102.3;
                _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons_Start.phys = 102.3;
                _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons.phys = 102.3;
                _mTC_Disp_Rq_ECM_AR.TC_SkipRng_Disp_Rq1.phys = 0;
                _mTC_Disp_Rq_ECM_AR.TC_SkipRng_Disp_Rq2.phys = 0;
            }

            TC_Disp_Rq_ECM_AR_output();
            _TC_Disp_Rq_ECM_AR_Cnt = _TC_Disp_Rq_ECM_AR_CycleCount;
        }
    }
}

TC_Disp_Rq_ECM_AR_init()
{   /* Botschaft TC_Disp_Rq_ECM_AR ID: 331 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 331 0;
BA_ "NmAsrMessage" BO_ 331 0;
BA_ "GenMsgMinAcceptLength" BO_ 331 8;
BA_ "GenMsgILSupport" BO_ 331 0;
BA_ "DiagState" BO_ 331 0;
BA_ "DiagRequest" BO_ 331 0;
BA_ "DiagResponse" BO_ 331 0;
BA_ "GenMsgStartValue" BO_ 331 "0";
BA_ "GenMsgStartDelayTime" BO_ 331 0;
BA_ "GenMsgCycleTime" BO_ 331 40;
BA_ "GenMsgSendType" BO_ 331 0;
    */
    _TC_Disp_Rq_ECM_AR_Timebase =           c_tDBKomTimer_20ms;
    _TC_Disp_Rq_ECM_AR_CycleCount =         40 / _TC_Disp_Rq_ECM_AR_Timebase;
    _TC_Disp_Rq_ECM_AR_StartDelay =          0 / _TC_Disp_Rq_ECM_AR_Timebase;
    _TC_Disp_Rq_ECM_AR_Cnt = _TC_Disp_Rq_ECM_AR_StartDelay;
    _TC_Disp_Rq_ECM_AR_SigActivity = 0;

    putValue( HMI__STMSGSD_TC_Disp_Rq_ECM_AR, _TC_Disp_Rq_ECM_AR_StartDelay * _TC_Disp_Rq_ECM_AR_Timebase );

    _mTC_Disp_Rq_ECM_AR.TC_PN14_RecupPwr.phys = getValue( HMI_TC_PN14_RecupPwr );
    _mTC_Disp_Rq_ECM_AR.ZeroEmission_Actv.phys = getValue( HMI_ZeroEmission_Actv );
    _mTC_Disp_Rq_ECM_AR.TC_FuelType_TC_DISP_RQ.phys = getValue( HMI_TC_FuelType_TC_DISP_RQ );
    _mTC_Disp_Rq_ECM_AR.TC_GasFuelCons.phys = getValue( HMI_TC_GasFuelCons );
    _mTC_Disp_Rq_ECM_AR.TC_GasFuelCons_Divsr.phys = getValue( HMI_TC_GasFuelCons_Divsr );
    _mTC_Disp_Rq_ECM_AR.TC_GasFuelCons_Reset.phys = getValue( HMI_TC_GasFuelCons_Reset );
    _mTC_Disp_Rq_ECM_AR.TC_GasFuelCons_Reset_Divsr.phys = getValue( HMI_TC_GasFuelCons_Reset_Divsr );
    _mTC_Disp_Rq_ECM_AR.TC_GasFuelCons_Start.phys = getValue( HMI_TC_GasFuelCons_Start );
    _mTC_Disp_Rq_ECM_AR.TC_GasFuelCons_Start_Divsr.phys = getValue( HMI_TC_GasFuelCons_Start_Divsr );
    _mTC_Disp_Rq_ECM_AR.TC_GasFuelTankLvl_Min_50.phys = getValue( HMI_TC_GasFuelTankLvl_Min_50 );
    _mTC_Disp_Rq_ECM_AR.TC_GasFuelTankRng.phys = getValue( HMI_TC_GasFuelTankRng );
    _mTC_Disp_Rq_ECM_AR.TC_GasFuelConsRecup.phys = getValue( HMI_TC_GasFuelConsRecup );
    _mTC_Disp_Rq_ECM_AR.TC_SkipRng_Disp_Rq1.phys = getValue( HMI_TC_SkipRng_Disp_Rq_Elec );
    _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons.phys = getValue( HMI_TC_LiquidFuelCons );
    _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons_Divsr.phys = getValue( HMI_TC_LiquidFuelCons_Divsr );
    _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons_Reset.phys = getValue( HMI_TC_LiquidFuelCons_Reset );
    _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons_Reset_Divsr.phys = getValue( HMI_TC_LiquidFuelCons_Reset_Divsr );
    _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons_Start.phys = getValue( HMI_TC_LiquidFuelCons_Start );
    _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons_Start_Divsr.phys = getValue( HMI_TC_LiquidFuelCons_Start_Divsr );
    _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelTankLvl_Min_50.phys = getValue( HMI_TC_LiquidFuelTankLvl_Min_50 );
    _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelTankRng.phys = getValue( HMI_TC_LiquidFuelTankRng );
    _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelConsRecup.phys = getValue( HMI_TC_LiquidFuelConsRecup );
    _mTC_Disp_Rq_ECM_AR.TC_SkipRng_Disp_Rq2.phys = getValue( HMI_TC_SkipRng_Disp_Rq_Liq );
    _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyCons.phys = getValue( HMI_TC_ElecEnergyCons );
    _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyCons_Divsr.phys = getValue( HMI_TC_ElecEnergyCons_Divsr );
    _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyCons_Reset.phys = getValue( HMI_TC_ElecEnergyCons_Reset );
    _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyCons_Reset_Divsr.phys = getValue( HMI_TC_ElecEnergyCons_Reset_Divsr );
    _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyCons_Start.phys = getValue( HMI_TC_ElecEnergyCons_Start );
    _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyCons_Start_Divsr.phys = getValue( HMI_TC_ElecEnergyCons_Start_Divsr );
    _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyLvl_Min_502.phys = getValue( HMI_TC_ElecEnergyLvl_Min_502 );
    _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyRng.phys = getValue( HMI_TC_ElecEnergyRng );
//    _mTC_Disp_Rq_ECM_AR.TC_SkipRng_Disp_Rq2.phys = getValue( HMI_TC_SkipRng_Disp_Rq_Liq );
//    _TC_Disp_Rq_ECM_ARTC_FuelTypeActState = TC_Disp_Rq_ECM_AR_Change( _TC_Disp_Rq_ECM_ARTC_FuelTypeActState, _mTC_Disp_Rq_ECM_AR.TC_FuelType_TC_DISP_RQ, 3);
    putValue( HMI_TC_FuelType, _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState );
}

TC_Disp_Rq_ECM_AR_next_values()
{
    if( ( getValue( HMI_TC_FuelType_TC_DISP_RQ_Liquid ) == 0 ) &     // 1
        ( getValue( HMI_TC_FuelType_TC_DISP_RQ_Gas    ) == 0 ) &     // 0
        ( getValue( HMI_TC_FuelType_TC_DISP_RQ_Elec   ) == 0 )    )   // 2
    {
        _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState = 3;  //SNA
        return;
    }
    else
    if( _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState == 3 )  //SNA
        _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState = 0;

    if( _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState == 0 )    // Gas
    {
        if( getValue( HMI_TC_FuelType_TC_DISP_RQ_Liquid ) == 1 )   // 1
        {
            _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState = 1;  // Liquid
            return;
        }
        if( getValue( HMI_TC_FuelType_TC_DISP_RQ_Elec ) == 1 )     // 2
        {
            _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState = 2;  // Elec
            return;
        }
        return; // no change, only one type active
    }

    if( _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState == 1 )    // Liquid
    {
        if( getValue( HMI_TC_FuelType_TC_DISP_RQ_Elec ) == 1 )   // 1
        {
            _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState = 2;  // Elec
            return;
        }
        if( getValue( HMI_TC_FuelType_TC_DISP_RQ_Gas ) == 1 )     // 2
        {
            _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState = 0;  // Gas
            return;
        }
        return; // no change, only one type active
    }
    if( _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState == 2 )    // Elec
    {
        if( getValue( HMI_TC_FuelType_TC_DISP_RQ_Gas ) == 1 )   // 1
        {
            _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState = 0;  // Gas
            return;
        }
        if( getValue( HMI_TC_FuelType_TC_DISP_RQ_Liquid ) == 1 )     // 2
        {
            _TC_Disp_Rq_ECM_AR_TC_FuelType_ActState = 1;  // Liquid
            return;
        }
        return; // no change, only one type active
    }
}

TC_Disp_Rq_ECM_AR_output()
{
    output( _mTC_Disp_Rq_ECM_AR );
}

TC_Disp_Rq_ECM_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: TC_Disp_Rq_ECM_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_TC_Disp_Rq_ECM_AR := %X\n", getValue( HMI__STMSG_TC_Disp_Rq_ECM_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_TC_Disp_Rq_ECM_AR := %X\n", getValue( HMI__STMSGT_TC_Disp_Rq_ECM_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_PN14_RecupPwr := %X\n", getValue( HMI_TC_PN14_RecupPwr ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ZeroEmission_Actv := %X\n", getValue( HMI_ZeroEmission_Actv ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_FuelType_TC_DISP_RQ := %X\n", getValue( HMI_TC_FuelType_TC_DISP_RQ ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_GasFuelCons := %X\n", getValue( HMI_TC_GasFuelCons ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_GasFuelCons_Divsr := %X\n", getValue( HMI_TC_GasFuelCons_Divsr ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_GasFuelCons_Reset := %X\n", getValue( HMI_TC_GasFuelCons_Reset ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_GasFuelCons_Reset_Divsr := %X\n", getValue( HMI_TC_GasFuelCons_Reset_Divsr ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_GasFuelCons_Start := %X\n", getValue( HMI_TC_GasFuelCons_Start ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_GasFuelCons_Start_Divsr := %X\n", getValue( HMI_TC_GasFuelCons_Start_Divsr ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_GasFuelTankLvl_Min_50 := %X\n", getValue( HMI_TC_GasFuelTankLvl_Min_50 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_GasFuelTankRng := %X\n", getValue( HMI_TC_GasFuelTankRng ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_SkipRng_Disp_Rq_Gas := %X\n", getValue( HMI_TC_SkipRng_Disp_Rq_Gas ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_LiquidFuelConsRecup := %X\n", getValue( HMI_TC_LiquidFuelConsRecup ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_LiquidFuelCons_Divsr := %X\n", getValue( HMI_TC_LiquidFuelCons_Divsr ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_LiquidFuelCons_Start := %X\n", getValue( HMI_TC_LiquidFuelCons_Start ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_LiquidFuelCons_Reset_Divsr := %X\n", getValue( HMI_TC_LiquidFuelCons_Reset_Divsr ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_LiquidFuelCons_Reset := %X\n", getValue( HMI_TC_LiquidFuelCons_Reset ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_LiquidFuelCons_Start_Divsr := %X\n", getValue( HMI_TC_LiquidFuelCons_Start_Divsr ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_LiquidFuelCons := %X\n", getValue( HMI_TC_LiquidFuelCons ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_LiquidFuelTankLvl_Min_50 := %X\n", getValue( HMI_TC_LiquidFuelTankLvl_Min_50 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_LiquidFuelTankRng := %X\n", getValue( HMI_TC_LiquidFuelTankRng ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_SkipRng_Disp_Rq_Liq := %X\n", getValue( HMI_TC_SkipRng_Disp_Rq_Liq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_ElecEnergyCons_Start := %X\n", getValue( HMI_TC_ElecEnergyCons_Start ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_ElecEnergyCons_Start_Divsr := %X\n", getValue( HMI_TC_ElecEnergyCons_Start_Divsr ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_ElecEnergyCons_Reset := %X\n", getValue( HMI_TC_ElecEnergyCons_Reset ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_ElecEnergyCons_Reset_Divsr := %X\n", getValue( HMI_TC_ElecEnergyCons_Reset_Divsr ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_ElecEnergyCons := %X\n", getValue( HMI_TC_ElecEnergyCons ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_ElecEnergyCons_Divsr := %X\n", getValue( HMI_TC_ElecEnergyCons_Divsr ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_ElecEnergyLvl_Min_502 := %X\n", getValue( HMI_TC_ElecEnergyLvl_Min_502 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_ElecEnergyRng := %X\n", getValue( HMI_TC_ElecEnergyRng ) );    filePutString( buffer, elcount( buffer ), hFile );
    //snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_SkipRng_Disp_Rq_Elec := %X\n", getValue( HMI_TC_SkipRng_Disp_Rq_Elec ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tTC_Disp_Rq_ECM_AR
{
    putValue( HMI__STMSG_TC_Disp_Rq_ECM_AR, 0 );
}

on EnvVar HMI__STMSG_TC_Disp_Rq_ECM_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_TC_Disp_Rq_ECM_AR );
        if( tDelay > 0)    
            setTimer( _tTC_Disp_Rq_ECM_AR, tDelay );
        else
            putValue( HMI__STMSG_TC_Disp_Rq_ECM_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_TC_Disp_Rq_ECM_AR
{
    if( getValue( this ) )
        openPanel("TC_Disp_Rq_ECM_AR");
}

on EnvVar HMI_TC_PN14_RecupPwr
{
    _mTC_Disp_Rq_ECM_AR.TC_PN14_RecupPwr.phys = getValue(this);
}

on EnvVar HMI_ZeroEmission_Actv
{
    _mTC_Disp_Rq_ECM_AR.ZeroEmission_Actv.phys = getValue(this);
}

on EnvVar HMI_TC_GasFuelCons
{
    _mTC_Disp_Rq_ECM_AR.TC_GasFuelCons.phys = getValue(this);
}

on EnvVar HMI_TC_GasFuelCons_Divsr
{
    _mTC_Disp_Rq_ECM_AR.TC_GasFuelCons_Divsr.phys = getValue(this);
}

on EnvVar HMI_TC_GasFuelCons_Reset
{
    _mTC_Disp_Rq_ECM_AR.TC_GasFuelCons_Reset.phys = getValue(this);
}

on EnvVar HMI_TC_GasFuelCons_Reset_Divsr
{
    _mTC_Disp_Rq_ECM_AR.TC_GasFuelCons_Reset_Divsr.phys = getValue(this);
}

on EnvVar HMI_TC_GasFuelCons_Start
{
    _mTC_Disp_Rq_ECM_AR.TC_GasFuelCons_Start.phys = getValue(this);
}

on EnvVar HMI_TC_GasFuelCons_Start_Divsr
{
    _mTC_Disp_Rq_ECM_AR.TC_GasFuelCons_Start_Divsr.phys = getValue(this);
}

on EnvVar HMI_TC_GasFuelTankRng
{
    _mTC_Disp_Rq_ECM_AR.TC_GasFuelTankRng.phys = getValue(this);
}

on EnvVar HMI_TC_GasFuelTankLvl_Min_50
{
    _mTC_Disp_Rq_ECM_AR.TC_GasFuelTankLvl_Min_50.phys = getValue(this);
}

on EnvVar HMI_TC_LiquidFuelCons
{
    _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons.phys = getValue(this);
}

on EnvVar HMI_TC_LiquidFuelCons_Divsr
{
    _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons_Divsr.phys = getValue(this);
}

on EnvVar HMI_TC_LiquidFuelCons_Reset
{
    _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons_Reset.phys = getValue(this);
}

on EnvVar HMI_TC_LiquidFuelCons_Reset_Divsr
{
    _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons_Reset_Divsr.phys = getValue(this);
}

on EnvVar HMI_TC_LiquidFuelCons_Start
{
    _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons_Start.phys = getValue(this);
}

on EnvVar HMI_TC_LiquidFuelCons_Start_Divsr
{
    _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelCons_Start_Divsr.phys = getValue(this);
}

on EnvVar HMI_TC_LiquidFuelTankRng
{
    _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelTankRng.phys = getValue(this);
}

on EnvVar HMI_TC_LiquidFuelTankLvl_Min_50
{
    _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelTankLvl_Min_50.phys = getValue(this);
}

on EnvVar HMI_TC_LiquidFuelConsRecup
{
    _mTC_Disp_Rq_ECM_AR.TC_LiquidFuelConsRecup.phys = getValue(this);
}

on EnvVar HMI_TC_ElecEnergyCons
{
    _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyCons.phys = getValue(this);
}

on EnvVar HMI_TC_ElecEnergyCons_Divsr
{
    _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyCons_Divsr.phys = getValue(this);
}

on EnvVar HMI_TC_ElecEnergyCons_Reset_Divsr
{
    _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyCons_Reset_Divsr.phys = getValue(this);
}

on EnvVar HMI_TC_ElecEnergyCons_Reset
{
    _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyCons_Reset.phys = getValue(this);
}

on EnvVar HMI_TC_ElecEnergyCons_Start
{
    _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyCons_Start.phys = getValue(this);
}

on EnvVar HMI_TC_ElecEnergyCons_Start_Divsr
{
    _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyCons_Start_Divsr.phys = getValue(this);
}

on EnvVar HMI_TC_ElecEnergyLvl_Min_502
{
    _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyLvl_Min_502.phys = getValue(this);
}

on EnvVar HMI_TC_ElecEnergyRng
{
    _mTC_Disp_Rq_ECM_AR.TC_ElecEnergyRng.phys = getValue(this);
}
/* Gas?
on EnvVar HMI_TC_SkipRng_Disp_Rq_Elec
{
    _mTC_Disp_Rq_ECM_AR.TC_SkipRng_Disp_Rq.phys = getValue(this);
}
*/
on EnvVar HMI_TC_SkipRng_Disp_Rq_Elec
{
    _mTC_Disp_Rq_ECM_AR.TC_SkipRng_Disp_Rq1.phys = getValue(this);
}

on EnvVar HMI_TC_SkipRng_Disp_Rq_Liq
{
    _mTC_Disp_Rq_ECM_AR.TC_SkipRng_Disp_Rq2.phys = getValue(this);
}

TC_EBBC_Disp_Rq_ECM_AR_check_output()
{
    if( !getValue( HMI__STMSG_TC_EBBC_Disp_Rq_ECM_AR ) )
    {
    //  message   TC_EBBC_Disp_Rq_ECM_AR ID: 333 --- Sendeart 0 cyclicX --- 
        _TC_EBBC_Disp_Rq_ECM_AR_Cnt--;
        if( _TC_EBBC_Disp_Rq_ECM_AR_Cnt < 1 )
        {
            TC_EBBC_Disp_Rq_ECM_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _TC_EBBC_Disp_Rq_ECM_AR_Cnt = _TC_EBBC_Disp_Rq_ECM_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

TC_EBBC_Disp_Rq_ECM_AR_init()
{   /* Botschaft TC_EBBC_Disp_Rq_ECM_AR ID: 333 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 333 0;
BA_ "NmAsrMessage" BO_ 333 0;
BA_ "GenMsgMinAcceptLength" BO_ 333 8;
BA_ "GenMsgILSupport" BO_ 333 1;
BA_ "DiagState" BO_ 333 0;
BA_ "DiagRequest" BO_ 333 0;
BA_ "DiagResponse" BO_ 333 0;
BA_ "GenMsgStartValue" BO_ 333 "0";
BA_ "GenMsgCycleTime" BO_ 333 100;
BA_ "GenMsgSendType" BO_ 333 0;
    */
    _TC_EBBC_Disp_Rq_ECM_AR_Timebase =        c_tDBKomTimer_20ms;
    _TC_EBBC_Disp_Rq_ECM_AR_CycleCount =    100 / _TC_EBBC_Disp_Rq_ECM_AR_Timebase;
    _TC_EBBC_Disp_Rq_ECM_AR_StartDelay =      0 / _TC_EBBC_Disp_Rq_ECM_AR_Timebase;
    _TC_EBBC_Disp_Rq_ECM_AR_Cnt = _TC_EBBC_Disp_Rq_ECM_AR_StartDelay;

    putValue( HMI__STMSGSD_TC_EBBC_Disp_Rq_ECM_AR, _TC_EBBC_Disp_Rq_ECM_AR_StartDelay * _TC_EBBC_Disp_Rq_ECM_AR_Timebase );

    _mTC_EBBC_Disp_Rq_ECM_AR.TC_EBBC_AvgFuelCons1.phys = getValue( HMI_TC_EBBC_AvgFuelCons1 );
    _mTC_EBBC_Disp_Rq_ECM_AR.TC_EBBC_AvgFuelCons2.phys = getValue( HMI_TC_EBBC_AvgFuelCons2 );
    _mTC_EBBC_Disp_Rq_ECM_AR.TC_EBBC_AvgRecupLvl1.phys = getValue( HMI_TC_EBBC_AvgRecupLvl1 );
    _mTC_EBBC_Disp_Rq_ECM_AR.TC_EBBC_AvgRecupLvl2.phys = getValue( HMI_TC_EBBC_AvgRecupLvl2 );
    _mTC_EBBC_Disp_Rq_ECM_AR.TC_EBBC_DispCnt1.phys = getValue( HMI_TC_EBBC_DispCnt1 );
    _mTC_EBBC_Disp_Rq_ECM_AR.TC_EBBC_DispCnt2.phys = getValue( HMI_TC_EBBC_DispCnt2 );
    _mTC_EBBC_Disp_Rq_ECM_AR.TC_EBBC_DispIdx.phys = getValue( HMI_TC_EBBC_DispIdx );
    _mTC_EBBC_Disp_Rq_ECM_AR.TC_EBBC_FuelCons.phys = getValue( HMI_TC_EBBC_FuelCons );
}

TC_EBBC_Disp_Rq_ECM_AR_output(void)
{
    output( _mTC_EBBC_Disp_Rq_ECM_AR );
}

TC_EBBC_Disp_Rq_ECM_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: TC_EBBC_Disp_Rq_ECM_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_TC_EBBC_Disp_Rq_ECM := %X\n", getValue( HMI__STMSG_TC_EBBC_Disp_Rq_ECM_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_TC_EBBC_Disp_Rq_ECM := %X\n", getValue( HMI__STMSGT_TC_EBBC_Disp_Rq_ECM_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EBBC_AvgFuelCons1 := %f\n", getValue( HMI_TC_EBBC_AvgFuelCons1 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EBBC_AvgFuelCons2 := %f\n", getValue( HMI_TC_EBBC_AvgFuelCons2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EBBC_AvgRecupLvl1 := %f\n", getValue( HMI_TC_EBBC_AvgRecupLvl1 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EBBC_AvgRecupLvl2 := %f\n", getValue( HMI_TC_EBBC_AvgRecupLvl2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EBBC_DispCnt1 := %f\n", getValue( HMI_TC_EBBC_DispCnt1 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EBBC_DispCnt2 := %f\n", getValue( HMI_TC_EBBC_DispCnt2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EBBC_DispIdx := %f\n", getValue( HMI_TC_EBBC_DispIdx ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EBBC_FuelCons := %f\n", getValue( HMI_TC_EBBC_FuelCons ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tTC_EBBC_Disp_Rq_ECM_AR
{
    putValue( HMI__STMSG_TC_EBBC_Disp_Rq_ECM_AR, 0 );
}

on EnvVar HMI__STMSG_TC_EBBC_Disp_Rq_ECM_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_TC_EBBC_Disp_Rq_ECM_AR );
        if( tDelay > 0)    
            setTimer( _tTC_EBBC_Disp_Rq_ECM_AR, tDelay );
        else
            putValue( HMI__STMSG_TC_EBBC_Disp_Rq_ECM_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_TC_EBBC_Disp_Rq_ECM_AR
{
    if( getValue( this ) )
        openPanel("TC_EBBC_Disp_Rq_ECM_AR");
}

on EnvVar HMI_TC_EBBC_AvgFuelCons1
{
    _mTC_EBBC_Disp_Rq_ECM_AR.TC_EBBC_AvgFuelCons1.phys = getValue(this);
}

on EnvVar HMI_TC_EBBC_AvgFuelCons2
{
    _mTC_EBBC_Disp_Rq_ECM_AR.TC_EBBC_AvgFuelCons2.phys = getValue(this);
}

on EnvVar HMI_TC_EBBC_AvgRecupLvl1
{
    _mTC_EBBC_Disp_Rq_ECM_AR.TC_EBBC_AvgRecupLvl1.phys = getValue(this);
}

on EnvVar HMI_TC_EBBC_AvgRecupLvl2
{
    _mTC_EBBC_Disp_Rq_ECM_AR.TC_EBBC_AvgRecupLvl2.phys = getValue(this);
}

on EnvVar HMI_TC_EBBC_DispCnt1
{
    _mTC_EBBC_Disp_Rq_ECM_AR.TC_EBBC_DispCnt1.phys = getValue(this);
}

on EnvVar HMI_TC_EBBC_DispCnt2
{
    _mTC_EBBC_Disp_Rq_ECM_AR.TC_EBBC_DispCnt2.phys = getValue(this);
}

on EnvVar HMI_TC_EBBC_DispIdx
{
    _mTC_EBBC_Disp_Rq_ECM_AR.TC_EBBC_DispIdx.phys = getValue(this);
}

on EnvVar HMI_TC_EBBC_FuelCons
{
    _mTC_EBBC_Disp_Rq_ECM_AR.TC_EBBC_FuelCons.phys = getValue(this);
}

TC_EEBBC_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_TC_EEBBC_Disp_Rq_AR ) )
    {
    //  message   TC_EEBBC_Disp_Rq_AR ID: 647 --- Sendeart 0 cyclicX --- 
        _TC_EEBBC_Disp_Rq_AR_Cnt--;
        if( _TC_EEBBC_Disp_Rq_AR_Cnt < 1 )
        {
            TC_EEBBC_Disp_Rq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _TC_EEBBC_Disp_Rq_AR_Cnt = _TC_EEBBC_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

TC_EEBBC_Disp_Rq_AR_init()
{   /* Botschaft TC_EEBBC_Disp_Rq_AR ID: 647 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 647 0;
BA_ "NmAsrMessage" BO_ 647 0;
BA_ "GenMsgMinAcceptLength" BO_ 647 8;
BA_ "GenMsgILSupport" BO_ 647 1;
BA_ "DiagState" BO_ 647 0;
BA_ "DiagRequest" BO_ 647 0;
BA_ "DiagResponse" BO_ 647 0;
BA_ "GenMsgStartValue" BO_ 647 "0";
BA_ "GenMsgCycleTime" BO_ 647 100;
BA_ "GenMsgSendType" BO_ 647 0;
    */
    _TC_EEBBC_Disp_Rq_AR_Timebase =        c_tDBKomTimer_20ms;
    _TC_EEBBC_Disp_Rq_AR_CycleCount =    100 / _TC_EEBBC_Disp_Rq_AR_Timebase;
    _TC_EEBBC_Disp_Rq_AR_StartDelay =      0 / _TC_EEBBC_Disp_Rq_AR_Timebase;
    _TC_EEBBC_Disp_Rq_AR_Cnt = _TC_EEBBC_Disp_Rq_AR_StartDelay;

    putValue( HMI__STMSGSD_TC_EEBBC_Disp_Rq_AR, _TC_EEBBC_Disp_Rq_AR_StartDelay * _TC_EEBBC_Disp_Rq_AR_Timebase );

    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_AvgEnergyCons1.phys = getValue( HMI_TC_EEBBC_AvgEnergyCons1 );
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_AvgEnergyCons2.phys = getValue( HMI_TC_EEBBC_AvgEnergyCons2 );
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_DispCnt1.phys = getValue( HMI_TC_EEBBC_DispCnt1 );
    _mTC_EEBBC_Disp_Rq_AR.PT4_PTCoor_Accel_Disp.phys = getValue( HMI_PT4_PTCoor_Accel_Disp );
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_DispCnt2.phys = getValue( HMI_TC_EEBBC_DispCnt2 );
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_DispIdx.phys = getValue( HMI_TC_EEBBC_DispIdx );
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_DrvProg1.phys = getValue( HMI_TC_EEBBC_DrvProg1 );
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_DrvProg2.phys = getValue( HMI_TC_EEBBC_DrvProg2 );
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_OprtnMd1.phys = getValue( HMI_TC_EEBBC_OprtnMd1 );
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_OprtnMd2.phys = getValue( HMI_TC_EEBBC_OprtnMd2 );
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_TmRng.phys = getValue( HMI_TC_EEBBC_TmRng );
}

TC_EEBBC_Disp_Rq_AR_output(void)
{
    output( _mTC_EEBBC_Disp_Rq_AR );
}

TC_EEBBC_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: TC_EEBBC_Disp_Rq_AR\n", 36, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_TC_EEBBC_Disp_Rq_AR := %X\n", getValue( HMI__STMSG_TC_EEBBC_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_TC_EEBBC_Disp_Rq_AR := %X\n", getValue( HMI__STMSGT_TC_EEBBC_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EEBBC_AvgEnergyCons1 := %f\n", getValue( HMI_TC_EEBBC_AvgEnergyCons1 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EEBBC_AvgEnergyCons2 := %f\n", getValue( HMI_TC_EEBBC_AvgEnergyCons2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EEBBC_DispCnt1 := %f\n", getValue( HMI_TC_EEBBC_DispCnt1 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PT4_PTCoor_Accel_Disp := %f\n", getValue( HMI_PT4_PTCoor_Accel_Disp ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EEBBC_DispCnt2 := %f\n", getValue( HMI_TC_EEBBC_DispCnt2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EEBBC_DispIdx := %f\n", getValue( HMI_TC_EEBBC_DispIdx ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EEBBC_DrvProg1 := %f\n", getValue( HMI_TC_EEBBC_DrvProg1 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EEBBC_DrvProg2 := %f\n", getValue( HMI_TC_EEBBC_DrvProg2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EEBBC_OprtnMd1 := %f\n", getValue( HMI_TC_EEBBC_OprtnMd1 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EEBBC_OprtnMd2 := %f\n", getValue( HMI_TC_EEBBC_OprtnMd2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_EEBBC_TmRng := %f\n", getValue( HMI_TC_EEBBC_TmRng ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tTC_EEBBC_Disp_Rq_AR
{
    putValue( HMI__STMSG_TC_EEBBC_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_TC_EEBBC_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_TC_EEBBC_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tTC_EEBBC_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_TC_EEBBC_Disp_Rq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_TC_EEBBC_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("TC_EEBBC_Disp_Rq_AR");
}

on EnvVar HMI_TC_EEBBC_AvgEnergyCons1
{
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_AvgEnergyCons1.phys = getValue(this);
}

on EnvVar HMI_TC_EEBBC_AvgEnergyCons2
{
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_AvgEnergyCons2.phys = getValue(this);
}

on EnvVar HMI_TC_EEBBC_DispCnt1
{
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_DispCnt1.phys = getValue(this);
}

on EnvVar HMI_PT4_PTCoor_Accel_Disp
{
    _mTC_EEBBC_Disp_Rq_AR.PT4_PTCoor_Accel_Disp.phys = getValue(this);
}

on EnvVar HMI_TC_EEBBC_DispCnt2
{
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_DispCnt2.phys = getValue(this);
}

on EnvVar HMI_TC_EEBBC_DispIdx
{
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_DispIdx.phys = getValue(this);
}

on EnvVar HMI_TC_EEBBC_DrvProg1
{
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_DrvProg1.phys = getValue(this);
}

on EnvVar HMI_TC_EEBBC_DrvProg2
{
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_DrvProg2.phys = getValue(this);
}

on EnvVar HMI_TC_EEBBC_OprtnMd1
{
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_OprtnMd1.phys = getValue(this);
}

on EnvVar HMI_TC_EEBBC_OprtnMd2
{
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_OprtnMd2.phys = getValue(this);
}

on EnvVar HMI_TC_EEBBC_TmRng
{
    _mTC_EEBBC_Disp_Rq_AR.TC_EEBBC_TmRng.phys = getValue(this);
}

TC_EU6_Cons_Disp_Rq_AR_check_output()
{
    if( !getValue( HMI__STMSG_TC_EU6_Cons_Disp_Rq_AR ) )
    {
    //  message   TC_EU6_Cons_Disp_Rq_AR ID: 1025 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _TC_EU6_Cons_Disp_Rq_AR_Cnt--;
        if( _TC_EU6_Cons_Disp_Rq_AR_Cnt < 1 )
        {
            TC_EU6_Cons_Disp_Rq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _TC_EU6_Cons_Disp_Rq_AR_Cnt = _TC_EU6_Cons_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag )
        {
            TC_EU6_Cons_Disp_Rq_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

TC_EU6_Cons_Disp_Rq_AR_init()
{   /* Botschaft TC_EU6_Cons_Disp_Rq_AR ID: 848 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 848 0;
BA_ "NmAsrMessage" BO_ 848 0;
BA_ "GenMsgMinAcceptLength" BO_ 848 8;
BA_ "GenMsgILSupport" BO_ 848 0;
BA_ "DiagState" BO_ 848 0;
BA_ "DiagRequest" BO_ 848 0;
BA_ "DiagResponse" BO_ 848 0;
BA_ "GenMsgStartValue" BO_ 848 "0";
BA_ "GenMsgDelayTime" BO_ 848 40;
BA_ "GenMsgNrOfRepetition" 848 692 0;
BA_ "GenMsgCycleTime" BO_ 848 1000;
BA_ "GenMsgSendType" BO_ 848 5;
    */
    _TC_EU6_Cons_Disp_Rq_AR_Timebase =               c_tDBKomTimer_20ms;
    _TC_EU6_Cons_Disp_Rq_AR_CycleCount =            1000 / _TC_EU6_Cons_Disp_Rq_AR_Timebase;
    _TC_EU6_Cons_Disp_Rq_AR_StartDelay =               0 / _TC_EU6_Cons_Disp_Rq_AR_Timebase;
    _TC_EU6_Cons_Disp_Rq_AR_MinDelay =                40 / _TC_EU6_Cons_Disp_Rq_AR_Timebase;
    _TC_EU6_Cons_Disp_Rq_AR_Cnt = _TC_EU6_Cons_Disp_Rq_AR_StartDelay;
    _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 0;
    _TC_EU6_Cons_Disp_Rq_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_TC_EU6_Cons_Disp_Rq_AR, _TC_EU6_Cons_Disp_Rq_AR_StartDelay * _TC_EU6_Cons_Disp_Rq_AR_Timebase );
    putValue( HMI__STMSGCT_TC_EU6_Cons_Disp_Rq_AR, _TC_EU6_Cons_Disp_Rq_AR_CycleCount * _TC_EU6_Cons_Disp_Rq_AR_Timebase );

    _mTC_EU6_Cons_Disp_Rq_AR.TC_FuelType_TC_DISP_RQ2.phys = getValue( HMI_TC_FuelType_TC_DISP_RQ2 );
    _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuel_Res_Disp_Rq.phys = getValue( HMI_TC_GasFuel_Res_Disp_Rq );
    _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuel_Res_Icon_Rq.phys = getValue( HMI_TC_GasFuel_Res_Icon_Rq );
    _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuel_Res_Warn_Rq.phys = getValue( HMI_TC_GasFuel_Res_Warn_Rq );
    _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuelCons_Actl.phys = getValue( HMI_TC_GasFuelCons_Actl );
    _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuelCons_LfTm.phys = getValue( HMI_TC_GasFuelCons_LfTm );
    _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuelCons_LfTm_Divsr.phys = getValue( HMI_TC_GasFuelCons_LfTm_Divsr );
    _mTC_EU6_Cons_Disp_Rq_AR.TC_LiquidFuelCons_Actl.phys = getValue( HMI_TC_LiquidFuelCons_Actl );
    _mTC_EU6_Cons_Disp_Rq_AR.TC_LiquidFuelCons_LfTm.phys = getValue( HMI_TC_LiquidFuelCons_LfTm );
    _mTC_EU6_Cons_Disp_Rq_AR.TC_LiquidFuelCons_LfTm_Divsr.phys = getValue( HMI_TC_LiquidFuelCons_LfTm_Divsr );
    _mTC_EU6_Cons_Disp_Rq_AR.TC_ElecEnergy_Res_Disp_Rq.phys = getValue( HMI_TC_ElecEnergy_Res_Disp_Rq );
    _mTC_EU6_Cons_Disp_Rq_AR.TC_ElecEnergy_Res_Icon_Rq.phys = getValue( HMI_TC_ElecEnergy_Res_Icon_Rq );
    _mTC_EU6_Cons_Disp_Rq_AR.TC_ElecEnergy_Res_Warn_Rq.phys = getValue( HMI_TC_ElecEnergy_Res_Warn_Rq );
    _mTC_EU6_Cons_Disp_Rq_AR.TC_ElecEnergyCons_Actl_V2.phys = getValue( HMI_TC_ElecEnergyCons_Actl_V2 );
    _mTC_EU6_Cons_Disp_Rq_AR.TC_ElecEnergyCons_LfTm.phys = getValue( HMI_TC_ElecEnergyCons_LfTm );
    _mTC_EU6_Cons_Disp_Rq_AR.TC_ElecEnergyCons_LfTm_Divsr.phys = getValue( HMI_TC_ElecEnergyCons_LfTm_Divsr );
}

TC_EU6_Cons_Disp_Rq_AR_next_values()
{
    if( ( getValue( HMI_TC_FuelType_TC_DISP_RQ2_Liquid ) == 0 ) &     // 1
        ( getValue( HMI_TC_FuelType_TC_DISP_RQ2_Gas    ) == 0 ) &     // 0
        ( getValue( HMI_TC_FuelType_TC_DISP_RQ2_Elec   ) == 0 )    )   // 2
    {
        _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState = 3;  //SNA
        return;
    }
    else
    if( _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState == 3 )  //SNA
        _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState = 0;

    if( _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState == 0 )    // Gas
    {
        if( getValue( HMI_TC_FuelType_TC_DISP_RQ2_Liquid ) == 1 )   // 1
        {
            _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState = 1;  // Liquid
            return;
        }
        if( getValue( HMI_TC_FuelType_TC_DISP_RQ2_Elec ) == 1 )     // 2
        {
            _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState = 2;  // Elec
            return;
        }
        return; // no change, only one type active
    }

    if( _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState == 1 )    // Liquid
    {
        if( getValue( HMI_TC_FuelType_TC_DISP_RQ2_Elec ) == 1 )   // 1
        {
            _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState = 2;  // Elec
            return;
        }
        if( getValue( HMI_TC_FuelType_TC_DISP_RQ2_Gas ) == 1 )     // 2
        {
            _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState = 0;  // Gas
            return;
        }
        return; // no change, only one type active
    }
    if( _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState == 2 )    // Elec
    {
        if( getValue( HMI_TC_FuelType_TC_DISP_RQ2_Gas ) == 1 )   // 1
        {
            _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState = 0;  // Gas
            return;
        }
        if( getValue( HMI_TC_FuelType_TC_DISP_RQ2_Liquid ) == 1 )     // 2
        {
            _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState = 1;  // Liquid
            return;
        }
        return; // no change, only one type active
    }
}

TC_EU6_Cons_Disp_Rq_AR_output()
{
    TC_EU6_Cons_Disp_Rq_AR_next_values();
    if( _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState == 0 )
    {
        putValue( HMI_TC_FuelType_TC_DISP_RQ2, _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_FuelType_TC_DISP_RQ2.phys = getValue( HMI_TC_FuelType_TC_DISP_RQ2 );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuel_Res_Disp_Rq.phys = getValue( HMI_TC_GasFuel_Res_Disp_Rq );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuel_Res_Icon_Rq.phys = getValue( HMI_TC_GasFuel_Res_Icon_Rq );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuel_Res_Warn_Rq.phys = getValue( HMI_TC_GasFuel_Res_Warn_Rq );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuelCons_Actl.phys = getValue( HMI_TC_GasFuelCons_Actl );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuelCons_LfTm.phys = getValue( HMI_TC_GasFuelCons_LfTm );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuelCons_LfTm_Divsr.phys = getValue( HMI_TC_GasFuelCons_LfTm_Divsr );
    }
    if( _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState == 1 )
    {
        putValue( HMI_TC_FuelType_TC_DISP_RQ2, _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_FuelType_TC_DISP_RQ2.phys = getValue( HMI_TC_FuelType_TC_DISP_RQ2 );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_LiquidFuelCons_Actl.phys = getValue( HMI_TC_LiquidFuelCons_Actl );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_LiquidFuelCons_LfTm.phys = getValue( HMI_TC_LiquidFuelCons_LfTm );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_LiquidFuelCons_LfTm_Divsr.phys = getValue( HMI_TC_LiquidFuelCons_LfTm_Divsr );
    }
    if( _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState == 2 )
    {
        putValue( HMI_TC_FuelType_TC_DISP_RQ2, _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_FuelType_TC_DISP_RQ2.phys = getValue( HMI_TC_FuelType_TC_DISP_RQ2 );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_ElecEnergy_Res_Disp_Rq.phys = getValue( HMI_TC_ElecEnergy_Res_Disp_Rq );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_ElecEnergy_Res_Icon_Rq.phys = getValue( HMI_TC_ElecEnergy_Res_Icon_Rq );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_ElecEnergy_Res_Warn_Rq.phys = getValue( HMI_TC_ElecEnergy_Res_Warn_Rq );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_ElecEnergyCons_Actl_V2.phys = getValue( HMI_TC_ElecEnergyCons_Actl_V2 );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_ElecEnergyCons_LfTm.phys = getValue( HMI_TC_ElecEnergyCons_LfTm );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_ElecEnergyCons_LfTm_Divsr.phys = getValue( HMI_TC_ElecEnergyCons_LfTm_Divsr );
    }
    if( _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState == 3 )
    {
        putValue( HMI_TC_FuelType_TC_DISP_RQ2, _TC_EU6_Cons_Disp_Rq_AR_TC_FuelType_ActState );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_FuelType_TC_DISP_RQ2.phys = getValue( HMI_TC_FuelType_TC_DISP_RQ2 );
        _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuel_Res_Disp_Rq.phys = 3;
        _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuel_Res_Icon_Rq.phys = 31;
        _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuel_Res_Warn_Rq.phys = 7;
        _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuelCons_Actl.phys = 10.23;
        _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuelCons_LfTm.phys = 102.3;
        _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuelCons_LfTm_Divsr.phys = 7;
    }

    output( _mTC_EU6_Cons_Disp_Rq_AR );
}

TC_EU6_Cons_Disp_Rq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: TC_EU6_Cons_Disp_Rq_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_SPV_Stat := %X\n", getValue( HMI__STMSG_TC_EU6_Cons_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_SPV_Stat := %X\n", getValue( HMI__STMSGT_TC_EU6_Cons_Disp_Rq_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_FuelType_TC_DISP_RQ2 := %X\n", getValue( HMI_TC_FuelType_TC_DISP_RQ2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_GasFuel_Res_Disp_Rq := %X\n", getValue( HMI_TC_GasFuel_Res_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_GasFuel_Res_Icon_Rq := %X\n", getValue( HMI_TC_GasFuel_Res_Icon_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_GasFuel_Res_Warn_Rq := %X\n", getValue( HMI_TC_GasFuel_Res_Warn_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_GasFuelCons_Actl := %X\n", getValue( HMI_TC_GasFuelCons_Actl ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_GasFuelCons_LfTm := %X\n", getValue( HMI_TC_GasFuelCons_LfTm ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_GasFuelCons_LfTm_Divsr := %X\n", getValue( HMI_TC_GasFuelCons_LfTm_Divsr ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_LiquidFuelCons_Actl := %X\n", getValue( HMI_TC_LiquidFuelCons_Actl ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_LiquidFuelCons_LfTm := %X\n", getValue( HMI_TC_LiquidFuelCons_LfTm ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_LiquidFuelCons_LfTm_Divsr := %X\n", getValue( HMI_TC_LiquidFuelCons_LfTm_Divsr ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_ElecEnergy_Res_Disp_Rq := %X\n", getValue( HMI_TC_ElecEnergy_Res_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_ElecEnergy_Res_Icon_Rq := %X\n", getValue( HMI_TC_ElecEnergy_Res_Icon_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_ElecEnergy_Res_Warn_Rq := %X\n", getValue( HMI_TC_ElecEnergy_Res_Warn_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_ElecEnergyCons_Actl_V2 := %X\n", getValue( HMI_TC_ElecEnergyCons_Actl_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_ElecEnergyCons_LfTm := %X\n", getValue( HMI_TC_ElecEnergyCons_LfTm ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TC_ElecEnergyCons_LfTm_Divsr := %X\n", getValue( HMI_TC_ElecEnergyCons_LfTm_Divsr ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tTC_EU6_Cons_Disp_Rq_AR
{
    putValue( HMI__STMSG_TC_EU6_Cons_Disp_Rq_AR, 0 );
}

on EnvVar HMI__STMSG_TC_EU6_Cons_Disp_Rq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_TC_EU6_Cons_Disp_Rq_AR );
        if( tDelay > 0)    
            setTimer( _tTC_EU6_Cons_Disp_Rq_AR, tDelay );
        else
            putValue( HMI__STMSG_TC_EU6_Cons_Disp_Rq_AR, 0 );
    }
}

on EnvVar HMI__STMSGCT_TC_EU6_Cons_Disp_Rq_AR
{
    if( getValue( this ) > 0 )
    {
        _TC_EU6_Cons_Disp_Rq_AR_CycleCount =getValue( this ) / _TC_EU6_Cons_Disp_Rq_AR_Timebase;     // set cycle counter to initial value
        _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 1;
    }
}

on envVar HMI__STMSG_PO_TC_EU6_Cons_Disp_Rq_AR
{
    if( getValue( this ) )
        openPanel("TC_EU6_Cons_Disp_Rq_AR");
}

on EnvVar HMI_TC_FuelType_TC_DISP_RQ2
{
    _mTC_EU6_Cons_Disp_Rq_AR.TC_FuelType_TC_DISP_RQ2.phys = getValue(this);
    _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TC_GasFuel_Res_Disp_Rq
{
    _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuel_Res_Disp_Rq.phys = getValue(this);
    _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TC_GasFuel_Res_Icon_Rq
{
    _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuel_Res_Icon_Rq.phys = getValue(this);
    _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TC_GasFuel_Res_Warn_Rq
{
    _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuel_Res_Warn_Rq.phys = getValue(this);
    _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TC_GasFuelCons_Actl
{
    _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuelCons_Actl.phys = getValue(this);
    _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TC_GasFuelCons_LfTm
{
    _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuelCons_LfTm.phys = getValue(this);
    _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TC_GasFuelCons_LfTm_Divsr
{
    _mTC_EU6_Cons_Disp_Rq_AR.TC_GasFuelCons_LfTm_Divsr.phys = getValue(this);
    _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TC_LiquidFuelCons_Actl
{
    _mTC_EU6_Cons_Disp_Rq_AR.TC_LiquidFuelCons_Actl.phys = getValue(this);
    _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TC_LiquidFuelCons_LfTm
{
    _mTC_EU6_Cons_Disp_Rq_AR.TC_LiquidFuelCons_LfTm.phys = getValue(this);
    _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TC_LiquidFuelCons_LfTm_Divsr
{
    _mTC_EU6_Cons_Disp_Rq_AR.TC_LiquidFuelCons_LfTm_Divsr.phys = getValue(this);
    _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TC_ElecEnergy_Res_Disp_Rq
{
    _mTC_EU6_Cons_Disp_Rq_AR.TC_ElecEnergy_Res_Disp_Rq.phys = getValue(this);
    _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TC_ElecEnergy_Res_Icon_Rq
{
    _mTC_EU6_Cons_Disp_Rq_AR.TC_ElecEnergy_Res_Icon_Rq.phys = getValue(this);
    _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TC_ElecEnergy_Res_Warn_Rq
{
    _mTC_EU6_Cons_Disp_Rq_AR.TC_ElecEnergy_Res_Warn_Rq.phys = getValue(this);
    _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TC_ElecEnergyCons_Actl_V2
{
    _mTC_EU6_Cons_Disp_Rq_AR.TC_ElecEnergyCons_Actl_V2.phys = getValue(this);
    _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TC_ElecEnergyCons_LfTm
{
    _mTC_EU6_Cons_Disp_Rq_AR.TC_ElecEnergyCons_LfTm.phys = getValue(this);
    _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 1;
}

on EnvVar HMI_TC_ElecEnergyCons_LfTm_Divsr
{
    _mTC_EU6_Cons_Disp_Rq_AR.TC_ElecEnergyCons_LfTm_Divsr.phys = getValue(this);
    _TC_EU6_Cons_Disp_Rq_AR_SpontanFlag = 1;
}

TCM_Disp_Rq_AMG_AR_check_output()
{
    if( !getValue( HMI__STMSG_TCM_Disp_Rq_AMG_AR ) )
    {
    //  message   TCM_Disp_Rq_AMG_AR ID: 653 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _TCM_Disp_Rq_AMG_AR_DelayCnt > 0) _TCM_Disp_Rq_AMG_AR_DelayCnt--; // Mindestsendeabstand
        _TCM_Disp_Rq_AMG_AR_Cnt--;
        if( _TCM_Disp_Rq_AMG_AR_Cnt < 1 )
        {
            if( _TCM_Disp_Rq_AMG_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                TCM_Disp_Rq_AMG_AR_output();
                 _TCM_Disp_Rq_AMG_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _TCM_Disp_Rq_AMG_AR_DelayCnt = _TCM_Disp_Rq_AMG_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _TCM_Disp_Rq_AMG_AR_SpontanFlag = 1;
            }
            _TCM_Disp_Rq_AMG_AR_Cnt = _TCM_Disp_Rq_AMG_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _TCM_Disp_Rq_AMG_AR_SpontanFlag)
        {
            if( _TCM_Disp_Rq_AMG_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                TCM_Disp_Rq_AMG_AR_output();
                _TCM_Disp_Rq_AMG_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _TCM_Disp_Rq_AMG_AR_DelayCnt = _TCM_Disp_Rq_AMG_AR_MinDelay;
            }
        }
    }
}

TCM_Disp_Rq_AMG_AR_init()
{   /* Botschaft TCM_Disp_Rq_AMG_AR ID: 653 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 653 0;
BA_ "NmAsrMessage" BO_ 653 0;
BA_ "GenMsgMinAcceptLength" BO_ 653 8;
BA_ "GenMsgILSupport" BO_ 653 1;
BA_ "DiagState" BO_ 653 0;
BA_ "DiagRequest" BO_ 653 0;
BA_ "DiagResponse" BO_ 653 0;
BA_ "GenMsgStartValue" BO_ 653 "0";
BA_ "GenMsgDelayTime" BO_ 653 40;
BA_ "GenMsgNrOfRepetitions" BO_ 653 0;
BA_ "GenMsgCycleTime" BO_ 653 200;
BA_ "GenMsgSendType" BO_ 653 5;
    */
    _TCM_Disp_Rq_AMG_AR_Timebase =        c_tDBKomTimer_20ms;
    _TCM_Disp_Rq_AMG_AR_CycleCount =     200 / _TCM_Disp_Rq_AMG_AR_Timebase;
    _TCM_Disp_Rq_AMG_AR_StartDelay =       0 / _TCM_Disp_Rq_AMG_AR_Timebase;
    _TCM_Disp_Rq_AMG_AR_MinDelay =        40 / _TCM_Disp_Rq_AMG_AR_Timebase;
    _TCM_Disp_Rq_AMG_AR_Cnt = _TCM_Disp_Rq_AMG_AR_StartDelay;
    _TCM_Disp_Rq_AMG_AR_SpontanFlag = 0;
    _TCM_Disp_Rq_AMG_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_TCM_Disp_Rq_AMG_AR, _TCM_Disp_Rq_AMG_AR_StartDelay * _TCM_Disp_Rq_AMG_AR_Timebase );

    _mTCM_Disp_Rq_AMG_AR.TCM_TxLED_Disp_Rq.phys = getValue( HMI_TCM_TxLED_Disp_Rq );
    _mTCM_Disp_Rq_AMG_AR.TCM_TxShift_Disp_Rq.phys = getValue( HMI_TCM_TxShift_Disp_Rq );
    _mTCM_Disp_Rq_AMG_AR.TxBurnOut_Stat.phys = getValue( HMI_TxBurnOut_Stat );
    _mTCM_Disp_Rq_AMG_AR.SBW_Msg_Disp_Rq.phys = getValue( HMI_SBW_Msg_Disp_Rq );
}

TCM_Disp_Rq_AMG_AR_output(void)
{
    output( _mTCM_Disp_Rq_AMG_AR );
}

TCM_Disp_Rq_AMG_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: TCM_Disp_Rq_AMG_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_TCM_Disp_Rq_AMG_AR := %X\n", getValue( HMI__STMSG_TCM_Disp_Rq_AMG_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_TCM_Disp_Rq_AMG_AR := %X\n", getValue( HMI__STMSGT_TCM_Disp_Rq_AMG_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCM_TxLED_Disp_Rq := %X\n", getValue( HMI_TCM_TxLED_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TCM_TxShift_Disp_Rq := %X\n", getValue( HMI_TCM_TxShift_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TxBurnOut_Stat := %X\n", getValue( HMI_TxBurnOut_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SBW_Msg_Disp_Rq := %X\n", getValue( HMI_SBW_Msg_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tTCM_Disp_Rq_AMG_AR
{
    putValue( HMI__STMSG_TCM_Disp_Rq_AMG_AR, 0 );
}

on EnvVar HMI__STMSG_TCM_Disp_Rq_AMG_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_TCM_Disp_Rq_AMG_AR );
        if( tDelay > 0)    
            setTimer( _tTCM_Disp_Rq_AMG_AR, tDelay );
        else
            putValue( HMI__STMSG_TCM_Disp_Rq_AMG_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_TCM_Disp_Rq_AMG_AR
{
    if( getValue( this ) )
        openPanel("TCM_DISP_RQ_AMG_AR");
}

on EnvVar HMI_TCM_TxLED_Disp_Rq
{
    _mTCM_Disp_Rq_AMG_AR.TCM_TxLED_Disp_Rq.phys = getValue(this);
    _TCM_Disp_Rq_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_TCM_TxShift_Disp_Rq
{
    _mTCM_Disp_Rq_AMG_AR.TCM_TxShift_Disp_Rq.phys = getValue(this);
    _TCM_Disp_Rq_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_TxBurnOut_Stat
{
    _mTCM_Disp_Rq_AMG_AR.TxBurnOut_Stat.phys = getValue(this);
    _TCM_Disp_Rq_AMG_AR_SpontanFlag = 1;
}

on EnvVar HMI_SBW_Msg_Disp_Rq
{
    _mTCM_Disp_Rq_AMG_AR.SBW_Msg_Disp_Rq.phys = getValue(this);
    _TCM_Disp_Rq_AMG_AR_SpontanFlag = 1;
}

Teleaid_WRN_AR_check_output()
{
    if( !getValue( HMI__STMSG_Teleaid_WRN_AR ) )
    {
    //  message   Teleaid_WRN_AR ID: 1199 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _Teleaid_WRN_AR_Cnt--;
        if( _Teleaid_WRN_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            Teleaid_WRN_AR_output();
            _Teleaid_WRN_AR_Cnt = _Teleaid_WRN_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _Teleaid_WRN_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _Teleaid_WRN_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            Teleaid_WRN_AR_output();
            _Teleaid_WRN_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

Teleaid_WRN_AR_init()
{   /* Botschaft Teleaid_WRN_AR ID: 1199 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1199 0;
BA_ "NmAsrMessage" BO_ 1199 0;
BA_ "GenMsgMinAcceptLength" BO_ 1199 4;
BA_ "GenMsgILSupport" BO_ 1199 1;
BA_ "DiagState" BO_ 1199 0;
BA_ "DiagRequest" BO_ 1199 0;
BA_ "DiagResponse" BO_ 1199 0;
BA_ "GenMsgStartValue" BO_ 1199 "0";
BA_ "GenMsgDelayTime" BO_ 1199 5;
BA_ "GenMsgNrOfRepetitions" BO_ 1199 0;
BA_ "GenMsgCycleTime" BO_ 1199 500;
BA_ "GenMsgSendType" BO_ 1199 5;
    */
    _Teleaid_WRN_AR_Timebase =          c_tDBKomTimer_20ms;
    _Teleaid_WRN_AR_CycleCount =       500 / _Teleaid_WRN_AR_Timebase;
    _Teleaid_WRN_AR_StartDelay =         0 / _Teleaid_WRN_AR_Timebase;
    _Teleaid_WRN_AR_Cnt = _Teleaid_WRN_AR_StartDelay;
    _Teleaid_WRN_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_Teleaid_WRN_AR, _Teleaid_WRN_AR_StartDelay * _Teleaid_WRN_AR_Timebase );

    _mTeleaid_WRN_AR.RemUpdt_HU_Rq.phys = getValue( HMI_RemUpdt_HU_Rq );  
    _mTeleaid_WRN_AR.Teleaid_Call_Stat.phys = getValue( HMI_Teleaid_Call_Stat );
    _mTeleaid_WRN_AR.Teleaid_Field_STR.phys = getValue( HMI_Teleaid_Field_STR );
    _mTeleaid_WRN_AR.Teleaid_HU_POP.phys = getValue( HMI_Teleaid_HU_POP );
    _mTeleaid_WRN_AR.Teleaid_IP_ERR.phys = getValue( HMI_Teleaid_IP_ERR );
    _mTeleaid_WRN_AR.Teleaid_Net_TYP.phys = getValue( HMI_Teleaid_Net_TYP );
                putValue( HMI_Teleaid_RD_A, 0 );
    _mTeleaid_WRN_AR.Teleaid_RD_A.phys = getValue( HMI_Teleaid_RD_A );
    _mTeleaid_WRN_AR.Teleaid_RD_DC.phys = getValue( HMI_Teleaid_RD_DC );
    _mTeleaid_WRN_AR.Teleaid_RD_L.phys = getValue( HMI_Teleaid_RD_L );
    _mTeleaid_WRN_AR.Teleaid_RD_UL.phys = getValue( HMI_Teleaid_RD_UL );
    _mTeleaid_WRN_AR.Teleaid_TA_DEF.phys = getValue( HMI_Teleaid_TA_DEF );
    _mTeleaid_WRN_AR.Teleaid_TA_NA.phys = getValue( HMI_Teleaid_TA_NA );
    _mTeleaid_WRN_AR.Teleaid_TR_A.phys = getValue( HMI_Teleaid_TR_A );
    _mTeleaid_WRN_AR.RemPushNtfcn_Rq.phys = getValue( HMI_RemPushNtfcn_Rq );
}

Teleaid_WRN_AR_output(void)
{
    output( _mTeleaid_WRN_AR );
}

Teleaid_WRN_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Teleaid_WRN_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Teleaid_WRN := %X\n", getValue( HMI__STMSG_Teleaid_WRN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Teleaid_WRN := %X\n", getValue( HMI__STMSGT_Teleaid_WRN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RemUpdt_HU_Rq := %X\n", getValue( HMI_RemUpdt_HU_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );  
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Teleaid_Call_Stat := %X\n", getValue( HMI_Teleaid_Call_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Teleaid_Field_STR := %X\n", getValue( HMI_Teleaid_Field_STR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Teleaid_HU_POP := %X\n", getValue( HMI_Teleaid_HU_POP ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Teleaid_IP_ERR := %X\n", getValue( HMI_Teleaid_IP_ERR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Teleaid_Net_TYP := %X\n", getValue( HMI_Teleaid_Net_TYP ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Teleaid_RD_A := %X\n", getValue( HMI_Teleaid_RD_A ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Teleaid_RD_DC := %X\n", getValue( HMI_Teleaid_RD_DC ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Teleaid_RD_L := %X\n", getValue( HMI_Teleaid_RD_L ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Teleaid_RD_UL := %X\n", getValue( HMI_Teleaid_RD_UL ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Teleaid_TA_DEF := %X\n", getValue( HMI_Teleaid_TA_DEF ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Teleaid_TA_NA := %X\n", getValue( HMI_Teleaid_TA_NA ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Teleaid_TR_A := %X\n", getValue( HMI_Teleaid_TR_A ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RemPushNtfcn_Rq := %X\n", getValue( HMI_RemPushNtfcn_Rq ) );        filePutString( buffer, elcount(buffer), hFile);
}

on timer _tTeleaid_WRN_AR
{
    putValue( HMI__STMSG_Teleaid_WRN_AR, 0 );
}

on EnvVar HMI__STMSG_Teleaid_WRN_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Teleaid_WRN_AR );
        if( tDelay > 0)    
            setTimer( _tTeleaid_WRN_AR, tDelay );
        else
            putValue( HMI__STMSG_Teleaid_WRN_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Teleaid_WRN_AR
{
    if( getValue( this ) )
        openPanel("Teleaid_WRN_AR");
}

on EnvVar HMI_RemUpdt_HU_Rq
{
    _mTeleaid_WRN_AR.RemUpdt_HU_Rq.phys = getValue(this);
    _Teleaid_WRN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Teleaid_Call_Stat
{
    _mTeleaid_WRN_AR.Teleaid_Call_Stat.phys = getValue(this);
    _Teleaid_WRN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Teleaid_Field_STR
{
    _mTeleaid_WRN_AR.Teleaid_Field_STR.phys = getValue(this);
    _Teleaid_WRN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Teleaid_HU_POP
{
    _mTeleaid_WRN_AR.Teleaid_HU_POP.phys = getValue(this);
    _Teleaid_WRN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Teleaid_IP_ERR
{
    _mTeleaid_WRN_AR.Teleaid_IP_ERR.phys = getValue(this);
    _Teleaid_WRN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Teleaid_Net_TYP
{
    _mTeleaid_WRN_AR.Teleaid_Net_TYP.phys = getValue(this);
    _Teleaid_WRN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Teleaid_RD_A
{
    _mTeleaid_WRN_AR.Teleaid_RD_A.phys = getValue(this);
    _Teleaid_WRN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Teleaid_RD_DC
{
    _mTeleaid_WRN_AR.Teleaid_RD_DC.phys = getValue(this);
    _Teleaid_WRN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Teleaid_RD_L
{
    _mTeleaid_WRN_AR.Teleaid_RD_L.phys = getValue(this);
    _Teleaid_WRN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Teleaid_RD_UL
{
    _mTeleaid_WRN_AR.Teleaid_RD_UL.phys = getValue(this);
    _Teleaid_WRN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Teleaid_TA_DEF
{
    _mTeleaid_WRN_AR.Teleaid_TA_DEF.phys = getValue(this);
    _Teleaid_WRN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Teleaid_TA_NA
{
    _mTeleaid_WRN_AR.Teleaid_TA_NA.phys = getValue(this);
    _Teleaid_WRN_AR_SpontanFlag = 1;
}

on EnvVar HMI_Teleaid_TR_A
{
    _mTeleaid_WRN_AR.Teleaid_TR_A.phys = getValue(this);
    _Teleaid_WRN_AR_SpontanFlag = 1;
}

on EnvVar HMI_RemPushNtfcn_Rq
{
    _mTeleaid_WRN_AR.RemPushNtfcn_Rq.phys = getValue(this);
    _Teleaid_WRN_AR_SpontanFlag = 1;
}

//TP_COM_TGW_Adapt_check_output()
//{
//    if( !getValue( HMI__STMSG_TP_COM_TGW_Adapt ) )
//    {
//    //  message   TP_COM_TGW_Adapt ID: 702 --- Sendeart 1 spontanX --- 
//        if( _TP_COM_TGW_Adapt_SpontanFlag )
//        {
//            TP_COM_TGW_Adapt_output(); // Nachricht wg. spontaner �nderung ausgeben
//            _TP_COM_TGW_Adapt_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
//        }
//    }
//}
//
//void TP_COM_TGW_Adapt_getValue(void)
//{
//    _mTP_COM_TGW_Adapt.byte( 0 ) = getValue( HMI_TP_COM_TGW_Adapt_0 );
//    _mTP_COM_TGW_Adapt.byte( 1 ) = getValue( HMI_TP_COM_TGW_Adapt_1 );
//    _mTP_COM_TGW_Adapt.byte( 2 ) = getValue( HMI_TP_COM_TGW_Adapt_2 );
//    _mTP_COM_TGW_Adapt.byte( 3 ) = getValue( HMI_TP_COM_TGW_Adapt_3 );
//    _mTP_COM_TGW_Adapt.byte( 4 ) = getValue( HMI_TP_COM_TGW_Adapt_4 );
//    _mTP_COM_TGW_Adapt.byte( 5 ) = getValue( HMI_TP_COM_TGW_Adapt_5 );
//    _mTP_COM_TGW_Adapt.byte( 6 ) = getValue( HMI_TP_COM_TGW_Adapt_6 );
//    _mTP_COM_TGW_Adapt.byte( 7 ) = getValue( HMI_TP_COM_TGW_Adapt_7 );
//}
//
//TP_COM_TGW_Adapt_init()
//{
//   /* Botschaft TP_COM_TGW_Adapt ID: 698 --- Sendeart 1 spontanX --- 
//BA_ "ApplMessage" BO_ 698 0;
//BA_ "NmAsrMessage" BO_ 698 0;
//BA_ "GenMsgMinAcceptLength" BO_ 698 8;
//BA_ "GenMsgILSupport" BO_ 698 0;
//BA_ "DiagState" BO_ 698 0;
//BA_ "DiagRequest" BO_ 698 0;
//BA_ "DiagResponse" BO_ 698 0;
//BA_ "GenMsgStartValue" BO_ 698 "0";
//    */
//    _TP_COM_TGW_Adapt_Timebase =        c_tDBKomTimer_5ms;
//    _TP_COM_TGW_Adapt_SpontanFlag = 0;
//
//    TP_COM_TGW_Adapt_getValue();
//}
//
//TP_COM_TGW_Adapt_output()
//{
//    output( _mTP_COM_TGW_Adapt );
//}
//
//TP_COM_TGW_Adapt_saveEnvVars( dword hFile )
//{
//    filePutString("\n// Knoten EIS: TP_COM_TGW_Adapt\n", 27, hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_TP_COM_TGW_Adapt := %X\n", getValue( HMI__STMSG_TP_COM_TGW_Adapt) );    filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_TP_COM_TGW_Adapt := %X\n", getValue( HMI__STMSGT_TP_COM_TGW_Adapt) );    filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_COM_TGW_Adapt_0 := %X\n", getValue( HMI_TP_COM_TGW_Adapt_0 ) );    filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_COM_TGW_Adapt_1 := %X\n", getValue( HMI_TP_COM_TGW_Adapt_1 ) );    filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_COM_TGW_Adapt_2 := %X\n", getValue( HMI_TP_COM_TGW_Adapt_2 ) );    filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_COM_TGW_Adapt_3 := %X\n", getValue( HMI_TP_COM_TGW_Adapt_3 ) );    filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_COM_TGW_Adapt_4 := %X\n", getValue( HMI_TP_COM_TGW_Adapt_4 ) );    filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_COM_TGW_Adapt_5 := %X\n", getValue( HMI_TP_COM_TGW_Adapt_5 ) );    filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_COM_TGW_Adapt_6 := %X\n", getValue( HMI_TP_COM_TGW_Adapt_6 ) );    filePutString( buffer, elcount( buffer ), hFile );
//    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_COM_TGW_Adapt_7 := %X\n", getValue( HMI_TP_COM_TGW_Adapt_7 ) );    filePutString( buffer, elcount( buffer ), hFile );
//}
//
//on timer _tTP_COM_TGW_Adapt
//{
//    putValue( HMI__STMSG_TP_COM_TGW_Adapt, 0 );
//}
//
//on EnvVar HMI__STMSG_TP_COM_TGW_Adapt
//{
//    long tDelay;
//    if( getValue( this ) == 2 )
//    {
//        tDelay = getValue( HMI__STMSGT_TP_COM_TGW_Adapt );
//        if( tDelay > 0 )    
//            setTimer( _tTP_COM_TGW_Adapt, tDelay );
//        else
//            putValue( HMI__STMSG_TP_COM_TGW_Adapt, 0 );
//    }
//}
//
//on EnvVar HMI_TP_COM_TGW_Adapt_Send
//{
//    TP_COM_TGW_Adapt_getValue();
//    _TP_COM_TGW_Adapt_SpontanFlag = 1;
//}
//
//on envVar HMI__STMSG_PO_TP_COM_TGW_Adapt
//{
//    if( getValue( this ) )
//        openPanel("TP_COM_TGW_Adapt");
//}
//
//TP_EIS_IC_SecOdo_check_output()
//{
//    if( !getValue( HMI__STMSG_TP_EIS_IC_SecOdo ) )
//    {
//    //  message   TP_EIS_IC_SecOdo ID: 359 --- Sendeart 1 spontanX --- 
//        if( _TP_EIS_IC_SecOdo_SpontanFlag )
//        {
//            TP_EIS_IC_SecOdo_output(); // Nachricht wg. spontaner �nderung ausgeben
//            _TP_EIS_IC_SecOdo_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
//        }
//    }
//}

void TP_EIS_IC_SecOdo_getValue(void)
{
    _mTP_EIS_IC_SecOdo.byte( 0 ) = getValue( HMI_TP_EIS_IC_SecOdo_0 );
    _mTP_EIS_IC_SecOdo.byte( 1 ) = getValue( HMI_TP_EIS_IC_SecOdo_1 );
    _mTP_EIS_IC_SecOdo.byte( 2 ) = getValue( HMI_TP_EIS_IC_SecOdo_2 );
    _mTP_EIS_IC_SecOdo.byte( 3 ) = getValue( HMI_TP_EIS_IC_SecOdo_3 );
    _mTP_EIS_IC_SecOdo.byte( 4 ) = getValue( HMI_TP_EIS_IC_SecOdo_4 );
    _mTP_EIS_IC_SecOdo.byte( 5 ) = getValue( HMI_TP_EIS_IC_SecOdo_5 );
    _mTP_EIS_IC_SecOdo.byte( 6 ) = getValue( HMI_TP_EIS_IC_SecOdo_6 );
    _mTP_EIS_IC_SecOdo.byte( 7 ) = getValue( HMI_TP_EIS_IC_SecOdo_7 );
}

TP_EIS_IC_SecOdo_init()
{   /* Botschaft TP_EIS_IC_SecOdo ID: 359 --- Sendeart 1 spontanX --- 
BA_ "ApplMessage" BO_ 359 0;
BA_ "NmAsrMessage" BO_ 359 0;
BA_ "GenMsgMinAcceptLength" BO_ 359 8;
BA_ "GenMsgILSupport" BO_ 359 0;
BA_ "DiagState" BO_ 359 0;
BA_ "DiagRequest" BO_ 359 0;
BA_ "DiagResponse" BO_ 359 0;
BA_ "GenMsgStartValue" BO_ 359 "0";
    */
    _TP_EIS_IC_SecOdo_Timebase =        c_tDBKomTimer_5ms;
    _TP_EIS_IC_SecOdo_SpontanFlag = 0;

    TP_EIS_IC_SecOdo_getValue();
}

TP_EIS_IC_SecOdo_output()
{
    output( _mTP_EIS_IC_SecOdo );
}

TP_EIS_IC_SecOdo_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: TP_EIS_IC_SecOdo\n", 32, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_TP_EIS_IC_SecOdo := %X\n", getValue( HMI__STMSG_TP_EIS_IC_SecOdo ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_TP_EIS_IC_SecOdo := %X\n", getValue( HMI__STMSGT_TP_EIS_IC_SecOdo ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_EIS_IC_SecOdo_0 := %X\n", getValue( HMI_TP_EIS_IC_SecOdo_0 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_EIS_IC_SecOdo_1 := %X\n", getValue( HMI_TP_EIS_IC_SecOdo_1 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_EIS_IC_SecOdo_2 := %X\n", getValue( HMI_TP_EIS_IC_SecOdo_2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_EIS_IC_SecOdo_3 := %X\n", getValue( HMI_TP_EIS_IC_SecOdo_3 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_EIS_IC_SecOdo_4 := %X\n", getValue( HMI_TP_EIS_IC_SecOdo_4 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_EIS_IC_SecOdo_5 := %X\n", getValue( HMI_TP_EIS_IC_SecOdo_5 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_EIS_IC_SecOdo_6 := %X\n", getValue( HMI_TP_EIS_IC_SecOdo_6 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_EIS_IC_SecOdo_7 := %X\n", getValue( HMI_TP_EIS_IC_SecOdo_7 ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tTP_EIS_IC_SecOdo
{
    putValue( HMI__STMSG_TP_EIS_IC_SecOdo, 0 );
}

on EnvVar HMI__STMSG_TP_EIS_IC_SecOdo
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_TP_EIS_IC_SecOdo );
        if( tDelay > 0 )    
            setTimer( _tTP_EIS_IC_SecOdo, tDelay );
        else
            putValue( HMI__STMSG_TP_EIS_IC_SecOdo, 0 );
    }
}

on EnvVar HMI_TP_EIS_IC_SecOdo_Send
{
    TP_EIS_IC_SecOdo_getValue();
    _TP_EIS_IC_SecOdo_SpontanFlag = 1;
}

on envVar HMI__STMSG_PO_TP_EIS_IC_SecOdo
{
    if( getValue( this ) )
        openPanel("TP_EIS_IC_SecOdo");
}

TP_MPM_TGW_Nav_check_output()
{
    if( !getValue( HMI__STMSG_TP_MPM_TGW_Nav ) )
    {
    //  message   TP_MPM_TGW_Nav ID: 664 --- Sendeart 0 cyclicX --- 
        if( _TP_MPM_TGW_Nav_SpontanFlag )
        {
            TP_MPM_TGW_Nav_output(); // Nachricht wg. request ausgeben
            _TP_MPM_TGW_Nav_SpontanFlag = 0;
        }
    }
}

void TP_MPM_TGW_Nav_getValue(void)
{
    _mTP_MPM_TGW_Nav.byte( 0 ) = getValue( HMI_TP_MPM_TGW_Nav_0 );
    _mTP_MPM_TGW_Nav.byte( 1 ) = getValue( HMI_TP_MPM_TGW_Nav_1 );
    _mTP_MPM_TGW_Nav.byte( 2 ) = getValue( HMI_TP_MPM_TGW_Nav_2 );
    _mTP_MPM_TGW_Nav.byte( 3 ) = getValue( HMI_TP_MPM_TGW_Nav_3 );
    _mTP_MPM_TGW_Nav.byte( 4 ) = getValue( HMI_TP_MPM_TGW_Nav_4 );
    _mTP_MPM_TGW_Nav.byte( 5 ) = getValue( HMI_TP_MPM_TGW_Nav_5 );
    _mTP_MPM_TGW_Nav.byte( 6 ) = getValue( HMI_TP_MPM_TGW_Nav_6 );
    _mTP_MPM_TGW_Nav.byte( 7 ) = getValue( HMI_TP_MPM_TGW_Nav_7 );
}

TP_MPM_TGW_Nav_init()
{   /* Botschaft TP_MPM_TGW_Nav ID: 745 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 745 0;
BA_ "NmAsrMessage" BO_ 745 0;
BA_ "GenMsgMinAcceptLength" BO_ 745 8;
BA_ "GenMsgILSupport" BO_ 745 0;
BA_ "DiagState" BO_ 745 0;
BA_ "DiagRequest" BO_ 745 0;
BA_ "DiagResponse" BO_ 745 0;
BA_ "GenMsgStartValue" BO_ 745 "0";
    */
    _TP_MPM_TGW_Nav_Timebase =        c_tDBKomTimer_20ms;
    _TP_MPM_TGW_Nav_SpontanFlag = 0;

    TP_MPM_TGW_Nav_getValue();
}

TP_MPM_TGW_Nav_output(void)
{
    output( _mTP_MPM_TGW_Nav );
}

TP_MPM_TGW_Nav_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: TP_MPM_TGW_Nav\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_TP_MPM_TGW_Nav := %X\n", getValue( HMI__STMSG_TP_MPM_TGW_Nav ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_TP_MPM_TGW_Nav := %X\n", getValue( HMI__STMSGT_TP_MPM_TGW_Nav ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_MPM_TGW_Nav_0 := %X\n", getValue( HMI_TP_MPM_TGW_Nav_0) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_MPM_TGW_Nav_1 := %X\n", getValue( HMI_TP_MPM_TGW_Nav_1) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_MPM_TGW_Nav_2 := %X\n", getValue( HMI_TP_MPM_TGW_Nav_2) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_MPM_TGW_Nav_3 := %X\n", getValue( HMI_TP_MPM_TGW_Nav_3) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_MPM_TGW_Nav_4 := %X\n", getValue( HMI_TP_MPM_TGW_Nav_4 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_MPM_TGW_Nav_5 := %X\n", getValue( HMI_TP_MPM_TGW_Nav_5 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_MPM_TGW_Nav_6 := %X\n", getValue( HMI_TP_MPM_TGW_Nav_6) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_MPM_TGW_Nav_7 := %X\n", getValue( HMI_TP_MPM_TGW_Nav_7) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tTP_MPM_TGW_Nav
{
    putValue( HMI__STMSG_TP_MPM_TGW_Nav, 0 );
}

on EnvVar HMI__STMSG_TP_MPM_TGW_Nav
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_TP_MPM_TGW_Nav );
        if( tDelay > 0)    
            setTimer( _tTP_MPM_TGW_Nav, tDelay );
        else
            putValue( HMI__STMSG_TP_MPM_TGW_Nav, 0 );
    }
}

on EnvVar HMI_TP_MPM_TGW_Nav_Send
{
    if( getValue( this ) )
    {
        TP_MPM_TGW_Nav_getValue();
    }
}

on envVar HMI__STMSG_PO_TP_MPM_TGW_Nav
{
    if( getValue( this ) )
        openPanel("TP_MPM_TGW_Nav");
}

TP_PARK_TGW_check_output()
{
    if( !getValue( HMI__STMSG_TP_PARK_TGW ) )
    {
    //  message   TP_PARK_TGW ID: 664 --- Sendeart 1 spontanX --- 
        if( _TP_PARK_TGW_SpontanFlag )
        {
            TP_PARK_TGW_output(); // Nachricht wg. spontaner �nderung ausgeben
            _TP_PARK_TGW_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

void TP_PARK_TGW_getValue(void)
{
    _mTP_PARK_TGW.byte( 0 ) = getValue( HMI_TP_PARK_TGW_0 );
    _mTP_PARK_TGW.byte( 1 ) = getValue( HMI_TP_PARK_TGW_1 );
    _mTP_PARK_TGW.byte( 2 ) = getValue( HMI_TP_PARK_TGW_2 );
    _mTP_PARK_TGW.byte( 3 ) = getValue( HMI_TP_PARK_TGW_3 );
    _mTP_PARK_TGW.byte( 4 ) = getValue( HMI_TP_PARK_TGW_4 );
    _mTP_PARK_TGW.byte( 5 ) = getValue( HMI_TP_PARK_TGW_5 );
    _mTP_PARK_TGW.byte( 6 ) = getValue( HMI_TP_PARK_TGW_6 );
    _mTP_PARK_TGW.byte( 7 ) = getValue( HMI_TP_PARK_TGW_7 );
}

TP_PARK_TGW_init()
{
   /* Botschaft TP_PARK_TGW ID: 662 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 662 0;
BA_ "NmAsrMessage" BO_ 662 0;
BA_ "GenMsgMinAcceptLength" BO_ 662 8;
BA_ "GenMsgILSupport" BO_ 662 0;
BA_ "DiagState" BO_ 662 0;
BA_ "DiagRequest" BO_ 662 0;
BA_ "DiagResponse" BO_ 662 0;
BA_ "GenMsgStartValue" BO_ 662 "0";
    */
    _TP_PARK_TGW_Timebase =        c_tDBKomTimer_5ms;
    _TP_PARK_TGW_SpontanFlag = 0;

    TP_PARK_TGW_getValue();
}

TP_PARK_TGW_output()
{
    output( _mTP_PARK_TGW );
}

TP_PARK_TGW_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: TP_PARK_TGW\n", 32, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_TP_PARK_TGW := %X\n", getValue( HMI__STMSG_TP_PARK_TGW ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_TP_PARK_TGW := %X\n", getValue( HMI__STMSGT_TP_PARK_TGW ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_PARK_TGW_0 := %X\n", getValue( HMI_TP_PARK_TGW_0 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_PARK_TGW_1 := %X\n", getValue( HMI_TP_PARK_TGW_1 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_PARK_TGW_2 := %X\n", getValue( HMI_TP_PARK_TGW_2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_PARK_TGW_3 := %X\n", getValue( HMI_TP_PARK_TGW_3 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_PARK_TGW_4 := %X\n", getValue( HMI_TP_PARK_TGW_4 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_PARK_TGW_5 := %X\n", getValue( HMI_TP_PARK_TGW_5 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_PARK_TGW_6 := %X\n", getValue( HMI_TP_PARK_TGW_6 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_PARK_TGW_7 := %X\n", getValue( HMI_TP_PARK_TGW_7 ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tTP_PARK_TGW
{
    putValue( HMI__STMSG_TP_PARK_TGW, 0 );
}

on EnvVar HMI__STMSG_TP_PARK_TGW
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_TP_PARK_TGW );
        if( tDelay > 0 )    
            setTimer( _tTP_PARK_TGW, tDelay );
        else
            putValue( HMI__STMSG_TP_PARK_TGW, 0 );
    }
}

on EnvVar HMI_TP_PARK_TGW_Send
{
    TP_PARK_TGW_getValue();
    _TP_PARK_TGW_SpontanFlag = 1;
}

on envVar HMI__STMSG_PO_TP_PARK_TGW
{
    openPanel("TP_PARK_TGW");
}

TP_TELEAID_TGW_check_output()
{
    if( !getValue( HMI__STMSG_TP_TELEAID_TGW ) )
    {
    //  message   TP_TELEAID_TGW ID: 739 --- Sendeart 1 spontanX --- 
        if( _TP_TELEAID_TGW_SpontanFlag )
        {
            output( _mTP_TELEAID_TGW ); // Nachricht wg. spontaner �nderung ausgeben
            _TP_TELEAID_TGW_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

void TP_TELEAID_TGW_getValue(void)
{
    _mTP_TELEAID_TGW.byte( 0 ) = getValue( HMI_TP_TELEAID_TGW_0 );
    _mTP_TELEAID_TGW.byte( 1 ) = getValue( HMI_TP_TELEAID_TGW_1 );
    _mTP_TELEAID_TGW.byte( 2 ) = getValue( HMI_TP_TELEAID_TGW_2 );
    _mTP_TELEAID_TGW.byte( 3 ) = getValue( HMI_TP_TELEAID_TGW_3 );
    _mTP_TELEAID_TGW.byte( 4 ) = getValue( HMI_TP_TELEAID_TGW_4 );
    _mTP_TELEAID_TGW.byte( 5 ) = getValue( HMI_TP_TELEAID_TGW_5 );
    _mTP_TELEAID_TGW.byte( 6 ) = getValue( HMI_TP_TELEAID_TGW_6 );
    _mTP_TELEAID_TGW.byte( 7 ) = getValue( HMI_TP_TELEAID_TGW_7 );
}

TP_TELEAID_TGW_init()
{
   /* Botschaft TP_TELEAID_TGW ID: 739 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 739 0;
BA_ "NmAsrMessage" BO_ 739 0;
BA_ "GenMsgMinAcceptLength" BO_ 739 8;
BA_ "GenMsgILSupport" BO_ 739 0;
BA_ "DiagState" BO_ 739 0;
BA_ "DiagRequest" BO_ 739 0;
BA_ "DiagResponse" BO_ 739 0;
BA_ "GenMsgStartValue" BO_ 739 "0";
    */
    _TP_TELEAID_TGW_Timebase =        c_tDBKomTimer_5ms;
    _TP_TELEAID_TGW_SpontanFlag = 0;

    TP_TELEAID_TGW_getValue();
}

TP_TELEAID_TGW_output()
{
    output( _mTP_TELEAID_TGW );
}

TP_TELEAID_TGW_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: TP_TELEAID_TGW\n", 32, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_TP_TELEAID_TGW := %X\n", getValue( HMI__STMSG_TP_TELEAID_TGW ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_TP_TELEAID_TGW := %X\n", getValue( HMI__STMSGT_TP_TELEAID_TGW ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_TELEAID_TGW_0 := %X\n", getValue( HMI_TP_TELEAID_TGW_0 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_TELEAID_TGW_1 := %X\n", getValue( HMI_TP_TELEAID_TGW_1 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_TELEAID_TGW_2 := %X\n", getValue( HMI_TP_TELEAID_TGW_2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_TELEAID_TGW_3 := %X\n", getValue( HMI_TP_TELEAID_TGW_3 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_TELEAID_TGW_4 := %X\n", getValue( HMI_TP_TELEAID_TGW_4 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_TELEAID_TGW_5 := %X\n", getValue( HMI_TP_TELEAID_TGW_5 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_TELEAID_TGW_6 := %X\n", getValue( HMI_TP_TELEAID_TGW_6 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_TELEAID_TGW_7 := %X\n", getValue( HMI_TP_TELEAID_TGW_7 ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tTP_TELEAID_TGW
{
    putValue( HMI__STMSG_TP_TELEAID_TGW, 0 );
}

on EnvVar HMI__STMSG_TP_TELEAID_TGW
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_TP_TELEAID_TGW );
        if( tDelay > 0 )
            setTimer( _tTP_TELEAID_TGW, tDelay );
        else
            putValue( HMI__STMSG_TP_TELEAID_TGW, 0 );
    }
}

on EnvVar HMI_TP_TELEAID_TGW_Send
{
    TP_TELEAID_TGW_getValue();
    _TP_TELEAID_TGW_SpontanFlag = 1;
}

on envVar HMI__STMSG_PO_TP_TELEAID_TGW
{
    if( getValue( this ) )
        openPanel("TP_TELEAID_TGW");
}

TP_WPT_IC_check_output()
{
    if( !getValue( HMI__STMSG_TP_WPT_IC ) )
    {
    //  message   TP_WPT_IC ID: 1230 --- Sendeart 1 spontanX --- 
        if( _TP_WPT_IC_SpontanFlag )
        {
            output( _mTP_WPT_IC ); // Nachricht wg. spontaner �nderung ausgeben
            _TP_WPT_IC_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

void TP_WPT_IC_getValue(void)
{
    _mTP_WPT_IC.byte( 0 ) = getValue( HMI_TP_WPT_IC_0 );
    _mTP_WPT_IC.byte( 1 ) = getValue( HMI_TP_WPT_IC_1 );
    _mTP_WPT_IC.byte( 2 ) = getValue( HMI_TP_WPT_IC_2 );
    _mTP_WPT_IC.byte( 3 ) = getValue( HMI_TP_WPT_IC_3 );
    _mTP_WPT_IC.byte( 4 ) = getValue( HMI_TP_WPT_IC_4 );
    _mTP_WPT_IC.byte( 5 ) = getValue( HMI_TP_WPT_IC_5 );
    _mTP_WPT_IC.byte( 6 ) = getValue( HMI_TP_WPT_IC_6 );
    _mTP_WPT_IC.byte( 7 ) = getValue( HMI_TP_WPT_IC_7 );
}

TP_WPT_IC_init()
{
   /* Botschaft TP_WPT_IC ID: 1230 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 1230 0;
BA_ "NmAsrMessage" BO_ 1230 0;
BA_ "GenMsgMinAcceptLength" BO_ 1230 8;
BA_ "GenMsgILSupport" BO_ 1230 0;
BA_ "DiagState" BO_ 1230 0;
BA_ "DiagRequest" BO_ 1230 0;
BA_ "DiagResponse" BO_ 1230 0;
BA_ "GenMsgStartValue" BO_ 1230 "0";
    */
    _TP_WPT_IC_Timebase =        c_tDBKomTimer_5ms;
    _TP_WPT_IC_SpontanFlag = 0;

    TP_WPT_IC_getValue();
}

TP_WPT_IC_output()
{
    output( _mTP_WPT_IC );
}

TP_WPT_IC_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: TP_WPT_IC\n", 32, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_TP_WPT_IC := %X\n", getValue( HMI__STMSG_TP_WPT_IC ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_TP_WPT_IC := %X\n", getValue( HMI__STMSGT_TP_WPT_IC ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_WPT_IC_0 := %X\n", getValue( HMI_TP_WPT_IC_0 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_WPT_IC_1 := %X\n", getValue( HMI_TP_WPT_IC_1 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_WPT_IC_2 := %X\n", getValue( HMI_TP_WPT_IC_2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_WPT_IC_3 := %X\n", getValue( HMI_TP_WPT_IC_3 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_WPT_IC_4 := %X\n", getValue( HMI_TP_WPT_IC_4 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_WPT_IC_5 := %X\n", getValue( HMI_TP_WPT_IC_5 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_WPT_IC_6 := %X\n", getValue( HMI_TP_WPT_IC_6 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_WPT_IC_7 := %X\n", getValue( HMI_TP_WPT_IC_7 ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tTP_WPT_IC
{
    putValue( HMI__STMSG_TP_WPT_IC, 0 );
}

on EnvVar HMI__STMSG_TP_WPT_IC
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_TP_WPT_IC );
        if( tDelay > 0 )    
            setTimer( _tTP_WPT_IC, tDelay );
        else
            putValue( HMI__STMSG_TP_WPT_IC, 0 );
    }
}

on EnvVar HMI_TP_WPT_IC_Send
{
    TP_WPT_IC_getValue();
    _TP_WPT_IC_SpontanFlag = 1;
}

on envVar HMI__STMSG_PO_TP_WPT_IC
{
    if( getValue( this ) )
        openPanel("TP_WPT_IC");
}

TP_WPT_TGW_check_output()
{
    if( !getValue( HMI__STMSG_TP_WPT_TGW ) )
    {
    //  message   TP_WPT_TGW ID: 643 --- Sendeart 1 spontanX --- 
        if( _TP_WPT_TGW_SpontanFlag )
        {
            output( _mTP_WPT_TGW ); // Nachricht wg. spontaner �nderung ausgeben
            _TP_WPT_TGW_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

void TP_WPT_TGW_getValue(void)
{
    _mTP_WPT_TGW.byte( 0 ) = getValue( HMI_TP_WPT_TGW_0 );
    _mTP_WPT_TGW.byte( 1 ) = getValue( HMI_TP_WPT_TGW_1 );
    _mTP_WPT_TGW.byte( 2 ) = getValue( HMI_TP_WPT_TGW_2 );
    _mTP_WPT_TGW.byte( 3 ) = getValue( HMI_TP_WPT_TGW_3 );
    _mTP_WPT_TGW.byte( 4 ) = getValue( HMI_TP_WPT_TGW_4 );
    _mTP_WPT_TGW.byte( 5 ) = getValue( HMI_TP_WPT_TGW_5 );
    _mTP_WPT_TGW.byte( 6 ) = getValue( HMI_TP_WPT_TGW_6 );
    _mTP_WPT_TGW.byte( 7 ) = getValue( HMI_TP_WPT_TGW_7 );
}

TP_WPT_TGW_init()
{
   /* Botschaft TP_WPT_TGW ID: 643 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 643 0;
BA_ "NmAsrMessage" BO_ 643 0;
BA_ "GenMsgMinAcceptLength" BO_ 643 8;
BA_ "GenMsgILSupport" BO_ 643 0;
BA_ "DiagState" BO_ 643 0;
BA_ "DiagRequest" BO_ 643 0;
BA_ "DiagResponse" BO_ 643 0;
BA_ "GenMsgStartValue" BO_ 643 "0";
    */
    _TP_WPT_TGW_Timebase =        c_tDBKomTimer_5ms;
    _TP_WPT_TGW_SpontanFlag = 0;

    TP_WPT_TGW_getValue();
}

TP_WPT_TGW_output()
{
    output( _mTP_WPT_TGW );
}

TP_WPT_TGW_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: TP_WPT_TGW\n", 32, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_TP_WPT_TGW := %X\n", getValue( HMI__STMSG_TP_WPT_TGW ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_TP_WPT_TGW := %X\n", getValue( HMI__STMSGT_TP_WPT_TGW ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_WPT_TGW_0 := %X\n", getValue( HMI_TP_WPT_TGW_0 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_WPT_TGW_1 := %X\n", getValue( HMI_TP_WPT_TGW_1 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_WPT_TGW_2 := %X\n", getValue( HMI_TP_WPT_TGW_2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_WPT_TGW_3 := %X\n", getValue( HMI_TP_WPT_TGW_3 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_WPT_TGW_4 := %X\n", getValue( HMI_TP_WPT_TGW_4 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_WPT_TGW_5 := %X\n", getValue( HMI_TP_WPT_TGW_5 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_WPT_TGW_6 := %X\n", getValue( HMI_TP_WPT_TGW_6 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TP_WPT_TGW_7 := %X\n", getValue( HMI_TP_WPT_TGW_7 ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tTP_WPT_TGW
{
    putValue( HMI__STMSG_TP_WPT_TGW, 0 );
}

on EnvVar HMI__STMSG_TP_WPT_TGW
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_TP_WPT_TGW );
        if( tDelay > 0 )    
            setTimer( _tTP_WPT_TGW, tDelay );
        else
            putValue( HMI__STMSG_TP_WPT_TGW, 0 );
    }
}

on EnvVar HMI_TP_WPT_TGW_Send
{
    TP_WPT_TGW_getValue();
    _TP_WPT_TGW_SpontanFlag = 1;
}

on envVar HMI__STMSG_PO_TP_WPT_TGW
{
    if( getValue( this ) )
        openPanel("TP_WPT_TGW");
}

Trailer_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_Trailer_Stat_AR ) )
    {
    //  message   Trailer_Stat_AR ID: 865 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _Trailer_Stat_AR_Cnt--;
        if( _Trailer_Stat_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            Trailer_Stat_AR_output();
            _Trailer_Stat_AR_Cnt = _Trailer_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _Trailer_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _Trailer_Stat_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            Trailer_Stat_AR_output();
            _Trailer_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

Trailer_Stat_AR_init()
{   /* Botschaft Trailer_Stat_AR ID: 865 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 865 0;
BA_ "NmAsrMessage" BO_ 865 0;
BA_ "GenMsgMinAcceptLength" BO_ 865 8;
BA_ "GenMsgILSupport" BO_ 865 1;
BA_ "DiagState" BO_ 865 0;
BA_ "DiagRequest" BO_ 865 0;
BA_ "DiagResponse" BO_ 865 0;
BA_ "GenMsgStartValue" BO_ 865 "0";
BA_ "GenMsgDelayTime" BO_ 865 5;
BA_ "GenMsgNrOfRepetitions" BO_ 865 0;
BA_ "GenMsgCycleTime" BO_ 865 500;
BA_ "GenMsgSendType" BO_ 865 5;
    */
    _Trailer_Stat_AR_Timebase =       c_tDBKomTimer_20ms;
    _Trailer_Stat_AR_CycleCount =    500 / _Trailer_Stat_AR_Timebase;
    _Trailer_Stat_AR_StartDelay =      0 / _Trailer_Stat_AR_Timebase;
    _Trailer_Stat_AR_Cnt = _Trailer_Stat_AR_StartDelay;
    _Trailer_Stat_AR_SpontanFlag= 0;

    putValue( HMI__STMSGSD_Trailer_Stat_AR, _Trailer_Stat_AR_StartDelay * _Trailer_Stat_AR_Timebase );

    _mTrailer_Stat_AR.BrkLmpStyle.phys = getValue( HMI_BrkLmpStyle );
    _mTrailer_Stat_AR.ElecTrlrHtch_Disengg.phys = getValue( HMI_ElecTrlrHtch_Disengg );
    _mTrailer_Stat_AR.ElecTrlrHtch_Disp_Rq.phys = getValue( HMI_ElecTrlrHtch_Disp_Rq );
    _mTrailer_Stat_AR.ElecTrlrHtch_WPosn.phys = getValue( HMI_ElecTrlrHtch_WPosn );
    _mTrailer_Stat_AR.SemiElecTrlrHtch_Flt.phys = getValue( HMI_SemiElecTrlrHtch_Flt );
    _mTrailer_Stat_AR.ElecTrlrHtch_PosnChg_Actv.phys = getValue( HMI_ElecTrlrHtch_PosnChg_Actv );
    _mTrailer_Stat_AR.ElecTrlrHtch_Stat_UB.phys = getValue( HMI_ElecTrlrHtch_Stat_UB );
    _mTrailer_Stat_AR.EmgLgtPath_Flt_TM.phys = getValue( HMI_EmgLgtPath_Flt_TM );
    _mTrailer_Stat_AR.Rsrv1_ElecTrlrHtch_Stat.phys = getValue( HMI_Rsrv1_ElecTrlrHtch_Stat );
    _mTrailer_Stat_AR.TM_FogLmp_Stat.phys = getValue( HMI_TM_FogLmp_Stat );
    _mTrailer_Stat_AR.Trlr_Stat.phys = getValue( HMI_Trlr_Stat );
    _mTrailer_Stat_AR.Trlr_Term54_Flt.phys = getValue( HMI_Trlr_Term54_Flt );
    _mTrailer_Stat_AR.TrlrBrkLmp_Flt.phys = getValue( HMI_TrlrBrkLmp_Flt );
    _mTrailer_Stat_AR.TrlrHtch_Flt.phys = getValue( HMI_TrlrHtch_Flt );
    _mTrailer_Stat_AR.TrlrTlLmp_Lt_Flt.phys = getValue( HMI_TrlrTlLmp_Lt_Flt );
    _mTrailer_Stat_AR.TrlrTlLmp_Rt_Flt.phys = getValue( HMI_TrlrTlLmp_Rt_Flt );
    _mTrailer_Stat_AR.TrlrTurnLmp_Lt_Flt.phys = getValue( HMI_TrlrTurnLmp_Lt_Flt );
    _mTrailer_Stat_AR.TrlrTurnLmp_Rt_Flt.phys = getValue( HMI_TrlrTurnLmp_Rt_Flt );
    _mTrailer_Stat_AR.TrlrHtch_Stat.phys = getValue( HMI_TrlrHtch_Stat );
}

Trailer_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_ElecTrlrHtch_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_ElecTrlrHtch_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _Trailer_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _Trailer_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_ElecTrlrHtch_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _Trailer_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _Trailer_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _Trailer_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _Trailer_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _Trailer_Stat_AR_SQC_RepeatedCnt ) &&
            ( _Trailer_Stat_AR_E2E_Armed == 1  )    )
        {
            _Trailer_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_ElecTrlrHtch_Stat, SQC_help );
    }
    _mTrailer_Stat_AR.SQC_ElecTrlrHtch_Stat = SQC_help;

    if( getValue( HMI_CRC_ElecTrlrHtch_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_ElecTrlrHtch_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mTrailer_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mTrailer_Stat_AR.byte( 1 ) ];
//            crc = crctable_profile02[ crc ^ _mTrailer_Stat_AR.byte( 2 ) ];
//            crc = crctable_profile02[ crc ^ _mTrailer_Stat_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mTrailer_Stat_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mTrailer_Stat_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mTrailer_Stat_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mTrailer_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _Trailer_Stat_AR_CRC_Offset[ _mTrailer_Stat_AR.SQC_ElecTrlrHtch_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _Trailer_Stat_AR_CRC_ErrorCnt   && ( _Trailer_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_ElecTrlrHtch_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _Trailer_Stat_AR_CRC_ErrorCnt > 0 )
                    _Trailer_Stat_AR_CRC_ErrorCnt--; 
            }
            _mTrailer_Stat_AR.CRC_ElecTrlrHtch_Stat = crc;
            putValue( HMI_CRC_ElecTrlrHtch_Stat, crc );
        }
        else
            _mTrailer_Stat_AR.CRC_ElecTrlrHtch_Stat = getValue( HMI_CRC_ElecTrlrHtch_Stat );
    }
    if( ( _Trailer_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _Trailer_Stat_AR_E2E_Armed == 1  )    )
    {
        _Trailer_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mTrailer_Stat_AR );
        
    if( _Trailer_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _Trailer_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _Trailer_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _Trailer_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _Trailer_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _Trailer_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_ElecTrlrHtch_Stat_State, 0 );
        }
    }
}

Trailer_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Trailer_Stat_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Trailer_Stat_AR := %X\n", getValue( HMI__STMSG_Trailer_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Trailer_Stat_AR := %X\n", getValue( HMI__STMSGT_Trailer_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkLmpStyle := %X\n", getValue( HMI_BrkLmpStyle ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ElecTrlrHtch_Stat := %X\n", getValue( HMI_CRC_ElecTrlrHtch_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ElecTrlrHtch_Stat_Auto := %X\n", getValue( HMI_CRC_ElecTrlrHtch_Stat_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_ElecTrlrHtch_Stat_Profile_02 := %X\n", getValue( HMI_CRC_ElecTrlrHtch_Stat_Profile_02 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ElecTrlrHtch_Disengg := %X\n", getValue( HMI_ElecTrlrHtch_Disengg ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ElecTrlrHtch_Disp_Rq := %X\n", getValue( HMI_ElecTrlrHtch_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ElecTrlrHtch_WPosn := %X\n", getValue( HMI_ElecTrlrHtch_WPosn ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SemiElecTrlrHtch_Flt := %X\n", getValue( HMI_SemiElecTrlrHtch_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ElecTrlrHtch_PosnChg_Actv := %X\n", getValue( HMI_ElecTrlrHtch_PosnChg_Actv ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ElecTrlrHtch_Stat_UB := %X\n", getValue( HMI_ElecTrlrHtch_Stat_UB ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EmgLgtPath_Flt_TM := %X\n", getValue( HMI_EmgLgtPath_Flt_TM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_ElecTrlrHtch_Stat := %X\n", getValue( HMI_Rsrv1_ElecTrlrHtch_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_ElecTrlrHtch_Stat := %X\n", getValue( HMI_SQC_ElecTrlrHtch_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_ElecTrlrHtch_Stat_Auto := %X\n", getValue( HMI_SQC_ElecTrlrHtch_Stat_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TM_FogLmp_Stat := %X\n", getValue( HMI_TM_FogLmp_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Trlr_Stat := %X\n", getValue( HMI_Trlr_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Trlr_Term54_Flt := %X\n", getValue( HMI_Trlr_Term54_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TrlrBrkLmp_Flt := %X\n", getValue( HMI_TrlrBrkLmp_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TrlrHtch_Flt := %X\n", getValue( HMI_TrlrHtch_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TrlrTlLmp_Lt_Flt := %X\n", getValue( HMI_TrlrTlLmp_Lt_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TrlrTlLmp_Rt_Flt := %X\n", getValue( HMI_TrlrTlLmp_Rt_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TrlrTurnLmp_Lt_Flt := %X\n", getValue( HMI_TrlrTurnLmp_Lt_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TrlrTurnLmp_Rt_Flt := %X\n", getValue( HMI_TrlrTurnLmp_Rt_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
     snprintf( buffer, elcount( buffer ), "0.0000 HMI_TrlrHtch_Stat := %X\n", getValue( HMI_TrlrHtch_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tTrailer_Stat_AR
{
    putValue( HMI__STMSG_Trailer_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_Trailer_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Trailer_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tTrailer_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_Trailer_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Trailer_Stat_AR
{
    if( getValue( this ) )
        openPanel("Trailer_Stat_AR");
}

on envVar HMI_E2E_ElecTrlrHtch_Stat_Inject
{
    if( getValue( this ) )
    {
        _Trailer_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_ElecTrlrHtch_Stat_ErrorCount );
        _Trailer_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_ElecTrlrHtch_Stat_TriggerPosition );
        _Trailer_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_ElecTrlrHtch_Stat_WrongSeq );
        _Trailer_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_ElecTrlrHtch_Stat_Repeated );
        _Trailer_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_ElecTrlrHtch_Stat_MSG_DropCnt );
        putValue( HMI_E2E_ElecTrlrHtch_Stat_State, 2 );
        _Trailer_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_BrkLmpStyle
{
    _mTrailer_Stat_AR.BrkLmpStyle.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ElecTrlrHtch_Disengg
{
    _mTrailer_Stat_AR.ElecTrlrHtch_Disengg.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ElecTrlrHtch_Disp_Rq
{
    _mTrailer_Stat_AR.ElecTrlrHtch_Disp_Rq.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ElecTrlrHtch_WPosn
{
    _mTrailer_Stat_AR.ElecTrlrHtch_WPosn.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SemiElecTrlrHtch_Flt
{
    _mTrailer_Stat_AR.SemiElecTrlrHtch_Flt.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ElecTrlrHtch_PosnChg_Actv
{
    _mTrailer_Stat_AR.ElecTrlrHtch_PosnChg_Actv.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_ElecTrlrHtch_Stat_UB
{
    _mTrailer_Stat_AR.ElecTrlrHtch_Stat_UB.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_EmgLgtPath_Flt_TM
{
    _mTrailer_Stat_AR.EmgLgtPath_Flt_TM.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_ElecTrlrHtch_Stat
{
    _mTrailer_Stat_AR.Rsrv1_ElecTrlrHtch_Stat.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_TM_FogLmp_Stat
{
    _mTrailer_Stat_AR.TM_FogLmp_Stat.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Trlr_Stat
{
    _mTrailer_Stat_AR.Trlr_Stat.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Trlr_Term54_Flt
{
    _mTrailer_Stat_AR.Trlr_Term54_Flt.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_TrlrBrkLmp_Flt
{
    _mTrailer_Stat_AR.TrlrBrkLmp_Flt.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_TrlrHtch_Flt
{
    _mTrailer_Stat_AR.TrlrHtch_Flt.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_TrlrTlLmp_Lt_Flt
{
    _mTrailer_Stat_AR.TrlrTlLmp_Lt_Flt.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_TrlrTlLmp_Rt_Flt
{
    _mTrailer_Stat_AR.TrlrTlLmp_Rt_Flt.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_TrlrTurnLmp_Lt_Flt
{
    _mTrailer_Stat_AR.TrlrTurnLmp_Lt_Flt.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_TrlrTurnLmp_Rt_Flt
{
    _mTrailer_Stat_AR.TrlrTurnLmp_Rt_Flt.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_TrlrHtch_Stat
{
    _mTrailer_Stat_AR.TrlrHtch_Stat.phys = getValue(this);
    _Trailer_Stat_AR_SpontanFlag = 1;
}

TSA_Disp_Rq1_AR_check_output()
{
    if( !getValue( HMI__STMSG_TSA_Disp_Rq1_AR ) )
    {
    //  message   TSA_Disp_Rq1_AR ID: 213 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _TSA_Disp_Rq1_AR_DelayCnt > 0) _TSA_Disp_Rq1_AR_DelayCnt--; // Mindestsendeabstand
        _TSA_Disp_Rq1_AR_Cnt--;
        if( _TSA_Disp_Rq1_AR_Cnt < 1 )
        {
            if( _TSA_Disp_Rq1_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                TSA_Disp_Rq1_AR_output();
                 _TSA_Disp_Rq1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _TSA_Disp_Rq1_AR_DelayCnt = _TSA_Disp_Rq1_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _TSA_Disp_Rq1_AR_SpontanFlag = 1;
            }
            _TSA_Disp_Rq1_AR_Cnt = _TSA_Disp_Rq1_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _TSA_Disp_Rq1_AR_SpontanFlag)
        {
            if( _TSA_Disp_Rq1_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                TSA_Disp_Rq1_AR_output();
                _TSA_Disp_Rq1_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _TSA_Disp_Rq1_AR_DelayCnt = _TSA_Disp_Rq1_AR_MinDelay;
            }
        }
    }
}

TSA_Disp_Rq1_AR_init()
{    /* Botschaft TSA_Disp_Rq1_AR ID: 213 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 213 0;
BA_ "NmAsrMessage" BO_ 213 0;
BA_ "GenMsgMinAcceptLength" BO_ 213 8;
BA_ "GenMsgILSupport" BO_ 213 1;
BA_ "DiagState" BO_ 213 0;
BA_ "DiagRequest" BO_ 213 0;
BA_ "DiagResponse" BO_ 213 0;
BA_ "GenMsgStartValue" BO_ 213 "0";
BA_ "GenMsgDelayTime" BO_ 213 50;
BA_ "GenMsgNrOfRepetitions" BO_ 213 0;
BA_ "GenMsgCycleTime" BO_ 213 200;
BA_ "GenMsgSendType" BO_ 213 5;
    */
    _TSA_Disp_Rq1_AR_Timebase =       c_tDBKomTimer_5ms;
    _TSA_Disp_Rq1_AR_CycleCount =    200 / _TSA_Disp_Rq1_AR_Timebase;
    _TSA_Disp_Rq1_AR_StartDelay =      0 / _TSA_Disp_Rq1_AR_Timebase;
    _TSA_Disp_Rq1_AR_MinDelay =       50 / _TSA_Disp_Rq1_AR_Timebase;
    _TSA_Disp_Rq1_AR_Cnt = _TSA_Disp_Rq1_AR_StartDelay;
    _TSA_Disp_Rq1_AR_SpontanFlag = 0;
    _TSA_Disp_Rq1_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_TSA_Disp_Rq1_AR, _TSA_Disp_Rq1_AR_StartDelay * _TSA_Disp_Rq1_AR_Timebase );

    _mTSA_Disp_Rq1_AR.CrossWalk_Warn_Rq.phys = getValue( HMI_CrossWalk_Warn_Rq );
    _mTSA_Disp_Rq1_AR.PMA_Pass_Warn_Rq.phys = getValue( HMI_PMA_Pass_Warn_Rq );
    _mTSA_Disp_Rq1_AR.PMA_Warn_Rq.phys = getValue( HMI_PMA_Warn_Rq );
    _mTSA_Disp_Rq1_AR.RoadWork_Warn_Rq.phys = getValue( HMI_RoadWork_Warn_Rq );
    _mTSA_Disp_Rq1_AR.SLA_SpdWarn_DispType.phys = getValue( HMI_SLA_SpdWarn_DispType );
    _mTSA_Disp_Rq1_AR.SLA_SpdWarn_IconDisp_Rq.phys = getValue( HMI_SLA_SpdWarn_IconDisp_Rq );
    _mTSA_Disp_Rq1_AR.SLA_SpdWarn_Rq_V2.phys = getValue( HMI_SLA_SpdWarn_Rq_V2 );
    _mTSA_Disp_Rq1_AR.SLA_Warn_Rq.phys = getValue( HMI_SLA_Warn_Rq );
    _mTSA_Disp_Rq1_AR.SLA_WarnSpd_Unit.phys = getValue( HMI_SLA_WarnSpd_Unit );
    _mTSA_Disp_Rq1_AR.SLA_WarnSpd_Val_V2.phys = getValue( HMI_SLA_WarnSpd_Val_V2 );
    _mTSA_Disp_Rq1_AR.SLA_WarnSpdNxt_Dist.phys = getValue( HMI_SLA_WarnSpdNxt_Dist );
    _mTSA_Disp_Rq1_AR.SLA_WarnSpdNxt_Type.phys = getValue( HMI_SLA_WarnSpdNxt_Type );
    _mTSA_Disp_Rq1_AR.SLA_WarnSpdNxt_Val.phys = getValue( HMI_SLA_WarnSpdNxt_Val );
    _mTSA_Disp_Rq1_AR.TSA_HU_DispMd_Stat.phys = getValue( HMI_TSA_HU_DispMd_Stat );
    _mTSA_Disp_Rq1_AR.TSA_IC_DispMd_Stat.phys = getValue( HMI_TSA_IC_DispMd_Stat );
    _mTSA_Disp_Rq1_AR.TSA_SpdWarnMd_Stat.phys = getValue( HMI_TSA_SpdWarnMd_Stat );
    _mTSA_Disp_Rq1_AR.TSA_SpdWarnOffset.phys = getValue( HMI_TSA_SpdWarnOffset );
    _mTSA_Disp_Rq1_AR.TSA_Stat.phys = getValue( HMI_TSA_Stat );
    _mTSA_Disp_Rq1_AR.TSA_WarnMd_Stat.phys = getValue( HMI_TSA_WarnMd_Stat );
    _mTSA_Disp_Rq1_AR.WWA_Warn_Rq.phys = getValue( HMI_WWA_Warn_Rq );
}

TSA_Disp_Rq1_AR_output()
{
    output( _mTSA_Disp_Rq1_AR );
}

TSA_Disp_Rq1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: TSA_Disp_Rq1_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_TSA_Disp_Rq1 := %X\n", getValue( HMI__STMSG_TSA_Disp_Rq1_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_TSA_Disp_Rq1 := %X\n", getValue( HMI__STMSGT_TSA_Disp_Rq1_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CrossWalk_Warn_Rq := %X\n", getValue( HMI_CrossWalk_Warn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PMA_Pass_Warn_Rq := %X\n", getValue( HMI_PMA_Pass_Warn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PMA_Warn_Rq := %X\n", getValue( HMI_PMA_Warn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RoadWork_Warn_Rq := %X\n", getValue( HMI_RoadWork_Warn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SLA_SpdWarn_DispType := %X\n", getValue( HMI_SLA_SpdWarn_DispType ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SLA_SpdWarn_IconDisp_Rq := %X\n", getValue( HMI_SLA_SpdWarn_IconDisp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SLA_SpdWarn_Rq_V2 := %X\n", getValue( HMI_SLA_SpdWarn_Rq_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SLA_Warn_Rq := %X\n", getValue( HMI_SLA_Warn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SLA_WarnSpd_Unit := %X\n", getValue( HMI_SLA_WarnSpd_Unit ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SLA_WarnSpd_Val_V2 := %X\n", getValue( HMI_SLA_WarnSpd_Val_V2 ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SLA_WarnSpdNxt_Dist := %X\n", getValue( HMI_SLA_WarnSpdNxt_Dist ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SLA_WarnSpdNxt_Type := %X\n", getValue( HMI_SLA_WarnSpdNxt_Type ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SLA_WarnSpdNxt_Val := %X\n", getValue( HMI_SLA_WarnSpdNxt_Val ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_HU_DispMd_Stat := %X\n", getValue( HMI_TSA_HU_DispMd_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_IC_DispMd_Stat := %X\n", getValue( HMI_TSA_IC_DispMd_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_SpdWarnMd_Stat := %X\n", getValue( HMI_TSA_SpdWarnMd_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_SpdWarnOffset := %X\n", getValue( HMI_TSA_SpdWarnOffset ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_Stat := %X\n", getValue( HMI_TSA_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_WarnMd_Stat := %X\n", getValue( HMI_TSA_WarnMd_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WWA_Warn_Rq := %X\n", getValue( HMI_WWA_Warn_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tTSA_Disp_Rq1_AR
{
    putValue( HMI__STMSG_TSA_Disp_Rq1_AR, 0 );
}

on EnvVar HMI__STMSG_TSA_Disp_Rq1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_TSA_Disp_Rq1_AR );
        if( tDelay > 0)    
            setTimer( _tTSA_Disp_Rq1_AR, tDelay );
        else
            putValue( HMI__STMSG_TSA_Disp_Rq1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_TSA_Disp_Rq1_AR
{
    if( getValue( this ) )
        openPanel("TSA_Disp_Rq1_AR");
}

on EnvVar HMI_CrossWalk_Warn_Rq
{
    _mTSA_Disp_Rq1_AR.CrossWalk_Warn_Rq.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PMA_Pass_Warn_Rq
{
    _mTSA_Disp_Rq1_AR.PMA_Pass_Warn_Rq.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_PMA_Warn_Rq
{
    _mTSA_Disp_Rq1_AR.PMA_Warn_Rq.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_RoadWork_Warn_Rq
{
    _mTSA_Disp_Rq1_AR.RoadWork_Warn_Rq.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_SLA_SpdWarn_DispType
{
    _mTSA_Disp_Rq1_AR.SLA_SpdWarn_DispType.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_SLA_SpdWarn_IconDisp_Rq
{
    _mTSA_Disp_Rq1_AR.SLA_SpdWarn_IconDisp_Rq.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_SLA_SpdWarn_Rq_V2
{
    _mTSA_Disp_Rq1_AR.SLA_SpdWarn_Rq_V2.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_SLA_Warn_Rq
{
    _mTSA_Disp_Rq1_AR.SLA_Warn_Rq.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_SLA_WarnSpd_Unit
{
    _mTSA_Disp_Rq1_AR.SLA_WarnSpd_Unit.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_SLA_WarnSpd_Val_V2
{
    _mTSA_Disp_Rq1_AR.SLA_WarnSpd_Val_V2.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_SLA_WarnSpdNxt_Dist
{
    _mTSA_Disp_Rq1_AR.SLA_WarnSpdNxt_Dist.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_SLA_WarnSpdNxt_Type
{
    _mTSA_Disp_Rq1_AR.SLA_WarnSpdNxt_Type.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_SLA_WarnSpdNxt_Val
{
    _mTSA_Disp_Rq1_AR.SLA_WarnSpdNxt_Val.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSA_HU_DispMd_Stat
{
    _mTSA_Disp_Rq1_AR.TSA_HU_DispMd_Stat.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSA_IC_DispMd_Stat
{
    _mTSA_Disp_Rq1_AR.TSA_IC_DispMd_Stat.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSA_SpdWarnMd_Stat
{
    _mTSA_Disp_Rq1_AR.TSA_SpdWarnMd_Stat.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSA_SpdWarnOffset
{
    _mTSA_Disp_Rq1_AR.TSA_SpdWarnOffset.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSA_Stat
{
    _mTSA_Disp_Rq1_AR.TSA_Stat.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSA_WarnMd_Stat
{
    _mTSA_Disp_Rq1_AR.TSA_WarnMd_Stat.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

on EnvVar HMI_WWA_Warn_Rq
{
    _mTSA_Disp_Rq1_AR.WWA_Warn_Rq.phys = getValue(this);
    _TSA_Disp_Rq1_AR_SpontanFlag = 1;
}

TSA_Disp_Rq2_AR_check_output()
{
    if( !getValue( HMI__STMSG_TSA_Disp_Rq2_AR ) )
    {
    //  message   TSA_Disp_Rq2_AR ID: 1051 --- Sendeart 0 cyclicX --- 
        _TSA_Disp_Rq2_AR_Cnt--;
        if( _TSA_Disp_Rq2_AR_Cnt == 1 )
        {
            putValue( HMI__STMSDT_TSA_Disp_Rq2_AR, 1 );
        }
        if( _TSA_Disp_Rq2_AR_Cnt < 1 )
        {
            putValue( HMI__STMSDT_TSA_Disp_Rq2_AR, 0 );
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            TSA_Disp_Rq2_AR_output();
            // Zyklus-Z�hler zur�cksetzen
            _TSA_Disp_Rq2_AR_Cnt = _TSA_Disp_Rq2_AR_CycleCount;
        }
    }
}

TSA_Disp_Rq2_AR_init()
{   /* Botschaft TSA_Disp_Rq2_AR ID: 1051 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 1051 0;
BA_ "NmAsrMessage" BO_ 1051 0;
BA_ "GenMsgMinAcceptLength" BO_ 1051 8;
BA_ "GenMsgILSupport" BO_ 1051 1;
BA_ "DiagState" BO_ 1051 0;
BA_ "DiagRequest" BO_ 1051 0;
BA_ "DiagResponse" BO_ 1051 0;
BA_ "GenMsgStartValue" BO_ 1051 "0";
BA_ "GenMsgStartDelayTime" BO_ 1051 0;
BA_ "GenMsgCycleTime" BO_ 1051 200;
BA_ "GenMsgSendType" BO_ 1051 0;
    */
    _TSA_Disp_Rq2_AR_Timebase =       c_tDBKomTimer_20ms;
    _TSA_Disp_Rq2_AR_CycleCount =    200 / _TSA_Disp_Rq2_AR_Timebase;
    _TSA_Disp_Rq2_AR_StartDelay =      0 / _TSA_Disp_Rq2_AR_Timebase;
    _TSA_Disp_Rq2_AR_Cnt = _TSA_Disp_Rq2_AR_StartDelay;
    _TSA_Disp_Rq2_AR_framecount = 0;

    putValue( HMI__STMSGSD_TSA_Disp_Rq2_AR, _TSA_Disp_Rq2_AR_StartDelay * _TSA_Disp_Rq2_AR_Timebase );

    _mTSA_Disp_Rq2_AR.TSA_Disp_Rq2_Data1.phys = getValue( HMI_TSA_Disp_Rq2_Data1 );
    _mTSA_Disp_Rq2_AR.TSA_Disp_Rq2_Data2.phys = getValue( HMI_TSA_Disp_Rq2_Data2 );
    _mTSA_Disp_Rq2_AR.TSA_Disp_Rq2_Data3.phys = getValue( HMI_TSA_Disp_Rq2_Data3 );
    _mTSA_Disp_Rq2_AR.TSA_Disp_Rq2_Data4.phys = getValue( HMI_TSA_Disp_Rq2_Data4 );
    _mTSA_Disp_Rq2_AR.TSA_Disp_Rq2_Data5.phys = getValue( HMI_TSA_Disp_Rq2_Data5 );
    _mTSA_Disp_Rq2_AR.TSA_Disp_Rq2_Data6.phys = getValue( HMI_TSA_Disp_Rq2_Data6 );
    _mTSA_Disp_Rq2_AR.TSA_Disp_Rq2_Data7.phys = getValue( HMI_TSA_Disp_Rq2_Data7 );
    _mTSA_Disp_Rq2_AR.TSA_Disp_Rq2_Data8.phys = getValue( HMI_TSA_Disp_Rq2_Data8 );
}

void TSA_Disp_Rq2_AR_output(void)
{
    if( getValue( HMI__STMSG_Manual_TSA_Disp_Rq2_AR ) )
    {
        if( _TSA_Disp_Rq2_AR_framecount == 1 )
        {
            putValue( HMI_TSA_Disp_Rq2_Data1, getvalue( Env_TSA_DISP_RQ2_10_Byte0 ) );
            putValue( HMI_TSA_Disp_Rq2_Data2, getvalue( Env_TSA_DISP_RQ2_10_Byte1 ) );
            putValue( HMI_TSA_Disp_Rq2_Data3, getvalue( Env_TSA_DISP_RQ2_10_Byte2 ) );
            putValue( HMI_TSA_Disp_Rq2_Data4, getvalue( Env_TSA_DISP_RQ2_10_Byte3 ) );
            putValue( HMI_TSA_Disp_Rq2_Data5, getvalue( Env_TSA_DISP_RQ2_10_Byte4 ) );
            putValue( HMI_TSA_Disp_Rq2_Data6, getvalue( Env_TSA_DISP_RQ2_10_Byte5 ) );
            putValue( HMI_TSA_Disp_Rq2_Data7, getvalue( Env_TSA_DISP_RQ2_10_Byte6 ) );
            putValue( HMI_TSA_Disp_Rq2_Data8, getvalue( Env_TSA_DISP_RQ2_10_Byte7 ) );
            if( getValue( Env_TSA_DISP_RQ2_21_Aktiv ) )
                _TSA_Disp_Rq2_AR_framecount = 3;
            else
                _TSA_Disp_Rq2_AR_framecount = 2;
        }

        if( _TSA_Disp_Rq2_AR_framecount == 2 )
        {
            putValue( HMI_TSA_Disp_Rq2_Data1, getvalue( Env_TSA_DISP_RQ2_20_Byte0 ) );
            putValue( HMI_TSA_Disp_Rq2_Data2, getvalue( Env_TSA_DISP_RQ2_20_Byte1 ) );
            putValue( HMI_TSA_Disp_Rq2_Data3, getvalue( Env_TSA_DISP_RQ2_20_Byte2 ) );
            putValue( HMI_TSA_Disp_Rq2_Data4, getvalue( Env_TSA_DISP_RQ2_20_Byte3 ) );
            putValue( HMI_TSA_Disp_Rq2_Data5, getvalue( Env_TSA_DISP_RQ2_20_Byte4 ) );
            putValue( HMI_TSA_Disp_Rq2_Data6, getvalue( Env_TSA_DISP_RQ2_20_Byte5 ) );
            putValue( HMI_TSA_Disp_Rq2_Data7, getvalue( Env_TSA_DISP_RQ2_20_Byte6 ) );
            putValue( HMI_TSA_Disp_Rq2_Data8, getvalue( Env_TSA_DISP_RQ2_20_Byte7 ) );
            _TSA_Disp_Rq2_AR_framecount = 1;
        }

        if( _TSA_Disp_Rq2_AR_framecount == 3 )
        {
            putValue( HMI_TSA_Disp_Rq2_Data1, getvalue( Env_TSA_DISP_RQ2_21_Byte0 ) );
            putValue( HMI_TSA_Disp_Rq2_Data2, getvalue( Env_TSA_DISP_RQ2_21_Byte1 ) );
            putValue( HMI_TSA_Disp_Rq2_Data3, getvalue( Env_TSA_DISP_RQ2_21_Byte2 ) );
            putValue( HMI_TSA_Disp_Rq2_Data4, getvalue( Env_TSA_DISP_RQ2_21_Byte3 ) );
            putValue( HMI_TSA_Disp_Rq2_Data5, getvalue( Env_TSA_DISP_RQ2_21_Byte4 ) );
            putValue( HMI_TSA_Disp_Rq2_Data6, getvalue( Env_TSA_DISP_RQ2_21_Byte5 ) );
            putValue( HMI_TSA_Disp_Rq2_Data7, getvalue( Env_TSA_DISP_RQ2_21_Byte6 ) );
            putValue( HMI_TSA_Disp_Rq2_Data8, getvalue( Env_TSA_DISP_RQ2_21_Byte7 ) );
            _TSA_Disp_Rq2_AR_framecount = 1;
        }
    }
    output( _mTSA_Disp_Rq2_AR );
}

TSA_Disp_Rq2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: TSA_Disp_Rq2\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_TSA_Disp_Rq2_AR := %X\n", getValue( HMI__STMSG_TSA_Disp_Rq2_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_TSA_Disp_Rq2_AR := %X\n", getValue( HMI__STMSGT_TSA_Disp_Rq2_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_Disp_Rq2_Data1 := %X\n", getValue( HMI_TSA_Disp_Rq2_Data1 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_Disp_Rq2_Data2 := %X\n", getValue( HMI_TSA_Disp_Rq2_Data2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_Disp_Rq2_Data3 := %X\n", getValue( HMI_TSA_Disp_Rq2_Data3 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_Disp_Rq2_Data4 := %X\n", getValue( HMI_TSA_Disp_Rq2_Data4 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_Disp_Rq2_Data5 := %X\n", getValue( HMI_TSA_Disp_Rq2_Data5 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_Disp_Rq2_Data6 := %X\n", getValue( HMI_TSA_Disp_Rq2_Data6 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_Disp_Rq2_Data7 := %X\n", getValue( HMI_TSA_Disp_Rq2_Data7 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_Disp_Rq2_Data8 := %X\n", getValue( HMI_TSA_Disp_Rq2_Data8 ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tTSA_Disp_Rq2_AR
{
    putValue( HMI__STMSG_TSA_Disp_Rq2_AR, 0 );
}

on EnvVar HMI__STMSG_TSA_Disp_Rq2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_TSA_Disp_Rq2_AR );
        if( tDelay > 0)    
            setTimer( _tTSA_Disp_Rq2_AR, tDelay );
        else
            putValue( HMI__STMSG_TSA_Disp_Rq2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_TSA_Disp_Rq2_AR
{
    if( getValue( this ) )
        openPanel("TSA_Disp_Rq2_AR");
}

on EnvVar HMI_TSA_Disp_Rq2_Data1
{
    _mTSA_Disp_Rq2_AR.TSA_Disp_Rq2_Data1.phys = getValue(this);
}

on EnvVar HMI_TSA_Disp_Rq2_Data2
{
    _mTSA_Disp_Rq2_AR.TSA_Disp_Rq2_Data2.phys = getValue(this);
}

on EnvVar HMI_TSA_Disp_Rq2_Data3
{
    _mTSA_Disp_Rq2_AR.TSA_Disp_Rq2_Data3.phys = getValue(this);
}

on EnvVar HMI_TSA_Disp_Rq2_Data4
{
    _mTSA_Disp_Rq2_AR.TSA_Disp_Rq2_Data4.phys = getValue(this);
}

on EnvVar HMI_TSA_Disp_Rq2_Data5
{
    _mTSA_Disp_Rq2_AR.TSA_Disp_Rq2_Data5.phys = getValue(this);
}

on EnvVar HMI_TSA_Disp_Rq2_Data6
{
    _mTSA_Disp_Rq2_AR.TSA_Disp_Rq2_Data6.phys = getValue(this);
}

on EnvVar HMI_TSA_Disp_Rq2_Data7
{
    _mTSA_Disp_Rq2_AR.TSA_Disp_Rq2_Data7.phys = getValue(this);
}

on EnvVar HMI_TSA_Disp_Rq2_Data8
{
    _mTSA_Disp_Rq2_AR.TSA_Disp_Rq2_Data8.phys = getValue(this);
}

TSA_Disp_Rq3_AR_check_output()
{
    if( !getValue( HMI__STMSG_TSA_Disp_Rq3_AR ) )
    {
    //  message   TSA_Disp_Rq3_AR ID: 1052 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _TSA_Disp_Rq3_AR_DelayCnt > 0) _TSA_Disp_Rq3_AR_DelayCnt--; // Mindestsendeabstand
        _TSA_Disp_Rq3_AR_Cnt--;
        if( _TSA_Disp_Rq3_AR_Cnt < 1 )
        {
            if( _TSA_Disp_Rq3_AR_DelayCnt < 1 )
            {
                TSA_Disp_Rq3_AR_output();  // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                 _TSA_Disp_Rq3_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _TSA_Disp_Rq3_AR_DelayCnt = _TSA_Disp_Rq3_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _TSA_Disp_Rq3_AR_SpontanFlag = 1;
            }
            _TSA_Disp_Rq3_AR_Cnt = _TSA_Disp_Rq3_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _TSA_Disp_Rq3_AR_SpontanFlag )
        {
            if( _TSA_Disp_Rq3_AR_DelayCnt < 1 )
            {
                TSA_Disp_Rq3_AR_output(); // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                _TSA_Disp_Rq3_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _TSA_Disp_Rq3_AR_DelayCnt = _TSA_Disp_Rq3_AR_MinDelay;
            }
        }
    }
}

TSA_Disp_Rq3_AR_init()
{   /* Botschaft TSA_Disp_Rq3_AR ID: 1052 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1052 0;
BA_ "NmAsrMessage" BO_ 1052 0;
BA_ "GenMsgMinAcceptLength" BO_ 1052 8;
BA_ "GenMsgILSupport" BO_ 1052 1;
BA_ "DiagState" BO_ 1052 0;
BA_ "DiagRequest" BO_ 1052 0;
BA_ "DiagResponse" BO_ 1052 0;
BA_ "GenMsgStartValue" BO_ 1052 "0";
BA_ "GenMsgDelayTime" BO_ 1052 50;
BA_ "GenMsgNrOfRepetition" BO_ 1052 0;
BA_ "GenMsgCycleTime" BO_ 1052 200;
BA_ "GenMsgSendType" BO_ 1052 5;
    */
    _TSA_Disp_Rq3_AR_Timebase =          c_tDBKomTimer_20ms;
    _TSA_Disp_Rq3_AR_CycleCount =       200 / _TSA_Disp_Rq3_AR_Timebase;
    _TSA_Disp_Rq3_AR_StartDelay =         0 / _TSA_Disp_Rq3_AR_Timebase;
    _TSA_Disp_Rq3_AR_MinDelay =          50 / _TSA_Disp_Rq3_AR_Timebase;
    _TSA_Disp_Rq3_AR_Cnt = _TSA_Disp_Rq3_AR_StartDelay;
    _TSA_Disp_Rq3_AR_SpontanFlag = 0;
    _TSA_Disp_Rq3_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_TSA_Disp_Rq3_AR, _TSA_Disp_Rq3_AR_StartDelay * _TSA_Disp_Rq3_AR_Timebase );

    _mTSA_Disp_Rq3_AR.SLA_WarnSpdNxt_Dist_HiRsltn.phys =      getValue( HMI_SLA_WarnSpdNxt_Dist_HiRsltn );
    _mTSA_Disp_Rq3_AR.TSA_SpdWarnOffset1.phys =  			getValue( HMI_TSA_SpdWarnOffset1 );
    _mTSA_Disp_Rq3_AR.TSA_SpdWarnOffset2.phys =     getValue( HMI_TSA_SpdWarnOffset2 );
    _mTSA_Disp_Rq3_AR.TSA_SpdWarnOffset_Stat.phys =      getValue( HMI_TSA_SpdWarnOffset_Stat );	
	  _mTSA_Disp_Rq3_AR.TSA_SpdWarnOffset_Unit_Rs.phys =      getValue( HMI_TSA_SpdWarnOffset_Unit_Rs );
	  _mTSA_Disp_Rq3_AR.TSA_SpdWarnOffsetBase.phys =      getValue( HMI_TSA_SpdWarnOffsetBase );
	  _mTSA_Disp_Rq3_AR.TSA_SpdWarnThrs.phys =      getValue( HMI_TSA_SpdWarnThrs );
	  _mTSA_Disp_Rq3_AR.TSA_StopSign_Dist.phys =      getValue( HMI_TSA_StopSign_Dist );
	  _mTSA_Disp_Rq3_AR.TSA_StopSignStyle.phys =      getValue( HMI_TSA_StopSignStyle );
	  _mTSA_Disp_Rq3_AR.DAS_LDP_SensSoil_Radar.phys =      getValue( HMI_DAS_LDP_SensSoil_Radar );
	  _mTSA_Disp_Rq3_AR.LDP_AcustWarn_Rq_V2.phys =      getValue( HMI_LDP_AcustWarn_Rq_V2 );
	  _mTSA_Disp_Rq3_AR.LDP_Add_Md_Stat_V2.phys =      getValue( HMI_LDP_Add_Md_Stat_V2 );
	  _mTSA_Disp_Rq3_AR.LDP_HandsOff_Warn_MsgDisp_Rq_V2.phys =      getValue( HMI_LDP_HandsOff_Warn_MsgDisp_Rq_V2 );
    _mTSA_Disp_Rq3_AR.TSA_SLR_Dyn_Ind_Stat.phys = getValue( HMI_TSA_SLR_Dyn_Ind_Stat );
    _mTSA_Disp_Rq3_AR.CamSensSoil_CMS_IconDisp_Rq_MPC.phys = getValue( HMI_CamSensSoil_CMS_IconDisp_Rq_MPC );
    _mTSA_Disp_Rq3_AR.CamSensSoil_IHC_IconDisp_Rq_MPC.phys = getValue( HMI_CamSensSoil_IHC_IconDisp_Rq_MPC );
    _mTSA_Disp_Rq3_AR.CamSensSoil_LDP_IconDisp_Rq_MPC.phys = getValue( HMI_CamSensSoil_LDP_IconDisp_Rq_MPC );
    _mTSA_Disp_Rq3_AR.CamSensSoil_MsgDisp_Rq_MPC.phys = getValue( HMI_CamSensSoil_MsgDisp_Rq_MPC );
    _mTSA_Disp_Rq3_AR.CamSensSoil_TSA_IconDisp_Rq_MPC.phys = getValue( HMI_CamSensSoil_TSA_IconDisp_Rq_MPC );
	
}

TSA_Disp_Rq3_AR_output(void)
{
    output( _mTSA_Disp_Rq3_AR );
}

TSA_Disp_Rq3_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: TSA_Disp_Rq3_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_TSA_Disp_Rq3_AR := %X\n", getValue( HMI__STMSG_TSA_Disp_Rq3_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_TSA_Disp_Rq3_AR := %X\n", getValue( HMI__STMSGT_TSA_Disp_Rq3_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SLA_WarnSpdNxt_Dist_HiRsltnP := %X\n", getValue( HMI_SLA_WarnSpdNxt_Dist_HiRsltn ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_SpdWarnOffset1 := %X\n", getValue( HMI_TSA_SpdWarnOffset1 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_SpdWarnOffset2 := %X\n", getValue( HMI_TSA_SpdWarnOffset2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_SpdWarnOffset_Stat := %X\n", getValue( HMI_TSA_SpdWarnOffset_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_SpdWarnOffset_Unit_Rs := %X\n", getValue( HMI_TSA_SpdWarnOffset_Unit_Rs ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_SpdWarnOffsetBase := %X\n", getValue( HMI_TSA_SpdWarnOffsetBase ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_SpdWarnThrs := %X\n", getValue( HMI_TSA_SpdWarnThrs ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_StopSign_Dist := %X\n", getValue( HMI_TSA_StopSign_Dist ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_TSA_StopSignStyle := %X\n", getValue( HMI_TSA_StopSignStyle ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_DAS_LDP_SensSoil_Radar := %X\n", getValue( HMI_DAS_LDP_SensSoil_Radar ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_AcustWarn_Rq_V2 := %X\n", getValue( HMI_LDP_AcustWarn_Rq_V2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_Add_Md_Stat_V2 := %X\n", getValue( HMI_LDP_Add_Md_Stat_V2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_LDP_HandsOff_Warn_MsgDisp_Rq_V2 := %X\n", getValue( HMI_LDP_HandsOff_Warn_MsgDisp_Rq_V2 ) );        filePutString ( buffer, elcount( buffer ), hFile );
  snprintf( buffer, elcount(buffer), "0.0000 HMI_TSA_SLR_Dyn_Ind_Stat := %X\n", getValue( HMI_TSA_SLR_Dyn_Ind_Stat ) );        filePutString( buffer, elcount(buffer), hFile);
  snprintf( buffer, elcount(buffer), "0.0000 HMI_CamSensSoil_CMS_IconDisp_Rq_MPC := %X\n", getValue( HMI_CamSensSoil_CMS_IconDisp_Rq_MPC ) );        filePutString( buffer, elcount(buffer), hFile);
  snprintf( buffer, elcount(buffer), "0.0000 HMI_CamSensSoil_IHC_IconDisp_Rq_MPC := %X\n", getValue( HMI_CamSensSoil_IHC_IconDisp_Rq_MPC ) );        filePutString( buffer, elcount(buffer), hFile);
  snprintf( buffer, elcount(buffer), "0.0000 HMI_CamSensSoil_LDP_IconDisp_Rq_MPC := %X\n", getValue( HMI_CamSensSoil_LDP_IconDisp_Rq_MPC ) );        filePutString( buffer, elcount(buffer), hFile);
  snprintf( buffer, elcount(buffer), "0.0000 HMI_CamSensSoil_MsgDisp_Rq_MPC := %X\n", getValue( HMI_CamSensSoil_MsgDisp_Rq_MPC ) );        filePutString( buffer, elcount(buffer), hFile);
  snprintf( buffer, elcount(buffer), "0.0000 HMI_CamSensSoil_TSA_IconDisp_Rq_MPC := %X\n", getValue( HMI_CamSensSoil_TSA_IconDisp_Rq_MPC ) );        filePutString( buffer, elcount(buffer), hFile);
}

on timer _tTSA_Disp_Rq3_AR
{
    putValue( HMI__STMSG_TSA_Disp_Rq3_AR, 0 );
}

on EnvVar HMI__STMSG_TSA_Disp_Rq3_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_TSA_Disp_Rq3_AR );
        if( tDelay > 0)    
            setTimer( _tTSA_Disp_Rq3_AR, tDelay );
        else
            putValue( HMI__STMSG_TSA_Disp_Rq3_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_TSA_Disp_Rq3_AR
{
    if( getValue( this ) )
        openPanel("TSA_Disp_Rq3_AR");
}

on EnvVar HMI_SLA_WarnSpdNxt_Dist_HiRsltn
{
    _mTSA_Disp_Rq3_AR.SLA_WarnSpdNxt_Dist_HiRsltn.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSA_SpdWarnOffset1
{
    _mTSA_Disp_Rq3_AR.TSA_SpdWarnOffset1.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSA_SpdWarnOffset2
{
    _mTSA_Disp_Rq3_AR.TSA_SpdWarnOffset2.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSA_SpdWarnOffset_Stat
{
    _mTSA_Disp_Rq3_AR.TSA_SpdWarnOffset_Stat.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSA_SpdWarnOffset_Unit_Rs
{
    _mTSA_Disp_Rq3_AR.TSA_SpdWarnOffset_Unit_Rs.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSA_SpdWarnOffsetBase
{
    _mTSA_Disp_Rq3_AR.TSA_SpdWarnOffsetBase.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSA_SpdWarnThrs
{
    _mTSA_Disp_Rq3_AR.TSA_SpdWarnThrs.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSA_StopSign_Dist
{
    _mTSA_Disp_Rq3_AR.TSA_StopSign_Dist.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}

on EnvVar HMI_TSA_StopSignStyle
{
    _mTSA_Disp_Rq3_AR.TSA_StopSignStyle.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}

on EnvVar HMI_DAS_LDP_SensSoil_Radar
{
    _mTSA_Disp_Rq3_AR.DAS_LDP_SensSoil_Radar.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDP_AcustWarn_Rq_V2
{
    _mTSA_Disp_Rq3_AR.LDP_AcustWarn_Rq_V2.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDP_Add_Md_Stat_V2
{
    _mTSA_Disp_Rq3_AR.LDP_Add_Md_Stat_V2.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}

on EnvVar HMI_LDP_HandsOff_Warn_MsgDisp_Rq_V2
{
    _mTSA_Disp_Rq3_AR.LDP_HandsOff_Warn_MsgDisp_Rq_V2.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}


on EnvVar HMI_TSA_SLR_Dyn_Ind_Stat
{
    _mTSA_Disp_Rq3_AR.TSA_SLR_Dyn_Ind_Stat.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}

on EnvVar HMI_CamSensSoil_CMS_IconDisp_Rq_MPC
{
    _mTSA_Disp_Rq3_AR.CamSensSoil_CMS_IconDisp_Rq_MPC.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}

on EnvVar HMI_CamSensSoil_IHC_IconDisp_Rq_MPC
{
    _mTSA_Disp_Rq3_AR.CamSensSoil_IHC_IconDisp_Rq_MPC.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}

on EnvVar HMI_CamSensSoil_LDP_IconDisp_Rq_MPC
{
    _mTSA_Disp_Rq3_AR.CamSensSoil_LDP_IconDisp_Rq_MPC.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}

on EnvVar HMI_CamSensSoil_MsgDisp_Rq_MPC
{
    _mTSA_Disp_Rq3_AR.CamSensSoil_MsgDisp_Rq_MPC.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}

on EnvVar HMI_CamSensSoil_TSA_IconDisp_Rq_MPC
{
    _mTSA_Disp_Rq3_AR.CamSensSoil_TSA_IconDisp_Rq_MPC.phys = getValue(this);
    _TSA_Disp_Rq3_AR_SpontanFlag = 1;
}

Veh_Susp_Adj_AR_check_output()
{
    if( !getValue( HMI__STMSG_Veh_Susp_Adj_AR ) )
    {
    //  message   Veh_Susp_Adj_AR ID: 864 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _Veh_Susp_Adj_AR_DelayCnt > 0) _Veh_Susp_Adj_AR_DelayCnt--; // Mindestsendeabstand
        _Veh_Susp_Adj_AR_Cnt--;
        if( _Veh_Susp_Adj_AR_Cnt < 1 )
        {
            if( _Veh_Susp_Adj_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                Veh_Susp_Adj_AR_output();
                 _Veh_Susp_Adj_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Veh_Susp_Adj_AR_DelayCnt = _Veh_Susp_Adj_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _Veh_Susp_Adj_AR_SpontanFlag = 1;
            }
            _Veh_Susp_Adj_AR_Cnt = _Veh_Susp_Adj_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _Veh_Susp_Adj_AR_SpontanFlag)
        {
            if( _Veh_Susp_Adj_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                Veh_Susp_Adj_AR_output();
                _Veh_Susp_Adj_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _Veh_Susp_Adj_AR_DelayCnt = _Veh_Susp_Adj_AR_MinDelay;
            }
        }
    }
}

Veh_Susp_Adj_AR_init()
{   /* Botschaft Veh_Susp_Adj_AR  ID: 864 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 864 0;
BA_ "NmAsrMessage" BO_ 864 0;
BA_ "GenMsgMinAcceptLength" BO_ 864 8;
BA_ "GenMsgILSupport" BO_ 864 1;
BA_ "DiagState" BO_ 864 0;
BA_ "DiagRequest" BO_ 864 0;
BA_ "DiagResponse" BO_ 864 0;
BA_ "GenMsgStartValue" BO_ 864 "0";
BA_ "GenMsgDelayTime" BO_ 864 20;
BA_ "GenMsgNrOfRepetition" BO_ 864 0;
BA_ "GenMsgCycleTime" BO_ 864 500;
BA_ "GenMsgSendType" BO_ 864 5;
    */
    _Veh_Susp_Adj_AR_Timebase =             c_tDBKomTimer_20ms;
    _Veh_Susp_Adj_AR_CycleCount =          500 / _Veh_Susp_Adj_AR_Timebase;
    _Veh_Susp_Adj_AR_StartDelay =            0 / _Veh_Susp_Adj_AR_Timebase;
    _Veh_Susp_Adj_AR_MinDelay =             20 / _Veh_Susp_Adj_AR_Timebase;
    _Veh_Susp_Adj_AR_Cnt = _Veh_Susp_Adj_AR_StartDelay;
    _Veh_Susp_Adj_AR_SpontanFlag = 0;
    _Veh_Susp_Adj_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_Veh_Susp_Adj_AR, _Veh_Susp_Adj_AR_StartDelay * _Veh_Susp_Adj_AR_Timebase);
    
    _mVeh_Susp_Adj_AR.SPC_LowLvl_Stat.phys = getValue( HMI_SPC_LowLvl_Stat );
    _mVeh_Susp_Adj_AR.IndWhlAdj_Stat.phys = getValue( HMI_IndWhlAdj_Stat );
    _mVeh_Susp_Adj_AR.SPC_Msg14_Disp_Rq.phys = getValue( HMI_SPC_Msg14_Disp_Rq );
    _mVeh_Susp_Adj_AR.SPC_Msg15_Disp_Rq.phys = getValue( HMI_SPC_Msg15_Disp_Rq );
    _mVeh_Susp_Adj_AR.SPC_Msg16_Disp_Rq.phys = getValue( HMI_SPC_Msg16_Disp_Rq );
    _mVeh_Susp_Adj_AR.VehLvl_Offset_FL.phys = getValue( HMI_VehLvl_Offset_FL );
    _mVeh_Susp_Adj_AR.VehLvl_Offset_FR.phys = getValue( HMI_VehLvl_Offset_FR );
    _mVeh_Susp_Adj_AR.VehLvl_Offset_RL.phys = getValue( HMI_VehLvl_Offset_RL );
    _mVeh_Susp_Adj_AR.VehLvl_Offset_RR.phys = getValue( HMI_VehLvl_Offset_RR );
    _mVeh_Susp_Adj_AR.SPC_Msg17_Disp_Rq.phys = getValue( HMI_SPC_Msg17_Disp_Rq );
    _mVeh_Susp_Adj_AR.Rsrv2_SPC_Msg_Rq2.phys = getValue( HMI_Rsrv2_SPC_Msg_Rq2 );
    _mVeh_Susp_Adj_AR.SuspLvlAdjSwLED_L_Rq.phys = getValue( HMI_SuspLvlAdjSwLED_L_Rq );
    _mVeh_Susp_Adj_AR.SuspLvlAdjSwLED_U_Rq.phys = getValue( HMI_SuspLvlAdjSwLED_U_Rq );  
    _mVeh_Susp_Adj_AR.Carwash_SuspLvl_Stat.phys = getValue( HMI_Carwash_SuspLvl_Stat );
     _mVeh_Susp_Adj_AR.SPC_ErrMsg7_Disp_Rq_V2.phys = getValue( HMI_SPC_ErrMsg7_Disp_Rq_V2 );
}

Veh_Susp_Adj_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_SPC_Msg_Rq2 ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_SPC_Msg_Rq2_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _Veh_Susp_Adj_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _Veh_Susp_Adj_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_SPC_Msg_Rq2_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _Veh_Susp_Adj_AR_SQC_WrongSeqJump != 0 ) &&
            ( _Veh_Susp_Adj_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _Veh_Susp_Adj_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _Veh_Susp_Adj_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _Veh_Susp_Adj_AR_SQC_RepeatedCnt ) &&
            ( _Veh_Susp_Adj_AR_E2E_Armed == 1  )    )
        {
            _Veh_Susp_Adj_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_SPC_Msg_Rq2, SQC_help );
    }
    _mVeh_Susp_Adj_AR.SQC_SPC_Msg_Rq2 = SQC_help;

    if( getValue( HMI_CRC_SPC_Msg_Rq2_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_SPC_Msg_Rq2_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable_profile02[ crc ^ _mVeh_Susp_Adj_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mVeh_Susp_Adj_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mVeh_Susp_Adj_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mVeh_Susp_Adj_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mVeh_Susp_Adj_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mVeh_Susp_Adj_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mVeh_Susp_Adj_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mVeh_Susp_Adj_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _Veh_Susp_Adj_AR_CRC_Offset[ _mVeh_Susp_Adj_AR.SQC_SPC_Msg_Rq2 ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _Veh_Susp_Adj_AR_CRC_ErrorCnt   && ( _Veh_Susp_Adj_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_SPC_Msg_Rq2_Invalid )                                         )    )
            {
                crc++;
                if( _Veh_Susp_Adj_AR_CRC_ErrorCnt > 0 )
                    _Veh_Susp_Adj_AR_CRC_ErrorCnt--; 
            }
            _mVeh_Susp_Adj_AR.CRC_SPC_Msg_Rq2 = crc;
            putValue( HMI_CRC_SPC_Msg_Rq2, crc );
        }
        else
            _mVeh_Susp_Adj_AR.CRC_SPC_Msg_Rq2 = getValue( HMI_CRC_SPC_Msg_Rq2 );
    }
    else
    {
        if( !getValue( HMI_CRC_SPC_Msg_Rq2_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mVeh_Susp_Adj_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mVeh_Susp_Adj_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mVeh_Susp_Adj_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mVeh_Susp_Adj_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mVeh_Susp_Adj_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mVeh_Susp_Adj_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mVeh_Susp_Adj_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mVeh_Susp_Adj_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _Veh_Susp_Adj_AR_CRC_ErrorCnt   && ( _Veh_Susp_Adj_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_SPC_Msg_Rq2_Invalid )                                         )    )
            {
                crc++;
                if( _Veh_Susp_Adj_AR_CRC_ErrorCnt > 0 )
                    _Veh_Susp_Adj_AR_CRC_ErrorCnt--; 
            }
            _mVeh_Susp_Adj_AR.CRC_SPC_Msg_Rq2 = crc;
            putValue( HMI_CRC_SPC_Msg_Rq2, crc );
        }
        else
            _mVeh_Susp_Adj_AR.CRC_SPC_Msg_Rq2 = getValue( HMI_CRC_SPC_Msg_Rq2 );
    }
    if( ( _Veh_Susp_Adj_AR_MSG_DropCnt > 0 ) &&
        ( _Veh_Susp_Adj_AR_E2E_Armed == 1  )    )
    {
        _Veh_Susp_Adj_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mVeh_Susp_Adj_AR );
        
    if( _Veh_Susp_Adj_AR_E2E_Armed == 1 )
    {
        if ( ( _Veh_Susp_Adj_AR_MSG_DropCnt == 0      ) &&
             ( _Veh_Susp_Adj_AR_CRC_ErrorCnt == 0     ) &&
             ( _Veh_Susp_Adj_AR_SQC_RepeatedCnt == 0  ) &&
             ( _Veh_Susp_Adj_AR_SQC_WrongSeqJump == 0 )    )
        {
            _Veh_Susp_Adj_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_SPC_Msg_Rq2_State, 0 );
        }
    }
}

Veh_Susp_Adj_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Veh_Susp_Adj_AR\n", 31, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Veh_Susp_Adj_AR := %X\n", getValue( HMI__STMSG_Veh_Susp_Adj_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Veh_Susp_Adj_AR := %X\n", getValue( HMI__STMSGT_Veh_Susp_Adj_AR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_SPC_Msg_Rq2 := %X\n", getValue( HMI_CRC_SPC_Msg_Rq2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_SPC_Msg_Rq2_Auto := %X\n", getValue( HMI_CRC_SPC_Msg_Rq2_Auto ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_SPC_Msg_Rq2_Profile_02 := %X\n", getValue( HMI_CRC_SPC_Msg_Rq2_Profile_02 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_eSusp_LowLvl_Stat := %X\n", getValue( HMI_SPC_LowLvl_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_IndWhlAdj_Stat := %X\n", getValue( HMI_IndWhlAdj_Stat ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_Msg14_Disp_Rq := %X\n", getValue( HMI_SPC_Msg14_Disp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_Msg15_Disp_Rq := %X\n", getValue( HMI_SPC_Msg15_Disp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_Msg16_Disp_Rq := %X\n", getValue( HMI_SPC_Msg16_Disp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLvl_Offset_FL := %X\n", getValue( HMI_VehLvl_Offset_FL ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLvl_Offset_FR := %X\n", getValue( HMI_VehLvl_Offset_FR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLvl_Offset_RL := %X\n", getValue( HMI_VehLvl_Offset_RL ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLvl_Offset_RR := %X\n", getValue( HMI_VehLvl_Offset_RR ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_Msg17_Disp_Rq := %X\n", getValue( HMI_SPC_Msg17_Disp_Rq ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_SPC_Msg_Rq2 := %X\n", getValue( HMI_Rsrv2_SPC_Msg_Rq2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_SPC_Msg_Rq2 := %X\n", getValue( HMI_SQC_SPC_Msg_Rq2 ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_SPC_Msg_Rq2_Auto := %X\n", getValue( HMI_SQC_SPC_Msg_Rq2_Auto ) );    filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount(buffer), "0.0000 HMI_SuspLvlAdjSwLED_L_Rq := %X\n", getValue( HMI_SuspLvlAdjSwLED_L_Rq ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_SuspLvlAdjSwLED_U_Rq := %X\n", getValue( HMI_SuspLvlAdjSwLED_U_Rq ) );        filePutString( buffer, elcount(buffer), hFile);
    snprintf( buffer, elcount(buffer), "0.0000 HMI_Carwash_SuspLvl_Stat := %X\n", getValue( HMI_Carwash_SuspLvl_Stat ) );        filePutString( buffer, elcount(buffer), hFile);
     snprintf( buffer, elcount(buffer), "0.0000 HMI_SPC_ErrMsg7_Disp_Rq_V2 := %X\n", getValue( HMI_SPC_ErrMsg7_Disp_Rq_V2 ) );        filePutString( buffer, elcount(buffer), hFile);
}

on timer _tVeh_Susp_Adj_AR
{
    putValue( HMI__STMSG_Veh_Susp_Adj_AR, 0 );
}

on EnvVar HMI__STMSG_Veh_Susp_Adj_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Veh_Susp_Adj_AR );
        if( tDelay > 0)    
            setTimer( _tVeh_Susp_Adj_AR, tDelay );
        else
            putValue( HMI__STMSG_Veh_Susp_Adj_AR, 0 );
    }
}

on envVar HMI_E2E_SPC_Msg_Rq2_Inject
{
    if( getValue( this ) )
    {
        _Veh_Susp_Adj_AR_CRC_ErrorCnt = getValue( HMI_CRC_SPC_Msg_Rq2_ErrorCount );
        _Veh_Susp_Adj_AR_SQC_TriggPos = getValue( HMI_SQC_SPC_Msg_Rq2_TriggerPosition );
        _Veh_Susp_Adj_AR_SQC_WrongSeqJump = getValue( HMI_SQC_SPC_Msg_Rq2_WrongSeq );
        _Veh_Susp_Adj_AR_SQC_RepeatedCnt = getValue( HMI_SQC_SPC_Msg_Rq2_Repeated );
        _Veh_Susp_Adj_AR_MSG_DropCnt = getValue( HMI_SQC_SPC_Msg_Rq2_MSG_DropCnt );
        putValue( HMI_E2E_SPC_Msg_Rq2_State, 2 );
        _Veh_Susp_Adj_AR_E2E_Armed = 2;  //armed
    }
}

on envVar HMI__STMSG_PO_Veh_Susp_Adj_AR
{
    if( getValue( this ) )
        openPanel("Veh_Susp_Adj_AR");
}

on EnvVar HMI_SPC_LowLvl_Stat
{
    _mVeh_Susp_Adj_AR.SPC_LowLvl_Stat.phys = getValue(this);
    _Veh_Susp_Adj_AR_SpontanFlag = 1;
}

on EnvVar HMI_IndWhlAdj_Stat
{
    _mVeh_Susp_Adj_AR.IndWhlAdj_Stat.phys = getValue(this);
    _Veh_Susp_Adj_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_Msg14_Disp_Rq
{
    _mVeh_Susp_Adj_AR.SPC_Msg14_Disp_Rq.phys = getValue(this);
    _Veh_Susp_Adj_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_Msg15_Disp_Rq
{
    _mVeh_Susp_Adj_AR.SPC_Msg15_Disp_Rq.phys = getValue(this);
    _Veh_Susp_Adj_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_Msg16_Disp_Rq
{
    _mVeh_Susp_Adj_AR.SPC_Msg16_Disp_Rq.phys = getValue(this);
    _Veh_Susp_Adj_AR_SpontanFlag = 1;
}

on EnvVar HMI_VehLvl_Offset_FL
{
    _mVeh_Susp_Adj_AR.VehLvl_Offset_FL.phys = getValue(this);
    _Veh_Susp_Adj_AR_SpontanFlag = 1;
}

on EnvVar HMI_VehLvl_Offset_FR
{
    _mVeh_Susp_Adj_AR.VehLvl_Offset_FR.phys = getValue(this);
    _Veh_Susp_Adj_AR_SpontanFlag = 1;
}

on EnvVar HMI_VehLvl_Offset_RL
{
    _mVeh_Susp_Adj_AR.VehLvl_Offset_RL.phys = getValue(this);
    _Veh_Susp_Adj_AR_SpontanFlag = 1;
}

on EnvVar HMI_VehLvl_Offset_RR
{
    _mVeh_Susp_Adj_AR.VehLvl_Offset_RR.phys = getValue(this);
    _Veh_Susp_Adj_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_Msg17_Disp_Rq
{
    _mVeh_Susp_Adj_AR.SPC_Msg17_Disp_Rq.phys = getValue(this);
    _Veh_Susp_Adj_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv2_SPC_Msg_Rq2
{
    _mVeh_Susp_Adj_AR.Rsrv2_SPC_Msg_Rq2.phys = getValue(this);
    _Veh_Susp_Adj_AR_SpontanFlag = 1;
}

on EnvVar HMI_SuspLvlAdjSwLED_L_Rq
{
    _mVeh_Susp_Adj_AR.SuspLvlAdjSwLED_L_Rq.phys = getValue(this);
    _Veh_Susp_Adj_AR_SpontanFlag = 1;
}

on EnvVar HMI_SuspLvlAdjSwLED_U_Rq
{
    _mVeh_Susp_Adj_AR.SuspLvlAdjSwLED_U_Rq.phys = getValue(this);
    _Veh_Susp_Adj_AR_SpontanFlag = 1;
}

on EnvVar HMI_Carwash_SuspLvl_Stat
{
    _mVeh_Susp_Adj_AR.Carwash_SuspLvl_Stat.phys = getValue(this);
    _Veh_Susp_Adj_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_ErrMsg7_Disp_Rq_V2
{
    _mVeh_Susp_Adj_AR.SPC_ErrMsg7_Disp_Rq_V2.phys = getValue(this);
    _Veh_Susp_Adj_AR_SpontanFlag = 1;
}

VehCarv_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_VehCarv_Stat_AR ) )
    {
        // Botschaft VehCarv_Stat_AR ID: 1046 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _VehCarv_Stat_AR_DelayCnt > 0 ) _VehCarv_Stat_AR_DelayCnt--; // Mindestsendeabstand
        _VehCarv_Stat_AR_Cnt--;
        if( _VehCarv_Stat_AR_Cnt < 1 )
        {
            if( _VehCarv_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                VehCarv_Stat_AR_output();
                _VehCarv_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _VehCarv_Stat_AR_DelayCnt = _VehCarv_Stat_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _VehCarv_Stat_AR_SpontanFlag = 1;
            }
            _VehCarv_Stat_AR_Cnt = _VehCarv_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _VehCarv_Stat_AR_SpontanFlag)
        {
            if( _VehCarv_Stat_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                VehCarv_Stat_AR_output();
                _VehCarv_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _VehCarv_Stat_AR_DelayCnt = _VehCarv_Stat_AR_MinDelay;
            }
        }
    }
}

VehCarv_Stat_AR_init()
{   /* Botschaft VehCarv_Stat_AR ID: 1046 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1046 0;
BA_ "NmAsrMessage" BO_ 1046 0;
BA_ "GenMsgMinAcceptLength" BO_ 1046 8;
BA_ "GenMsgILSupport" BO_ 1046 1;
BA_ "DiagState" BO_ 1046 0;
BA_ "DiagRequest" BO_ 1046 0;
BA_ "DiagResponse" BO_ 1046 0;
BA_ "GenMsgStartValue" BO_ 1046 "0";
BA_ "GenMsgStartDelayTime" BO_ 1046 100;
BA_ "GenMsgDelayTime" BO_ 1046 20;
BA_ "GenMsgNrOfRepetition" BO_ 1046 0;
BA_ "GenMsgCycleTime" BO_ 1046 200;
BA_ "GenMsgSendType" BO_ 1046 5;
    */
    _VehCarv_Stat_AR_Timebase =      c_tDBKomTimer_20ms;
    _VehCarv_Stat_AR_CycleCount =   	200 / _VehCarv_Stat_AR_Timebase;
    _VehCarv_Stat_AR_StartDelay =    	100 / _VehCarv_Stat_AR_Timebase;
    _VehCarv_Stat_AR_MinDelay =       	 20 / _VehCarv_Stat_AR_Timebase;
    _VehCarv_Stat_AR_Cnt = _VehCarv_Stat_AR_StartDelay;
    _VehCarv_Stat_AR_SpontanFlag = 0;
    _VehCarv_Stat_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_VehCarv_Stat_AR, _VehCarv_Stat_AR_StartDelay * _VehCarv_Stat_AR_Timebase );

    _mVehCarv_Stat_AR.AxleRollMomentRatio_Rs.phys = getValue( HMI_AxleRollMomentRatio_Rs );
    _mVehCarv_Stat_AR.DPC_Md_ABC_Carv_Rs.phys = getValue( HMI_DPC_Md_ABC_Carv_Rs );
    _mVehCarv_Stat_AR.SPC_CarvProg_Stat.phys = getValue( HMI_SPC_CarvProg_Stat );
    _mVehCarv_Stat_AR.VehCarv_Stat.phys = getValue( HMI_VehCarv_Stat );
    _mVehCarv_Stat_AR.VehLoad_Adj_Stat_AMG.phys = getValue( HMI_VehLoad_Adj_Stat_AMG );
    _mVehCarv_Stat_AR.VehLoad_Mass_AMG.phys = getValue( HMI_VehLoad_Mass_AMG );
    _mVehCarv_Stat_AR.VehRollAngl.phys = getValue( HMI_VehRollAngl );
    _mVehCarv_Stat_AR.VehRollAngl_Carv.phys = getValue( HMI_VehRollAngl_Carv );
}

VehCarv_Stat_AR_output(void)
{
    output( _mVehCarv_Stat_AR );
}

VehCarv_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: VehCarv_Stat_AR\n", 27, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_VehCarv_Stat_AR := %X\n", getValue( HMI__STMSG_VehCarv_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_VehCarv_Stat_AR := %X\n", getValue( HMI__STMSGT_VehCarv_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_AxleRollMomentRatio_Rs := %X\n", getValue( HMI_AxleRollMomentRatio_Rs ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DPC_Md_ABC_Carv_Rs := %X\n", getValue( HMI_DPC_Md_ABC_Carv_Rs ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPC_CarvProg_Stat := %X\n", getValue( HMI_SPC_CarvProg_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLoad_Adj_Stat_AMG := %X\n", getValue( HMI_VehLoad_Adj_Stat_AMG ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLoad_Mass_AMG := %X\n", getValue( HMI_VehLoad_Mass_AMG ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehCarv_Stat := %X\n", getValue( HMI_VehCarv_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehRollAngl := %X\n", getValue( HMI_VehRollAngl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehRollAngl_Carv := %X\n", getValue( HMI_VehRollAngl_Carv ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tVehCarv_Stat_AR
{
    putValue( HMI__STMSG_VehCarv_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_VehCarv_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_VehCarv_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tVehCarv_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_VehCarv_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_VehCarv_Stat_AR
{
    if( getValue( this ) )
        openPanel("VehCarv_Stat_AR");
}

on EnvVar HMI_DPC_Md_ABC_Carv_Rs
{
    _mVehCarv_Stat_AR.DPC_Md_ABC_Carv_Rs.phys = getValue(this);
    _VehCarv_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SPC_CarvProg_Stat
{
    _mVehCarv_Stat_AR.SPC_CarvProg_Stat.phys = getValue(this);
    _VehCarv_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_VehCarv_Stat
{
    _mVehCarv_Stat_AR.VehCarv_Stat.phys = getValue(this);
    _VehCarv_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_VehRollAngl
{
    _mVehCarv_Stat_AR.VehRollAngl.phys = getValue(this);
    _VehCarv_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_AxleRollMomentRatio_Rs
{
    _mVehCarv_Stat_AR.AxleRollMomentRatio_Rs.phys = getValue(this);
    _VehCarv_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_VehRollAngl_Carv
{
    _mVehCarv_Stat_AR.VehRollAngl_Carv.phys = getValue(this);
    _VehCarv_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_VehLoad_Adj_Stat_AMG
{
    _mVehCarv_Stat_AR.VehLoad_Adj_Stat_AMG.phys = getValue(this);
    _VehCarv_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_VehLoad_Mass_AMG
{
    _mVehCarv_Stat_AR.VehLoad_Mass_AMG.phys = getValue(this);
    _VehCarv_Stat_AR_SpontanFlag = 1;
}

VehDyn_Stat1_AR_check_output()
{
    if( !getValue( HMI__STMSG_VehDyn_Stat1_AR ) )
    {
    //  message   VehDyn_Stat1_AR ID: 148 --- Sendeart 0 cyclicX --- 
        _VehDyn_Stat1_AR_Cnt--;
        if( _VehDyn_Stat1_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            VehDyn_Stat1_AR_output();
            // Zyklus-Z�hler zur�cksetzen
            _VehDyn_Stat1_AR_Cnt = _VehDyn_Stat1_AR_CycleCount;
        }
    }
}

VehDyn_Stat1_AR_init()
{   /* Botschaft VehDyn_Stat1_AR ID: 148 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 148 0;
BA_ "NmAsrMessage" BO_ 148 0;
BA_ "GenMsgMinAcceptLength" BO_ 148 8;
BA_ "GenMsgILSupport" BO_ 148 1;
BA_ "DiagState" BO_ 148 0;
BA_ "DiagRequest" BO_ 148 0;
BA_ "DiagResponse" BO_ 148 0;
BA_ "GenMsgStartValue" BO_ 148 "0";
BA_ "GenMsgStartDelayTime" BO_ 148 0;
BA_ "GenMsgCycleTime" BO_ 148 20;
BA_ "GenMsgSendType" BO_ 148 0;
    */
    _VehDyn_Stat1_AR_Timebase =      c_tDBKomTimer_20ms;
    _VehDyn_Stat1_AR_CycleCount =     20 / _VehDyn_Stat1_AR_Timebase;
    _VehDyn_Stat1_AR_StartDelay =      0 / _VehDyn_Stat1_AR_Timebase;
    _VehDyn_Stat1_AR_Cnt = _VehDyn_Stat1_AR_StartDelay;

    putValue( HMI__STMSGSD_VehDyn_Stat1_AR, _VehDyn_Stat1_AR_StartDelay * _VehDyn_Stat1_AR_Timebase );


    _mVehDyn_Stat1_AR.Rsrv1_VehDyn_Stat1.phys = getValue( HMI_Rsrv1_VehDyn_Stat1 );
    _mVehDyn_Stat1_AR.SPCR_Excpt_Rq_V2.phys = getValue( HMI_SPCR_Excpt_Rq_V2 );
    _mVehDyn_Stat1_AR.SPCR_Md.phys = getValue( HMI_SPCR_Md );
    _mVehDyn_Stat1_AR.SPCR_Sp_Stat.phys = getValue( HMI_SPCR_Sp_Stat );
    _mVehDyn_Stat1_AR.VehAccel_X_V2.phys = getValue( HMI_VehAccel_X_V2 );
    _mVehDyn_Stat1_AR.VehAccel_X_Offset.phys = getValue( HMI_VehAccel_X_Offset );
    _mVehDyn_Stat1_AR.VehAccel_X_Qual.phys = getValue( HMI_VehAccel_X_Qual );
    _mVehDyn_Stat1_AR.VehAccel_Y_V2.phys = getValue( HMI_VehAccel_Y_V2 );
    _mVehDyn_Stat1_AR.VehAccel_Y_Offset.phys = getValue( HMI_VehAccel_Y_Offset );
    _mVehDyn_Stat1_AR.VehAccel_Y_Qual.phys = getValue( HMI_VehAccel_Y_Qual );
}

VehDyn_Stat1_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_VehDyn_Stat1 ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_VehDyn_Stat1_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _VehDyn_Stat1_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _VehDyn_Stat1_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_VehDyn_Stat1_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _VehDyn_Stat1_AR_SQC_WrongSeqJump != 0 ) &&
            ( _VehDyn_Stat1_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _VehDyn_Stat1_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _VehDyn_Stat1_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _VehDyn_Stat1_AR_SQC_RepeatedCnt ) &&
            ( _VehDyn_Stat1_AR_E2E_Armed == 1  )    )
        {
            _VehDyn_Stat1_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_VehDyn_Stat1, SQC_help );
    }
    _mVehDyn_Stat1_AR.SQC_VehDyn_Stat1 = SQC_help;

    if( getValue( HMI_CRC_VehDyn_Stat1_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_VehDyn_Stat1_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mVehDyn_Stat1_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mVehDyn_Stat1_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mVehDyn_Stat1_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mVehDyn_Stat1_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mVehDyn_Stat1_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mVehDyn_Stat1_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mVehDyn_Stat1_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mVehDyn_Stat1_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _VehDyn_Stat1_AR_CRC_Offset[ _mVehDyn_Stat1_AR.SQC_VehDyn_Stat1 ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _VehDyn_Stat1_AR_CRC_ErrorCnt   && ( _VehDyn_Stat1_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_VehDyn_Stat1_Invalid )                                         )    )
            {
                crc++;
                if( _VehDyn_Stat1_AR_CRC_ErrorCnt > 0 )
                    _VehDyn_Stat1_AR_CRC_ErrorCnt--; 
            }
            _mVehDyn_Stat1_AR.CRC_VehDyn_Stat1 = crc;
            putValue( HMI_CRC_VehDyn_Stat1, crc );
        }
        else
            _mVehDyn_Stat1_AR.CRC_VehDyn_Stat1 = getValue( HMI_CRC_VehDyn_Stat1 );
    }
    else
    {
        if( !getValue( HMI_CRC_VehDyn_Stat1_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mVehDyn_Stat1_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mVehDyn_Stat1_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mVehDyn_Stat1_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mVehDyn_Stat1_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mVehDyn_Stat1_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mVehDyn_Stat1_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mVehDyn_Stat1_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mVehDyn_Stat1_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _VehDyn_Stat1_AR_CRC_ErrorCnt   && ( _VehDyn_Stat1_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_VehDyn_Stat1_Invalid )                                         )    )
            {
                crc++;
                if( _VehDyn_Stat1_AR_CRC_ErrorCnt > 0 )
                    _VehDyn_Stat1_AR_CRC_ErrorCnt--; 
            }
            _mVehDyn_Stat1_AR.CRC_VehDyn_Stat1 = crc;
            putValue( HMI_CRC_VehDyn_Stat1, crc );
        }
        else
            _mVehDyn_Stat1_AR.CRC_VehDyn_Stat1 = getValue( HMI_CRC_VehDyn_Stat1 );
    }
    if( ( _VehDyn_Stat1_AR_MSG_DropCnt > 0 ) &&
        ( _VehDyn_Stat1_AR_E2E_Armed == 1  )    )
    {
        _VehDyn_Stat1_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mVehDyn_Stat1_AR );
        
    if( _VehDyn_Stat1_AR_E2E_Armed == 1 )
    {
        if ( ( _VehDyn_Stat1_AR_MSG_DropCnt == 0      ) &&
             ( _VehDyn_Stat1_AR_CRC_ErrorCnt == 0     ) &&
             ( _VehDyn_Stat1_AR_SQC_RepeatedCnt == 0  ) &&
             ( _VehDyn_Stat1_AR_SQC_WrongSeqJump == 0 )    )
        {
            _VehDyn_Stat1_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_VehDyn_Stat1_State, 0 );
        }
    }
}

VehDyn_Stat1_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: VehDyn_Stat1_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_VehDyn_Stat1_AR := %X\n", getValue( HMI__STMSG_VehDyn_Stat1_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_VehDyn_Stat1_AR := %X\n", getValue( HMI__STMSGT_VehDyn_Stat1_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_BrkTrq_R := %X\n", getValue( HMI_BrkTrq_R ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_VehDyn_Stat1 := %X\n", getValue( HMI_CRC_VehDyn_Stat1 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_VehDyn_Stat1_Auto := %X\n", getValue( HMI_CRC_VehDyn_Stat1_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EPKB_Enbl_Rq := %X\n", getValue( HMI_EPKB_Enbl_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PkBrk_Rq_SPCR := %X\n", getValue( HMI_PkBrk_Rq_SPCR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_VehDyn_Stat1 := %X\n", getValue( HMI_Rsrv1_VehDyn_Stat1 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_VehDyn_Stat1 := %X\n", getValue( HMI_SQC_VehDyn_Stat1 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_VehDyn_Stat1_Auto := %X\n", getValue( HMI_SQC_VehDyn_Stat1_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehAccel_X_V2 := %X\n", getValue( HMI_VehAccel_X_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehAccel_X_Offset := %X\n", getValue( HMI_VehAccel_X_Offset ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehAccel_X_Qual := %X\n", getValue( HMI_VehAccel_X_Qual ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehAccel_Y_V2 := %X\n", getValue( HMI_VehAccel_Y_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehAccel_Y_Offset := %X\n", getValue( HMI_VehAccel_Y_Offset ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehAccel_Y_Qual := %X\n", getValue( HMI_VehAccel_Y_Qual ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tVehDyn_Stat1_AR
{
    putValue( HMI__STMSG_VehDyn_Stat1_AR, 0 );
}

on EnvVar HMI__STMSG_VehDyn_Stat1_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_VehDyn_Stat1_AR );
        if( tDelay > 0)    
            setTimer( _tVehDyn_Stat1_AR, tDelay );
        else
            putValue( HMI__STMSG_VehDyn_Stat1_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_VehDyn_Stat1_AR
{
    if( getValue( this ) )
        openPanel("VehDyn_Stat1_AR");
}

on envVar HMI_E2E_VehDyn_Stat1_Inject
{
    if( getValue( this ) )
    {
        _VehDyn_Stat1_AR_CRC_ErrorCnt = getValue( HMI_CRC_VehDyn_Stat1_ErrorCount );
        _VehDyn_Stat1_AR_SQC_TriggPos = getValue( HMI_SQC_VehDyn_Stat1_TriggerPosition );
        _VehDyn_Stat1_AR_SQC_WrongSeqJump = getValue( HMI_SQC_VehDyn_Stat1_WrongSeq );
        _VehDyn_Stat1_AR_SQC_RepeatedCnt = getValue( HMI_SQC_VehDyn_Stat1_Repeated );
        _VehDyn_Stat1_AR_MSG_DropCnt = getValue( HMI_SQC_VehDyn_Stat1_MSG_DropCnt );
        putValue( HMI_E2E_VehDyn_Stat1_State, 2 );
        _VehDyn_Stat1_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_Rsrv1_VehDyn_Stat1
{
    _mVehDyn_Stat1_AR.Rsrv1_VehDyn_Stat1.phys = getValue(this);
}

on EnvVar HMI_SPCR_Excpt_Rq_V2
{
    _mVehDyn_Stat1_AR.SPCR_Excpt_Rq_V2.phys = getValue(this);
}

on EnvVar HMI_SPCR_Md
{
    _mVehDyn_Stat1_AR.SPCR_Md.phys = getValue(this);
}

on EnvVar HMI_SPCR_Sp_Stat
{
    _mVehDyn_Stat1_AR.SPCR_Sp_Stat.phys = getValue(this);
}

on EnvVar HMI_VehAccel_X_V2
{
    _mVehDyn_Stat1_AR.VehAccel_X_V2.phys = getValue(this);
}

on EnvVar HMI_VehAccel_X_Offset
{
    _mVehDyn_Stat1_AR.VehAccel_X_Offset.phys = getValue(this);
}

on EnvVar HMI_VehAccel_X_Qual
{
    _mVehDyn_Stat1_AR.VehAccel_X_Qual.phys = getValue(this);
}

on EnvVar HMI_VehAccel_Y_V2
{
    _mVehDyn_Stat1_AR.VehAccel_Y_V2.phys = getValue(this);
}

on EnvVar HMI_VehAccel_Y_Offset
{
    _mVehDyn_Stat1_AR.VehAccel_Y_Offset.phys = getValue(this);
}

on EnvVar HMI_VehAccel_Y_Qual
{
    _mVehDyn_Stat1_AR.VehAccel_Y_Qual.phys = getValue(this);
}

VehDyn_Stat2_AR_check_output()
{
    if( !getValue( HMI__STMSG_VehDyn_Stat2_AR ) )
    {
    //  message   VehDyn_Stat2_AR ID: 150 --- Sendeart 0 cyclicX
        _VehDyn_Stat2_AR_Cnt--;
        if( _VehDyn_Stat2_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            VehDyn_Stat2_AR_output();
            // Zyklus-Z�hler zur�cksetzen
            _VehDyn_Stat2_AR_Cnt = _VehDyn_Stat2_AR_CycleCount;
        }
    }
}

VehDyn_Stat2_AR_init()
{   /* Botschaft VehDyn_Stat2_AR ID: 150 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 150 0;
BA_ "NmAsrMessage" BO_ 150 0;
BA_ "GenMsgMinAcceptLength" BO_ 150 8;
BA_ "GenMsgILSupport" BO_ 150 1;
BA_ "DiagState" BO_ 150 0;
BA_ "DiagRequest" BO_ 150 0;
BA_ "DiagResponse" BO_ 150 0;
BA_ "GenMsgStartValue" BO_ 150 "0";
BA_ "GenMsgStartDelayTime" BO_ 150 10;
BA_ "GenMsgCycleTime" BO_ 150 20;
BA_ "GenMsgSendType" BO_ 150 0;
    */
    _VehDyn_Stat2_AR_Timebase =      c_tDBKomTimer_20ms;
    _VehDyn_Stat2_AR_CycleCount =     20 / _VehDyn_Stat2_AR_Timebase;
    _VehDyn_Stat2_AR_StartDelay =     10 / _VehDyn_Stat2_AR_Timebase;
    _VehDyn_Stat2_AR_Cnt = _VehDyn_Stat2_AR_StartDelay;

    putValue( HMI__STMSGSD_VehDyn_Stat2_AR, _VehDyn_Stat2_AR_StartDelay * _VehDyn_Stat2_AR_Timebase );

    _mVehDyn_Stat2_AR.BrkTrq_R.phys = getValue( HMI_BrkTrq_R );
    _mVehDyn_Stat2_AR.EPKB_Enbl_Rq.phys = getValue( HMI_EPKB_Enbl_Rq );
    _mVehDyn_Stat2_AR.PkBrk_Rq_SPCR.phys = getValue( HMI_PkBrk_Rq_SPCR );
    _mVehDyn_Stat2_AR.HSA_Sys_Flt.phys = getValue( HMI_HSA_Sys_Flt );
    _mVehDyn_Stat2_AR.SPCR_AS_Dsabl.phys = getValue( HMI_SPCR_AS_Dsabl );
    _mVehDyn_Stat2_AR.SPCR_AS_Off_Rq.phys = getValue( HMI_SPCR_AS_Off_Rq );
    _mVehDyn_Stat2_AR.SPCR_Style.phys = getValue( HMI_SPCR_Style );
    _mVehDyn_Stat2_AR.SPCR_Veh_Immo.phys = getValue( HMI_SPCR_Veh_Immo );
    _mVehDyn_Stat2_AR.TxPkPosn_Rq_SPCR.phys = getValue( HMI_TxPkPosn_Rq_SPCR );
    _mVehDyn_Stat2_AR.VehYawRate_Raw.phys = getValue( HMI_VehYawRate_Raw );
    _mVehDyn_Stat2_AR.VehYawRate_Raw_Qual.phys = getValue( HMI_VehYawRate_Raw_Qual );
    _mVehDyn_Stat2_AR.VehYawRateOffset_V2.phys = getValue( HMI_VehYawRateOffset_V2 );
}

VehDyn_Stat2_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_VehDyn_Stat2 ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_VehDyn_Stat2_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _VehDyn_Stat2_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _VehDyn_Stat2_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_VehDyn_Stat2_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _VehDyn_Stat2_AR_SQC_WrongSeqJump != 0 ) &&
            ( _VehDyn_Stat2_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _VehDyn_Stat2_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _VehDyn_Stat2_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _VehDyn_Stat2_AR_SQC_RepeatedCnt ) &&
            ( _VehDyn_Stat2_AR_E2E_Armed == 1  )    )
        {
            _VehDyn_Stat2_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_VehDyn_Stat2, SQC_help );
    }
    _mVehDyn_Stat2_AR.SQC_VehDyn_Stat2 = SQC_help;

    if( getValue( HMI_CRC_VehDyn_Stat2_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_VehDyn_Stat2_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mVehDyn_Stat2_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mVehDyn_Stat2_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mVehDyn_Stat2_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mVehDyn_Stat2_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mVehDyn_Stat2_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mVehDyn_Stat2_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mVehDyn_Stat2_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mVehDyn_Stat2_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _VehDyn_Stat2_AR_CRC_Offset[ _mVehDyn_Stat2_AR.SQC_VehDyn_Stat2 ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _VehDyn_Stat2_AR_CRC_ErrorCnt   && ( _VehDyn_Stat2_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_VehDyn_Stat2_Invalid )                                         )    )
            {
                crc++;
                if( _VehDyn_Stat2_AR_CRC_ErrorCnt > 0 )
                    _VehDyn_Stat2_AR_CRC_ErrorCnt--; 
            }
            _mVehDyn_Stat2_AR.CRC_VehDyn_Stat2 = crc;
            putValue( HMI_CRC_VehDyn_Stat2, crc );
        }
        else
            _mVehDyn_Stat2_AR.CRC_VehDyn_Stat2 = getValue( HMI_CRC_VehDyn_Stat2 );
    }
    else
    {
        if( !getValue( HMI_CRC_VehDyn_Stat2_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mVehDyn_Stat2_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mVehDyn_Stat2_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mVehDyn_Stat2_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mVehDyn_Stat2_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mVehDyn_Stat2_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mVehDyn_Stat2_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mVehDyn_Stat2_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mVehDyn_Stat2_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _VehDyn_Stat2_AR_CRC_ErrorCnt   && ( _VehDyn_Stat2_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_VehDyn_Stat2_Invalid )                                         )    )
            {
                crc++;
                if( _VehDyn_Stat2_AR_CRC_ErrorCnt > 0 )
                    _VehDyn_Stat2_AR_CRC_ErrorCnt--; 
            }
            _mVehDyn_Stat2_AR.CRC_VehDyn_Stat2 = crc;
            putValue( HMI_CRC_VehDyn_Stat2, crc );
        }
        else
            _mVehDyn_Stat2_AR.CRC_VehDyn_Stat2 = getValue( HMI_CRC_VehDyn_Stat2 );
    }
    if( ( _VehDyn_Stat2_AR_MSG_DropCnt > 0 ) &&
        ( _VehDyn_Stat2_AR_E2E_Armed == 1  )    )
    {
        _VehDyn_Stat2_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mVehDyn_Stat2_AR );
        
    if( _VehDyn_Stat2_AR_E2E_Armed == 1 )
    {
        if ( ( _VehDyn_Stat2_AR_MSG_DropCnt == 0      ) &&
             ( _VehDyn_Stat2_AR_CRC_ErrorCnt == 0     ) &&
             ( _VehDyn_Stat2_AR_SQC_RepeatedCnt == 0  ) &&
             ( _VehDyn_Stat2_AR_SQC_WrongSeqJump == 0 )    )
        {
            _VehDyn_Stat2_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_VehDyn_Stat2_State, 0 );
        }
    }
}

VehDyn_Stat2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: VehDyn_Stat2_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_VehDyn_Stat2_AR := %X\n", getValue( HMI__STMSG_VehDyn_Stat2_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_VehDyn_Stat2_AR := %X\n", getValue( HMI__STMSGT_VehDyn_Stat2_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_VehDyn_Stat2 := %X\n", getValue( HMI_CRC_VehDyn_Stat2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_VehDyn_Stat2_Auto := %X\n", getValue( HMI_CRC_VehDyn_Stat2_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HSA_Sys_Flt := %X\n", getValue( HMI_HSA_Sys_Flt ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPCR_AS_Dsabl := %X\n", getValue( HMI_SPCR_AS_Dsabl ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPCR_AS_Off_Rq := %X\n", getValue( HMI_SPCR_AS_Off_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPCR_Excpt_Rq_V2 := %X\n", getValue( HMI_SPCR_Excpt_Rq_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPCR_Md := %X\n", getValue( HMI_SPCR_Md ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPCR_Sp_Stat := %X\n", getValue( HMI_SPCR_Sp_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPCR_Style := %X\n", getValue( HMI_SPCR_Style ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SPCR_Veh_Immo := %X\n", getValue( HMI_SPCR_Veh_Immo ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_VehDyn_Stat2 := %X\n", getValue( HMI_SQC_VehDyn_Stat2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_VehDyn_Stat2_Auto := %X\n", getValue( HMI_SQC_VehDyn_Stat2_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_TxPkPosn_Rq_SPCR := %X\n", getValue( HMI_TxPkPosn_Rq_SPCR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehYawRate_Raw := %X\n", getValue( HMI_VehYawRate_Raw ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehYawRate_Raw_Qual := %X\n", getValue( HMI_VehYawRate_Raw_Qual ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehYawRateOffset_V2 := %X\n", getValue( HMI_VehYawRateOffset_V2 ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tVehDyn_Stat2_AR
{
    putValue( HMI__STMSG_VehDyn_Stat2_AR, 0 );
}

on EnvVar HMI__STMSG_VehDyn_Stat2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_VehDyn_Stat2_AR );
        if( tDelay > 0)    
            setTimer( _tVehDyn_Stat2_AR, tDelay );
        else
            putValue( HMI__STMSG_VehDyn_Stat2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_VehDyn_Stat2_AR
{
    if( getValue( this ) )
        openPanel("VehDyn_Stat2_AR");
}

on envVar HMI_E2E_VehDyn_Stat2_Inject
{
    if( getValue( this ) )
    {
        _VehDyn_Stat2_AR_CRC_ErrorCnt = getValue( HMI_CRC_VehDyn_Stat2_ErrorCount );
        _VehDyn_Stat2_AR_SQC_TriggPos = getValue( HMI_SQC_VehDyn_Stat2_TriggerPosition );
        _VehDyn_Stat2_AR_SQC_WrongSeqJump = getValue( HMI_SQC_VehDyn_Stat2_WrongSeq );
        _VehDyn_Stat2_AR_SQC_RepeatedCnt = getValue( HMI_SQC_VehDyn_Stat2_Repeated );
        _VehDyn_Stat2_AR_MSG_DropCnt = getValue( HMI_SQC_VehDyn_Stat2_MSG_DropCnt );
        putValue( HMI_E2E_VehDyn_Stat2_State, 2 );
        _VehDyn_Stat2_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_BrkTrq_R
{
    _mVehDyn_Stat2_AR.BrkTrq_R.phys = getValue(this);
}

on EnvVar HMI_EPKB_Enbl_Rq
{
    _mVehDyn_Stat2_AR.EPKB_Enbl_Rq.phys = getValue(this);
}

on EnvVar HMI_HSA_Sys_Flt
{
    _mVehDyn_Stat2_AR.HSA_Sys_Flt.phys = getValue(this);
}

on EnvVar HMI_PkBrk_Rq_SPCR
{
    _mVehDyn_Stat2_AR.PkBrk_Rq_SPCR.phys = getValue(this);
}

on EnvVar HMI_SPCR_AS_Dsabl
{
    _mVehDyn_Stat2_AR.SPCR_AS_Dsabl.phys = getValue(this);
}

on EnvVar HMI_SPCR_AS_Off_Rq
{
    _mVehDyn_Stat2_AR.SPCR_AS_Off_Rq.phys = getValue(this);
}

on EnvVar HMI_SPCR_Style
{
    _mVehDyn_Stat2_AR.SPCR_Style.phys = getValue(this);
}

on EnvVar HMI_SPCR_Veh_Immo
{
    _mVehDyn_Stat2_AR.SPCR_Veh_Immo.phys = getValue(this);
}

on EnvVar HMI_TxPkPosn_Rq_SPCR
{
    _mVehDyn_Stat2_AR.TxPkPosn_Rq_SPCR.phys = getValue(this);
}

on EnvVar HMI_VehYawRate_Raw
{
    _mVehDyn_Stat2_AR.VehYawRate_Raw.phys = getValue(this);
}

on EnvVar HMI_VehYawRate_Raw_Qual
{
    _mVehDyn_Stat2_AR.VehYawRate_Raw_Qual.phys = getValue(this);
}

on EnvVar HMI_VehYawRateOffset_V2
{
    _mVehDyn_Stat2_AR.VehYawRateOffset_V2.phys = getValue(this);
}

VehLvl_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_VehLvl_Stat_AR ) )
    {
    //  message   VehLvl_Stat_AR ID: 172 --- Sendeart 0 cyclicX --- 
        _VehLvl_Stat_AR_Cnt--;
        if( _VehLvl_Stat_AR_Cnt < 1 )
        {
            VehLvl_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _VehLvl_Stat_AR_Cnt = _VehLvl_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

VehLvl_Stat_AR_init()
{   /* Botschaft VehLvl_Stat_AR ID: 172 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 172 0;
BA_ "NmAsrMessage" BO_ 172 0;
BA_ "GenMsgMinAcceptLength" BO_ 172 8;
BA_ "GenMsgILSupport" BO_ 172 1;
BA_ "DiagState" BO_ 172 0;
BA_ "DiagRequest" BO_ 172 0;
BA_ "DiagResponse" BO_ 172 0;
BA_ "GenMsgStartValue" BO_ 172 "0";
BA_ "GenMsgStartDelayTime" BO_ 172 0;
BA_ "GenMsgCycleTime" BO_ 172 20;
BA_ "GenMsgSendType" BO_ 172 0;
    */
    _VehLvl_Stat_AR_Timebase =         c_tDBKomTimer_20ms;
    _VehLvl_Stat_AR_CycleCount =      20 / _VehLvl_Stat_AR_Timebase;
    _VehLvl_Stat_AR_StartDelay =       0 / _VehLvl_Stat_AR_Timebase;
    _VehLvl_Stat_AR_Cnt = _VehLvl_Stat_AR_StartDelay;

    putValue( HMI__STMSGSD_VehLvl_Stat_AR, _VehLvl_Stat_AR_StartDelay * _VehLvl_Stat_AR_Timebase );

    _mVehLvl_Stat_AR.LvlCal_Exec.phys = getValue( HMI_LvlCal_Exec );
    _mVehLvl_Stat_AR.Rsrv1_VehLvl_Stat.phys = getValue( HMI_Rsrv1_VehLvl_Stat );
    _mVehLvl_Stat_AR.VehLoad_Stat.phys = getValue( HMI_VehLoad_Stat );
    _mVehLvl_Stat_AR.VehLoad_Stat_Vld.phys = getValue( HMI_VehLoad_Stat_Vld );
    _mVehLvl_Stat_AR.VehLvl_FL.phys = getValue( HMI_VehLvl_FL );
    _mVehLvl_Stat_AR.VehLvl_FR.phys = getValue( HMI_VehLvl_FR );
    _mVehLvl_Stat_AR.VehLvl_Rel.phys = getValue( HMI_VehLvl_Rel );
    _mVehLvl_Stat_AR.VehLvl_RL.phys = getValue( HMI_VehLvl_RL );
    _mVehLvl_Stat_AR.VehLvl_RR.phys = getValue( HMI_VehLvl_RR );
}

VehLvl_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_VehLvl_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_VehLvl_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _VehLvl_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _VehLvl_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_VehLvl_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _VehLvl_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _VehLvl_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _VehLvl_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _VehLvl_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _VehLvl_Stat_AR_SQC_RepeatedCnt ) &&
            ( _VehLvl_Stat_AR_E2E_Armed == 1  )    )
        {
            _VehLvl_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_VehLvl_Stat, SQC_help );
    }
    _mVehLvl_Stat_AR.SQC_VehLvl_Stat = SQC_help;

    if( getValue( HMI_CRC_VehLvl_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_VehLvl_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mVehLvl_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mVehLvl_Stat_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mVehLvl_Stat_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mVehLvl_Stat_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mVehLvl_Stat_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mVehLvl_Stat_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mVehLvl_Stat_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mVehLvl_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _VehLvl_Stat_AR_CRC_Offset[ _mVehLvl_Stat_AR.SQC_VehLvl_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _VehLvl_Stat_AR_CRC_ErrorCnt   && ( _VehLvl_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_VehLvl_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _VehLvl_Stat_AR_CRC_ErrorCnt > 0 )
                    _VehLvl_Stat_AR_CRC_ErrorCnt--; 
            }
            _mVehLvl_Stat_AR.CRC_VehLvl_Stat = crc;
            putValue( HMI_CRC_VehLvl_Stat, crc );
        }
        else
            _mVehLvl_Stat_AR.CRC_VehLvl_Stat = getValue( HMI_CRC_VehLvl_Stat );
    }
    if( ( _VehLvl_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _VehLvl_Stat_AR_E2E_Armed == 1  )    )
    {
        _VehLvl_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mVehLvl_Stat_AR );
        
    if( _VehLvl_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _VehLvl_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _VehLvl_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _VehLvl_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _VehLvl_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _VehLvl_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_VehLvl_Stat_State, 0 );
        }
    }
}

VehLvl_Stat_AR_saveEnvVars( dword hFile )
{
        filePutString("\n// Knoten EIS: VehLvl_Stat_AR\n", 28, hFile );
        snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_VehLvl_Stat_AR := %X\n", getValue( HMI__STMSG_VehLvl_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
        snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_VehLvl_Stat_AR := %X\n", getValue( HMI__STMSGT_VehLvl_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
        snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_VehLvl_Stat := %X\n", getValue( HMI_CRC_VehLvl_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
        snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_VehLvl_Stat_Auto := %X\n", getValue( HMI_CRC_VehLvl_Stat_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
        snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_VehLvl_Stat_Profile_02     := %X\n", getValue( HMI_CRC_VehLvl_Stat_Profile_02 ) );        filePutString( buffer, elcount( buffer ), hFile );
        snprintf( buffer, elcount( buffer ), "0.0000 HMI_LvlCal_Exec := %X\n", getValue( HMI_LvlCal_Exec ) );        filePutString( buffer, elcount( buffer ), hFile );
        snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_VehLvl_Stat := %X\n", getValue( HMI_Rsrv1_VehLvl_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
        snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_VehLvl_Stat := %X\n", getValue( HMI_SQC_VehLvl_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
        snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_VehLvl_Stat_Auto := %X\n", getValue( HMI_SQC_VehLvl_Stat_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
        snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLoad_Stat := %X\n", getValue( HMI_VehLoad_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
        snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLoad_Stat_Vld := %X\n", getValue( HMI_VehLoad_Stat_Vld ) );        filePutString( buffer, elcount( buffer ), hFile );
        snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLvl_FL := %X\n", getValue( HMI_VehLvl_FL ) );        filePutString( buffer, elcount( buffer ), hFile );
        snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLvl_FR := %X\n", getValue( HMI_VehLvl_FR ) );        filePutString( buffer, elcount( buffer ), hFile );
        snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLvl_Rel := %X\n", getValue( HMI_VehLvl_Rel ) );        filePutString( buffer, elcount( buffer ), hFile );
        snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLvl_RL := %X\n", getValue( HMI_VehLvl_RL ) );        filePutString( buffer, elcount( buffer ), hFile );
        snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehLvl_RR := %X\n", getValue( HMI_VehLvl_RR ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tVehLvl_Stat_AR
{
    putValue( HMI__STMSG_VehLvl_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_VehLvl_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_VehLvl_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tVehLvl_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_VehLvl_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_VehLvl_Stat_AR
{
    if( getValue( this ) )
        openPanel("VehLvl_Stat_AR");
}

on envVar HMI_E2E_VehLvl_Stat_Inject
{
    if( getValue( this ) )
    {
        _VehLvl_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_VehLvl_Stat_ErrorCount );
        _VehLvl_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_VehLvl_Stat_TriggerPosition );
        _VehLvl_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_VehLvl_Stat_WrongSeq );
        _VehLvl_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_VehLvl_Stat_Repeated );
        _VehLvl_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_VehLvl_Stat_MSG_DropCnt );
        putValue( HMI_E2E_VehLvl_Stat_State, 2 );
        _VehLvl_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_LvlCal_Exec
{
    _mVehLvl_Stat_AR.LvlCal_Exec.phys = getValue(this);
}

on EnvVar HMI_Rsrv1_VehLvl_Stat
{
    _mVehLvl_Stat_AR.Rsrv1_VehLvl_Stat.phys = getValue(this);
}

on EnvVar HMI_VehLoad_Stat
{
    _mVehLvl_Stat_AR.VehLoad_Stat.phys = getValue(this);
}

on EnvVar HMI_VehLoad_Stat_Vld
{
    _mVehLvl_Stat_AR.VehLoad_Stat_Vld.phys = getValue(this);
}

on EnvVar HMI_VehLvl_FL
{
    _mVehLvl_Stat_AR.VehLvl_FL.phys = getValue(this);
}

on EnvVar HMI_VehLvl_FR
{
    _mVehLvl_Stat_AR.VehLvl_FR.phys = getValue(this);
}

on EnvVar HMI_VehLvl_Rel
{
    _mVehLvl_Stat_AR.VehLvl_Rel.phys = getValue(this);
}

on EnvVar HMI_VehLvl_RL
{
    _mVehLvl_Stat_AR.VehLvl_RL.phys = getValue(this);
}

on EnvVar HMI_VehLvl_RR
{
    _mVehLvl_Stat_AR.VehLvl_RR.phys = getValue(this);
}

VehPwrMngmnt_EMM_Stat2_AR_check_output()
{
    if( !getValue( HMI__STMSG_VehPwrMngmnt_EMM_Stat2_AR ) )
    {
    //  message   VehPwrMngmnt_EMM_Stat2_AR ID: 1185 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _VehPwrMngmnt_EMM_Stat2_AR_DelayCnt > 0) _VehPwrMngmnt_EMM_Stat2_AR_DelayCnt--; // Mindestsendeabstand
        _VehPwrMngmnt_EMM_Stat2_AR_Cnt--;
        if( _VehPwrMngmnt_EMM_Stat2_AR_Cnt < 1 )
        {
            if( _VehPwrMngmnt_EMM_Stat2_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                VehPwrMngmnt_EMM_Stat2_AR_output();
                _VehPwrMngmnt_EMM_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _VehPwrMngmnt_EMM_Stat2_AR_DelayCnt = _VehPwrMngmnt_EMM_Stat2_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _VehPwrMngmnt_EMM_Stat2_AR_SpontanFlag = 1;
            }
            _VehPwrMngmnt_EMM_Stat2_AR_Cnt = _VehPwrMngmnt_EMM_Stat2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _VehPwrMngmnt_EMM_Stat2_AR_SpontanFlag)
        {
            if( _VehPwrMngmnt_EMM_Stat2_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                VehPwrMngmnt_EMM_Stat2_AR_output();
                _VehPwrMngmnt_EMM_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _VehPwrMngmnt_EMM_Stat2_AR_DelayCnt = _VehPwrMngmnt_EMM_Stat2_AR_MinDelay;
            }
        }
    }
}

VehPwrMngmnt_EMM_Stat2_AR_init()
{   /* Botschaft VehPwrMngmnt_EMM_Stat2_AR ID: 1185 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1185 0;
BA_ "NmAsrMessage" BO_ 1185 0;
BA_ "GenMsgMinAcceptLength" BO_ 1185 8;
BA_ "GenMsgILSupport" BO_ 1185 1;
BA_ "DiagState" BO_ 1185 0;
BA_ "DiagRequest" BO_ 1185 0;
BA_ "DiagResponse" BO_ 1185 0;
BA_ "GenMsgStartValue" BO_ 1185 "0";
BA_ "GenMsgStartDelayTime" BO_ 1185   0;
BA_ "GenMsgDelayTime" BO_ 1185 200;
BA_ "GenMsgNrOfRepetitions" BO_ 1185 0;
BA_ "GenMsgCycleTime" BO_ 1185 1000;
BA_ "GenMsgSendType" BO_ 1185 5;
    */
    _VehPwrMngmnt_EMM_Stat2_AR_Timebase =      c_tDBKomTimer_20ms;
    _VehPwrMngmnt_EMM_Stat2_AR_CycleCount =   1000 / _VehPwrMngmnt_EMM_Stat2_AR_Timebase;
    _VehPwrMngmnt_EMM_Stat2_AR_StartDelay =      0 / _VehPwrMngmnt_EMM_Stat2_AR_Timebase;
    _VehPwrMngmnt_EMM_Stat2_AR_MinDelay =      200 / _VehPwrMngmnt_EMM_Stat2_AR_Timebase;
    _VehPwrMngmnt_EMM_Stat2_AR_Cnt = _VehPwrMngmnt_EMM_Stat2_AR_StartDelay;
    _VehPwrMngmnt_EMM_Stat2_AR_SpontanFlag = 0;
    _VehPwrMngmnt_EMM_Stat2_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_VehPwrMngmnt_EMM_Stat2_AR, _VehPwrMngmnt_EMM_Stat2_AR_StartDelay * _VehPwrMngmnt_EMM_Stat2_AR_Timebase );

    _mVehPwrMngmnt_EMM_Stat2_AR.EMM_DriveNoShift.phys = getValue( HMI_EMM_DriveNoShift );
    _mVehPwrMngmnt_EMM_Stat2_AR.EMM_TowProhibit_MsgDisp_Rq.phys = getValue( HMI_EMM_TowProhibit_MsgDisp_Rq );
    _mVehPwrMngmnt_EMM_Stat2_AR.PNHV_EnergyConsReset.phys = getValue( HMI_PNHV_EnergyConsReset );
    _mVehPwrMngmnt_EMM_Stat2_AR.PNHV_EnergyConsStart.phys = getValue( HMI_PNHV_EnergyConsStart );
    _mVehPwrMngmnt_EMM_Stat2_AR.PNHV_HV_WarnLmp_On_Rq.phys = getValue( HMI_PNHV_HV_WarnLmp_On_Rq );
    _mVehPwrMngmnt_EMM_Stat2_AR.PNHV_NoEngStart_Disp_Rq.phys = getValue( HMI_PNHV_NoEngStart_Disp_Rq );
    _mVehPwrMngmnt_EMM_Stat2_AR.PNHV_PN14_QuiesCurr_Md_Rq.phys = getValue( HMI_PNHV_PN14_QuiesCurr_Md_Rq );
    _mVehPwrMngmnt_EMM_Stat2_AR.PNHV_Term61_WarnIcon_Disp_Rq.phys = getValue( HMI_PNHV_Term61_WarnIcon_Disp_Rq );
    _mVehPwrMngmnt_EMM_Stat2_AR.Rsrv1_EMM_Disp_Rq.phys = getValue( HMI_Rsrv1_EMM_Disp_Rq );
    _mVehPwrMngmnt_EMM_Stat2_AR.PNHV_ChrgFlapSens_Stat_Disp_Rq.phys = getValue( HMI_PNHV_ChrgFlapSens_Stat_Disp_Rq );
    _mVehPwrMngmnt_EMM_Stat2_AR.ElecPwr_Avl_Disp.phys = getValue( HMI_ElecPwr_Avl_Disp );
}

VehPwrMngmnt_EMM_Stat2_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_EMM_Disp_Rq ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_EMM_Disp_Rq_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _VehPwrMngmnt_EMM_Stat2_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _VehPwrMngmnt_EMM_Stat2_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_EMM_Disp_Rq_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _VehPwrMngmnt_EMM_Stat2_AR_SQC_WrongSeqJump != 0 ) &&
            ( _VehPwrMngmnt_EMM_Stat2_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _VehPwrMngmnt_EMM_Stat2_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _VehPwrMngmnt_EMM_Stat2_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _VehPwrMngmnt_EMM_Stat2_AR_SQC_RepeatedCnt ) &&
            ( _VehPwrMngmnt_EMM_Stat2_AR_E2E_Armed == 1  )    )
        {
            _VehPwrMngmnt_EMM_Stat2_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_EMM_Disp_Rq, SQC_help );
    }
    _mVehPwrMngmnt_EMM_Stat2_AR.SQC_EMM_Disp_Rq = SQC_help;

    if( getValue( HMI_CRC_EMM_Disp_Rq_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_EMM_Disp_Rq_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mVehPwrMngmnt_EMM_Stat2_AR.byte( 0 ) ];
//            crc = crctable_profile02[ crc ^ _mVehPwrMngmnt_EMM_Stat2_AR.byte( 1 ) ];
//            crc = crctable_profile02[ crc ^ _mVehPwrMngmnt_EMM_Stat2_AR.byte( 2 ) ];
//            crc = crctable_profile02[ crc ^ _mVehPwrMngmnt_EMM_Stat2_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mVehPwrMngmnt_EMM_Stat2_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mVehPwrMngmnt_EMM_Stat2_AR.byte( 5 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mVehPwrMngmnt_EMM_Stat2_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mVehPwrMngmnt_EMM_Stat2_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _VehPwrMngmnt_EMM_Stat2_AR_CRC_Offset[ _mVehPwrMngmnt_EMM_Stat2_AR.SQC_EMM_Disp_Rq ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _VehPwrMngmnt_EMM_Stat2_AR_CRC_ErrorCnt   && ( _VehPwrMngmnt_EMM_Stat2_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EMM_Disp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _VehPwrMngmnt_EMM_Stat2_AR_CRC_ErrorCnt > 0 )
                    _VehPwrMngmnt_EMM_Stat2_AR_CRC_ErrorCnt--; 
            }
            _mVehPwrMngmnt_EMM_Stat2_AR.CRC_EMM_Disp_Rq = crc;
            putValue( HMI_CRC_EMM_Disp_Rq, crc );
        }
        else
            _mVehPwrMngmnt_EMM_Stat2_AR.CRC_EMM_Disp_Rq = getValue( HMI_CRC_EMM_Disp_Rq );
    }
    else
    {
        if( !getValue( HMI_CRC_EMM_Disp_Rq_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mVehPwrMngmnt_EMM_Stat2_AR.byte( 0 ) ];
//            crc = crctable[ crc ^ _mVehPwrMngmnt_EMM_Stat2_AR.byte( 1 ) ];
//            crc = crctable[ crc ^ _mVehPwrMngmnt_EMM_Stat2_AR.byte( 2 ) ];
//            crc = crctable[ crc ^ _mVehPwrMngmnt_EMM_Stat2_AR.byte( 3 ) ];
//            crc = crctable[ crc ^ _mVehPwrMngmnt_EMM_Stat2_AR.byte( 4 ) ];
//            crc = crctable[ crc ^ _mVehPwrMngmnt_EMM_Stat2_AR.byte( 5 ) ];  CRC
            crc = crctable[ crc ^ _mVehPwrMngmnt_EMM_Stat2_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mVehPwrMngmnt_EMM_Stat2_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _VehPwrMngmnt_EMM_Stat2_AR_CRC_ErrorCnt   && ( _VehPwrMngmnt_EMM_Stat2_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_EMM_Disp_Rq_Invalid )                                         )    )
            {
                crc++;
                if( _VehPwrMngmnt_EMM_Stat2_AR_CRC_ErrorCnt > 0 )
                    _VehPwrMngmnt_EMM_Stat2_AR_CRC_ErrorCnt--; 
            }
            _mVehPwrMngmnt_EMM_Stat2_AR.CRC_EMM_Disp_Rq = crc;
            putValue( HMI_CRC_EMM_Disp_Rq, crc );
        }
        else
            _mVehPwrMngmnt_EMM_Stat2_AR.CRC_EMM_Disp_Rq = getValue( HMI_CRC_EMM_Disp_Rq );
    }
    if( ( _VehPwrMngmnt_EMM_Stat2_AR_MSG_DropCnt > 0 ) &&
        ( _VehPwrMngmnt_EMM_Stat2_AR_E2E_Armed == 1  )    )
    {
        _VehPwrMngmnt_EMM_Stat2_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mVehPwrMngmnt_EMM_Stat2_AR );
        
    if( _VehPwrMngmnt_EMM_Stat2_AR_E2E_Armed == 1 )
    {
        if ( ( _VehPwrMngmnt_EMM_Stat2_AR_MSG_DropCnt == 0      ) &&
             ( _VehPwrMngmnt_EMM_Stat2_AR_CRC_ErrorCnt == 0     ) &&
             ( _VehPwrMngmnt_EMM_Stat2_AR_SQC_RepeatedCnt == 0  ) &&
             ( _VehPwrMngmnt_EMM_Stat2_AR_SQC_WrongSeqJump == 0 )    )
        {
            _VehPwrMngmnt_EMM_Stat2_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_EMM_Disp_Rq_State, 0 );
        }
    }
}

VehPwrMngmnt_EMM_Stat2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: VehPwrMngmnt_EMM_Stat2_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_VehPwrMngmnt_EMM_Stat2_AR := %X\n", getValue( HMI__STMSG_VehPwrMngmnt_EMM_Stat2_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_VehPwrMngmnt_EMM_Stat2_AR := %X\n", getValue( HMI__STMSGT_VehPwrMngmnt_EMM_Stat2_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EMM_Disp_Rq := %X\n", getValue( HMI_CRC_EMM_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EMM_Disp_Rq_Auto := %X\n", getValue( HMI_CRC_EMM_Disp_Rq_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_EMM_Disp_Rq_Profile_02 := %X\n", getValue( HMI_CRC_EMM_Disp_Rq_Profile_02 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EMM_DriveNoShift := %X\n", getValue( HMI_EMM_DriveNoShift ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_EMM_TowProhibit_MsgDisp_Rq := %X\n", getValue( HMI_EMM_TowProhibit_MsgDisp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_EnergyConsReset := %X\n", getValue( HMI_PNHV_EnergyConsReset ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_EnergyConsStart := %X\n", getValue( HMI_PNHV_EnergyConsStart ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_HV_WarnLmp_On_Rq := %X\n", getValue( HMI_PNHV_HV_WarnLmp_On_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_NoEngStart_Disp_Rq := %X\n", getValue( HMI_PNHV_NoEngStart_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_PN14_QuiesCurr_Md_Rq := %X\n", getValue( HMI_PNHV_PN14_QuiesCurr_Md_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_Term61_WarnIcon_Disp_Rq := %X\n", getValue( HMI_PNHV_Term61_WarnIcon_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_EMM_Disp_Rq := %X\n", getValue( HMI_Rsrv1_EMM_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EMM_Disp_Rq := %X\n", getValue( HMI_SQC_EMM_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_EMM_Disp_Rq_Auto := %X\n", getValue( HMI_SQC_EMM_Disp_Rq_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_ChrgFlapSens_Stat_Disp_Rq := %X\n", getValue( HMI_PNHV_ChrgFlapSens_Stat_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_ElecPwr_Avl_Disp := %X\n", getValue( HMI_ElecPwr_Avl_Disp ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tVehPwrMngmnt_EMM_Stat2_AR
{
    putValue( HMI__STMSG_VehPwrMngmnt_EMM_Stat2_AR, 0 );
}

on EnvVar HMI__STMSG_VehPwrMngmnt_EMM_Stat2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_VehPwrMngmnt_EMM_Stat2_AR );
        if( tDelay > 0)    
            setTimer( _tVehPwrMngmnt_EMM_Stat2_AR, tDelay );
        else
            putValue( HMI__STMSG_VehPwrMngmnt_EMM_Stat2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_VehPwrMngmnt_EMM_Stat2_AR
{
    if( getValue( this ) )
        openPanel("VehPwrMngmnt_EMM_Stat2_AR");
}

on envVar HMI_E2E_EMM_Disp_Rq_Inject
{
    if( getValue( this ) )
    {
        _VehPwrMngmnt_EMM_Stat2_AR_CRC_ErrorCnt = getValue( HMI_CRC_EMM_Disp_Rq_ErrorCount );
        _VehPwrMngmnt_EMM_Stat2_AR_SQC_TriggPos = getValue( HMI_SQC_EMM_Disp_Rq_TriggerPosition );
        _VehPwrMngmnt_EMM_Stat2_AR_SQC_WrongSeqJump = getValue( HMI_SQC_EMM_Disp_Rq_WrongSeq );
        _VehPwrMngmnt_EMM_Stat2_AR_SQC_RepeatedCnt = getValue( HMI_SQC_EMM_Disp_Rq_Repeated );
        _VehPwrMngmnt_EMM_Stat2_AR_MSG_DropCnt = getValue( HMI_SQC_EMM_Disp_Rq_MSG_DropCnt );
        putValue( HMI_E2E_EMM_Disp_Rq_State, 2 );
        _VehPwrMngmnt_EMM_Stat2_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_EMM_DriveNoShift
{
    _mVehPwrMngmnt_EMM_Stat2_AR.EMM_DriveNoShift.phys = getValue(this);
    _VehPwrMngmnt_EMM_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_EMM_TowProhibit_MsgDisp_Rq
{
    _mVehPwrMngmnt_EMM_Stat2_AR.EMM_TowProhibit_MsgDisp_Rq.phys = getValue(this);
    _VehPwrMngmnt_EMM_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_EnergyConsReset
{
    _mVehPwrMngmnt_EMM_Stat2_AR.PNHV_EnergyConsReset.phys = getValue(this);
    _VehPwrMngmnt_EMM_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_EnergyConsStart
{
    _mVehPwrMngmnt_EMM_Stat2_AR.PNHV_EnergyConsStart.phys = getValue(this);
    _VehPwrMngmnt_EMM_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_HV_WarnLmp_On_Rq
{
    _mVehPwrMngmnt_EMM_Stat2_AR.PNHV_HV_WarnLmp_On_Rq.phys = getValue(this);
    _VehPwrMngmnt_EMM_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_NoEngStart_Disp_Rq
{
    _mVehPwrMngmnt_EMM_Stat2_AR.PNHV_NoEngStart_Disp_Rq.phys = getValue(this);
    _VehPwrMngmnt_EMM_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_PN14_QuiesCurr_Md_Rq
{
    _mVehPwrMngmnt_EMM_Stat2_AR.PNHV_PN14_QuiesCurr_Md_Rq.phys = getValue(this);
    _VehPwrMngmnt_EMM_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_Term61_WarnIcon_Disp_Rq
{
    _mVehPwrMngmnt_EMM_Stat2_AR.PNHV_Term61_WarnIcon_Disp_Rq.phys = getValue(this);
    _VehPwrMngmnt_EMM_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv1_EMM_Disp_Rq
{
    _mVehPwrMngmnt_EMM_Stat2_AR.Rsrv1_EMM_Disp_Rq.phys = getValue(this);
    _VehPwrMngmnt_EMM_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_PNHV_ChrgFlapSens_Stat_Disp_Rq
{
    _mVehPwrMngmnt_EMM_Stat2_AR.PNHV_ChrgFlapSens_Stat_Disp_Rq.phys = getValue(this);
    _VehPwrMngmnt_EMM_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_ElecPwr_Avl_Disp
{
    _mVehPwrMngmnt_EMM_Stat2_AR.ElecPwr_Avl_Disp.phys = getValue(this);
    _VehPwrMngmnt_EMM_Stat2_AR_SpontanFlag = 1;
}

VehSpd_X_AR_check_output()
{
    if( !getValue( HMI__STMSG_VehSpd_X_AR ) )
    {
        _VehSpd_X_AR_Cnt--;
        if( _VehSpd_X_AR_Cnt < 1 )
        {
            VehSpd_X_AR_output();  // Nachricht wg. abgelaufenem Zyklus ausgeben
            _VehSpd_X_AR_Cnt = _VehSpd_X_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

VehSpd_X_AR_init()
{   /* Botschaft VehSpd_X_AR ID: 152 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 152 0;
BA_ "NmAsrMessage" BO_ 152 0;
BA_ "GenMsgMinAcceptLength" BO_ 152 8;
BA_ "GenMsgILSupport" BO_ 152 1;
BA_ "DiagState" BO_ 152 0;
BA_ "DiagRequest" BO_ 152 0;
BA_ "DiagResponse" BO_ 152 0;
BA_ "GenMsgStartValue" BO_ 152 "0";
BA_ "GenMsgCycleTime" BO_ 152 20;
BA_ "GenMsgSendType" BO_ 152 0;
    */
    _VehSpd_X_AR_Timebase =      c_tDBKomTimer_20ms;
    _VehSpd_X_AR_CycleCount =     20 / _VehSpd_X_AR_Timebase;
    _VehSpd_X_AR_StartDelay =      0 / _VehSpd_X_AR_Timebase;
    _VehSpd_X_AR_Cnt = _VehSpd_X_AR_StartDelay;

    putValue( HMI__STMSGSD_VehSpd_X_AR, _VehSpd_X_AR_StartDelay * _VehSpd_X_AR_Timebase );

    _mVehSpd_X_AR.CRC_VehSpd_X.phys = getValue( HMI_CRC_VehSpd_X );
    _mVehSpd_X_AR.DiffLk_Deactv_Rq_ESP.phys = getValue( HMI_DiffLk_Deactv_Rq_ESP );
    _mVehSpd_X_AR.SQC_VehSpd_X.phys = getValue( HMI_SQC_VehSpd_X );
    _mVehSpd_X_AR.StWhl_Angl_CarvOffset.phys = getValue( HMI_StWhl_Angl_CarvOffset );
    _mVehSpd_X_AR.VehDrvDir_Stat.phys = getValue( HMI_VehDrvDir_Stat );
    _mVehSpd_X_AR.VehSp_Stat.phys = getValue( HMI_VehSp_Stat );
    _mVehSpd_X_AR.VehSpd_X.phys = getValue( HMI_VehSpd_X );
    _mVehSpd_X_AR.VehSpd_X_Max.phys = getValue( HMI_VehSpd_X_Max );
    _mVehSpd_X_AR.VehSpd_X_Min.phys = getValue( HMI_VehSpd_X_Min );
    _mVehSpd_X_AR.VehSpd_X_Qual.phys = getValue( HMI_VehSpd_X_Qual );
}

VehSpd_X_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_VehSpd_X ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_VehSpd_X_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _VehSpd_X_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _VehSpd_X_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_VehSpd_X_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _VehSpd_X_AR_SQC_WrongSeqJump != 0 ) &&
            ( _VehSpd_X_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _VehSpd_X_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _VehSpd_X_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _VehSpd_X_AR_SQC_RepeatedCnt ) &&
            ( _VehSpd_X_AR_E2E_Armed == 1  )    )
        {
            _VehSpd_X_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_VehSpd_X, SQC_help );
    }
    _mVehSpd_X_AR.SQC_VehSpd_X = SQC_help;

    if( getValue( HMI_CRC_VehSpd_X_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_VehSpd_X_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mVehSpd_X_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mVehSpd_X_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mVehSpd_X_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mVehSpd_X_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mVehSpd_X_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mVehSpd_X_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mVehSpd_X_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mVehSpd_X_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _VehSpd_X_AR_CRC_Offset[ _mVehSpd_X_AR.SQC_VehSpd_X ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _VehSpd_X_AR_CRC_ErrorCnt   && ( _VehSpd_X_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_VehSpd_X_Invalid )                                         )    )
            {
                crc++;
                if( _VehSpd_X_AR_CRC_ErrorCnt > 0 )
                    _VehSpd_X_AR_CRC_ErrorCnt--; 
            }
            _mVehSpd_X_AR.CRC_VehSpd_X = crc;
            putValue( HMI_CRC_VehSpd_X, crc );
        }
        else
            _mVehSpd_X_AR.CRC_VehSpd_X = getValue( HMI_CRC_VehSpd_X );
    }
    else
    {
        if( !getValue( HMI_CRC_VehSpd_X_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mVehSpd_X_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mVehSpd_X_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mVehSpd_X_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mVehSpd_X_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mVehSpd_X_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mVehSpd_X_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mVehSpd_X_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mVehSpd_X_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _VehSpd_X_AR_CRC_ErrorCnt   && ( _VehSpd_X_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_VehSpd_X_Invalid )                                         )    )
            {
                crc++;
                if( _VehSpd_X_AR_CRC_ErrorCnt > 0 )
                    _VehSpd_X_AR_CRC_ErrorCnt--; 
            }
            _mVehSpd_X_AR.CRC_VehSpd_X = crc;
            putValue( HMI_CRC_VehSpd_X, crc );
        }
        else
            _mVehSpd_X_AR.CRC_VehSpd_X = getValue( HMI_CRC_VehSpd_X );
    }
    if( ( _VehSpd_X_AR_MSG_DropCnt > 0 ) &&
        ( _VehSpd_X_AR_E2E_Armed == 1  )    )
    {
        _VehSpd_X_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mVehSpd_X_AR );
        
    if( _VehSpd_X_AR_E2E_Armed == 1 )
    {
        if ( ( _VehSpd_X_AR_MSG_DropCnt == 0      ) &&
             ( _VehSpd_X_AR_CRC_ErrorCnt == 0     ) &&
             ( _VehSpd_X_AR_SQC_RepeatedCnt == 0  ) &&
             ( _VehSpd_X_AR_SQC_WrongSeqJump == 0 )    )
        {
            _VehSpd_X_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_VehSpd_X_State, 0 );
        }
    }
}

VehSpd_X_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: VehSpd_X_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_VehSpd_X_AR := %X\n", getValue( HMI__STMSG_VehSpd_X_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_VehSpd_X_AR := %X\n", getValue( HMI__STMSGT_VehSpd_X_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_VehSpd_X := %X\n", getValue( HMI_CRC_VehSpd_X ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DiffLk_Deactv_Rq_ESP := %X\n", getValue( HMI_DiffLk_Deactv_Rq_ESP ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_VehSpd_X := %X\n", getValue( HMI_SQC_VehSpd_X ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_StWhl_Angl_CarvOffset := %X\n", getValue( HMI_StWhl_Angl_CarvOffset ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehDrvDir_Stat := %X\n", getValue( HMI_VehDrvDir_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehSp_Stat := %X\n", getValue( HMI_VehSp_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehSpd_X := %X\n", getValue( HMI_VehSpd_X ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehSpd_X_Max := %X\n", getValue( HMI_VehSpd_X_Max ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehSpd_X_Min := %X\n", getValue( HMI_VehSpd_X_Min ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VehSpd_X_Qual := %X\n", getValue( HMI_VehSpd_X_Qual ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tVehSpd_X_AR
{
    putValue( HMI__STMSG_VehSpd_X_AR, 0 );
}

on EnvVar HMI__STMSG_VehSpd_X_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_VehSpd_X_AR );
        if( tDelay > 0)    
            setTimer( _tVehSpd_X_AR, tDelay );
        else
            putValue( HMI__STMSG_VehSpd_X_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_VehSpd_X_AR
{
    if( getValue( this ) )
        openPanel("VehSpd_X_AR");
}

on envVar HMI_E2E_VehSpd_X_Inject
{
    if( getValue( this ) )
    {
        _VehSpd_X_AR_CRC_ErrorCnt = getValue( HMI_CRC_VehSpd_X_ErrorCount );
        _VehSpd_X_AR_SQC_TriggPos = getValue( HMI_SQC_VehSpd_X_TriggerPosition );
        _VehSpd_X_AR_SQC_WrongSeqJump = getValue( HMI_SQC_VehSpd_X_WrongSeq );
        _VehSpd_X_AR_SQC_RepeatedCnt = getValue( HMI_SQC_VehSpd_X_Repeated );
        _VehSpd_X_AR_MSG_DropCnt = getValue( HMI_SQC_VehSpd_X_MSG_DropCnt );
        putValue( HMI_E2E_VehSpd_X_State, 2 );
        _VehSpd_X_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_CRC_VehSpd_X
{
    _mVehSpd_X_AR.CRC_VehSpd_X.phys = getValue(this);
}

on EnvVar HMI_DiffLk_Deactv_Rq_ESP
{
    _mVehSpd_X_AR.DiffLk_Deactv_Rq_ESP.phys = getValue(this);
}

on EnvVar HMI_SQC_VehSpd_X
{
    _mVehSpd_X_AR.SQC_VehSpd_X.phys = getValue(this);
}

on EnvVar HMI_StWhl_Angl_CarvOffset
{
    _mVehSpd_X_AR.StWhl_Angl_CarvOffset.phys = getValue(this);
}

on EnvVar HMI_VehDrvDir_Stat
{
    _mVehSpd_X_AR.VehDrvDir_Stat.phys = getValue(this);
}

on EnvVar HMI_VehSp_Stat
{
    _mVehSpd_X_AR.VehSp_Stat.phys = getValue(this);
}

on EnvVar HMI_VehSpd_X
{
    _mVehSpd_X_AR.VehSpd_X.phys = getValue(this);
}

on EnvVar HMI_VehSpd_X_Max
{
    _mVehSpd_X_AR.VehSpd_X_Max.phys = getValue(this);
}

on EnvVar HMI_VehSpd_X_Min
{
    _mVehSpd_X_AR.VehSpd_X_Min.phys = getValue(this);
}

on EnvVar HMI_VehSpd_X_Qual
{
    _mVehSpd_X_AR.VehSpd_X_Qual.phys = getValue(this);
}

VIN_AR_check_output()
{
    if( !getValue( HMI__STMSG_VIN_AR ) )
    {
    //  message   VIN_AR ID: 113 --- Sendeart 1 spontanX --- 
        if( _VIN_AR_SpontanFlag)
        {
            VIN_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _VIN_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

VIN_AR_init()
{   /* Botschaft VIN_AR ID: 113 --- Sendeart 1 spontanX --- 
BA_ "ApplMessage" BO_ 113 0;
BA_ "NmAsrMessage" BO_ 113 0;
BA_ "GenMsgMinAcceptLength" BO_ 113 8;
BA_ "GenMsgILSupport" BO_ 113 1;
BA_ "DiagState" BO_ 113 0;
BA_ "DiagRequest" BO_ 113 0;
BA_ "DiagResponse" BO_ 113 0;
BA_ "GenMsgStartValue" BO_ 113 "0";
BA_ "GenMsgDelayTime" BO_ 113 5;
BA_ "GenMsgNrOfRepetitions" BO_ 113 0;
BA_ "GenMsgSendType" BO_ 113 1;
    */
    _VIN_AR_Timebase =      c_tDBKomTimer_20ms;
    _VIN_AR_SpontanFlag = 0;

    _mVIN_AR.VIN_Data1.phys = getValue( HMI_VIN_Data1 );
    _mVIN_AR.VIN_Data2.phys = getValue( HMI_VIN_Data2 );
    _mVIN_AR.VIN_Data3.phys = getValue( HMI_VIN_Data3 );
    _mVIN_AR.VIN_Data4.phys = getValue( HMI_VIN_Data4 );
    _mVIN_AR.VIN_Data5.phys = getValue( HMI_VIN_Data5 );
    _mVIN_AR.VIN_Data6.phys = getValue( HMI_VIN_Data6 );
    _mVIN_AR.VIN_Data7.phys = getValue( HMI_VIN_Data7 );
    _mVIN_AR.VIN_MsgPart.phys = getValue( HMI_VIN_MsgPart );
}

VIN_AR_output(void)
{
    output( _mVIN_AR );
}

VIN_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: VIN_AR\n", 24, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_VehIdNr := %X\n", getValue( HMI__STMSG_VIN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_VehIdNr := %X\n", getValue( HMI__STMSGT_VIN_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VIN_Data1 := %X\n", getValue( HMI_VIN_Data1 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VIN_Data2 := %X\n", getValue( HMI_VIN_Data2 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VIN_Data3 := %X\n", getValue( HMI_VIN_Data3 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VIN_Data4 := %X\n", getValue( HMI_VIN_Data4 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VIN_Data5 := %X\n", getValue( HMI_VIN_Data5 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VIN_Data6 := %X\n", getValue( HMI_VIN_Data6 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VIN_Data7 := %X\n", getValue( HMI_VIN_Data7 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VIN_MsgPart := %X\n", getValue( HMI_VIN_MsgPart ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tVIN_AR
{
    putValue( HMI__STMSG_VIN_AR, 0 );
}

on EnvVar HMI__STMSG_VIN_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_VIN_AR );
        if( tDelay > 0)    
            setTimer( _tVIN_AR, tDelay );
        else
            putValue( HMI__STMSG_VIN_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_VIN_AR
{
    if( getValue( this ) )
        openPanel("VIN_AR");
}

on EnvVar HMI_VIN_Data1
{
    _mVIN_AR.VIN_Data1.phys = getValue(this);
    _VIN_AR_SpontanFlag = 1;
}

on EnvVar HMI_VIN_Data2
{
    _mVIN_AR.VIN_Data2.phys = getValue(this);
    _VIN_AR_SpontanFlag = 1;
}

on EnvVar HMI_VIN_Data3
{
    _mVIN_AR.VIN_Data3.phys = getValue(this);
    _VIN_AR_SpontanFlag = 1;
}

on EnvVar HMI_VIN_Data4
{
    _mVIN_AR.VIN_Data4.phys = getValue(this);
    _VIN_AR_SpontanFlag = 1;
}

on EnvVar HMI_VIN_Data5
{
    _mVIN_AR.VIN_Data5.phys = getValue(this);
    _VIN_AR_SpontanFlag = 1;
}

on EnvVar HMI_VIN_Data6
{
    _mVIN_AR.VIN_Data6.phys = getValue(this);
    _VIN_AR_SpontanFlag = 1;
}

on EnvVar HMI_VIN_Data7
{
    _mVIN_AR.VIN_Data7.phys = getValue(this);
    _VIN_AR_SpontanFlag = 1;
}

on EnvVar HMI_VIN_MsgPart
{
    _mVIN_AR.VIN_MsgPart.phys = getValue(this);
    _VIN_AR_SpontanFlag = 1;
}

VTA_Event_Disp_AR_check_output()
{
    if( !getValue( HMI__STMSG_VTA_Event_Disp_AR ) )
    {
    //  message   VTA_Event_Disp_AR ID: 1194 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        if( _VTA_Event_Disp_AR_DelayCnt > 0) _VTA_Event_Disp_AR_DelayCnt--; // Mindestsendeabstand
        _VTA_Event_Disp_AR_Cnt--;
        if( _VTA_Event_Disp_AR_Cnt < 1 )
        {
            if( _VTA_Event_Disp_AR_DelayCnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
                VTA_Event_Disp_AR_output();
                _VTA_Event_Disp_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _VTA_Event_Disp_AR_DelayCnt = _VTA_Event_Disp_AR_MinDelay;
            }
            else
            {
                // Spontanflag setzen damit nach Ablauf Mindestsendeabstand gesendet wird
                 _VTA_Event_Disp_AR_SpontanFlag = 1;
            }
            _VTA_Event_Disp_AR_Cnt = _VTA_Event_Disp_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
        else if( _VTA_Event_Disp_AR_SpontanFlag)
        {
            if( _VTA_Event_Disp_AR_DelayCnt < 1 )
            {
                // Nachricht wg. spontaner �nderung ausgeben (Mindestsendeabstand eingehalten)
                VTA_Event_Disp_AR_output();
                _VTA_Event_Disp_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
                _VTA_Event_Disp_AR_DelayCnt = _VehPwrMngmnt_EMM_Stat2_AR_MinDelay;
            }
        }
    }
}

VTA_Event_Disp_AR_init()
{   /* Botschaft VTA_Event_Disp_AR ID: 1194 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 1194 0;
BA_ "NmAsrMessage" BO_ 1194 0;
BA_ "GenMsgMinAcceptLength" BO_ 1194 4;
BA_ "GenMsgILSupport" BO_ 1194 1;
BA_ "DiagState" BO_ 1194 0;
BA_ "DiagRequest" BO_ 1194 0;
BA_ "DiagResponse" BO_ 1194 0;
BA_ "GenMsgStartValue" BO_ 1194 "0";
BA_ "GenMsgDelayTime" BO_ 1194 100;
BA_ "GenMsgNrOfRepetition" BO_ 1194 0;
BA_ "GenMsgCycleTime" BO_ 1194 1000;
BA_ "GenMsgSendType" BO_ 1194 5;
    */
    _VTA_Event_Disp_AR_Timebase =      c_tDBKomTimer_20ms;
    _VTA_Event_Disp_AR_CycleCount =   1000 / _VTA_Event_Disp_AR_Timebase;
    _VTA_Event_Disp_AR_StartDelay =      0 / _VTA_Event_Disp_AR_Timebase;
    _VTA_Event_Disp_AR_MinDelay =      100 / _VTA_Event_Disp_AR_Timebase;
    _VTA_Event_Disp_AR_Cnt = _VTA_Event_Disp_AR_StartDelay;
    _VTA_Event_Disp_AR_SpontanFlag = 0;
    _VTA_Event_Disp_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_VTA_Event_Disp_AR, _VTA_Event_Disp_AR_StartDelay * _VTA_Event_Disp_AR_Timebase );

    _mVTA_Event_Disp_AR.VTA_Park_Event_Disp_Rq.phys = getValue( HMI_VTA_Park_Event_Disp_Rq );
    _mVTA_Event_Disp_AR.VTA_Park_Event_Lvl.phys = getValue( HMI_VTA_Park_Event_Lvl );
    _mVTA_Event_Disp_AR.VTA_Park_Event_Rq.phys = getValue( HMI_VTA_Park_Event_Rq );
    _mVTA_Event_Disp_AR.VTA_Park_Event_TS_Day.phys = getValue( HMI_VTA_Park_Event_TS_Day );
    _mVTA_Event_Disp_AR.VTA_Park_Event_TS_Hour.phys = getValue( HMI_VTA_Park_Event_TS_Hour );
    _mVTA_Event_Disp_AR.VTA_Park_Event_TS_Minute.phys = getValue( HMI_VTA_Park_Event_TS_Minute );
    _mVTA_Event_Disp_AR.VTA_Park_Event_TS_Month.phys = getValue( HMI_VTA_Park_Event_TS_Month );
    _mVTA_Event_Disp_AR.VTA_Park_Event_Type.phys = getValue( HMI_VTA_Park_Event_Type );
}

VTA_Event_Disp_AR_output(void)
{
    output( _mVTA_Event_Disp_AR );
}

VTA_Event_Disp_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: VTA_Event_Disp_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_VTA_Event_Disp_AR := %X\n", getValue( HMI__STMSG_VTA_Event_Disp_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_VTA_Event_Disp_AR := %X\n", getValue( HMI__STMSGT_VTA_Event_Disp_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VTA_Park_Event_Disp_Rq := %X\n", getValue( HMI_VTA_Park_Event_Disp_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VTA_Park_Event_Lvl := %X\n", getValue( HMI_VTA_Park_Event_Lvl ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VTA_Park_Event_Rq := %X\n", getValue( HMI_VTA_Park_Event_Rq ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VTA_Park_Event_TS_Day := %X\n", getValue( HMI_VTA_Park_Event_TS_Day ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VTA_Park_Event_TS_Hour := %X\n", getValue( HMI_VTA_Park_Event_TS_Hour ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VTA_Park_Event_TS_Minute := %X\n", getValue( HMI_VTA_Park_Event_TS_Minute ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VTA_Park_Event_TS_Month := %X\n", getValue( HMI_VTA_Park_Event_TS_Month ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_VTA_Park_Event_Type := %X\n", getValue( HMI_VTA_Park_Event_Type ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tVTA_Event_Disp_AR
{
    putValue( HMI__STMSG_VTA_Event_Disp_AR, 0 );
}

on EnvVar HMI__STMSG_VTA_Event_Disp_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_VTA_Event_Disp_AR );
        if( tDelay > 0)    
            setTimer( _tVTA_Event_Disp_AR, tDelay );
        else
            putValue( HMI__STMSG_VTA_Event_Disp_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_VTA_Event_Disp_AR
{
    if( getValue( this ) )
        openPanel("VTA_Event_Disp_AR");
}

on EnvVar HMI_VTA_Park_Event_Disp_Rq
{
    _mVTA_Event_Disp_AR.VTA_Park_Event_Disp_Rq.phys = getValue(this);
    _VTA_Event_Disp_AR_SpontanFlag = 1;
}

on EnvVar HMI_VTA_Park_Event_Lvl
{
    _mVTA_Event_Disp_AR.VTA_Park_Event_Lvl.phys = getValue(this);
    _VTA_Event_Disp_AR_SpontanFlag = 1;
}

on EnvVar HMI_VTA_Park_Event_Rq
{
    _mVTA_Event_Disp_AR.VTA_Park_Event_Rq.phys = getValue(this);
    _VTA_Event_Disp_AR_SpontanFlag = 1;
}

on EnvVar HMI_VTA_Park_Event_TS_Day
{
    _mVTA_Event_Disp_AR.VTA_Park_Event_TS_Day.phys = getValue(this);
    _VTA_Event_Disp_AR_SpontanFlag = 1;
}

on EnvVar HMI_VTA_Park_Event_TS_Hour
{
    _mVTA_Event_Disp_AR.VTA_Park_Event_TS_Hour.phys = getValue(this);
    _VTA_Event_Disp_AR_SpontanFlag = 1;
}

on EnvVar HMI_VTA_Park_Event_TS_Minute
{
    _mVTA_Event_Disp_AR.VTA_Park_Event_TS_Minute.phys = getValue(this);
    _VTA_Event_Disp_AR_SpontanFlag = 1;
}

on EnvVar HMI_VTA_Park_Event_TS_Month
{
    _mVTA_Event_Disp_AR.VTA_Park_Event_TS_Month.phys = getValue(this);
    _VTA_Event_Disp_AR_SpontanFlag = 1;
}

on EnvVar HMI_VTA_Park_Event_Type
{
    _mVTA_Event_Disp_AR.VTA_Park_Event_Type.phys = getValue(this);
    _VTA_Event_Disp_AR_SpontanFlag = 1;
}


	DLM_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_DLM_Stat_AR ) )
    {
    //  message   DLM_Stat_AR ID: 161 --- Sendeart 0 cyclicX --- 
        _DLM_Stat_AR_Cnt--;
        if( _DLM_Stat_AR_Cnt < 1 )
        {
            DLM_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _DLM_Stat_AR_Cnt = _DLM_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

DLM_Stat_AR_init()
{   /* Botschaft DLM_Stat_AR ID: 996 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 996 0;
BA_ "NmAsrMessage" BO_ 996 0;
BA_ "GenMsgMinAcceptLength" BO_ 996 8;
BA_ "GenMsgILSupport" BO_ 996 1;
BA_ "DiagState" BO_ 996 0;
BA_ "DiagRequest" BO_ 996 0;
BA_ "DiagResponse" BO_ 996 0;
BA_ "GenMsgStartValue" BO_ 996 "0";
BA_ "GenMsgStartDelayTime" BO_ 996 0;
BA_ "GenMsgDelayTime" BO_ 996 5;
BA_ "GenMsgNrOfRepetitions" BO_ 996 0;
BA_ "GenMsgCycleTime" BO_ 996 100;
BA_ "GenMsgSendType" BO_ 996 5;
    */
    _DLM_Stat_AR_Timebase =           c_tDBKomTimer_20ms;
    _DLM_Stat_AR_CycleCount =       100 / _DLM_Stat_AR_Timebase;
    _DLM_Stat_AR_StartDelay =         0 / _DLM_Stat_AR_Timebase;
    _DLM_Stat_AR_MinDelay =           5 / _DLM_Stat_AR_Timebase;
    _DLM_Stat_AR_Cnt = _DLM_Stat_AR_StartDelay;
    _DLM_Stat_AR_SpontanFlag = 0;
    _DLM_Stat_AR_DelayCnt = 0;

    putValue( HMI__STMSGSD_DLM_Stat_AR, _DLM_Stat_AR_StartDelay * _DLM_Stat_AR_Timebase );

    _mDLM_Stat_AR.DiffLk_F_Stat_DLM.phys = getValue( HMI_DiffLk_F_Stat_DLM );
    _mDLM_Stat_AR.DiffLk_M_Stat_DLM.phys = getValue( HMI_DiffLk_M_Stat_DLM );
    _mDLM_Stat_AR.DiffLk_R_Stat_DLM.phys = getValue( HMI_DiffLk_R_Stat_DLM );
    _mDLM_Stat_AR.DLM_Msg1_Disp_Rq.phys = getValue( HMI_DLM_Msg1_Disp_Rq );
    _mDLM_Stat_AR.DLM_Msg2_Disp_Rq.phys = getValue( HMI_DLM_Msg2_Disp_Rq );
    _mDLM_Stat_AR.DLM_Msg3_Disp_Rq.phys = getValue( HMI_DLM_Msg3_Disp_Rq );
    _mDLM_Stat_AR.DLM_Msg4_Disp_Rq.phys = getValue( HMI_DLM_Msg4_Disp_Rq );
    _mDLM_Stat_AR.DLM_Msg5_Disp_Rq.phys = getValue( HMI_DLM_Msg5_Disp_Rq );
    _mDLM_Stat_AR.DLM_Msg6_Disp_Rq.phys = getValue( HMI_DLM_Msg6_Disp_Rq );
    _mDLM_Stat_AR.DLM_Msg7_Disp_Rq.phys = getValue( HMI_DLM_Msg7_Disp_Rq );
    _mDLM_Stat_AR.DLM_Msg8_Disp_Rq.phys = getValue( HMI_DLM_Msg8_Disp_Rq );
    _mDLM_Stat_AR.RLDS_RoofRack_Stat.phys = getValue( HMI_RLDS_RoofRack_Stat );
    _mDLM_Stat_AR.Rsrv01_DLM_Stat.phys = getValue( HMI_Rsrv01_DLM_Stat );
    _mDLM_Stat_AR.Rsrv02_DLM_Stat.phys = getValue( HMI_Rsrv02_DLM_Stat );
}

DLM_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_DLM_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_DLM_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _DLM_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _DLM_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_DLM_Stat_AR_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _DLM_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _DLM_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _DLM_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _DLM_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _DLM_Stat_AR_SQC_RepeatedCnt ) &&
            ( _DLM_Stat_AR_E2E_Armed == 1  )    )
        {
            _DLM_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_DLM_Stat, SQC_help );
    }
    _mDLM_Stat_AR.SQC_DLM_Stat = SQC_help;

    if( getValue( HMI_CRC_DLM_Stat_AR_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_DLM_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable_profile02[ crc ^ _mDLM_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mDLM_Stat_AR.byte( 1 ) ];
//            crc = crctable_profile02[ crc ^ _mDLM_Stat_AR.byte( 2 ) ];
//            crc = crctable_profile02[ crc ^ _mDLM_Stat_AR.byte( 3 ) ];
//            crc = crctable_profile02[ crc ^ _mDLM_Stat_AR.byte( 4 ) ];
//            crc = crctable_profile02[ crc ^ _mDLM_Stat_AR.byte( 5 ) ];
//            crc = crctable_profile02[ crc ^ _mDLM_Stat_AR.byte( 6 ) ];
//            crc = crctable_profile02[ crc ^ _mDLM_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _DLM_Stat_AR_CRC_Offset[ _mDLM_Stat_AR.SQC_DLM_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _DLM_Stat_AR_CRC_ErrorCnt   && ( _DLM_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_DLM_Stat_AR_Invalid )                                         )    )
            {
                crc++;
                if( _DLM_Stat_AR_CRC_ErrorCnt > 0 )
                    _DLM_Stat_AR_CRC_ErrorCnt--; 
            }
            _mDLM_Stat_AR.CRC_DLM_Stat = crc;
            putValue( HMI_CRC_DLM_Stat, crc );
        }
        else
            _mDLM_Stat_AR.CRC_DLM_Stat = getValue( HMI_CRC_DLM_Stat );
    }
    else
    {
        if( !getValue( HMI_CRC_DLM_Stat_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mDLM_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mDLM_Stat_AR.byte( 1 ) ];
//            crc = crctable[ crc ^ _mDLM_Stat_AR.byte( 2 ) ];
//            crc = crctable[ crc ^ _mDLM_Stat_AR.byte( 3 ) ];
//            crc = crctable[ crc ^ _mDLM_Stat_AR.byte( 4 ) ];
//            crc = crctable[ crc ^ _mDLM_Stat_AR.byte( 5 ) ];
//            crc = crctable[ crc ^ _mDLM_Stat_AR.byte( 6 ) ];
//            crc = crctable[ crc ^ _mDLM_Stat_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _DLM_Stat_AR_CRC_ErrorCnt   && ( _DLM_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_DLM_Stat_AR_Invalid )                                         )    )
            {
                crc++;
                if( _DLM_Stat_AR_CRC_ErrorCnt > 0 )
                    _DLM_Stat_AR_CRC_ErrorCnt--; 
            }
            _mDLM_Stat_AR.CRC_DLM_Stat = crc;
            putValue( HMI_CRC_DLM_Stat, crc );
        }
        else
            _mDLM_Stat_AR.CRC_DLM_Stat = getValue( HMI_CRC_DLM_Stat );
    }
    if( ( _DLM_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _DLM_Stat_AR_E2E_Armed == 1  )    )
    {
        _DLM_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mDLM_Stat_AR );
        
    if( _DLM_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _DLM_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _DLM_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _DLM_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _DLM_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _DLM_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_DLM_Stat_AR_State, 0 );
        }
    }
}

DLM_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: DLM_Stat_AR\n", 29, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_DLM_Stat_AR := %X\n", getValue( HMI__STMSG_DLM_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_DLM_Stat_AR := %X\n", getValue( HMI__STMSGT_DLM_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_DLM_Stat := %X\n", getValue( HMI_CRC_DLM_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DiffLk_F_Stat_DLM := %X\n", getValue( HMI_DiffLk_F_Stat_DLM ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DiffLk_M_Stat_DLM := %X\n", getValue( HMI_DiffLk_M_Stat_DLM ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DiffLk_R_Stat_DLM := %X\n", getValue( HMI_DiffLk_R_Stat_DLM ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DLM_Msg1_Disp_Rq := %X\n", getValue( HMI_DLM_Msg1_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_DLM_Stat_Auto := %X\n", getValue( HMI_CRC_DLM_Stat_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DLM_Msg2_Disp_Rq := %X\n", getValue( HMI_DLM_Msg2_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DLM_Msg3_Disp_Rq := %X\n", getValue( HMI_DLM_Msg3_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DLM_Msg4_Disp_Rq := %X\n", getValue( HMI_DLM_Msg4_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DLM_Msg5_Disp_Rq := %X\n", getValue( HMI_DLM_Msg5_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DLM_Msg6_Disp_Rq := %X\n", getValue( HMI_DLM_Msg6_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DLM_Msg7_Disp_Rq := %X\n", getValue( HMI_DLM_Msg7_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_DLM_Msg8_Disp_Rq := %X\n", getValue( HMI_DLM_Msg8_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_RLDS_RoofRack_Stat := %X\n", getValue( HMI_RLDS_RoofRack_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv01_DLM_Stat := %X\n", getValue( HMI_Rsrv01_DLM_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv02_DLM_Stat := %X\n", getValue( HMI_Rsrv02_DLM_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_DLM_Stat := %X\n", getValue( HMI_SQC_DLM_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_DLM_Stat_Auto := %X\n", getValue( HMI_SQC_DLM_Stat_Auto ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tDLM_Stat_AR
{
    putValue( HMI__STMSG_DLM_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_DLM_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_DLM_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tDLM_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_DLM_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_DLM_Stat_AR
{
    if( getValue( this ) )
        openPanel("DLM_Stat_AR");
}

on envVar HMI_E2E_DLM_Stat_AR_Inject
{
    if( getValue( this ) )
    {
        _DLM_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_DLM_Stat_AR_ErrorCount );
        _DLM_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_DLM_Stat_TriggerPosition );
        _DLM_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_DLM_Stat_WrongSeq );
        _DLM_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_DLM_Stat_Repeated );
        _DLM_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_DLM_Stat_MSG_DropCnt );
        putValue( HMI_E2E_DLM_Stat_AR_State, 2 );
        _DLM_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_CRC_DLM_Stat
{
    _mDLM_Stat_AR.CRC_DLM_Stat.phys = getValue(this);
    _DLM_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DiffLk_F_Stat_DLM
{
    _mDLM_Stat_AR.DiffLk_F_Stat_DLM.phys = getValue(this);
    _DLM_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DiffLk_M_Stat_DLM
{
    _mDLM_Stat_AR.DiffLk_M_Stat_DLM.phys = getValue(this);
    _DLM_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DiffLk_R_Stat_DLM
{
    _mDLM_Stat_AR.DiffLk_R_Stat_DLM.phys = getValue(this);
    _DLM_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DLM_Msg1_Disp_Rq
{
    _mDLM_Stat_AR.DLM_Msg1_Disp_Rq.phys = getValue(this);
    _DLM_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DLM_Msg2_Disp_Rq
{
    _mDLM_Stat_AR.DLM_Msg2_Disp_Rq.phys = getValue(this);
    _DLM_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DLM_Msg3_Disp_Rq
{
    _mDLM_Stat_AR.DLM_Msg3_Disp_Rq.phys = getValue(this);
    _DLM_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DLM_Msg4_Disp_Rq
{
    _mDLM_Stat_AR.DLM_Msg4_Disp_Rq.phys = getValue(this);
    _DLM_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DLM_Msg5_Disp_Rq
{
    _mDLM_Stat_AR.DLM_Msg5_Disp_Rq.phys = getValue(this);
    _DLM_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DLM_Msg6_Disp_Rq
{
    _mDLM_Stat_AR.DLM_Msg6_Disp_Rq.phys = getValue(this);
    _DLM_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DLM_Msg7_Disp_Rq
{
    _mDLM_Stat_AR.DLM_Msg7_Disp_Rq.phys = getValue(this);
    _DLM_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_DLM_Msg8_Disp_Rq
{
    _mDLM_Stat_AR.DLM_Msg8_Disp_Rq.phys = getValue(this);
    _DLM_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_RLDS_RoofRack_Stat
{
    _mDLM_Stat_AR.RLDS_RoofRack_Stat.phys = getValue(this);
    _DLM_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv01_DLM_Stat
{
    _mDLM_Stat_AR.Rsrv01_DLM_Stat.phys = getValue(this);
    _DLM_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Rsrv02_DLM_Stat
{
    _mDLM_Stat_AR.Rsrv02_DLM_Stat.phys = getValue(this);
    _DLM_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_SQC_DLM_Stat
{
    _mDLM_Stat_AR.SQC_DLM_Stat.phys = getValue(this);
    _DLM_Stat_AR_SpontanFlag = 1;
}

Whl_Lt_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_Whl_Lt_Stat_AR ) )
    {
    //  message   Whl_Lt_Stat_AR ID: 161 --- Sendeart 0 cyclicX --- 
        _Whl_Lt_Stat_AR_Cnt--;
        if( _Whl_Lt_Stat_AR_Cnt < 1 )
        {
            Whl_Lt_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _Whl_Lt_Stat_AR_Cnt = _Whl_Lt_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

Whl_Lt_Stat_AR_init()
{   /* Botschaft Whl_Lt_Stat_AR ID: 161 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 161 0;
BA_ "NmAsrMessage" BO_ 161 0;
BA_ "GenMsgMinAcceptLength" BO_ 161 8;
BA_ "GenMsgILSupport" BO_ 161 1;
BA_ "DiagState" BO_ 161 0;
BA_ "DiagRequest" BO_ 161 0;
BA_ "DiagResponse" BO_ 161 0;
BA_ "GenMsgStartValue" BO_ 161 "0";
BA_ "GenMsgStartDelayTime" BO_ 161 0;
BA_ "GenMsgCycleTime" BO_ 161 20;
BA_ "GenMsgSendType" BO_ 161 0;
    */
    _Whl_Lt_Stat_AR_Timebase =      c_tDBKomTimer_20ms;
    _Whl_Lt_Stat_AR_CycleCount =    20 / _Whl_Lt_Stat_AR_Timebase;
    _Whl_Lt_Stat_AR_StartDelay =     0 / _Whl_Lt_Stat_AR_Timebase;
    _Whl_Lt_Stat_AR_Cnt = _Whl_Lt_Stat_AR_StartDelay;

    putValue( HMI__STMSGSD_Whl_Lt_Stat_AR, _Whl_Lt_Stat_AR_StartDelay * _Whl_Lt_Stat_AR_Timebase );

    _mWhl_Lt_Stat_AR.CRC_Whl_Lt_Stat.phys = getValue( HMI_CRC_Whl_Lt_Stat );
    _mWhl_Lt_Stat_AR.SQC_Whl_Lt_Stat.phys = getValue( HMI_SQC_Whl_Lt_Stat );
    _mWhl_Lt_Stat_AR.WhlDir_FL_Stat.phys = getValue( HMI_WhlDir_FL_Stat );
    _mWhl_Lt_Stat_AR.WhlDir_RL_Stat.phys = getValue( HMI_WhlDir_RL_Stat );
    _mWhl_Lt_Stat_AR.WhlPlsCnt_FL.phys = getValue( HMI_WhlPlsCnt_FL );
    _mWhl_Lt_Stat_AR.WhlPlsCnt_RL.phys = getValue( HMI_WhlPlsCnt_RL );
    _mWhl_Lt_Stat_AR.WhlRPM_FL.phys = getValue( HMI_WhlRPM_FL );
    _mWhl_Lt_Stat_AR.WhlRPM_FL_Qual.phys = getValue( HMI_WhlRPM_FL_Qual );
    _mWhl_Lt_Stat_AR.WhlRPM_RL.phys = getValue( HMI_WhlRPM_RL );
    _mWhl_Lt_Stat_AR.WhlRPM_RL_Qual.phys = getValue( HMI_WhlRPM_RL_Qual );
}

Whl_Lt_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_Whl_Lt_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_Whl_Lt_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _Whl_Lt_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _Whl_Lt_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_Whl_Lt_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _Whl_Lt_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _Whl_Lt_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _Whl_Lt_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _Whl_Lt_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _Whl_Lt_Stat_AR_SQC_RepeatedCnt ) &&
            ( _Whl_Lt_Stat_AR_E2E_Armed == 1  )    )
        {
            _Whl_Lt_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_Whl_Lt_Stat, SQC_help );
    }
    _mWhl_Lt_Stat_AR.SQC_Whl_Lt_Stat = SQC_help;

    if( getValue( HMI_CRC_Whl_Lt_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_Whl_Lt_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mWhl_Lt_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mWhl_Lt_Stat_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mWhl_Lt_Stat_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mWhl_Lt_Stat_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mWhl_Lt_Stat_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mWhl_Lt_Stat_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mWhl_Lt_Stat_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mWhl_Lt_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _Whl_Lt_Stat_AR_CRC_Offset[ _mWhl_Lt_Stat_AR.SQC_Whl_Lt_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _Whl_Lt_Stat_AR_CRC_ErrorCnt   && ( _Whl_Lt_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Whl_Lt_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _Whl_Lt_Stat_AR_CRC_ErrorCnt > 0 )
                    _Whl_Lt_Stat_AR_CRC_ErrorCnt--; 
            }
            _mWhl_Lt_Stat_AR.CRC_Whl_Lt_Stat = crc;
            putValue( HMI_CRC_Whl_Lt_Stat, crc );
        }
        else
            _mWhl_Lt_Stat_AR.CRC_Whl_Lt_Stat = getValue( HMI_CRC_Whl_Lt_Stat );
    }
    else
    {
        if( !getValue( HMI_CRC_Whl_Lt_Stat_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mWhl_Lt_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mWhl_Lt_Stat_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mWhl_Lt_Stat_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mWhl_Lt_Stat_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mWhl_Lt_Stat_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mWhl_Lt_Stat_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mWhl_Lt_Stat_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mWhl_Lt_Stat_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _Whl_Lt_Stat_AR_CRC_ErrorCnt   && ( _Whl_Lt_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Whl_Lt_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _Whl_Lt_Stat_AR_CRC_ErrorCnt > 0 )
                    _Whl_Lt_Stat_AR_CRC_ErrorCnt--; 
            }
            _mWhl_Lt_Stat_AR.CRC_Whl_Lt_Stat = crc;
            putValue( HMI_CRC_Whl_Lt_Stat, crc );
        }
        else
            _mWhl_Lt_Stat_AR.CRC_Whl_Lt_Stat = getValue( HMI_CRC_Whl_Lt_Stat );
    }
    if( ( _Whl_Lt_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _Whl_Lt_Stat_AR_E2E_Armed == 1  )    )
    {
        _Whl_Lt_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mWhl_Lt_Stat_AR );
        
    if( _Whl_Lt_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _Whl_Lt_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _Whl_Lt_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _Whl_Lt_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _Whl_Lt_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _Whl_Lt_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_Whl_Lt_Stat_State, 0 );
        }
    }
}

Whl_Lt_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Whl_Lt_Stat_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Whl_Lt_Stat := %X\n", getValue( HMI__STMSG_Whl_Lt_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Whl_Lt_Stat := %X\n", getValue( HMI__STMSGT_Whl_Lt_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Whl_Lt_Stat := %X\n", getValue( HMI_CRC_Whl_Lt_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Whl_Lt_Stat_Auto := %X\n", getValue( HMI_CRC_Whl_Lt_Stat_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Whl_Lt_Stat := %X\n", getValue( HMI_SQC_Whl_Lt_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Whl_Lt_Stat_Auto := %X\n", getValue( HMI_SQC_Whl_Lt_Stat_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlDir_FL_Stat := %X\n", getValue( HMI_WhlDir_FL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlDir_RL_Stat := %X\n", getValue( HMI_WhlDir_RL_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlPlsCnt_FL := %X\n", getValue( HMI_WhlPlsCnt_FL ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlPlsCnt_RL := %X\n", getValue( HMI_WhlPlsCnt_RL ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlRPM_FL := %X\n", getValue( HMI_WhlRPM_FL ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlRPM_FL_Qual := %X\n", getValue( HMI_WhlRPM_FL_Qual ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlRPM_RL := %X\n", getValue( HMI_WhlRPM_RL ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlRPM_RL_Qual := %X\n", getValue( HMI_WhlRPM_RL_Qual ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tWhl_Lt_Stat_AR
{
    putValue( HMI__STMSG_Whl_Lt_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_Whl_Lt_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Whl_Lt_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tWhl_Lt_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_Whl_Lt_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Whl_Lt_Stat_AR
{
    if( getValue( this ) )
        openPanel("Whl_Lt_Rt_Stat_AR");
}

on envVar HMI_E2E_Whl_Lt_Stat_Inject
{
    if( getValue( this ) )
    {
        _Whl_Lt_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_Whl_Lt_Stat_ErrorCount );
        _Whl_Lt_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_Whl_Lt_Stat_TriggerPosition );
        _Whl_Lt_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_Whl_Lt_Stat_WrongSeq );
        _Whl_Lt_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_Whl_Lt_Stat_Repeated );
        _Whl_Lt_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_Whl_Lt_Stat_MSG_DropCnt );
        putValue( HMI_E2E_Whl_Lt_Stat_State, 2 );
        _Whl_Lt_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_WhlDir_FL_Stat
{
    _mWhl_Lt_Stat_AR.WhlDir_FL_Stat.phys = getValue(this);
}

on EnvVar HMI_WhlDir_RL_Stat
{
    _mWhl_Lt_Stat_AR.WhlDir_RL_Stat.phys = getValue(this);
}

on EnvVar HMI_WhlPlsCnt_FL
{
    _mWhl_Lt_Stat_AR.WhlPlsCnt_FL.phys = getValue(this);
}

on EnvVar HMI_WhlPlsCnt_RL
{
    _mWhl_Lt_Stat_AR.WhlPlsCnt_RL.phys = getValue(this);
}

on EnvVar HMI_WhlRPM_FL
{
    _mWhl_Lt_Stat_AR.WhlRPM_FL.phys = getValue(this);
}

on EnvVar HMI_WhlRPM_FL_Qual
{
    _mWhl_Lt_Stat_AR.WhlRPM_FL_Qual.phys = getValue(this);
}

on EnvVar HMI_WhlRPM_RL
{
    _mWhl_Lt_Stat_AR.WhlRPM_RL.phys = getValue(this);
}

on EnvVar HMI_WhlRPM_RL_Qual
{
    _mWhl_Lt_Stat_AR.WhlRPM_RL_Qual.phys = getValue(this);
}

Whl_Rt_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_Whl_Rt_Stat_AR ) )
    {
    //  message   Whl_Rt_Stat_AR ID: 163 --- Sendeart 0 cyclicX --- 
        _Whl_Rt_Stat_AR_Cnt--;
        if( _Whl_Rt_Stat_AR_Cnt < 1 )
        {
            Whl_Rt_Stat_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _Whl_Rt_Stat_AR_Cnt = _Whl_Rt_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

Whl_Rt_Stat_AR_init()
{   /* Botschaft Whl_Rt_Stat_AR ID: 163 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 163 0;
BA_ "NmAsrMessage" BO_ 163 0;
BA_ "GenMsgMinAcceptLength" BO_ 163 8;
BA_ "GenMsgILSupport" BO_ 163 1;
BA_ "DiagState" BO_ 163 0;
BA_ "DiagRequest" BO_ 163 0;
BA_ "DiagResponse" BO_ 163 0;
BA_ "GenMsgStartValue" BO_ 163 "0";
BA_ "GenMsgStartDelayTime" BO_ 163 0;
BA_ "GenMsgCycleTime" BO_ 163 20;
BA_ "GenMsgSendType" BO_ 163 0;
    */
    _Whl_Rt_Stat_AR_Timebase =      c_tDBKomTimer_20ms;
    _Whl_Rt_Stat_AR_CycleCount =    20 / _Whl_Rt_Stat_AR_Timebase;
    _Whl_Rt_Stat_AR_StartDelay =     0 / _Whl_Rt_Stat_AR_Timebase;
    _Whl_Rt_Stat_AR_Cnt = _Whl_Rt_Stat_AR_StartDelay;

    putValue( HMI__STMSGSD_Whl_Rt_Stat_AR, _Whl_Rt_Stat_AR_StartDelay * _Whl_Rt_Stat_AR_Timebase );

    _mWhl_Rt_Stat_AR.CRC_Whl_Rt_Stat.phys = getValue( HMI_CRC_Whl_Rt_Stat );
    _mWhl_Rt_Stat_AR.SQC_Whl_Rt_Stat.phys = getValue( HMI_SQC_Whl_Rt_Stat );
    _mWhl_Rt_Stat_AR.WhlDir_FR_Stat.phys = getValue( HMI_WhlDir_FR_Stat );
    _mWhl_Rt_Stat_AR.WhlDir_RR_Stat.phys = getValue( HMI_WhlDir_RR_Stat );
    _mWhl_Rt_Stat_AR.WhlPlsCnt_FR.phys = getValue( HMI_WhlPlsCnt_FR );
    _mWhl_Rt_Stat_AR.WhlPlsCnt_RR.phys = getValue( HMI_WhlPlsCnt_RR );
    _mWhl_Rt_Stat_AR.WhlRPM_FR.phys = getValue( HMI_WhlRPM_FR );
    _mWhl_Rt_Stat_AR.WhlRPM_FR_Qual.phys = getValue( HMI_WhlRPM_FR_Qual );
    _mWhl_Rt_Stat_AR.WhlRPM_RR.phys = getValue( HMI_WhlRPM_RR );
    _mWhl_Rt_Stat_AR.WhlRPM_RR_Qual.phys = getValue( HMI_WhlRPM_RR_Qual );
}

Whl_Rt_Stat_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_Whl_Rt_Stat ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_Whl_Rt_Stat_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _Whl_Rt_Stat_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _Whl_Rt_Stat_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_Whl_Rt_Stat_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _Whl_Rt_Stat_AR_SQC_WrongSeqJump != 0 ) &&
            ( _Whl_Rt_Stat_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _Whl_Rt_Stat_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _Whl_Rt_Stat_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _Whl_Rt_Stat_AR_SQC_RepeatedCnt ) &&
            ( _Whl_Rt_Stat_AR_E2E_Armed == 1  )    )
        {
            _Whl_Rt_Stat_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_Whl_Rt_Stat, SQC_help );
    }
    _mWhl_Rt_Stat_AR.SQC_Whl_Rt_Stat = SQC_help;

    if( getValue( HMI_CRC_Whl_Rt_Stat_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_Whl_Rt_Stat_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mWhl_Rt_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mWhl_Rt_Stat_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mWhl_Rt_Stat_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mWhl_Rt_Stat_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mWhl_Rt_Stat_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mWhl_Rt_Stat_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mWhl_Rt_Stat_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mWhl_Rt_Stat_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _Whl_Rt_Stat_AR_CRC_Offset[ _mWhl_Rt_Stat_AR.SQC_Whl_Rt_Stat ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _Whl_Rt_Stat_AR_CRC_ErrorCnt   && ( _Whl_Rt_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Whl_Rt_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _Whl_Rt_Stat_AR_CRC_ErrorCnt > 0 )
                    _Whl_Rt_Stat_AR_CRC_ErrorCnt--; 
            }
            _mWhl_Rt_Stat_AR.CRC_Whl_Rt_Stat = crc;
            putValue( HMI_CRC_Whl_Rt_Stat, crc );
        }
        else
            _mWhl_Rt_Stat_AR.CRC_Whl_Rt_Stat = getValue( HMI_CRC_Whl_Rt_Stat );
    }
    else
    {
        if( !getValue( HMI_CRC_Whl_Rt_Stat_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mWhl_Rt_Stat_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mWhl_Rt_Stat_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mWhl_Rt_Stat_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mWhl_Rt_Stat_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mWhl_Rt_Stat_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mWhl_Rt_Stat_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mWhl_Rt_Stat_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mWhl_Rt_Stat_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _Whl_Rt_Stat_AR_CRC_ErrorCnt   && ( _Whl_Rt_Stat_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_Whl_Rt_Stat_Invalid )                                         )    )
            {
                crc++;
                if( _Whl_Rt_Stat_AR_CRC_ErrorCnt > 0 )
                    _Whl_Rt_Stat_AR_CRC_ErrorCnt--; 
            }
            _mWhl_Rt_Stat_AR.CRC_Whl_Rt_Stat = crc;
            putValue( HMI_CRC_Whl_Rt_Stat, crc );
        }
        else
            _mWhl_Rt_Stat_AR.CRC_Whl_Rt_Stat = getValue( HMI_CRC_Whl_Rt_Stat );
    }
    if( ( _Whl_Rt_Stat_AR_MSG_DropCnt > 0 ) &&
        ( _Whl_Rt_Stat_AR_E2E_Armed == 1  )    )
    {
        _Whl_Rt_Stat_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mWhl_Rt_Stat_AR );
        
    if( _Whl_Rt_Stat_AR_E2E_Armed == 1 )
    {
        if ( ( _Whl_Rt_Stat_AR_MSG_DropCnt == 0      ) &&
             ( _Whl_Rt_Stat_AR_CRC_ErrorCnt == 0     ) &&
             ( _Whl_Rt_Stat_AR_SQC_RepeatedCnt == 0  ) &&
             ( _Whl_Rt_Stat_AR_SQC_WrongSeqJump == 0 )    )
        {
            _Whl_Rt_Stat_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_Whl_Rt_Stat_State, 0 );
        }
    }
}

Whl_Rt_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Whl_Rt_Stat_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Whl_Rt_Stat := %X\n", getValue( HMI__STMSG_Whl_Rt_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Whl_Rt_Stat := %X\n", getValue( HMI__STMSGT_Whl_Rt_Stat_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Whl_Rt_Stat := %X\n", getValue( HMI_CRC_Whl_Rt_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_Whl_Rt_Stat_Auto := %X\n", getValue( HMI_CRC_Whl_Rt_Stat_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Whl_Rt_Stat := %X\n", getValue( HMI_SQC_Whl_Rt_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_Whl_Rt_Stat_Auto := %X\n", getValue( HMI_SQC_Whl_Rt_Stat_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlDir_FR_Stat := %X\n", getValue( HMI_WhlDir_FR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlDir_RR_Stat := %X\n", getValue( HMI_WhlDir_RR_Stat ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlPlsCnt_FR := %X\n", getValue( HMI_WhlPlsCnt_FR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlPlsCnt_RR := %X\n", getValue( HMI_WhlPlsCnt_RR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlRPM_FR := %X\n", getValue( HMI_WhlRPM_FR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlRPM_FR_Qual := %X\n", getValue( HMI_WhlRPM_FR_Qual ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlRPM_RR := %X\n", getValue( HMI_WhlRPM_RR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlRPM_RR_Qual := %X\n", getValue( HMI_WhlRPM_RR_Qual ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tWhl_Rt_Stat_AR
{
    putValue( HMI__STMSG_Whl_Rt_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_Whl_Rt_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Whl_Rt_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tWhl_Rt_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_Whl_Rt_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Whl_Rt_Stat_AR
{
    if( getValue( this ) )
        openPanel("Whl_Lt_Rt_Stat_AR");
}

on envVar HMI_E2E_Whl_Rt_Stat_Inject
{
    if( getValue( this ) )
    {
        _Whl_Rt_Stat_AR_CRC_ErrorCnt = getValue( HMI_CRC_Whl_Rt_Stat_ErrorCount );
        _Whl_Rt_Stat_AR_SQC_TriggPos = getValue( HMI_SQC_Whl_Rt_Stat_TriggerPosition );
        _Whl_Rt_Stat_AR_SQC_WrongSeqJump = getValue( HMI_SQC_Whl_Rt_Stat_WrongSeq );
        _Whl_Rt_Stat_AR_SQC_RepeatedCnt = getValue( HMI_SQC_Whl_Rt_Stat_Repeated );
        _Whl_Rt_Stat_AR_MSG_DropCnt = getValue( HMI_SQC_Whl_Rt_Stat_MSG_DropCnt );
        putValue( HMI_E2E_Whl_Rt_Stat_State, 2 );
        _Whl_Rt_Stat_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_WhlDir_FR_Stat
{
    _mWhl_Rt_Stat_AR.WhlDir_FR_Stat.phys = getValue(this);
}

on EnvVar HMI_WhlDir_RR_Stat
{
    _mWhl_Rt_Stat_AR.WhlDir_RR_Stat.phys = getValue(this);
}

on EnvVar HMI_WhlPlsCnt_FR
{
    _mWhl_Rt_Stat_AR.WhlPlsCnt_FR.phys = getValue(this);
}

on EnvVar HMI_WhlPlsCnt_RR
{
    _mWhl_Rt_Stat_AR.WhlPlsCnt_RR.phys = getValue(this);
}

on EnvVar HMI_WhlRPM_FR
{
    _mWhl_Rt_Stat_AR.WhlRPM_FR.phys = getValue(this);
}

on EnvVar HMI_WhlRPM_FR_Qual
{
    _mWhl_Rt_Stat_AR.WhlRPM_FR_Qual.phys = getValue(this);
}

on EnvVar HMI_WhlRPM_RR
{
    _mWhl_Rt_Stat_AR.WhlRPM_RR.phys = getValue(this);
}

on EnvVar HMI_WhlRPM_RR_Qual
{
    _mWhl_Rt_Stat_AR.WhlRPM_RR_Qual.phys = getValue(this);
}

WhlPlsCnt_TPM_AR_check_output()
{
    if( !getValue( HMI__STMSG_WhlPlsCnt_TPM_AR ) )
    {
    //  message   WhlPlsCnt_TPM_AR ID: 233 --- Sendeart 0 cyclicX --- 
        _WhlPlsCnt_TPM_AR_Cnt--;
        if( _WhlPlsCnt_TPM_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            WhlPlsCnt_TPM_AR_output();
            // Zyklus-Z�hler zur�cksetzen
            _WhlPlsCnt_TPM_AR_Cnt = _WhlPlsCnt_TPM_AR_CycleCount;
        }
    }
}

WhlPlsCnt_TPM_AR_init()
{   /* Botschaft WhlPlsCnt_TPM_AR ID: 233 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 233 0;
BA_ "NmAsrMessage" BO_ 233 0;
BA_ "GenMsgMinAcceptLength" BO_ 233 8;
BA_ "GenMsgILSupport" BO_ 233 1;
BA_ "DiagState" BO_ 233 0;
BA_ "DiagRequest" BO_ 233 0;
BA_ "DiagResponse" BO_ 233 0;
BA_ "GenMsgStartValue" BO_ 233 "0";
BA_ "GenMsgCycleTime" BO_ 233 20;
BA_ "GenMsgSendType" BO_ 233 0;
    */
    _WhlPlsCnt_TPM_AR_Timebase =      c_tDBKomTimer_20ms;
    _WhlPlsCnt_TPM_AR_CycleCount =     20 / _WhlPlsCnt_TPM_AR_Timebase;
    _WhlPlsCnt_TPM_AR_StartDelay =      0 / _WhlPlsCnt_TPM_AR_Timebase;
    _WhlPlsCnt_TPM_AR_Cnt = _WhlPlsCnt_TPM_AR_StartDelay;

    putValue( HMI__STMSGSD_WhlPlsCnt_TPM_AR, _WhlPlsCnt_TPM_AR_StartDelay * _WhlPlsCnt_TPM_AR_Timebase );

    _mWhlPlsCnt_TPM_AR.Rsrv1_WhlPlsCnt_TPM.phys = getValue( HMI_Rsrv1_WhlPlsCnt_TPM );
    _mWhlPlsCnt_TPM_AR.Rsrv2_WhlPlsCnt_TPM.phys = getValue( HMI_Rsrv2_WhlPlsCnt_TPM );
    _mWhlPlsCnt_TPM_AR.WhlPlsCnt_FL.phys = getValue( HMI_WhlPlsCnt_FL_TPM );
    _mWhlPlsCnt_TPM_AR.WhlPlsCnt_FR.phys = getValue( HMI_WhlPlsCnt_FR_TPM );
    _mWhlPlsCnt_TPM_AR.WhlPlsCnt_RL.phys = getValue( HMI_WhlPlsCnt_RL_TPM );
    _mWhlPlsCnt_TPM_AR.WhlPlsCnt_RR.phys = getValue( HMI_WhlPlsCnt_RR_TPM );
    _mWhlPlsCnt_TPM_AR.WhlPlsCnt_TmStmp.phys = getValue( HMI_WhlPlsCnt_TmStmp );
}

WhlPlsCnt_TPM_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_WhlPlsCnt_TPM ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_WhlPlsCnt_TPM_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _WhlPlsCnt_TPM_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _WhlPlsCnt_TPM_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_WhlPlsCnt_TPM_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _WhlPlsCnt_TPM_AR_SQC_WrongSeqJump != 0 ) &&
            ( _WhlPlsCnt_TPM_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _WhlPlsCnt_TPM_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _WhlPlsCnt_TPM_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _WhlPlsCnt_TPM_AR_SQC_RepeatedCnt ) &&
            ( _WhlPlsCnt_TPM_AR_E2E_Armed == 1  )    )
        {
            _WhlPlsCnt_TPM_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_WhlPlsCnt_TPM, SQC_help );
    }
    _mWhlPlsCnt_TPM_AR.SQC_WhlPlsCnt_TPM = SQC_help;

    if( getValue( HMI_CRC_WhlPlsCnt_TPM_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_WhlPlsCnt_TPM_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mWhlPlsCnt_TPM_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mWhlPlsCnt_TPM_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mWhlPlsCnt_TPM_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mWhlPlsCnt_TPM_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mWhlPlsCnt_TPM_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mWhlPlsCnt_TPM_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mWhlPlsCnt_TPM_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mWhlPlsCnt_TPM_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _WhlPlsCnt_TPM_AR_CRC_Offset[ _mWhlPlsCnt_TPM_AR.SQC_WhlPlsCnt_TPM ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _WhlPlsCnt_TPM_AR_CRC_ErrorCnt   && ( _WhlPlsCnt_TPM_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_WhlPlsCnt_TPM_Invalid )                                         )    )
            {
                crc++;
                if( _WhlPlsCnt_TPM_AR_CRC_ErrorCnt > 0 )
                    _WhlPlsCnt_TPM_AR_CRC_ErrorCnt--; 
            }
            _mWhlPlsCnt_TPM_AR.CRC_WhlPlsCnt_TPM = crc;
            putValue( HMI_CRC_WhlPlsCnt_TPM, crc );
        }
        else
            _mWhlPlsCnt_TPM_AR.CRC_WhlPlsCnt_TPM = getValue( HMI_CRC_WhlPlsCnt_TPM );
    }
    else
    {
        if( !getValue( HMI_CRC_WhlPlsCnt_TPM_Auto ) )
        {   // CRC according to SAE1850 ( W222 )
            // berechne crc
            crc = 0xFF;
//            crc = crctable[ crc ^ _mWhlPlsCnt_TPM_AR.byte( 0 ) ];  CRC
            crc = crctable[ crc ^ _mWhlPlsCnt_TPM_AR.byte( 1 ) ];
            crc = crctable[ crc ^ _mWhlPlsCnt_TPM_AR.byte( 2 ) ];
            crc = crctable[ crc ^ _mWhlPlsCnt_TPM_AR.byte( 3 ) ];
            crc = crctable[ crc ^ _mWhlPlsCnt_TPM_AR.byte( 4 ) ];
            crc = crctable[ crc ^ _mWhlPlsCnt_TPM_AR.byte( 5 ) ];
            crc = crctable[ crc ^ _mWhlPlsCnt_TPM_AR.byte( 6 ) ];
            crc = crctable[ crc ^ _mWhlPlsCnt_TPM_AR.byte( 7 ) ];
            crc = (crc ^ 0xFF);
            if( ( _WhlPlsCnt_TPM_AR_CRC_ErrorCnt   && ( _WhlPlsCnt_TPM_AR_E2E_Armed == 1   ) ) ||
                ( getValue( HMI_CRC_WhlPlsCnt_TPM_Invalid )                                         )    )
            {
                crc++;
                if( _WhlPlsCnt_TPM_AR_CRC_ErrorCnt > 0 )
                    _WhlPlsCnt_TPM_AR_CRC_ErrorCnt--; 
            }
            _mWhlPlsCnt_TPM_AR.CRC_WhlPlsCnt_TPM = crc;
            putValue( HMI_CRC_WhlPlsCnt_TPM, crc );
        }
        else
            _mWhlPlsCnt_TPM_AR.CRC_WhlPlsCnt_TPM = getValue( HMI_CRC_WhlPlsCnt_TPM );
    }
    if( ( _WhlPlsCnt_TPM_AR_MSG_DropCnt > 0 ) &&
        ( _WhlPlsCnt_TPM_AR_E2E_Armed == 1  )    )
    {
        _WhlPlsCnt_TPM_AR_MSG_DropCnt--;  // do not send message
    }
    else
        output( _mWhlPlsCnt_TPM_AR );
        
    if( _WhlPlsCnt_TPM_AR_E2E_Armed == 1 )
    {
        if ( ( _WhlPlsCnt_TPM_AR_MSG_DropCnt == 0      ) &&
             ( _WhlPlsCnt_TPM_AR_CRC_ErrorCnt == 0     ) &&
             ( _WhlPlsCnt_TPM_AR_SQC_RepeatedCnt == 0  ) &&
             ( _WhlPlsCnt_TPM_AR_SQC_WrongSeqJump == 0 )    )
        {
            _WhlPlsCnt_TPM_AR_E2E_Armed = 0; // no further influence, injetion completed
            putValue( HMI_E2E_WhlPlsCnt_TPM_State, 0 );
        }
    }
}

WhlPlsCnt_TPM_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: WhlPlsCnt_TPM_AR\n", 28, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_WhlPlsCnt_TPM_AR := %X\n", getValue( HMI__STMSG_WhlPlsCnt_TPM_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_WhlPlsCnt_TPM_AR := %X\n", getValue( HMI__STMSGT_WhlPlsCnt_TPM_AR ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_WhlPlsCnt_TPM := %X\n", getValue( HMI_CRC_WhlPlsCnt_TPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_WhlPlsCnt_TPM_Auto := %X\n", getValue( HMI_CRC_WhlPlsCnt_TPM_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_CRC_WhlPlsCnt_TPM_Profile_02 := %X\n", getValue( HMI_CRC_WhlPlsCnt_TPM_Profile_02 ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv1_WhlPlsCnt_TPM := %X\n", getValue( HMI_Rsrv1_WhlPlsCnt_TPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Rsrv2_WhlPlsCnt_TPM := %X\n", getValue( HMI_Rsrv2_WhlPlsCnt_TPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_WhlPlsCnt_TPM := %X\n", getValue( HMI_SQC_WhlPlsCnt_TPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_SQC_WhlPlsCnt_TPM_Auto := %X\n", getValue( HMI_SQC_WhlPlsCnt_TPM_Auto ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlPlsCnt_FL := %X\n", getValue( HMI_WhlPlsCnt_FL_TPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlPlsCnt_FR := %X\n", getValue( HMI_WhlPlsCnt_FR_TPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlPlsCnt_RL := %X\n", getValue( HMI_WhlPlsCnt_RL_TPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlPlsCnt_RR := %X\n", getValue( HMI_WhlPlsCnt_RR_TPM ) );        filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WhlPlsCnt_TmStmp := %X\n", getValue( HMI_WhlPlsCnt_TmStmp ) );        filePutString( buffer, elcount( buffer ), hFile );
}

on timer _tWhlPlsCnt_TPM_AR
{
    putValue( HMI__STMSG_WhlPlsCnt_TPM_AR, 0 );
}

on EnvVar HMI__STMSG_WhlPlsCnt_TPM_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_WhlPlsCnt_TPM_AR );
        if( tDelay > 0)    
            setTimer( _tWhlPlsCnt_TPM_AR, tDelay );
        else
            putValue( HMI__STMSG_WhlPlsCnt_TPM_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_WhlPlsCnt_TPM_AR
{
    if( getValue( this ) )
        openPanel("WhlPlsCnt_TPM_AR");
}

on EnvVar HMI_Rsrv1_WhlPlsCnt_TPM
{
    _mWhlPlsCnt_TPM_AR.Rsrv1_WhlPlsCnt_TPM.phys = getValue(this);
}

on EnvVar HMI_Rsrv2_WhlPlsCnt_TPM
{
    _mWhlPlsCnt_TPM_AR.Rsrv2_WhlPlsCnt_TPM.phys = getValue(this);
}

on EnvVar HMI_WhlPlsCnt_FL_TPM
{
    _mWhlPlsCnt_TPM_AR.WhlPlsCnt_FL.phys = getValue(this);
}

on EnvVar HMI_WhlPlsCnt_FR_TPM
{
    _mWhlPlsCnt_TPM_AR.WhlPlsCnt_FR.phys = getValue(this);
}

on EnvVar HMI_WhlPlsCnt_RL_TPM
{
    _mWhlPlsCnt_TPM_AR.WhlPlsCnt_RL.phys = getValue(this);
}

on EnvVar HMI_WhlPlsCnt_RR_TPM
{
    _mWhlPlsCnt_TPM_AR.WhlPlsCnt_RR.phys = getValue(this);
}

on EnvVar HMI_WhlPlsCnt_TmStmp
{
    _mWhlPlsCnt_TPM_AR.WhlPlsCnt_TmStmp.phys = getValue(this);
}

WIA_EngTrq_AR_check_output()
{
    if( !getValue( HMI__STMSG_WIA_EngTrq_AR ) )
    {
    //  message   WIA_EngTrq_AR ID: 1149 --- Sendeart 0 cyclicX --- 
        _WIA_EngTrq_AR_Cnt--;
        if( _WIA_EngTrq_AR_Cnt < 1 )
        {
            WIA_EngTrq_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _WIA_EngTrq_AR_Cnt = _WIA_EngTrq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
        }
    }
}

WIA_EngTrq_AR_init()
{   /* Botschaft WIA_EngTrq_AR ID: 1149 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 1149 0;
BA_ "NmAsrMessage" BO_ 1149 0;
BA_ "GenMsgMinAcceptLength" BO_ 1149 6;
BA_ "GenMsgILSupport" BO_ 1149 1;
BA_ "DiagState" BO_ 1149 0;
BA_ "DiagRequest" BO_ 1149 0;
BA_ "DiagResponse" BO_ 1149 0;
BA_ "GenMsgStartValue" BO_ 1149 "0";
BA_ "GenMsgStartDelayTime" BO_ 1149 0;
BA_ "GenMsgCycleTime" BO_ 1149 500;
BA_ "GenMsgSendType" BO_ 1149 0;
    */
    _WIA_EngTrq_AR_Timebase =      c_tDBKomTimer_20ms;
    _WIA_EngTrq_AR_CycleCount =   500 / _WIA_EngTrq_AR_Timebase;
    _WIA_EngTrq_AR_StartDelay =     0 / _WIA_EngTrq_AR_Timebase;
    _WIA_EngTrq_AR_Cnt = _WIA_EngTrq_AR_StartDelay;

    putValue( HMI__STMSGSD_WIA_EngTrq_AR, _WIA_EngTrq_AR_StartDelay * _WIA_EngTrq_AR_Timebase );

    _mWIA_EngTrq_AR.WIA_EngTrqMax.phys = getValue( HMI_WIA_EngTrqMax );
    _mWIA_EngTrq_AR.WIA_EngTrqMin.phys = getValue( HMI_WIA_EngTrqMin );
    _mWIA_EngTrq_AR.WIA_EngTrqStatic.phys = getValue( HMI_WIA_EngTrqStatic );
}

WIA_EngTrq_AR_output(void)
{
    output( _mWIA_EngTrq_AR );
}

WIA_EngTrq_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: WIA_EngTrq_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_WIA_EngTrq_AR := %X\n", getValue( HMI__STMSG_WIA_EngTrq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_WIA_EngTrq_AR := %X\n", getValue( HMI__STMSGT_WIA_EngTrq_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WIA_EngTrqMax := %X\n", getValue( HMI_WIA_EngTrqMax ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WIA_EngTrqMin := %X\n", getValue( HMI_WIA_EngTrqMin ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WIA_EngTrqStatic := %X\n", getValue( HMI_WIA_EngTrqStatic ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tWIA_EngTrq_AR
{
    putValue( HMI__STMSG_WIA_EngTrq_AR, 0 );
}

on EnvVar HMI__STMSG_WIA_EngTrq_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_WIA_EngTrq_AR );
        if( tDelay > 0)    
            setTimer( _tWIA_EngTrq_AR, tDelay );
        else
            putValue( HMI__STMSG_WIA_EngTrq_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_WIA_EngTrq_AR
{
    if( getValue( this ) )
        openPanel("WIA_EngTrq_AR");
}

on EnvVar HMI_WIA_EngTrqMax
{
    _mWIA_EngTrq_AR.WIA_EngTrqMax.phys = getValue(this);
}

on EnvVar HMI_WIA_EngTrqMin
{
    _mWIA_EngTrq_AR.WIA_EngTrqMin.phys = getValue(this);
}

on EnvVar HMI_WIA_EngTrqStatic
{
    _mWIA_EngTrq_AR.WIA_EngTrqStatic.phys = getValue(this);
}

Wpr_Stat_AR_check_output()
{
    if( !getValue( HMI__STMSG_Wpr_Stat_AR ) )
    {
    //  message   Wpr_Stat_AR ID: 845 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _Wpr_Stat_AR_Cnt--;
        if( _Wpr_Stat_AR_Cnt < 1 )
        {
            // Nachricht wg. abgelaufenem Zyklus ausgeben
            Wpr_Stat_AR_output();
            _Wpr_Stat_AR_Cnt = _Wpr_Stat_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _Wpr_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _Wpr_Stat_AR_SpontanFlag)
        {
            // Nachricht wg. spontaner �nderung ausgeben
            Wpr_Stat_AR_output();
            _Wpr_Stat_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

Wpr_Stat_AR_init()
{   /* Botschaft Wpr_Stat_AR ID: 845 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 845 0;
BA_ "NmAsrMessage" BO_ 845 0;
BA_ "GenMsgMinAcceptLength" BO_ 845 2;
BA_ "GenMsgILSupport" BO_ 845 1;
BA_ "DiagState" BO_ 845 0;
BA_ "DiagRequest" BO_ 845 0;
BA_ "DiagResponse" BO_ 845 0;
BA_ "GenMsgStartValue" BO_ 845 "0";
BA_ "GenMsgStartDelayTime" BO_ 845 0;
BA_ "GenMsgDelayTime" BO_ 845 5;
BA_ "GenMsgNrOfRepetitions" BO_ 845 0;
BA_ "GenMsgCycleTime" BO_ 845 1000;
BA_ "GenMsgSendType" BO_ 845 5;
    */
    _Wpr_Stat_AR_Timebase =        c_tDBKomTimer_20ms;
    _Wpr_Stat_AR_CycleCount =    1000 / _Wpr_Stat_AR_Timebase;
    _Wpr_Stat_AR_StartDelay =       0 / _Wpr_Stat_AR_Timebase;
    _Wpr_Stat_AR_Cnt = _Wpr_Stat_AR_StartDelay;
    _Wpr_Stat_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_Wpr_Stat_AR, _Wpr_Stat_AR_StartDelay * _Wpr_Stat_AR_Timebase );

    _mWpr_Stat_AR.HL_Wash_Actv.phys = getValue( HMI_HL_Wash_Actv );
    _mWpr_Stat_AR.Splash.phys = getValue( HMI_Splash );
    _mWpr_Stat_AR.Wpr_R_Actv.phys = getValue( HMI_Wpr_R_Actv );
    _mWpr_Stat_AR.Wpr_R_On_Rq.phys = getValue( HMI_Wpr_R_On_Rq );
    _mWpr_Stat_AR.Wpr_Stat.phys = getValue( HMI_Wpr_Stat );
    _mWpr_Stat_AR.WprFltMsgDisp_Rq_WPRM.phys = getValue( HMI_WprFltMsgDisp_Rq_WPRM );
    _mWpr_Stat_AR.WprOutsdPkPosn.phys = getValue( HMI_WprOutsdPkPosn );  
    _mWpr_Stat_AR.Carwash_RainSens_Actv_Stat.phys = getValue( HMI_Carwash_RainSens_Actv_Stat );
    _mWpr_Stat_AR.Carwash_Wpr_R_Stat.phys = getValue( HMI_Carwash_Wpr_R_Stat );
}

Wpr_Stat_AR_output(void)
{
    output( _mWpr_Stat_AR );
}

Wpr_Stat_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: Wpr_Stat_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_Wpr_Stat_AR := %X\n", getValue( HMI__STMSG_Wpr_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_Wpr_Stat_AR := %X\n", getValue( HMI__STMSGT_Wpr_Stat_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_HL_Wash_Actv := %X\n", getValue( HMI_HL_Wash_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Splash := %X\n", getValue( HMI_Splash ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Wpr_R_Actv := %X\n", getValue( HMI_Wpr_R_Actv ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Wpr_R_On_Rq := %X\n", getValue( HMI_Wpr_R_On_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Wpr_Stat := %X\n", getValue( HMI_Wpr_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WprFltMsgDisp_Rq_WPRM := %X\n", getValue( HMI_WprFltMsgDisp_Rq_WPRM ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WprOutsdPkPosn := %X\n", getValue( HMI_WprOutsdPkPosn ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Carwash_RainSens_Actv_Stat := %X\n", getValue( HMI_Carwash_RainSens_Actv_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_Carwash_Wpr_R_Stat := %X\n", getValue( HMI_Carwash_Wpr_R_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tWpr_Stat_AR
{
    putValue( HMI__STMSG_Wpr_Stat_AR, 0 );
}

on EnvVar HMI__STMSG_Wpr_Stat_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_Wpr_Stat_AR );
        if( tDelay > 0)    
            setTimer( _tWpr_Stat_AR, tDelay );
        else
            putValue( HMI__STMSG_Wpr_Stat_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_Wpr_Stat_AR
{
    if( getValue( this ) )
        openPanel("Wpr_Stat_AR");
}

on EnvVar HMI_HL_Wash_Actv
{
    _mWpr_Stat_AR.HL_Wash_Actv.phys = getValue(this);
    _Wpr_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Splash
{
    _mWpr_Stat_AR.Splash.phys = getValue(this);
    _Wpr_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Wpr_R_Actv
{
    _mWpr_Stat_AR.Wpr_R_Actv.phys = getValue(this);
    _Wpr_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Wpr_R_On_Rq
{
    _mWpr_Stat_AR.Wpr_R_On_Rq.phys = getValue(this);
    _Wpr_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Wpr_Stat
{
    _mWpr_Stat_AR.Wpr_Stat.phys = getValue(this);
    _Wpr_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_WprFltMsgDisp_Rq_WPRM
{
    _mWpr_Stat_AR.WprFltMsgDisp_Rq_WPRM.phys = getValue(this);
    _Wpr_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_WprOutsdPkPosn
{
    _mWpr_Stat_AR.WprOutsdPkPosn.phys = getValue(this);
    _Wpr_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Carwash_RainSens_Actv_Stat
{
    _mWpr_Stat_AR.Carwash_RainSens_Actv_Stat.phys = getValue(this);
    _Wpr_Stat_AR_SpontanFlag = 1;
}

on EnvVar HMI_Carwash_Wpr_R_Stat
{
    _mWpr_Stat_AR.Carwash_Wpr_R_Stat.phys = getValue(this);
    _Wpr_Stat_AR_SpontanFlag = 1;
}

WPT_Stat2_AR_check_output()
{
    if( !getValue( HMI__STMSG_WPT_Stat2_AR ) )
    {
    //  message   WPT_Stat2_AR ID: 634 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
        _WPT_Stat2_AR_Cnt--;
        if( _WPT_Stat2_AR_Cnt < 1 )
        {
            WPT_Stat2_AR_output(); // Nachricht wg. abgelaufenem Zyklus ausgeben
            _WPT_Stat2_AR_Cnt = _WPT_Stat2_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            _WPT_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
        else if( _WPT_Stat2_AR_SpontanFlag)
        {
            WPT_Stat2_AR_output(); // Nachricht wg. spontaner �nderung ausgeben
            _WPT_Stat2_AR_SpontanFlag = 0; // Spontan-Flag zur�cksetzen
        }
    }
}

WPT_Stat2_AR_init()
{   /* Botschaft WPT_Stat2_AR ID: 634 --- Sendeart 5 cyclicAndSpontanWithDelay --- 
BA_ "ApplMessage" BO_ 634 0;
BA_ "NmAsrMessage" BO_ 634 0;
BA_ "GenMsgMinAcceptLength" BO_ 634 8;
BA_ "GenMsgILSupport" BO_ 634 1;
BA_ "DiagState" BO_ 634 0;
BA_ "DiagRequest" BO_ 634 0;
BA_ "DiagResponse" BO_ 634 0;
BA_ "GenMsgStartValue" BO_ 634 "0";
BA_ "GenMsgDelayTime" BO_ 634 20;
BA_ "GenMsgNrOfRepetition" BO_ 634 0;
BA_ "GenMsgCycleTime" BO_ 634 200;
BA_ "GenMsgSendType" BO_ 634 5;
    */
    _WPT_Stat2_AR_Timebase =        c_tDBKomTimer_20ms;
    _WPT_Stat2_AR_CycleCount =     200 / _WPT_Stat2_AR_Timebase;
    _WPT_Stat2_AR_StartDelay =       0 / _WPT_Stat2_AR_Timebase;
    _WPT_Stat2_AR_Cnt = _WPT_Stat2_AR_StartDelay;
    _WPT_Stat2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_WPT_Stat2_AR, _WPT_Stat2_AR_StartDelay * _WPT_Stat2_AR_Timebase );

    _mWPT_Stat2_AR.WPT_GPM_CPM_Con_Stat.phys = getValue( HMI_WPT_GPM_CPM_Con_Stat );
    _mWPT_Stat2_AR.WPT_ObjDtct.phys = getValue( HMI_WPT_ObjDtct );
    _mWPT_Stat2_AR.WPT_Posn_DstrtnAngl.phys = getValue( HMI_WPT_Posn_DstrtnAngl );
    _mWPT_Stat2_AR.WPT_Posn_Stat.phys = getValue( HMI_WPT_Posn_Stat );
    _mWPT_Stat2_AR.WPT_Posn_Stat_Disp_Rq.phys = getValue( HMI_WPT_Posn_Stat_Disp_Rq );
    _mWPT_Stat2_AR.WPT_Posn_X_Disp_Rq.phys = getValue( HMI_WPT_Posn_X_Disp_Rq );
    _mWPT_Stat2_AR.WPT_Posn_Y_Disp_Rq.phys = getValue( HMI_WPT_Posn_Y_Disp_Rq );
    _mWPT_Stat2_AR.WPT_RelDist.phys = getValue( HMI_WPT_RelDist );
    _mWPT_Stat2_AR.WPT_Sound_Rq.phys = getValue( HMI_WPT_Sound_Rq );
    _mWPT_Stat2_AR.WPT_Susp_Rq.phys = getValue( HMI_WPT_Susp_Rq );
    _mWPT_Stat2_AR.WPT_Flt_Disp_Rq.phys = getValue( HMI_WPT_Flt_Disp_Rq );
}

WPT_Stat2_AR_output(void)
{
    output( _mWPT_Stat2_AR );
}

WPT_Stat2_AR_saveEnvVars( dword hFile )
{
    filePutString("\n// Knoten EIS: WPT_Stat2_AR\n", 25, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_WPT_Stat2_AR := %X\n", getValue( HMI__STMSG_WPT_Stat2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_WPT_Stat2_AR := %X\n", getValue( HMI__STMSGT_WPT_Stat2_AR ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WPT_GPM_CPM_Con_Stat := %X\n", getValue( HMI_WPT_GPM_CPM_Con_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WPT_ObjDtct := %X\n", getValue( HMI_WPT_ObjDtct ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WPT_Posn_DstrtnAngl := %X\n", getValue( HMI_WPT_Posn_DstrtnAngl ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WPT_Posn_Stat := %X\n", getValue( HMI_WPT_Posn_Stat ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WPT_Posn_Stat_Disp_Rq := %X\n", getValue( HMI_WPT_Posn_Stat_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WPT_Posn_X_Disp_Rq := %X\n", getValue( HMI_WPT_Posn_X_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WPT_Posn_Y_Disp_Rq := %X\n", getValue( HMI_WPT_Posn_Y_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WPT_RelDist := %X\n", getValue( HMI_WPT_RelDist ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WPT_Sound_Rq := %X\n", getValue( HMI_WPT_Sound_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WPT_Susp_Rq := %X\n", getValue( HMI_WPT_Susp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_WPT_Flt_Disp_Rq := %X\n", getValue( HMI_WPT_Flt_Disp_Rq ) );        filePutString ( buffer, elcount( buffer ), hFile );
}

on timer _tWPT_Stat2_AR
{
    putValue( HMI__STMSG_WPT_Stat2_AR, 0 );
}

on EnvVar HMI__STMSG_WPT_Stat2_AR
{
    long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_WPT_Stat2_AR );
        if( tDelay > 0)    
            setTimer( _tWPT_Stat2_AR, tDelay );
        else
            putValue( HMI__STMSG_WPT_Stat2_AR, 0 );
    }
}

on envVar HMI__STMSG_PO_WPT_Stat2_AR
{
    if( getValue( this ) )
        openPanel("WPT_Stat2_AR");
}

on envVar HMI_E2E_WhlPlsCnt_TPM_Inject
{
    if( getValue( this ) )
    {
        _WhlPlsCnt_TPM_AR_CRC_ErrorCnt = getValue( HMI_CRC_WhlPlsCnt_TPM_ErrorCount );
        _WhlPlsCnt_TPM_AR_SQC_TriggPos = getValue( HMI_SQC_WhlPlsCnt_TPM_TriggerPosition );
        _WhlPlsCnt_TPM_AR_SQC_WrongSeqJump = getValue( HMI_SQC_WhlPlsCnt_TPM_WrongSeq );
        _WhlPlsCnt_TPM_AR_SQC_RepeatedCnt = getValue( HMI_SQC_WhlPlsCnt_TPM_Repeated );
        _WhlPlsCnt_TPM_AR_MSG_DropCnt = getValue( HMI_SQC_WhlPlsCnt_TPM_MSG_DropCnt );
        putValue( HMI_E2E_WhlPlsCnt_TPM_State, 2 );
        _WhlPlsCnt_TPM_AR_E2E_Armed = 2;  //armed
    }
}

on EnvVar HMI_WPT_GPM_CPM_Con_Stat
{
    _mWPT_Stat2_AR.WPT_GPM_CPM_Con_Stat.phys = getValue(this);
    _WPT_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_WPT_ObjDtct
{
    _mWPT_Stat2_AR.WPT_ObjDtct.phys = getValue(this);
    _WPT_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_WPT_Posn_DstrtnAngl
{
    _mWPT_Stat2_AR.WPT_Posn_DstrtnAngl.phys = getValue(this);
    _WPT_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_WPT_Posn_Stat
{
    _mWPT_Stat2_AR.WPT_Posn_Stat.phys = getValue(this);
    _WPT_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_WPT_Posn_Stat_Disp_Rq
{
    _mWPT_Stat2_AR.WPT_Posn_Stat_Disp_Rq.phys = getValue(this);
    _WPT_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_WPT_Posn_X_Disp_Rq
{
    _mWPT_Stat2_AR.WPT_Posn_X_Disp_Rq.phys = getValue(this);
    _WPT_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_WPT_Posn_Y_Disp_Rq
{
    _mWPT_Stat2_AR.WPT_Posn_Y_Disp_Rq.phys = getValue(this);
    _WPT_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_WPT_RelDist
{
    _mWPT_Stat2_AR.WPT_RelDist.phys = getValue(this);
    _WPT_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_WPT_Sound_Rq
{
    _mWPT_Stat2_AR.WPT_Sound_Rq.phys = getValue(this);
    _WPT_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_WPT_Susp_Rq
{
    _mWPT_Stat2_AR.WPT_Susp_Rq.phys = getValue(this);
    _WPT_Stat2_AR_SpontanFlag = 1;
}

on EnvVar HMI_WPT_Flt_Disp_Rq
{
    _mWPT_Stat2_AR.WPT_Flt_Disp_Rq.phys = getValue(this);
    _WPT_Stat2_AR_SpontanFlag = 1;
}

PNHV_Disp_Rq2_AR_init()
{
    _PNHV_Disp_Rq2_AR_Timebase =           c_tDBKomTimer_20ms;
    _PNHV_Disp_Rq2_AR_CycleCount =      1000 / _PNHV_Disp_Rq2_AR_Timebase;
    _PNHV_Disp_Rq2_AR_StartDelay =         0 / _PNHV_Disp_Rq2_AR_Timebase;
    _PNHV_Disp_Rq2_AR_Cnt = _PNHV_Disp_Rq2_AR_CycleCount;
    _PNHV_Disp_Rq2_AR_DelayCnt = 0;

    
    putValue( HMI__STMSGSD_PNHV_Disp_Rq2_AR, _PNHV_Disp_Rq2_AR_StartDelay *_PNHV_Disp_Rq2_AR_Timebase );

/*
    _mPNHV_Disp_Rq2_AR.PNHV_AutoUnlk_Stat.phys = getValue( HMI_PNHV_AutoUnlk_Stat );
	_mPNHV_Disp_Rq2_AR.PNHV_EcoChrg_Stat.phys = getValue( HMI_PNHV_EcoChrg_Stat );
	_mPNHV_Disp_Rq2_AR.PNHV_ChrgPwr_Disp_Rq_V2.phys = getValue( HMI_PNHV_ChrgPwr_Disp_Rq_V2 );
	_mPNHV_Disp_Rq2_AR.PNHV_InPos_Stat.phys = getValue( HMI_PNHV_InPos_Stat );
	_mPNHV_Disp_Rq2_AR.PNHV_InPos_Stat.phys = getValue( HMI_PNHV_InPos_Stat ); 
    _mPNHV_Disp_Rq2_AR.PNHV_PwrMeter_PosPwrLmt_Perc_Disp_Rq.phys = getValue( HMI_PNHV_PwrMeter_PosPwrLmt_Perc_Disp_Rq );
	_mPNHV_Disp_Rq2_AR.PNHV_PwrMeter_RecupLmt_Perc_Disp_Rq.phys = getValue( HMI_PNHV_PwrMeter_RecupLmt_Perc_Disp_Rq );	
	_mPNHV_Disp_Rq2_AR.ChrgProgSel_Stat.phys = getValue( HMI_ChrgProgSel_Stat );
    _mPNHV_Disp_Rq2_AR.PNHV_PwrMeter_Color_Disp_Rq.phys = getValue( HMI_PNHV_PwrMeter_Color_Disp_Rq );
	_mPNHV_Disp_Rq2_AR.PNHV_Rcmnd_Spd_Marker_Disp_Rq.phys = getValue( HMI_PNHV_Rcmnd_Spd_Marker_Disp_Rq );
	_mPNHV_Disp_Rq2_AR.PNHV_Rcmnd_Spd_Ring_Disp_Rq.phys = getValue( HMI_PNHV_Rcmnd_Spd_Ring_Disp_Rq );
  	_mPNHV_Disp_Rq2_AR.PNHV_ChrgSys_Chrg_Stat_Ind.phys = getValue( HMI_PNHV_ChrgSys_Chrg_Stat_Ind );
	_mPNHV_Disp_Rq2_AR.PNHV_ChrgSys_ErrEval_Icon_Disp_Rq.phys = getValue( HMI_PNHV_ChrgSys_ErrEval_Icon_Disp_Rq );
    _mPNHV_Disp_Rq2_AR.PNHV_ChrgSys_ErrEval_Msg_Disp_Rq.phys = getValue( HMI_PNHV_ChrgSys_ErrEval_Msg_Disp_Rq ); 
     _mPNHV_Disp_Rq2_AR.PNHV_WeeklyProf_Stat.phys = getValue( HMI_PNHV_WeeklyProf_Stat );   
  
*/

}

PNHV_Disp_Rq2_AR_check_output()
{
	if( !getValue( HMI__STMSG_PNHV_Disp_Rq2_AR) )
    {
        if( _ExitWarn_Disp_Rq_AR_DelayCnt > 0) 
            _ExitWarn_Disp_Rq_AR_DelayCnt--; // Mindestsendeabstand

        _PNHV_Disp_Rq2_AR_Cnt--;

        if( _PNHV_Disp_Rq2_AR_Cnt < 1 )
        {

            // Nachricht wg. abgelaufenem Zyklus ausgeben (Mindestsendeabstand eingehalten)
            PNHV_Disp_Rq2_AR_output();

            _PNHV_Disp_Rq2_AR_Cnt =  _PNHV_Disp_Rq2_AR_CycleCount;  //_ExitWarn_Disp_Rq_AR_CycleCount; // Zyklus-Z�hler zur�cksetzen
            //write("%d",  _PNHV_Disp_Rq2_AR_CycleCount);
        }
	}
}

on timer _tPNHV_Disp_Rq2_AR
{
    putValue( HMI__STMSG_PNHV_Disp_Rq2_AR, 0 );
}

on envVar HMI__STMSG_PNHV_Disp_Rq2_AR
{
        long tDelay;
    if( getValue( this ) == 2 )
    {
        tDelay = getValue( HMI__STMSGT_PNHV_Disp_Rq2_AR );
        if( tDelay > 0)    
            setTimer( _tPNHV_Disp_Rq2_AR, tDelay );
        else
            putValue( HMI__STMSG_PNHV_Disp_Rq2_AR, 0 );
    }
}

PNHV_Disp_Rq2_AR_saveEnvVars (dword hFile)
{
    filePutString("\n// Knoten EIS: PNHV_Disp_Rq2_AR\n", 33, hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSG_PNHV_Disp_Rq2_AR := %X\n", getValue( HMI__STMSG_PNHV_Disp_Rq2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI__STMSGT_PNHV_Disp_Rq2_AR := %X\n", getValue( HMI__STMSGT_PNHV_Disp_Rq2_AR ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_AutoUnlk_Stat := %X\n", getValue( HMI_PNHV_AutoUnlk_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_EcoChrg_Stat := %X\n", getValue( HMI_PNHV_EcoChrg_Stat ) );		filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_InPos_Stat := %X\n", getValue( HMI_PNHV_InPos_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_LocBsd_Stat := %X\n", getValue( HMI_PNHV_LocBsd_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_TripDist_Max_Disp_Rq := %X\n", getValue( HMI_PNHV_TripDist_Max_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_TripDist_Min_Disp_Rq := %X\n", getValue( HMI_PNHV_TripDist_Min_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_Rcmnd_Spd_Disp_Rq := %X\n", getValue( HMI_PNHV_Rcmnd_Spd_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
	snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_Rcmnd_PwrLmt_Perc_Disp_Rq := %X\n", getValue( HMI_PNHV_Rcmnd_PwrLmt_Perc_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_TripDist_Trnd_Disp_Rq := %X\n", getValue( HMI_PNHV_TripDist_Trnd_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_Rcmnd_Spd_Unit_Disp_Rq := %X\n", getValue( HMI_PNHV_Rcmnd_Spd_Unit_Disp_Rq ) );    filePutString( buffer, elcount( buffer ), hFile );
    snprintf( buffer, elcount( buffer ), "0.0000 HMI_PNHV_WeeklyProf_Stat := %X\n", getValue( HMI_PNHV_WeeklyProf_Stat ) );    filePutString( buffer, elcount( buffer ), hFile );
}

on envVar HMI_PNHV_AutoUnlk_Stat
{
   _mPNHV_Disp_Rq2_AR.PNHV_AutoUnlk_Stat.phys = getValue(this);
}

on EnvVar HMI_PNHV_EcoChrg_Stat
{
	_mPNHV_Disp_Rq2_AR.PNHV_EcoChrg_Stat.phys = getValue(this);
}

on envVar HMI_PNHV_InPos_Stat
{
   _mPNHV_Disp_Rq2_AR.PNHV_InPos_Stat.phys = getValue(this);
}

on envVar HMI_PNHV_LocBsd_Stat
{
   _mPNHV_Disp_Rq2_AR.PNHV_LocBsd_Stat.phys = getValue(this);
}

on envVar HMI_PNHV_TripDist_Max_Disp_Rq
{
   _mPNHV_Disp_Rq2_AR.PNHV_TripDist_Max_Disp_Rq.phys = getValue(this);
}

on envVar HMI_PNHV_TripDist_Min_Disp_Rq
{
	_mPNHV_Disp_Rq2_AR.PNHV_TripDist_Min_Disp_Rq.phys = getValue(this);
}

on envVar HMI_PNHV_Rcmnd_Spd_Disp_Rq
{
	_mPNHV_Disp_Rq2_AR.PNHV_Rcmnd_Spd_Disp_Rq.phys = getValue(this);
}

on envVar HMI_PNHV_Rcmnd_PwrLmt_Perc_Disp_Rq 
{
	_mPNHV_Disp_Rq2_AR.PNHV_Rcmnd_PwrLmt_Perc_Disp_Rq.phys = getValue(this);
}

on envVar HMI_PNHV_TripDist_Trnd_Disp_Rq 
{
	_mPNHV_Disp_Rq2_AR.PNHV_TripDist_Trnd_Disp_Rq.phys = getValue(this);
}

on envVar HMI_PNHV_Rcmnd_Spd_Unit_Disp_Rq
{
	_mPNHV_Disp_Rq2_AR.PNHV_Rcmnd_Spd_Unit_Disp_Rq.phys = getValue(this);
}

on envVar HMI_PNHV_WeeklyProf_Stat
{
   _mPNHV_Disp_Rq2_AR.PNHV_WeeklyProf_Stat.phys = getValue(this);
}

PNHV_Disp_Rq2_AR_output ()
{
    output( _mPNHV_Disp_Rq2_AR );
}



CamLane_LaneAttr2_AR_check_output()
{
    if( !getValue( HMI__STMSG_CamLane_LaneAttr2_AR ) )
        {
        //  message   CamLane_LaneAttr2_AR ID: 486 --- Sendeart 0 cyclicX --- 
            _CamLane_LaneAttr2_AR_Cnt--;
            if( _CamLane_LaneAttr2_AR_Cnt < 1 )
            {
                // Nachricht wg. abgelaufenem Zyklus ausgeben
                CamLane_LaneAttr2_AR_output();
                // Zyklus-Z�hler zur�cksetzen
                _CamLane_LaneAttr2_AR_Cnt = _CamLane_LaneAttr2_AR_CycleCount;
            }
        }
}

CamLane_LaneAttr2_AR_init()
{    /* Botschaft CamLane_LaneAttr2_AR ID: 486 --- Sendeart 0 cyclicX --- 
BA_ "ApplMessage" BO_ 486 0;
BA_ "NmAsrMessage" BO_ 486 0;
BA_ "GenMsgMinAcceptLength" BO_ 486 8;
BA_ "GenMsgILSupport" BO_ 486 1;
BA_ "DiagState" BO_ 486 0;
BA_ "DiagRequest" BO_ 486 0;
BA_ "DiagResponse" BO_ 486 0;
BA_ "GenMsgStartValue" BO_ 486 "0";
BA_ "GenMsgCycleTime" BO_ 486 40;
BA_ "GenMsgSendType" BO_ 486 0;
    */
    _CamLane_LaneAttr2_AR_Timebase =      c_tDBKomTimer_20ms;
    _CamLane_LaneAttr2_AR_CycleCount =     40 / _CamLane_LaneAttr2_AR_Timebase;
    _CamLane_LaneAttr2_AR_StartDelay =      0 / _CamLane_LaneAttr2_AR_Timebase;
    _CamLane_LaneAttr2_AR_Cnt = _CamLane_LaneAttr2_AR_StartDelay;
    _CamLane_LaneAttr2_AR_SpontanFlag = 0;

    putValue( HMI__STMSGSD_CamLane_LaneAttr2_AR, _CamLane_LaneAttr2_AR_StartDelay * _CamLane_LaneAttr2_AR_Timebase );

    _mCamLane_LaneAttr2_AR.CamLane_2ndClothoid_C1_Lt.phys = getValue( HMI_CamLane_2ndClothoid_C1_Lt );
    _mCamLane_LaneAttr2_AR.CamLane_2ndClothoid_Stat_Lt.phys = getValue( HMI_CamLane_2ndClothoid_Stat_Lt );
    _mCamLane_LaneAttr2_AR.NghbrLaneMarkType_Lt.phys = getValue( HMI_NghbrLaneMarkType_Lt );
	_mCamLane_LaneAttr2_AR.VLN_DtctDist_Lt.phys = getValue( HMI_VLN_DtctDist_Lt );
    _mCamLane_LaneAttr2_AR.CamLane_2ndClothoid_InitDist_Lt.phys = getValue( HMI_CamLane_2ndClothoid_InitDist_Lt );
    _mCamLane_LaneAttr2_AR.CamLane_LaneHrztCrv_Lt.phys = getValue( HMI_CamLane_LaneHrztCrv_Lt );
	_mCamLane_LaneAttr2_AR.CamLane_LaneMarkType_Lt.phys = getValue( HMI_CamLane_LaneMarkType_Lt );
    _mCamLane_LaneAttr2_AR.CamLane_LaneAttr2_Sync.phys = getValue( HMI_CamLane_LaneAttr2_Sync );
	
}

CamLane_LaneAttr2_AR_output()
{
    byte crc;
    byte SQC_help;

    SQC_help = getValue( HMI_SQC_CamLane_LaneAttr2 ); //get copy of actual EnvVar
    if( !getValue( HMI_SQC_CamLane_LaneAttr2_Auto ) ) // automatic SQC-calculation active ?
    {
        if( SQC_help == _CamLane_LaneAttr2_AR_SQC_TriggPos ) // start injection of error when trigger reached
        {
            _CamLane_LaneAttr2_AR_E2E_Armed = 1;   // run
            putValue( HMI_E2E_CamLane_LaneAttr2_State, 1 );
        }
        // calculate new sequence counter
        
        if( ( _CamLane_LaneAttr2_AR_SQC_WrongSeqJump != 0 ) &&
            ( _CamLane_LaneAttr2_AR_E2E_Armed == 1        )    )
        {
            SQC_help = SQC_help + 16 + _CamLane_LaneAttr2_AR_SQC_WrongSeqJump;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            if( SQC_help > 15 )
                SQC_help = SQC_help - 16;
            _CamLane_LaneAttr2_AR_SQC_WrongSeqJump = 0;
        }
        
        if( ( _CamLane_LaneAttr2_AR_SQC_RepeatedCnt ) &&
            ( _CamLane_LaneAttr2_AR_E2E_Armed == 1  )    )
        {
            _CamLane_LaneAttr2_AR_SQC_RepeatedCnt--;
        }
        else
        {
            if( SQC_help >= 15 ) SQC_help = 0;
            else SQC_help++;
        }
            
        putValue( HMI_SQC_CamLane_LaneAttr2, SQC_help );
    }
    _mCamLane_LaneAttr2_AR.SQC_CamLane_LaneAttr2 = SQC_help;

    if( getValue( HMI_CRC_CamLane_LaneAttr2_Profile_02 ) )
    {
        if( !getValue( HMI_CRC_CamLane_LaneAttr2_Auto ) )
        {   // CRC according Profile_02 ( W213 )
            // berechne crc
            crc = 0xFF;
//          crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr2_AR.byte( 0 ) ];  CRC
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr2_AR.byte( 1 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr2_AR.byte( 2 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr2_AR.byte( 3 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr2_AR.byte( 4 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr2_AR.byte( 5 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr2_AR.byte( 6 ) ];
            crc = crctable_profile02[ crc ^ _mCamLane_LaneAttr2_AR.byte( 7 ) ];
            crc = crctable_profile02[ crc ^ _CamLane_LaneAttr2_AR_CRC_Offset[ _mCamLane_LaneAttr2_AR.SQC_CamLane_LaneAttr2 ] ]; // load offset
            crc = (crc ^ 0xFF);
            
            if( ( _CamLane_LaneAttr2_AR_CRC_ErrorCnt   && ( _CamLane_LaneAttr2_AR_E2E_Armed == 1   ) ) ||
