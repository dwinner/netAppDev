    putValue( HIL_s_LED_ACC_Ego_rot_blinken, getProfileInt( "Settings", "HIL_s_LED_ACC_Ego_rot_blinken", 0, profileFile ) );
    putValue( HIL_b_ACC_Abstand_Abstandswarner, getProfileInt( "Settings", "HIL_b_ACC_Abstand_Abstandswarner", 0, profileFile ) );
    putValue( HIL_b_ACC_Abstand_RNS, getProfileFloat( "Settings", "HIL_b_ACC_Abstand_RNS", 0, profileFile ) );
    putValue( HIL_b_ACC_Akustik_03, getProfileInt( "Settings", "HIL_b_ACC_Akustik_03", 0, profileFile ) );
    putValue( HIL_b_ACC_Anzeige_Zeitluecke, getProfileInt( "Settings", "HIL_b_ACC_Anzeige_Zeitluecke", 0, profileFile ) );
    putValue( HIL_b_ACC_Display_Prio, getProfileInt( "Settings", "HIL_b_ACC_Display_Prio", 0, profileFile ) );
    putValue( HIL_b_ACC_Einheit_maxSetzgeschw, getProfileInt( "Settings", "HIL_b_ACC_Einheit_maxSetzgeschw", 0, profileFile ) );
    putValue( HIL_b_ACC_ENG_Texte, getProfileInt( "Settings", "HIL_b_ACC_ENG_Texte", 0, profileFile ) );
    putValue( HIL_b_ACC_Gesetzte_Zeitluecke, getProfileInt( "Settings", "HIL_b_ACC_Gesetzte_Zeitluecke", 0, profileFile ) );
    putValue( HIL_b_ACC_maxSetzgeschw, getProfileInt( "Settings", "HIL_b_ACC_maxSetzgeschw", 0, profileFile ) );
    putValue( HIL_b_ACC_Modus_Pop_Up, getProfileInt( "Settings", "HIL_b_ACC_Modus_Pop_Up", 0, profileFile ) );
    putValue( HIL_b_ACC_Optischer_Fahrerhinweis, getProfileInt( "Settings", "HIL_b_ACC_Optischer_Fahrerhinweis", 0, profileFile ) );
    putValue( HIL_b_ACC_Relevantes_Objekt_02, getProfileInt( "Settings", "HIL_b_ACC_Relevantes_Objekt_02", 0, profileFile ) );
    putValue( HIL_b_ACC_RUV, getProfileInt( "Settings", "HIL_b_ACC_RUV", 0, profileFile ) );
    putValue( HIL_b_ACC_Tachokranz, getProfileInt( "Settings", "HIL_b_ACC_Tachokranz", 0, profileFile ) );
    putValue( HIL_b_ACC_Typ_Tachokranz_unten, getProfileInt( "Settings", "HIL_b_ACC_Typ_Tachokranz_unten", 0, profileFile ) );
    putValue( HIL_b_ACC_Warnhinweis, getProfileInt( "Settings", "HIL_b_ACC_Warnhinweis", 0, profileFile ) );
    putValue( HIL_b_ACC_Wunschgeschw_02, getProfileFloat( "Settings", "HIL_b_ACC_Wunschgeschw_02", 0, profileFile ) );
    putValue( HIL_s_ACC_Status, getProfileInt( "Settings", "HIL_s_ACC_Status", 0, profileFile ) );
    putValue( HIL_s_LED_ACC_Ego_gruen, getProfileInt( "Settings", "HIL_s_LED_ACC_Ego_gruen", 0, profileFile ) );
    putValue( HIL_b_ACC_Abstand_LNS, getProfileFloat( "Settings", "HIL_b_ACC_Abstand_LNS", 0, profileFile ) );
    putValue( HIL_b_ACC_Abstandsindex_02, getProfileInt( "Settings", "HIL_b_ACC_Abstandsindex_02", 0, profileFile ) );
    putValue( HIL_b_ACC_Status_Anzeige, getProfileInt( "Settings", "HIL_b_ACC_Status_Anzeige", 0, profileFile ) );
    putValue( HIL_b_ACC_Texte_02, getProfileInt( "Settings", "HIL_b_ACC_Texte_02", 0, profileFile ) );
    putValue( HIL_b_ACC_Texte_Primaeranz_03, getProfileInt( "Settings", "HIL_b_ACC_Texte_Primaeranz_03", 0, profileFile ) );
    putValue( HIL_b_ACC_Texte_Zusatzanz_03, getProfileInt( "Settings", "HIL_b_ACC_Texte_Zusatzanz_03", 0, profileFile ) );
    putValue( HIL_b_FOD_State_ACC, getProfileInt( "Settings", "HIL_b_FOD_State_ACC", 0, profileFile ) );
    putValue( HIL_b_PH_Stoermeldung, getProfileInt( "Settings", "HIL_b_PH_Stoermeldung", 0, profileFile ) );
    putValue( HIL_b_PH_Verschmutzungsmeldung, getProfileInt( "Settings", "HIL_b_PH_Verschmutzungsmeldung", 0, profileFile ) );
    putValue( HIL_b_PH_WAH_Meldung, getProfileInt( "Settings", "HIL_b_PH_WAH_Meldung", 0, profileFile ) );
    putValue( HIL_hmi_ACC_Wunschgeschw_02, getProfileFloat( "Settings", "HIL_hmi_ACC_Wunschgeschw_02", 0, profileFile ) );
    putValue( HIL_s_FOD_State_ACC, getProfileInt( "Settings", "HIL_s_FOD_State_ACC", 0, profileFile ) );
    putValue( HIL_b_ASW_Kombitexte, getProfileInt( "Settings", "HIL_b_ASW_Kombitexte", 0, profileFile ) );
    putValue( HIL_b_AWV_Status_Anzeige, getProfileInt( "Settings", "HIL_b_AWV_Status_Anzeige", 0, profileFile ) );
    putValue( HIL_b_EA_Texte, getProfileInt( "Settings", "HIL_b_EA_Texte", 0, profileFile ) );
    putValue( HIL_b_LoGeWa_C2C_Event_Einheit, getProfileInt( "Settings", "HIL_b_LoGeWa_C2C_Event_Einheit", 0, profileFile ) );
    putValue( HIL_b_LoGeWa_C2C_Event_Entfernung, getProfileFloat( "Settings", "HIL_b_LoGeWa_C2C_Event_Entfernung", 0, profileFile ) );
    putValue( HIL_b_LoGeWa_C2C_Event_Richtung, getProfileInt( "Settings", "HIL_b_LoGeWa_C2C_Event_Richtung", 0, profileFile ) );
    putValue( HIL_b_LoGeWa_C2C_Event_Status, getProfileInt( "Settings", "HIL_b_LoGeWa_C2C_Event_Status", 0, profileFile ) );
    putValue( HIL_b_LoGeWa_C2C_Event_Warnung, getProfileInt( "Settings", "HIL_b_LoGeWa_C2C_Event_Warnung", 0, profileFile ) );
    putValue( HIL_b_TSK_Texte, getProfileInt( "Settings", "HIL_b_TSK_Texte", 0, profileFile ) );
    putValue( HIL_hmi_VZA_available, getProfileInt( "Settings", "HIL_hmi_VZA_available", 0, profileFile ) );
    putValue( HIL_b_LH_Bremslicht_H_aktiv, getProfileInt( "Settings", "HIL_b_LH_Bremslicht_H_aktiv", 0, profileFile ) );
    putValue( HIL_hmi_zpm_anzeigeID, getProfileInt( "Settings", "HIL_hmi_zpm_anzeigeID", 0, profileFile ) );
    putValue( HIL_hmi_zpm_meldungsspeicher_anzahl, getProfileInt( "Settings", "HIL_hmi_zpm_meldungsspeicher_anzahl", 0, profileFile ) );
    putValue( HIL_hmi_zpm_meldungsspeicher_warningID, getProfileInt( "Settings", "HIL_hmi_zpm_meldungsspeicher_warningID", 0, profileFile ) );
    putValue( HIL_s_emv_reku_charge_aktiv, getProfileInt( "Settings", "HIL_s_emv_reku_charge_aktiv", 0, profileFile ) );
    putValue( HIL_s_emv_reku_fahrz_stand, getProfileInt( "Settings", "HIL_s_emv_reku_fahrz_stand", 0, profileFile ) );
    putValue( HIL_b_FT_Tuer_Status, getProfileInt( "Settings", "HIL_b_FT_Tuer_Status", 0, profileFile ) );
    putValue( HIL_b_ISA_Regelung_aktiv, getProfileInt( "Settings", "HIL_b_ISA_Regelung_aktiv", 0, profileFile ) );
    putValue( HIL_b_ISA_Tempolimitwarnung, getProfileInt( "Settings", "HIL_b_ISA_Tempolimitwarnung", 0, profileFile ) );
    putValue( HIL_b_TSK_Fahrzeugstatus_praed_Fkt, getProfileInt( "Settings", "HIL_b_TSK_Fahrzeugstatus_praed_Fkt", 0, profileFile ) );
    putValue( HIL_b_TSK_naechstes_Event, getProfileInt( "Settings", "HIL_b_TSK_naechstes_Event", 0, profileFile ) );
    putValue( HIL_b_TSK_praediktiver_Hinweis, getProfileInt( "Settings", "HIL_b_TSK_praediktiver_Hinweis", 0, profileFile ) );
    putValue( HIL_hmi_acc_optischer_fahrerhinweis, getProfileInt( "Settings", "HIL_hmi_acc_optischer_fahrerhinweis", 0, profileFile ) );
    putValue( HIL_hmi_aktive_Tubenfunktion, getProfileInt( "Settings", "HIL_hmi_aktive_Tubenfunktion", 0, profileFile ) );
    putValue( HIL_hmi_bc_nachtankmenge, getProfileInt( "Settings", "HIL_hmi_bc_nachtankmenge", 0, profileFile ) );
    putValue( HIL_hmi_blinken_links, getProfileInt( "Settings", "HIL_hmi_blinken_links", 0, profileFile ) );
    putValue( HIL_hmi_blinken_rechts, getProfileInt( "Settings", "HIL_hmi_blinken_rechts", 0, profileFile ) );
    putValue( HIL_hmi_car_outline_aktiv, getProfileInt( "Settings", "HIL_hmi_car_outline_aktiv", 0, profileFile ) );
    putValue( HIL_hmi_defekt_anzeigen, getProfileInt( "Settings", "HIL_hmi_defekt_anzeigen", 0, profileFile ) );
    putValue( HIL_hmi_heckdeckel_offen, getProfileInt( "Settings", "HIL_hmi_heckdeckel_offen", 0, profileFile ) );
    putValue( HIL_hmi_heckscheibe_offen, getProfileInt( "Settings", "HIL_hmi_heckscheibe_offen", 0, profileFile ) );
    putValue( HIL_hmi_motorhaube_offen, getProfileInt( "Settings", "HIL_hmi_motorhaube_offen", 0, profileFile ) );
    putValue( HIL_hmi_pla_akustik, getProfileInt( "Settings", "HIL_hmi_pla_akustik", 0, profileFile ) );
    putValue( HIL_hmi_pla_bremssymbol, getProfileInt( "Settings", "HIL_hmi_pla_bremssymbol", 0, profileFile ) );
    putValue( HIL_hmi_pla_schwellpfeil_anzeigen, getProfileInt( "Settings", "HIL_hmi_pla_schwellpfeil_anzeigen", 0, profileFile ) );
    putValue( HIL_hmi_tankklappe_offen, getProfileInt( "Settings", "HIL_hmi_tankklappe_offen", 0, profileFile ) );
    putValue( HIL_hmi_tuerzustand_hinten_links, getProfileInt( "Settings", "HIL_hmi_tuerzustand_hinten_links", 0, profileFile ) );
    putValue( HIL_hmi_tuerzustand_hinten_rechts, getProfileInt( "Settings", "HIL_hmi_tuerzustand_hinten_rechts", 0, profileFile ) );
    putValue( HIL_hmi_tuerzustand_vorne_links, getProfileInt( "Settings", "HIL_hmi_tuerzustand_vorne_links", 0, profileFile ) );
    putValue( HIL_hmi_tuerzustand_vorne_rechts, getProfileInt( "Settings", "HIL_hmi_tuerzustand_vorne_rechts", 0, profileFile ) );
    putValue( HIL_hmi_zpm_meldungsspeicher_anzeigen, getProfileInt( "Settings", "HIL_hmi_zpm_meldungsspeicher_anzeigen", 0, profileFile ) );
    putValue( HIL_hmi_zpm_piktogrammrolle_anzeigen, getProfileInt( "Settings", "HIL_hmi_zpm_piktogrammrolle_anzeigen", 0, profileFile ) );
    putValue( HIL_hmi_bc_oeltemperatur_sonderbehandlung, getProfileInt( "Settings", "HIL_hmi_bc_oeltemperatur_sonderbehandlung", 0, profileFile ) );
    putValue( HIL_hmi_bc_oeltemperatur_vorhanden, getProfileInt( "Settings", "HIL_hmi_bc_oeltemperatur_vorhanden", 0, profileFile ) );
    putValue( HIL_hmi_BcmE_ConsumerList_available, getProfileInt( "Settings", "HIL_hmi_BcmE_ConsumerList_available", 0, profileFile ) );
    putValue( HIL_hmi_BcmE_LifeTips_available, getProfileInt( "Settings", "HIL_hmi_BcmE_LifeTips_available", 0, profileFile ) );
    putValue( HIL_hmi_digitalgeschwindigkeit_available, getProfileInt( "Settings", "HIL_hmi_digitalgeschwindigkeit_available", 0, profileFile ) );
    putValue( HIL_b_AGA_ohne_Funktion, getProfileInt( "Settings", "HIL_b_AGA_ohne_Funktion", 0, profileFile ) );
    putValue( HIL_b_AGA_Texte, getProfileInt( "Settings", "HIL_b_AGA_Texte", 0, profileFile ) );
    putValue( HIL_b_BEM_Batteriediagnose, getProfileInt( "Settings", "HIL_b_BEM_Batteriediagnose", 0, profileFile ) );
    putValue( HIL_b_BEM_Generatordiagnose, getProfileInt( "Settings", "HIL_b_BEM_Generatordiagnose", 0, profileFile ) );
    putValue( HIL_b_BEM_Ladezustand, getProfileInt( "Settings", "HIL_b_BEM_Ladezustand", 0, profileFile ) );
    putValue( HIL_b_HVEM_Text_1, getProfileInt( "Settings", "HIL_b_HVEM_Text_1", 0, profileFile ) );
    putValue( HIL_b_HVLM_Bat_laden_aktiv, getProfileInt( "Settings", "HIL_b_HVLM_Bat_laden_aktiv", 0, profileFile ) );
    putValue( HIL_b_HVLM_Ladeart, getProfileInt( "Settings", "HIL_b_HVLM_Ladeart", 0, profileFile ) );
    putValue( HIL_b_HVLM_Ladesystemhinweise, getProfileInt( "Settings", "HIL_b_HVLM_Ladesystemhinweise", 0, profileFile ) );
    putValue( HIL_b_HVLM_Stecker_Status, getProfileInt( "Settings", "HIL_b_HVLM_Stecker_Status", 0, profileFile ) );
    putValue( HIL_b_MO_E_Mode, getProfileInt( "Settings", "HIL_b_MO_E_Mode", 0, profileFile ) );
    putValue( HIL_b_MO_E_Texte, getProfileInt( "Settings", "HIL_b_MO_E_Texte", 0, profileFile ) );
    putValue( HIL_b_MO_E_Warnungen, getProfileInt( "Settings", "HIL_b_MO_E_Warnungen", 0, profileFile ) );
    putValue( HIL_b_MO_HYB_Fahrbereitschaft, getProfileInt( "Settings", "HIL_b_MO_HYB_Fahrbereitschaft", 0, profileFile ) );
    putValue( HIL_b_MO_RedFahrleistung_Lampe, getProfileInt( "Settings", "HIL_b_MO_RedFahrleistung_Lampe", 0, profileFile ) );
    putValue( HIL_b_MVK_MV_Netz_Warnungen, getProfileInt( "Settings", "HIL_b_MVK_MV_Netz_Warnungen", 0, profileFile ) );
    putValue( HIL_b_NVEM_Batterie_Service, getProfileInt( "Settings", "HIL_b_NVEM_Batterie_Service", 0, profileFile ) );
    putValue( HIL_b_NVEM_Bordnetzdiagnose, getProfileInt( "Settings", "HIL_b_NVEM_Bordnetzdiagnose", 0, profileFile ) );
    putValue( HIL_b_SI_T_Schutz, getProfileInt( "Settings", "HIL_b_SI_T_Schutz", 0, profileFile ) );
    putValue( HIL_hmi_bc_momentanrekuperation_not_a_number, getProfileInt( "Settings", "HIL_hmi_bc_momentanrekuperation_not_a_number", 0, profileFile ) );
    putValue( HIL_s_batteriekapazitaet_display, getProfileFloat( "Settings", "HIL_s_batteriekapazitaet_display", 0, profileFile ) );
    putValue( HIL_s_Fahrbereitschaftsakustik_ausg, getProfileInt( "Settings", "HIL_s_Fahrbereitschaftsakustik_ausg", 0, profileFile ) );
    putValue( HIL_s_Ladezustand_02, getProfileFloat( "Settings", "HIL_s_Ladezustand_02", 0, profileFile ) );
    putValue( HIL_s_Ladezustand_02_Werte_vorhanden, getProfileInt( "Settings", "HIL_s_Ladezustand_02_Werte_vorhanden", 0, profileFile ) );
    putValue( HIL_s_LED_HYB_Fahrbereitschaft, getProfileInt( "Settings", "HIL_s_LED_HYB_Fahrbereitschaft", 0, profileFile ) );
    putValue( HIL_s_LED_TurtleMode, getProfileInt( "Settings", "HIL_s_LED_TurtleMode", 0, profileFile ) );
    putValue( HIL_s_MO_HYB_Fahrbereitschaft_ausg, getProfileInt( "Settings", "HIL_s_MO_HYB_Fahrbereitschaft_ausg", 0, profileFile ) );
    putValue( HIL_b_BMS_KundenWarnung, getProfileInt( "Settings", "HIL_b_BMS_KundenWarnung", 0, profileFile ) );
    putValue( HIL_hmi_bc_fahrzeit_e2, getProfileInt( "Settings", "HIL_hmi_bc_fahrzeit_e2", 0, profileFile ) );
    putValue( HIL_hmi_bc_fahrzeit_e3, getProfileInt( "Settings", "HIL_hmi_bc_fahrzeit_e3", 0, profileFile ) );
    putValue( HIL_s_batteriekapazitaet_anzeigefreigabe, getProfileInt( "Settings", "HIL_s_batteriekapazitaet_anzeigefreigabe", 0, profileFile ) );
    putValue( HIL_b_DC_Verbrauch_Ueberlauf, getProfileInt( "Settings", "HIL_b_DC_Verbrauch_Ueberlauf", 0, profileFile ) );
    putValue( HIL_b_MO_Rekuperation_EM_Ges_Ueberlauf, getProfileInt( "Settings", "HIL_b_MO_Rekuperation_EM_Ges_Ueberlauf", 0, profileFile ) );
    putValue( HIL_b_MO_Rekuperation_Ges_EM, getProfileInt( "Settings", "HIL_b_MO_Rekuperation_Ges_EM", 0, profileFile ) );
    putValue( HIL_b_MO_Verbrauch_EM_Ges_Ueberlauf, getProfileInt( "Settings", "HIL_b_MO_Verbrauch_EM_Ges_Ueberlauf", 0, profileFile ) );
    putValue( HIL_b_MO_Zust_Antrieb, getProfileInt( "Settings", "HIL_b_MO_Zust_Antrieb", 0, profileFile ) );
    putValue( HIL_b_Thermo_Verbrauch_BTL, getProfileInt( "Settings", "HIL_b_Thermo_Verbrauch_BTL", 0, profileFile ) );
    putValue( HIL_b_Thermo_Verbrauch_BTL_Ueberlauf, getProfileInt( "Settings", "HIL_b_Thermo_Verbrauch_BTL_Ueberlauf", 0, profileFile ) );
    putValue( HIL_s_chrg_reku_gewinn, getProfileInt( "Settings", "HIL_s_chrg_reku_gewinn", 0, profileFile ) );
    putValue( HIL_b_BMS_Rekuperation, getProfileInt( "Settings", "HIL_b_BMS_Rekuperation", 0, profileFile ) );
    putValue( HIL_b_BMS_Rekuperation_Ueberlauf, getProfileInt( "Settings", "HIL_b_BMS_Rekuperation_Ueberlauf", 0, profileFile ) );
    putValue( HIL_b_DC_Verbrauch, getProfileInt( "Settings", "HIL_b_DC_Verbrauch", 0, profileFile ) );
    putValue( HIL_b_Ladezustand_02, getProfileFloat( "Settings", "HIL_b_Ladezustand_02", 0, profileFile ) );
    putValue( HIL_b_MO_Verbrauch_EM_Ges, getProfileInt( "Settings", "HIL_b_MO_Verbrauch_EM_Ges", 0, profileFile ) );
    putValue( HIL_s_Ladezustand_02_ausg, getProfileFloat( "Settings", "HIL_s_Ladezustand_02_ausg", 0, profileFile ) );
    putValue( HIL_b_EV_Rekuperationsstufe, getProfileInt( "Settings", "HIL_b_EV_Rekuperationsstufe", 0, profileFile ) );
    putValue( HIL_b_HVLM_Anzeigetexte, getProfileInt( "Settings", "HIL_b_HVLM_Anzeigetexte", 0, profileFile ) );
    putValue( HIL_b_HVLM_Restladezeit_HV_Bat_02, getProfileInt( "Settings", "HIL_b_HVLM_Restladezeit_HV_Bat_02", 0, profileFile ) );
    putValue( HIL_b_MO_Waehlpos, getProfileInt( "Settings", "HIL_b_MO_Waehlpos", 0, profileFile ) );
    putValue( HIL_b_RW_Prim_Reichweitenverbrauch, getProfileFloat( "Settings", "HIL_b_RW_Prim_Reichweitenverbrauch", 0, profileFile ) );
    putValue( HIL_b_RW_Reservewarnung_aktiv, getProfileInt( "Settings", "HIL_b_RW_Reservewarnung_aktiv", 0, profileFile ) );
    putValue( HIL_b_RW_Sek_Reichweitenverbrauch, getProfileFloat( "Settings", "HIL_b_RW_Sek_Reichweitenverbrauch", 0, profileFile ) );
    putValue( HIL_b_RW_Texte, getProfileInt( "Settings", "HIL_b_RW_Texte", 0, profileFile ) );
    putValue( HIL_b_Thermo_Verbrauch_Innen_Ueberlauf, getProfileInt( "Settings", "HIL_b_Thermo_Verbrauch_Innen_Ueberlauf", 0, profileFile ) );
    putValue( HIL_hmi_chrg_reku_rwgewinn_aktiv, getProfileInt( "Settings", "HIL_hmi_chrg_reku_rwgewinn_aktiv", 0, profileFile ) );
    putValue( HIL_s_MO_ePerformance, getProfileFloat( "Settings", "HIL_s_MO_ePerformance", 0, profileFile ) );
    putValue( HIL_b_MO_Powermeter_Charge_Grenze, getProfileInt( "Settings", "HIL_b_MO_Powermeter_Charge_Grenze", 0, profileFile ) );
    putValue( HIL_b_MO_Powermeter_Elm_02, getProfileFloat( "Settings", "HIL_b_MO_Powermeter_Elm_02", 0, profileFile ) );
    putValue( HIL_b_MO_Powermeter_Grenze_strategisch, getProfileInt( "Settings", "HIL_b_MO_Powermeter_Grenze_strategisch", 0, profileFile ) );
    putValue( HIL_b_MO_Powermeter_obere_E_Grenze, getProfileInt( "Settings", "HIL_b_MO_Powermeter_obere_E_Grenze", 0, profileFile ) );
    putValue( HIL_b_MO_Powermeter_untere_E_Grenze, getProfileInt( "Settings", "HIL_b_MO_Powermeter_untere_E_Grenze", 0, profileFile ) );
    putValue( HIL_s_bargraph_batteriekapazitaet_intern_an, getProfileInt( "Settings", "HIL_s_bargraph_batteriekapazitaet_intern_an", 0, profileFile ) );
    putValue( HIL_s_batteriebargraph_extern_an, getProfileInt( "Settings", "HIL_s_batteriebargraph_extern_an", 0, profileFile ) );
    putValue( HIL_b_HVK_Gesamtst_Spgfreiheit, getProfileInt( "Settings", "HIL_b_HVK_Gesamtst_Spgfreiheit", 0, profileFile ) );
    putValue( HIL_b_MO_Anzeige_Betriebsmodus, getProfileInt( "Settings", "HIL_b_MO_Anzeige_Betriebsmodus", 0, profileFile ) );
    putValue( HIL_b_MO_ePowermeter, getProfileFloat( "Settings", "HIL_b_MO_ePowermeter", 0, profileFile ) );
    putValue( HIL_b_MO_Powermeter, getProfileInt( "Settings", "HIL_b_MO_Powermeter", 0, profileFile ) );
    putValue( HIL_b_MO_Powermeter_Grenze, getProfileInt( "Settings", "HIL_b_MO_Powermeter_Grenze", 0, profileFile ) );
    putValue( HIL_s_bargraph_bat_aktiv, getProfileInt( "Settings", "HIL_s_bargraph_bat_aktiv", 0, profileFile ) );
    putValue( HIL_s_HVK_Gesamtst_Spgfreiheit, getProfileInt( "Settings", "HIL_s_HVK_Gesamtst_Spgfreiheit", 0, profileFile ) );
    putValue( HIL_s_powermeter_displayanzeige, getProfileInt( "Settings", "HIL_s_powermeter_displayanzeige", 0, profileFile ) );
    putValue( HIL_b_LE_Kuehlmittel_Sensor, getProfileInt( "Settings", "HIL_b_LE_Kuehlmittel_Sensor", 0, profileFile ) );
    putValue( HIL_b_MO_ePerformance, getProfileFloat( "Settings", "HIL_b_MO_ePerformance", 0, profileFile ) );
    putValue( HIL_b_Thermo_Verbrauch_Innen, getProfileInt( "Settings", "HIL_b_Thermo_Verbrauch_Innen", 0, profileFile ) );
    putValue( HIL_hmi_chrg_reku_rwgewinn, getProfileInt( "Settings", "HIL_hmi_chrg_reku_rwgewinn", 0, profileFile ) );
    putValue( HIL_hmi_chrg_reku_rwgewinn_einheit, getProfileInt( "Settings", "HIL_hmi_chrg_reku_rwgewinn_einheit", 0, profileFile ) );
    putValue( HIL_s_Batterie_Reserve_BEV, getProfileInt( "Settings", "HIL_s_Batterie_Reserve_BEV", 0, profileFile ) );
    putValue( HIL_s_Batterie_Reserve_PHEV, getProfileInt( "Settings", "HIL_s_Batterie_Reserve_PHEV", 0, profileFile ) );
    putValue( HIL_s_ePerformance_displayanzeige, getProfileFloat( "Settings", "HIL_s_ePerformance_displayanzeige", 0, profileFile ) );
    putValue( HIL_s_KBI_Phototransistor, getProfileInt( "Settings", "HIL_s_KBI_Phototransistor", 0, profileFile ) );
    putValue( HIL_s_kuehlmittelmangel_LE, getProfileInt( "Settings", "HIL_s_kuehlmittelmangel_LE", 0, profileFile ) );
    putValue( HIL_s_fahrzeit_e1, getProfileInt( "Settings", "HIL_s_fahrzeit_e1", 0, profileFile ) );
    putValue( HIL_s_fahrzeit_e2, getProfileInt( "Settings", "HIL_s_fahrzeit_e2", 0, profileFile ) );
    putValue( HIL_hmi_bc_fahrzeit_e1, getProfileInt( "Settings", "HIL_hmi_bc_fahrzeit_e1", 0, profileFile ) );
    putValue( HIL_s_fahrzeit_e3, getProfileInt( "Settings", "HIL_s_fahrzeit_e3", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_einheit_elektrisch, getProfileInt( "Settings", "HIL_hmi_durchschnittsverbrauch_einheit_elektrisch", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_elektrisch_e1, getProfileFloat( "Settings", "HIL_hmi_durchschnittsverbrauch_elektrisch_e1", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_elektrisch_e1_sonderbehandlung, getProfileInt( "Settings", "HIL_hmi_durchschnittsverbrauch_elektrisch_e1_sonderbehandlung", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_elektrisch_e2, getProfileFloat( "Settings", "HIL_hmi_durchschnittsverbrauch_elektrisch_e2", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_elektrisch_e2_sonderbehandlung, getProfileInt( "Settings", "HIL_hmi_durchschnittsverbrauch_elektrisch_e2_sonderbehandlung", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_elektrisch_e3, getProfileFloat( "Settings", "HIL_hmi_durchschnittsverbrauch_elektrisch_e3", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_elektrisch_e3_sonderbehandlung, getProfileInt( "Settings", "HIL_hmi_durchschnittsverbrauch_elektrisch_e3_sonderbehandlung", 0, profileFile ) );
    putValue( HIL_hmi_momentanverbrauch_einheit_elektrisch, getProfileInt( "Settings", "HIL_hmi_momentanverbrauch_einheit_elektrisch", 0, profileFile ) );
    putValue( HIL_hmi_momentanverbrauch_einheit_elektrisch_bargraph, getProfileInt( "Settings", "HIL_hmi_momentanverbrauch_einheit_elektrisch_bargraph", 0, profileFile ) );
    putValue( HIL_hmi_momentanverbrauch_elektrisch_not_a_number, getProfileInt( "Settings", "HIL_hmi_momentanverbrauch_elektrisch_not_a_number", 0, profileFile ) );
    putValue( HIL_hmi_momentanverbrauch_elektrisch_not_a_number_bargraph, getProfileInt( "Settings", "HIL_hmi_momentanverbrauch_elektrisch_not_a_number_bargraph", 0, profileFile ) );
    putValue( HIL_b_BMS_Verbrauch, getProfileInt( "Settings", "HIL_b_BMS_Verbrauch", 0, profileFile ) );
    putValue( HIL_b_BMS_Verbrauch_Ueberlauf, getProfileInt( "Settings", "HIL_b_BMS_Verbrauch_Ueberlauf", 0, profileFile ) );
    putValue( HIL_b_MO_Anzeige_Rekuperation, getProfileFloat( "Settings", "HIL_b_MO_Anzeige_Rekuperation", 0, profileFile ) );
    putValue( HIL_b_MO_Anzeige_Verbr_Einheit, getProfileInt( "Settings", "HIL_b_MO_Anzeige_Verbr_Einheit", 0, profileFile ) );
    putValue( HIL_b_MO_Anzeige_Verbrauch_oE, getProfileFloat( "Settings", "HIL_b_MO_Anzeige_Verbrauch_oE", 0, profileFile ) );
    putValue( HIL_s_mv_einheit_verbrauch, getProfileInt( "Settings", "HIL_s_mv_einheit_verbrauch", 0, profileFile ) );
    putValue( HIL_s_mv_fahrz_stand, getProfileInt( "Settings", "HIL_s_mv_fahrz_stand", 0, profileFile ) );
    putValue( HIL_s_mv_schub_fahrt, getProfileInt( "Settings", "HIL_s_mv_schub_fahrt", 0, profileFile ) );
    putValue( HIL_s_mv_schub_stand, getProfileInt( "Settings", "HIL_s_mv_schub_stand", 0, profileFile ) );
    putValue( HIL_s_mv_x_100km, getProfileFloat( "Settings", "HIL_s_mv_x_100km", 0, profileFile ) );
    putValue( HIL_s_dv_prozent, getProfileFloat( "Settings", "HIL_s_dv_prozent", 0, profileFile ) );
    putValue( HIL_s_dv_prozent_gas, getProfileFloat( "Settings", "HIL_s_dv_prozent_gas", 0, profileFile ) );
    putValue( HIL_s_mv_gefiltert, getProfileFloat( "Settings", "HIL_s_mv_gefiltert", 0, profileFile ) );
    putValue( HIL_s_mv_mit_hyst, getProfileFloat( "Settings", "HIL_s_mv_mit_hyst", 0, profileFile ) );
    putValue( HIL_s_mv_kg_100km_anzverbr, getProfileFloat( "Settings", "HIL_s_mv_kg_100km_anzverbr", 0, profileFile ) );
    putValue( HIL_s_mv_mit_reku, getProfileFloat( "Settings", "HIL_s_mv_mit_reku", 0, profileFile ) );
    putValue( HIL_s_mv_prozent, getProfileFloat( "Settings", "HIL_s_mv_prozent", 0, profileFile ) );
    putValue( HIL_s_mv_schub_anzverbr, getProfileInt( "Settings", "HIL_s_mv_schub_anzverbr", 0, profileFile ) );
    putValue( HIL_hmi_momentanverbrauch_elektrisch, getProfileFloat( "Settings", "HIL_hmi_momentanverbrauch_elektrisch", 0, profileFile ) );
    putValue( HIL_hmi_momentanverbrauch_elektrisch_bargraph, getProfileFloat( "Settings", "HIL_hmi_momentanverbrauch_elektrisch_bargraph", 0, profileFile ) );
    putValue( HIL_s_mv_l_100km_anzverbr, getProfileFloat( "Settings", "HIL_s_mv_l_100km_anzverbr", 0, profileFile ) );
    putValue( HIL_s_rekuperationsfaktor, getProfileFloat( "Settings", "HIL_s_rekuperationsfaktor", 0, profileFile ) );
    putValue( HIL_s_tank_vol_geber_2_roh, getProfileFloat( "Settings", "HIL_s_tank_vol_geber_2_roh", 0, profileFile ) );
    putValue( HIL_s_tank_vol_geber_3_roh, getProfileFloat( "Settings", "HIL_s_tank_vol_geber_3_roh", 0, profileFile ) );
    putValue( HIL_s_tank_vol_geber_4_roh, getProfileFloat( "Settings", "HIL_s_tank_vol_geber_4_roh", 0, profileFile ) );
    putValue( HIL_s_tank_vol_geber_g1_kalibriert_unbegrenzt, getProfileFloat( "Settings", "HIL_s_tank_vol_geber_g1_kalibriert_unbegrenzt", 0, profileFile ) );
    putValue( HIL_s_tank_vol_geber_g2_kalibriert_unbegrenzt, getProfileFloat( "Settings", "HIL_s_tank_vol_geber_g2_kalibriert_unbegrenzt", 0, profileFile ) );
    putValue( HIL_s_tank_vol_nte_zu, getProfileFloat( "Settings", "HIL_s_tank_vol_nte_zu", 0, profileFile ) );
    putValue( HIL_s_tank_vol_geber_g3_kalibriert_unbegrenzt, getProfileFloat( "Settings", "HIL_s_tank_vol_geber_g3_kalibriert_unbegrenzt", 0, profileFile ) );
    putValue( HIL_s_tank_vol_geber_g4_kalibriert_unbegrenzt, getProfileFloat( "Settings", "HIL_s_tank_vol_geber_g4_kalibriert_unbegrenzt", 0, profileFile ) );
    putValue( HIL_s_tank_vol_geber_gesamt_roh, getProfileFloat( "Settings", "HIL_s_tank_vol_geber_gesamt_roh", 0, profileFile ) );
    putValue( HIL_s_zeigerposition_kraftstoffvorrat, getProfileFloat( "Settings", "HIL_s_zeigerposition_kraftstoffvorrat", 0, profileFile ) );
    putValue( HIL_s_zeigerposition_kraftstoffvorrat_gas, getProfileFloat( "Settings", "HIL_s_zeigerposition_kraftstoffvorrat_gas", 0, profileFile ) );
    putValue( HIL_s_tank_verbr_gewichtung, getProfileFloat( "Settings", "HIL_s_tank_verbr_gewichtung", 0, profileFile ) );
    putValue( HIL_s_tank_vol_geber_avrg, getProfileFloat( "Settings", "HIL_s_tank_vol_geber_avrg", 0, profileFile ) );
    putValue( HIL_s_tank_vol_geber_avrg_clip, getProfileFloat( "Settings", "HIL_s_tank_vol_geber_avrg_clip", 0, profileFile ) );
    putValue( HIL_s_tank_vol_geber_gesamt_kalibriert, getProfileFloat( "Settings", "HIL_s_tank_vol_geber_gesamt_kalibriert", 0, profileFile ) );
    putValue( HIL_s_tank_vol_gedaempft, getProfileFloat( "Settings", "HIL_s_tank_vol_gedaempft", 0, profileFile ) );
    putValue( HIL_s_tank_vol_ref, getProfileFloat( "Settings", "HIL_s_tank_vol_ref", 0, profileFile ) );
    putValue( HIL_s_tank_vol_anzeige, getProfileFloat( "Settings", "HIL_s_tank_vol_anzeige", 0, profileFile ) );
    putValue( HIL_s_tank_vol_anzeige_alt, getProfileFloat( "Settings", "HIL_s_tank_vol_anzeige_alt", 0, profileFile ) );
    putValue( HIL_s_adc_obd_nibble_g1, getProfileInt( "Settings", "HIL_s_adc_obd_nibble_g1", 0, profileFile ) );
    putValue( HIL_s_adc_obd_nibble_g2, getProfileInt( "Settings", "HIL_s_adc_obd_nibble_g2", 0, profileFile ) );
    putValue( HIL_s_adc_obd_nibble_g3, getProfileInt( "Settings", "HIL_s_adc_obd_nibble_g3", 0, profileFile ) );
    putValue( HIL_s_adc_obd_ohmwert_g1, getProfileFloat( "Settings", "HIL_s_adc_obd_ohmwert_g1", 0, profileFile ) );
    putValue( HIL_s_adc_obd_ohmwert_g2, getProfileFloat( "Settings", "HIL_s_adc_obd_ohmwert_g2", 0, profileFile ) );
    putValue( HIL_s_adc_obd_ohmwert_g3, getProfileFloat( "Settings", "HIL_s_adc_obd_ohmwert_g3", 0, profileFile ) );
    putValue( HIL_s_adc_obd_ohmwert_g4, getProfileFloat( "Settings", "HIL_s_adc_obd_ohmwert_g4", 0, profileFile ) );
    putValue( HIL_b_ESP_Laengsbeschl, getProfileFloat( "Settings", "HIL_b_ESP_Laengsbeschl", 0, profileFile ) );
    putValue( HIL_b_ESP_Querbeschleunigung, getProfileFloat( "Settings", "HIL_b_ESP_Querbeschleunigung", 0, profileFile ) );
    putValue( HIL_s_gastank_warnung_cng, getProfileInt( "Settings", "HIL_s_gastank_warnung_cng", 0, profileFile ) );
    putValue( HIL_s_KBI_FStatus_Tank, getProfileInt( "Settings", "HIL_s_KBI_FStatus_Tank", 0, profileFile ) );
    putValue( HIL_s_KBI_Max_Tankinhalt, getProfileFloat( "Settings", "HIL_s_KBI_Max_Tankinhalt", 0, profileFile ) );
    putValue( HIL_s_KBI_Min_Tankinhalt, getProfileFloat( "Settings", "HIL_s_KBI_Min_Tankinhalt", 0, profileFile ) );
    putValue( HIL_s_KBI_Tankfuellstand_Prozent, getProfileInt( "Settings", "HIL_s_KBI_Tankfuellstand_Prozent", 0, profileFile ) );
    putValue( HIL_s_KBI_Tankinhalt_hochaufl, getProfileFloat( "Settings", "HIL_s_KBI_Tankinhalt_hochaufl", 0, profileFile ) );
    putValue( HIL_s_KBI_Tankinhalt_roh, getProfileFloat( "Settings", "HIL_s_KBI_Tankinhalt_roh", 0, profileFile ) );
    putValue( HIL_s_adc_obd_nibble_g4, getProfileInt( "Settings", "HIL_s_adc_obd_nibble_g4", 0, profileFile ) );
    putValue( HIL_s_KBI_Inhalt_Tank, getProfileInt( "Settings", "HIL_s_KBI_Inhalt_Tank", 0, profileFile ) );
    putValue( HIL_s_KBI_Nachtanken_erkannt, getProfileInt( "Settings", "HIL_s_KBI_Nachtanken_erkannt", 0, profileFile ) );
    putValue( HIL_s_KBI_Tankwarnung, getProfileInt( "Settings", "HIL_s_KBI_Tankwarnung", 0, profileFile ) );
    putValue( HIL_s_KBI_Tankwarnung_ungueltig, getProfileInt( "Settings", "HIL_s_KBI_Tankwarnung_ungueltig", 0, profileFile ) );
    putValue( HIL_b_ACC_Anzeige_Objektregelung, getProfileInt( "Settings", "HIL_b_ACC_Anzeige_Objektregelung", 0, profileFile ) );
    putValue( HIL_b_ACC_Sollabstand_1, getProfileFloat( "Settings", "HIL_b_ACC_Sollabstand_1", 0, profileFile ) );
    putValue( HIL_b_ACC_Sollabstand_2, getProfileFloat( "Settings", "HIL_b_ACC_Sollabstand_2", 0, profileFile ) );
    putValue( HIL_b_ACC_Sollabstand_3, getProfileFloat( "Settings", "HIL_b_ACC_Sollabstand_3", 0, profileFile ) );
    putValue( HIL_b_ACC_Sollabstand_4, getProfileFloat( "Settings", "HIL_b_ACC_Sollabstand_4", 0, profileFile ) );
    putValue( HIL_b_ACC_Sollabstand_5, getProfileFloat( "Settings", "HIL_b_ACC_Sollabstand_5", 0, profileFile ) );
    putValue( HIL_b_ACC_Statusicon, getProfileInt( "Settings", "HIL_b_ACC_Statusicon", 0, profileFile ) );
    putValue( HIL_b_ACC_Wunschgeschw_Farbe_02, getProfileInt( "Settings", "HIL_b_ACC_Wunschgeschw_Farbe_02", 0, profileFile ) );
    putValue( HIL_s_KBI_aktive_Laengsfunktion_02, getProfileInt( "Settings", "HIL_s_KBI_aktive_Laengsfunktion_02", 0, profileFile ) );
    putValue( HIL_b_ACC_Texte_Sekundaeranz_02, getProfileInt( "Settings", "HIL_b_ACC_Texte_Sekundaeranz_02", 0, profileFile ) );
    putValue( HIL_b_ACC_Typ_LNS, getProfileInt( "Settings", "HIL_b_ACC_Typ_LNS", 0, profileFile ) );
    putValue( HIL_b_ACC_Typ_RNS, getProfileInt( "Settings", "HIL_b_ACC_Typ_RNS", 0, profileFile ) );
    putValue( HIL_b_ACC_Typ_WZO, getProfileInt( "Settings", "HIL_b_ACC_Typ_WZO", 0, profileFile ) );
    putValue( HIL_b_PLA_Fortschritt_bis_Zugende, getProfileInt( "Settings", "HIL_b_PLA_Fortschritt_bis_Zugende", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Ego_li_Seg1_QuerAbst, getProfileFloat( "Settings", "HIL_b_TA_HMI_Ego_li_Seg1_QuerAbst", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Ego_li_Typ, getProfileInt( "Settings", "HIL_b_TA_HMI_Ego_li_Typ", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Ego_re_Typ, getProfileInt( "Settings", "HIL_b_TA_HMI_Ego_re_Typ", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Nachb_li_Typ, getProfileInt( "Settings", "HIL_b_TA_HMI_Nachb_li_Typ", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Nachb_re_Typ, getProfileInt( "Settings", "HIL_b_TA_HMI_Nachb_re_Typ", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Zoomstufe, getProfileFloat( "Settings", "HIL_b_TA_HMI_Zoomstufe", 0, profileFile ) );
    putValue( HIL_s_KBI_Anzeigefehler_SWA, getProfileInt( "Settings", "HIL_s_KBI_Anzeigefehler_SWA", 0, profileFile ) );
    putValue( HIL_s_KBI_Anzeigestatus_ACC, getProfileInt( "Settings", "HIL_s_KBI_Anzeigestatus_ACC", 0, profileFile ) );
    putValue( HIL_s_KBI_ARA_in_Anzeige, getProfileInt( "Settings", "HIL_s_KBI_ARA_in_Anzeige", 0, profileFile ) );
    putValue( HIL_s_KBI_Fehler_Anzeige_ACC, getProfileInt( "Settings", "HIL_s_KBI_Fehler_Anzeige_ACC", 0, profileFile ) );
    putValue( HIL_s_KBI_Konsistenz_ACC, getProfileInt( "Settings", "HIL_s_KBI_Konsistenz_ACC", 0, profileFile ) );
    putValue( HIL_s_kbi_pla_in_anzeige, getProfileInt( "Settings", "HIL_s_kbi_pla_in_anzeige", 0, profileFile ) );
    putValue( HIL_s_pla_timeout_reakt, getProfileInt( "Settings", "HIL_s_pla_timeout_reakt", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Ego_re_Seg1_QuerAbst, getProfileFloat( "Settings", "HIL_b_TA_HMI_Ego_re_Seg1_QuerAbst", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Nachb_li_Seg1_QuerAbst, getProfileFloat( "Settings", "HIL_b_TA_HMI_Nachb_li_Seg1_QuerAbst", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Nachb_re_Seg1_QuerAbst, getProfileFloat( "Settings", "HIL_b_TA_HMI_Nachb_re_Seg1_QuerAbst", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Seg1_Kruemmung, getProfileInt( "Settings", "HIL_b_TA_HMI_Seg1_Kruemmung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Seg2_Beginn, getProfileFloat( "Settings", "HIL_b_TA_HMI_Seg2_Beginn", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_TrajektSeg2_Beginn, getProfileFloat( "Settings", "HIL_b_TA_HMI_TrajektSeg2_Beginn", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_01_Typ, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_01_Typ", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Seg1_Gierwinkel, getProfileFloat( "Settings", "HIL_b_TA_HMI_Seg1_Gierwinkel", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Seg2_Kruemmung, getProfileInt( "Settings", "HIL_b_TA_HMI_Seg2_Kruemmung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Spurwechsel_re, getProfileInt( "Settings", "HIL_b_TA_HMI_Spurwechsel_re", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_TrajektSeg1_Kruemmung, getProfileInt( "Settings", "HIL_b_TA_HMI_TrajektSeg1_Kruemmung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_TrajektSeg1_QuerAbst, getProfileFloat( "Settings", "HIL_b_TA_HMI_TrajektSeg1_QuerAbst", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_TrajektSeg2_Kruemmung, getProfileInt( "Settings", "HIL_b_TA_HMI_TrajektSeg2_Kruemmung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_EgoObj_dy, getProfileFloat( "Settings", "HIL_b_TA_HMI_EgoObj_dy", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Kurvenwarnung, getProfileInt( "Settings", "HIL_b_TA_HMI_Kurvenwarnung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_01_dx, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_01_dx", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_02_Typ, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_02_Typ", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_03_Typ, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_03_Typ", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_04_Typ, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_04_Typ", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_05_Typ, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_05_Typ", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_06_Typ, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_06_Typ", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_07_Typ, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_07_Typ", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_08_Typ, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_08_Typ", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_09_Typ, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_09_Typ", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_10_Typ, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_10_Typ", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_11_Typ, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_11_Typ", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Spurwechsel_li, getProfileInt( "Settings", "HIL_b_TA_HMI_Spurwechsel_li", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_TaZoomstufeAktiv, getProfileInt( "Settings", "HIL_b_TA_HMI_TaZoomstufeAktiv", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_TrajektSeg1_Gierwinkel, getProfileFloat( "Settings", "HIL_b_TA_HMI_TrajektSeg1_Gierwinkel", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_TrajektSeg1_Valid, getProfileInt( "Settings", "HIL_b_TA_HMI_TrajektSeg1_Valid", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_01_Spurzuordnung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_01_Spurzuordnung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_03_dx, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_03_dx", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_04_dx, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_04_dx", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_05_dx, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_05_dx", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_06_dx, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_06_dx", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_07_dx, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_07_dx", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_11_dy, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_11_dy", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_01_dy, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_01_dy", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_02_dy, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_02_dy", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_02_Spurzuordnung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_02_Spurzuordnung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_03_Spurzuordnung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_03_Spurzuordnung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_04_Spurzuordnung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_04_Spurzuordnung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_08_dx, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_08_dx", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_09_dx, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_09_dx", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_10_dx, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_10_dx", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_11_dx, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_11_dx", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_03_dy, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_03_dy", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_04_dy, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_04_dy", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_05_dy, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_05_dy", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_05_Spurzuordnung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_05_Spurzuordnung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_06_dy, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_06_dy", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_06_Spurzuordnung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_06_Spurzuordnung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_07_dy, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_07_dy", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_07_Spurzuordnung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_07_Spurzuordnung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_08_dy, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_08_dy", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_08_Spurzuordnung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_08_Spurzuordnung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_09_dy, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_09_dy", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_10_dy, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_10_dy", 0, profileFile ) );
    putValue( HIL_b_ACC_Abstand_WZO, getProfileFloat( "Settings", "HIL_b_ACC_Abstand_WZO", 0, profileFile ) );
    putValue( HIL_b_ACC_Status_GRA_Modus, getProfileInt( "Settings", "HIL_b_ACC_Status_GRA_Modus", 0, profileFile ) );
    putValue( HIL_b_AWV_AW_Texte, getProfileInt( "Settings", "HIL_b_AWV_AW_Texte", 0, profileFile ) );
    putValue( HIL_b_AWV_AW_Zeitluecke, getProfileInt( "Settings", "HIL_b_AWV_AW_Zeitluecke", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_01_LaengsRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_01_LaengsRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_01_QuerRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_01_QuerRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_02_LaengsRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_02_LaengsRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_02_QuerRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_02_QuerRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_03_LaengsRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_03_LaengsRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_03_QuerRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_03_QuerRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_04_LaengsRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_04_LaengsRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_04_QuerRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_04_QuerRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_05_LaengsRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_05_LaengsRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_05_QuerRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_05_QuerRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_06_LaengsRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_06_LaengsRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_06_QuerRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_06_QuerRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_07_LaengsRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_07_LaengsRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_07_QuerRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_07_QuerRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_08_LaengsRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_08_LaengsRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_08_QuerRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_08_QuerRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_09_LaengsRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_09_LaengsRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_09_QuerRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_09_QuerRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_09_Spurzuordnung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_09_Spurzuordnung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_10_LaengsRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_10_LaengsRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_10_QuerRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_10_QuerRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_10_Spurzuordnung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_10_Spurzuordnung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_11_LaengsRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_11_LaengsRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_11_QuerRegelung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_11_QuerRegelung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_11_Spurzuordnung, getProfileInt( "Settings", "HIL_b_TA_HMI_Obj_11_Spurzuordnung", 0, profileFile ) );
    putValue( HIL_s_KBI_Anzeigestatus_GRA, getProfileInt( "Settings", "HIL_s_KBI_Anzeigestatus_GRA", 0, profileFile ) );
    putValue( HIL_s_KBI_Anzeigestatus_LIM, getProfileInt( "Settings", "HIL_s_KBI_Anzeigestatus_LIM", 0, profileFile ) );
    putValue( HIL_s_LED_GRA, getProfileInt( "Settings", "HIL_s_LED_GRA", 0, profileFile ) );
    putValue( HIL_s_LED_GRA_US, getProfileInt( "Settings", "HIL_s_LED_GRA_US", 0, profileFile ) );
    putValue( HIL_s_LED_Laengsregelung, getProfileInt( "Settings", "HIL_s_LED_Laengsregelung", 0, profileFile ) );
    putValue( HIL_s_LED_Laengsregelung_blinken, getProfileInt( "Settings", "HIL_s_LED_Laengsregelung_blinken", 0, profileFile ) );
    putValue( HIL_s_LED_LIM, getProfileInt( "Settings", "HIL_s_LED_LIM", 0, profileFile ) );
    putValue( HIL_s_LED_LIM_blinken, getProfileInt( "Settings", "HIL_s_LED_LIM_blinken", 0, profileFile ) );
    putValue( HIL_hmi_FAS_Wunschgeschwindigkeit_in_kodierter_einheit, getProfileFloat( "Settings", "HIL_hmi_FAS_Wunschgeschwindigkeit_in_kodierter_einheit", 0, profileFile ) );
    putValue( HIL_b_ESC_FBA_Meldungen, getProfileInt( "Settings", "HIL_b_ESC_FBA_Meldungen", 0, profileFile ) );
    putValue( HIL_s_KBI_angez_Geschw_CAN, getProfileFloat( "Settings", "HIL_s_KBI_angez_Geschw_CAN", 0, profileFile ) );
    putValue( HIL_s_KBI_GAP_Warn_Zeit_abgelaufen, getProfileInt( "Settings", "HIL_s_KBI_GAP_Warn_Zeit_abgelaufen", 0, profileFile ) );
    putValue( HIL_s_KBI_Kilometerstand_HiRes, getProfileFloat( "Settings", "HIL_s_KBI_Kilometerstand_HiRes", 0, profileFile ) );
    putValue( HIL_s_KBI_MFA_v_Einheit, getProfileInt( "Settings", "HIL_s_KBI_MFA_v_Einheit", 0, profileFile ) );
    putValue( HIL_s_KBI_RDK_Kalibrier_Anf, getProfileInt( "Settings", "HIL_s_KBI_RDK_Kalibrier_Anf", 0, profileFile ) );
    putValue( HIL_s_KBI_V_Digital, getProfileInt( "Settings", "HIL_s_KBI_V_Digital", 0, profileFile ) );
    putValue( HIL_s_radumfang_mittel, getProfileInt( "Settings", "HIL_s_radumfang_mittel", 0, profileFile ) );
    putValue( HIL_s_tageswegstrecke_reset, getProfileInt( "Settings", "HIL_s_tageswegstrecke_reset", 0, profileFile ) );
    putValue( HIL_b_DBK_Fahrerwarnung, getProfileInt( "Settings", "HIL_b_DBK_Fahrerwarnung", 0, profileFile ) );
    putValue( HIL_b_EPB_Fehlermeldungen_02, getProfileInt( "Settings", "HIL_b_EPB_Fehlermeldungen_02", 0, profileFile ) );
    putValue( HIL_hmi_navi_rg_distancebargraph_available, getProfileInt( "Settings", "HIL_hmi_navi_rg_distancebargraph_available", 0, profileFile ) );
    putValue( HIL_hmi_navi_rg_timebargraph_available, getProfileInt( "Settings", "HIL_hmi_navi_rg_timebargraph_available", 0, profileFile ) );
    putValue( HIL_s_feststellbremse_konv_ausg, getProfileInt( "Settings", "HIL_s_feststellbremse_konv_ausg", 0, profileFile ) );
    putValue( HIL_s_KBI_Weg_Zaehler, getProfileInt( "Settings", "HIL_s_KBI_Weg_Zaehler", 0, profileFile ) );
    putValue( HIL_s_KBI_Weg_Zaehler_F, getProfileInt( "Settings", "HIL_s_KBI_Weg_Zaehler_F", 0, profileFile ) );
    putValue( HIL_s_LED_EPB_NAR_rot, getProfileInt( "Settings", "HIL_s_LED_EPB_NAR_rot", 0, profileFile ) );
    putValue( HIL_s_LED_EPB_RDW_rot, getProfileInt( "Settings", "HIL_s_LED_EPB_RDW_rot", 0, profileFile ) );
    putValue( HIL_s_tageswegstrecke, getProfileFloat( "Settings", "HIL_s_tageswegstrecke", 0, profileFile ) );
    putValue( HIL_b_KBI_Kilometerstand_HiRes_meter, getProfileInt( "Settings", "HIL_b_KBI_Kilometerstand_HiRes_meter", 0, profileFile ) );
    putValue( HIL_hmi_HistoryState_LeftTube_PHEV_Skin0, getProfileInt( "Settings", "HIL_hmi_HistoryState_LeftTube_PHEV_Skin0", 0, profileFile ) );
    putValue( HIL_hmi_HistoryState_LeftTube_PHEV_Skin1, getProfileInt( "Settings", "HIL_hmi_HistoryState_LeftTube_PHEV_Skin1", 0, profileFile ) );
    putValue( HIL_hmi_HistoryState_LeftTube_PHEV_Skin2, getProfileInt( "Settings", "HIL_hmi_HistoryState_LeftTube_PHEV_Skin2", 0, profileFile ) );
    putValue( HIL_hmi_HistoryState_Nebenanzeige_Skin0, getProfileInt( "Settings", "HIL_hmi_HistoryState_Nebenanzeige_Skin0", 0, profileFile ) );
    putValue( HIL_hmi_HistoryState_Nebenanzeige_Skin1, getProfileInt( "Settings", "HIL_hmi_HistoryState_Nebenanzeige_Skin1", 0, profileFile ) );
    putValue( HIL_hmi_HistoryState_Nebenanzeige_Skin2, getProfileInt( "Settings", "HIL_hmi_HistoryState_Nebenanzeige_Skin2", 0, profileFile ) );
    putValue( HIL_hmi_HistoryState_Zusatzanzeige_Skin1, getProfileInt( "Settings", "HIL_hmi_HistoryState_Zusatzanzeige_Skin1", 0, profileFile ) );
    putValue( HIL_hmi_aktive_Nebenanzeige_links, getProfileInt( "Settings", "HIL_hmi_aktive_Nebenanzeige_links", 0, profileFile ) );
    putValue( HIL_hmi_aktive_Nebenanzeige_rechts, getProfileInt( "Settings", "HIL_hmi_aktive_Nebenanzeige_rechts", 0, profileFile ) );
    putValue( HIL_hmi_aktiver_View, getProfileInt( "Settings", "HIL_hmi_aktiver_View", 0, profileFile ) );
    putValue( HIL_s_DTC_Kombi_defekt, getProfileInt( "Settings", "HIL_s_DTC_Kombi_defekt", 0, profileFile ) );
    putValue( HIL_s_DTC_TI_B200FF0, getProfileInt( "Settings", "HIL_s_DTC_TI_B200FF0", 0, profileFile ) );
    putValue( HIL_s_DTC_TI_B174404, getProfileInt( "Settings", "HIL_s_DTC_TI_B174404", 0, profileFile ) );
    putValue( HIL_s_DTC_TI_B200041, getProfileInt( "Settings", "HIL_s_DTC_TI_B200041", 0, profileFile ) );
    putValue( HIL_s_DTC_TI_B200043, getProfileInt( "Settings", "HIL_s_DTC_TI_B200043", 0, profileFile ) );
    putValue( HIL_s_KBI_Einheit_Datum, getProfileInt( "Settings", "HIL_s_KBI_Einheit_Datum", 0, profileFile ) );
    putValue( HIL_s_KBI_Einheit_Druck, getProfileInt( "Settings", "HIL_s_KBI_Einheit_Druck", 0, profileFile ) );
    putValue( HIL_s_KBI_Einheit_Masse, getProfileInt( "Settings", "HIL_s_KBI_Einheit_Masse", 0, profileFile ) );
    putValue( HIL_s_KBI_Einheit_Streckenanz, getProfileInt( "Settings", "HIL_s_KBI_Einheit_Streckenanz", 0, profileFile ) );
    putValue( HIL_s_KBI_Einheit_Tacho, getProfileInt( "Settings", "HIL_s_KBI_Einheit_Tacho", 0, profileFile ) );
    putValue( HIL_s_KBI_Einheit_Temp, getProfileInt( "Settings", "HIL_s_KBI_Einheit_Temp", 0, profileFile ) );
    putValue( HIL_s_KBI_Einheit_Verbrauch, getProfileInt( "Settings", "HIL_s_KBI_Einheit_Verbrauch", 0, profileFile ) );
    putValue( HIL_s_KBI_Einheit_Verbrauch_elektr, getProfileInt( "Settings", "HIL_s_KBI_Einheit_Verbrauch_elektr", 0, profileFile ) );
    putValue( HIL_s_KBI_Einheit_Verbrauch_Gas, getProfileInt( "Settings", "HIL_s_KBI_Einheit_Verbrauch_Gas", 0, profileFile ) );
    putValue( HIL_s_KBI_Einheit_Volumen, getProfileInt( "Settings", "HIL_s_KBI_Einheit_Volumen", 0, profileFile ) );
    putValue( HIL_s_KBI_im_Stellgliedtest, getProfileInt( "Settings", "HIL_s_KBI_im_Stellgliedtest", 0, profileFile ) );
    putValue( HIL_s_KBI_KD_fehler, getProfileInt( "Settings", "HIL_s_KBI_KD_fehler", 0, profileFile ) );
    putValue( HIL_s_KBI_Variante, getProfileInt( "Settings", "HIL_s_KBI_Variante", 0, profileFile ) );
    putValue( HIL_s_Kombi_01_BZ, getProfileInt( "Settings", "HIL_s_Kombi_01_BZ", 0, profileFile ) );
    putValue( HIL_s_Kombi_Abschaltstufe, getProfileInt( "Settings", "HIL_s_Kombi_Abschaltstufe", 0, profileFile ) );
    putValue( HIL_s_Kombi_Transport_Mode, getProfileInt( "Settings", "HIL_s_Kombi_Transport_Mode", 0, profileFile ) );
    putValue( HIL_s_NM_Kombi_CAB, getProfileInt( "Settings", "HIL_s_NM_Kombi_CAB", 0, profileFile ) );
    putValue( HIL_s_NM_Kombi_Car_Wakeup, getProfileInt( "Settings", "HIL_s_NM_Kombi_Car_Wakeup", 0, profileFile ) );
    putValue( HIL_s_NM_Kombi_NM_aktiv_Buzzer, getProfileInt( "Settings", "HIL_s_NM_Kombi_NM_aktiv_Buzzer", 0, profileFile ) );
    putValue( HIL_b_MO_Anzeige_Leistung, getProfileFloat( "Settings", "HIL_b_MO_Anzeige_Leistung", 0, profileFile ) );
    putValue( HIL_b_TSK_Einheit_vMax_FahrerInfo, getProfileInt( "Settings", "HIL_b_TSK_Einheit_vMax_FahrerInfo", 0, profileFile ) );
    putValue( HIL_b_TSK_vMax_FahrerInfo, getProfileInt( "Settings", "HIL_b_TSK_vMax_FahrerInfo", 0, profileFile ) );
    putValue( HIL_b_WIV_laufender_Motor, getProfileInt( "Settings", "HIL_b_WIV_laufender_Motor", 0, profileFile ) );
    putValue( HIL_b_WIV_nicht_betriebswarm, getProfileInt( "Settings", "HIL_b_WIV_nicht_betriebswarm", 0, profileFile ) );
    putValue( HIL_b_WIV_Schieflage, getProfileInt( "Settings", "HIL_b_WIV_Schieflage", 0, profileFile ) );
    putValue( HIL_hmi_service_sonderbehandlung, getProfileInt( "Settings", "HIL_hmi_service_sonderbehandlung", 0, profileFile ) );
    putValue( HIL_hmi_WBA_Schaltempfehlung_vorhanden, getProfileInt( "Settings", "HIL_hmi_WBA_Schaltempfehlung_vorhanden", 0, profileFile ) );
    putValue( HIL_s_fusi_Auto_P, getProfileInt( "Settings", "HIL_s_fusi_Auto_P", 0, profileFile ) );
    putValue( HIL_s_KBI_Oelwechsel_durchgefuehrt, getProfileInt( "Settings", "HIL_s_KBI_Oelwechsel_durchgefuehrt", 0, profileFile ) );
    putValue( HIL_s_KBI_Standzeit_02, getProfileInt( "Settings", "HIL_s_KBI_Standzeit_02", 0, profileFile ) );
    putValue( HIL_s_LED_Oeldruck, getProfileInt( "Settings", "HIL_s_LED_Oeldruck", 0, profileFile ) );
    putValue( HIL_s_manuell_zeit_datum_monat, getProfileInt( "Settings", "HIL_s_manuell_zeit_datum_monat", 0, profileFile ) );
    putValue( HIL_s_manuell_zeit_uhrzeit_sekunde, getProfileInt( "Settings", "HIL_s_manuell_zeit_uhrzeit_sekunde", 0, profileFile ) );
    putValue( HIL_s_NM_Kombi_Wakeup, getProfileInt( "Settings", "HIL_s_NM_Kombi_Wakeup", 0, profileFile ) );
    putValue( HIL_s_UH_DLS, getProfileInt( "Settings", "HIL_s_UH_DLS", 0, profileFile ) );
    putValue( HIL_s_insp_restlauf_km, getProfileInt( "Settings", "HIL_s_insp_restlauf_km", 0, profileFile ) );
    putValue( HIL_s_insp_restlauf_tage, getProfileInt( "Settings", "HIL_s_insp_restlauf_tage", 0, profileFile ) );
    putValue( HIL_s_oil_ueberschreitung_km, getProfileInt( "Settings", "HIL_s_oil_ueberschreitung_km", 0, profileFile ) );
    putValue( HIL_s_oil_ueberschreitung_tage, getProfileInt( "Settings", "HIL_s_oil_ueberschreitung_tage", 0, profileFile ) );
    putValue( HIL_s_oil_restlauf_km, getProfileInt( "Settings", "HIL_s_oil_restlauf_km", 0, profileFile ) );
    putValue( HIL_s_oil_restlauf_tage, getProfileInt( "Settings", "HIL_s_oil_restlauf_tage", 0, profileFile ) );
    putValue( HIL_s_service_restlauf_km, getProfileInt( "Settings", "HIL_s_service_restlauf_km", 0, profileFile ) );
    putValue( HIL_s_service_restlauf_tage, getProfileInt( "Settings", "HIL_s_service_restlauf_tage", 0, profileFile ) );
    putValue( HIL_s_gMeter_ax_oben_max, getProfileFloat( "Settings", "HIL_s_gMeter_ax_oben_max", 0, profileFile ) );
    putValue( HIL_s_gMeter_ax_unten_max, getProfileFloat( "Settings", "HIL_s_gMeter_ax_unten_max", 0, profileFile ) );
    putValue( HIL_s_gMeter_ay_links_max, getProfileFloat( "Settings", "HIL_s_gMeter_ay_links_max", 0, profileFile ) );
    putValue( HIL_s_gMeter_ay_rechts_max, getProfileFloat( "Settings", "HIL_s_gMeter_ay_rechts_max", 0, profileFile ) );
    putValue( HIL_s_gMeter_Winkel, getProfileInt( "Settings", "HIL_s_gMeter_Winkel", 0, profileFile ) );
    putValue( HIL_set_HMI_G_max_Reset, getProfileInt( "Settings", "HIL_set_HMI_G_max_Reset", 0, profileFile ) );
    putValue( HIL_hmi_boot_download_finished, getProfileInt( "Settings", "HIL_hmi_boot_download_finished", 0, profileFile ) );
    putValue( HIL_hmi_laptimer_letzte_rundenzeit, getProfileFloat( "Settings", "HIL_hmi_laptimer_letzte_rundenzeit", 0, profileFile ) );
    putValue( HIL_s_laptimer_rundenzeiten, getProfileFloat( "Settings", "HIL_s_laptimer_rundenzeiten", 0, profileFile ) );
    putValue( HIL_s_manuell_zeit_datum_jahr, getProfileInt( "Settings", "HIL_s_manuell_zeit_datum_jahr", 0, profileFile ) );
    putValue( HIL_s_manuell_zeit_datum_tag, getProfileInt( "Settings", "HIL_s_manuell_zeit_datum_tag", 0, profileFile ) );
    putValue( HIL_s_dzm_zeigerposition_drehzahl, getProfileFloat( "Settings", "HIL_s_dzm_zeigerposition_drehzahl", 0, profileFile ) );
    putValue( HIL_s_emv_reku_delta_dc, getProfileInt( "Settings", "HIL_s_emv_reku_delta_dc", 0, profileFile ) );
    putValue( HIL_s_emv_reku_delta_weg, getProfileInt( "Settings", "HIL_s_emv_reku_delta_weg", 0, profileFile ) );
    putValue( HIL_s_emv_reku_mv_nebenverbrauch, getProfileInt( "Settings", "HIL_s_emv_reku_mv_nebenverbrauch", 0, profileFile ) );
    putValue( HIL_s_emv_reku_delta_antrieb_reku, getProfileInt( "Settings", "HIL_s_emv_reku_delta_antrieb_reku", 0, profileFile ) );
    putValue( HIL_s_emv_reku_delta_antrieb_verbr, getProfileInt( "Settings", "HIL_s_emv_reku_delta_antrieb_verbr", 0, profileFile ) );
    putValue( HIL_s_emv_reku_delta_tme, getProfileInt( "Settings", "HIL_s_emv_reku_delta_tme", 0, profileFile ) );
    putValue( HIL_s_emv_reku_mv_antrieb_hyst, getProfileFloat( "Settings", "HIL_s_emv_reku_mv_antrieb_hyst", 0, profileFile ) );
    putValue( HIL_s_emv_reku_dv_slider_prozent, getProfileFloat( "Settings", "HIL_s_emv_reku_dv_slider_prozent", 0, profileFile ) );
    putValue( HIL_s_emv_reku_mv_gesamt_nachfilter, getProfileFloat( "Settings", "HIL_s_emv_reku_mv_gesamt_nachfilter", 0, profileFile ) );
    putValue( HIL_s_emv_reku_mv_gesamt_prozent, getProfileFloat( "Settings", "HIL_s_emv_reku_mv_gesamt_prozent", 0, profileFile ) );
    putValue( HIL_s_emv_reku_stand_umsch_aktiv, getProfileInt( "Settings", "HIL_s_emv_reku_stand_umsch_aktiv", 0, profileFile ) );
    putValue( HIL_s_KBI_Kilometerstand, getProfileInt( "Settings", "HIL_s_KBI_Kilometerstand", 0, profileFile ) );
    putValue( HIL_b_KBI_Kilometerstand_Extended, getProfileInt( "Settings", "HIL_b_KBI_Kilometerstand_Extended", 0, profileFile ) );
    putValue( HIL_s_emv_reku_mv_antrieb, getProfileFloat( "Settings", "HIL_s_emv_reku_mv_antrieb", 0, profileFile ) );
    putValue( HIL_s_GNSS_V_Geschw, getProfileFloat( "Settings", "HIL_s_GNSS_V_Geschw", 0, profileFile ) );
    putValue( HIL_s_radumfang_korrektur, getProfileInt( "Settings", "HIL_s_radumfang_korrektur", 0, profileFile ) );
    putValue( HIL_s_radumfang_opt, getProfileInt( "Settings", "HIL_s_radumfang_opt", 0, profileFile ) );
    putValue( HIL_s_radumfang_sync, getProfileInt( "Settings", "HIL_s_radumfang_sync", 0, profileFile ) );
    putValue( HIL_b_GNSS_V_Geschw_2D, getProfileFloat( "Settings", "HIL_b_GNSS_V_Geschw_2D", 0, profileFile ) );
    putValue( HIL_b_GNSS_V_Geschw_Vertikal, getProfileFloat( "Settings", "HIL_b_GNSS_V_Geschw_Vertikal", 0, profileFile ) );
    putValue( HIL_s_GNSS_Geschw_fehler, getProfileInt( "Settings", "HIL_s_GNSS_Geschw_fehler", 0, profileFile ) );
    putValue( HIL_s_sync_ESP_m_Raddrehz, getProfileFloat( "Settings", "HIL_s_sync_ESP_m_Raddrehz", 0, profileFile ) );
    putValue( HIL_s_sync_GNSS_V_Geschw, getProfileFloat( "Settings", "HIL_s_sync_GNSS_V_Geschw", 0, profileFile ) );
    putValue( HIL_b_GNSS_Nachrichtenpaket_ID5, getProfileInt( "Settings", "HIL_b_GNSS_Nachrichtenpaket_ID5", 0, profileFile ) );
    putValue( HIL_b_GNSS_Nachrichtenpaket_ID7, getProfileInt( "Settings", "HIL_b_GNSS_Nachrichtenpaket_ID7", 0, profileFile ) );
    putValue( HIL_b_GNSS_V_FIX_Typ, getProfileInt( "Settings", "HIL_b_GNSS_V_FIX_Typ", 0, profileFile ) );
    putValue( HIL_b_GNSS_V_Latenz_vollstaendig, getProfileInt( "Settings", "HIL_b_GNSS_V_Latenz_vollstaendig", 0, profileFile ) );
    putValue( HIL_s_Gewichtungsfaktor_altersbasiert, getProfileFloat( "Settings", "HIL_s_Gewichtungsfaktor_altersbasiert", 0, profileFile ) );
    putValue( HIL_s_Gewichtungsfaktor_geschwindigkeitsbasiert, getProfileFloat( "Settings", "HIL_s_Gewichtungsfaktor_geschwindigkeitsbasiert", 0, profileFile ) );
    putValue( HIL_s_Gewichtungsfaktor_Ringspeicher, getProfileFloat( "Settings", "HIL_s_Gewichtungsfaktor_Ringspeicher", 0, profileFile ) );
    putValue( HIL_s_GNSS_2D_fehler, getProfileInt( "Settings", "HIL_s_GNSS_2D_fehler", 0, profileFile ) );
    putValue( HIL_s_GNSS_3D_fehler, getProfileInt( "Settings", "HIL_s_GNSS_3D_fehler", 0, profileFile ) );
    putValue( HIL_s_koeff_lernen_verlernen, getProfileFloat( "Settings", "HIL_s_koeff_lernen_verlernen", 0, profileFile ) );
    putValue( HIL_s_laenge_puffer_zeitliche_synchronisierung, getProfileInt( "Settings", "HIL_s_laenge_puffer_zeitliche_synchronisierung", 0, profileFile ) );
    putValue( HIL_s_n_Eintraege_Ringspeicher, getProfileInt( "Settings", "HIL_s_n_Eintraege_Ringspeicher", 0, profileFile ) );
    putValue( HIL_s_trigger_ringspeicher, getProfileInt( "Settings", "HIL_s_trigger_ringspeicher", 0, profileFile ) );
    putValue( HIL_b_GNSS_UTC_Zeit, getProfileInt( "Settings", "HIL_b_GNSS_UTC_Zeit", 0, profileFile ) );
    putValue( HIL_b_GNSS_V_Daten_Veraltet, getProfileInt( "Settings", "HIL_b_GNSS_V_Daten_Veraltet", 0, profileFile ) );
    putValue( HIL_b_GNSS_V_Geschw_2D_Guete95, getProfileFloat( "Settings", "HIL_b_GNSS_V_Geschw_2D_Guete95", 0, profileFile ) );
    putValue( HIL_b_GNSS_V_Geschw_Vertikal_Guete95, getProfileFloat( "Settings", "HIL_b_GNSS_V_Geschw_Vertikal_Guete95", 0, profileFile ) );
    putValue( HIL_s_sync_GNSS_UTC_Zeit, getProfileInt( "Settings", "HIL_s_sync_GNSS_UTC_Zeit", 0, profileFile ) );
    putValue( HIL_s_gMeter_ax_oben, getProfileFloat( "Settings", "HIL_s_gMeter_ax_oben", 0, profileFile ) );
    putValue( HIL_s_gMeter_ax_oben_kz_max, getProfileFloat( "Settings", "HIL_s_gMeter_ax_oben_kz_max", 0, profileFile ) );
    putValue( HIL_s_gMeter_ax_unten, getProfileFloat( "Settings", "HIL_s_gMeter_ax_unten", 0, profileFile ) );
    putValue( HIL_s_gMeter_ax_unten_kz_max, getProfileFloat( "Settings", "HIL_s_gMeter_ax_unten_kz_max", 0, profileFile ) );
    putValue( HIL_s_gMeter_ay_links, getProfileFloat( "Settings", "HIL_s_gMeter_ay_links", 0, profileFile ) );
    putValue( HIL_s_gMeter_ay_rechts, getProfileFloat( "Settings", "HIL_s_gMeter_ay_rechts", 0, profileFile ) );
    putValue( HIL_s_gMeter_ax_oben_kz_max_prozent, getProfileInt( "Settings", "HIL_s_gMeter_ax_oben_kz_max_prozent", 0, profileFile ) );
    putValue( HIL_s_gMeter_ax_oben_max_prozent, getProfileInt( "Settings", "HIL_s_gMeter_ax_oben_max_prozent", 0, profileFile ) );
    putValue( HIL_s_gMeter_ax_unten_kz_max_prozent, getProfileInt( "Settings", "HIL_s_gMeter_ax_unten_kz_max_prozent", 0, profileFile ) );
    putValue( HIL_s_gMeter_ax_unten_max_prozent, getProfileInt( "Settings", "HIL_s_gMeter_ax_unten_max_prozent", 0, profileFile ) );
    putValue( HIL_s_gMeter_ay_links_kz_max_prozent, getProfileInt( "Settings", "HIL_s_gMeter_ay_links_kz_max_prozent", 0, profileFile ) );
    putValue( HIL_s_gMeter_ay_links_max_prozent, getProfileInt( "Settings", "HIL_s_gMeter_ay_links_max_prozent", 0, profileFile ) );
    putValue( HIL_s_gMeter_ay_rechts_kz_max_prozent, getProfileInt( "Settings", "HIL_s_gMeter_ay_rechts_kz_max_prozent", 0, profileFile ) );
    putValue( HIL_s_gMeter_ay_rechts_max_prozent, getProfileInt( "Settings", "HIL_s_gMeter_ay_rechts_max_prozent", 0, profileFile ) );
    putValue( HIL_b_FDR_M_HL_02, getProfileInt( "Settings", "HIL_b_FDR_M_HL_02", 0, profileFile ) );
    putValue( HIL_b_FDR_M_HR_02, getProfileInt( "Settings", "HIL_b_FDR_M_HR_02", 0, profileFile ) );
    putValue( HIL_b_FDR_M_VL_02, getProfileInt( "Settings", "HIL_b_FDR_M_VL_02", 0, profileFile ) );
    putValue( HIL_b_FDR_M_VR_02, getProfileInt( "Settings", "HIL_b_FDR_M_VR_02", 0, profileFile ) );
    putValue( HIL_b_TSL_Warnung, getProfileInt( "Settings", "HIL_b_TSL_Warnung", 0, profileFile ) );
    putValue( HIL_b_TSR_Warnung, getProfileInt( "Settings", "HIL_b_TSR_Warnung", 0, profileFile ) );
    putValue( HIL_hmi_gmeter_aktuelle_Darstellung, getProfileInt( "Settings", "HIL_hmi_gmeter_aktuelle_Darstellung", 0, profileFile ) );
    putValue( HIL_s_gMeter_anzeige_ungueltig, getProfileInt( "Settings", "HIL_s_gMeter_anzeige_ungueltig", 0, profileFile ) );
    putValue( HIL_s_gMeter_ay_links_kz_max, getProfileFloat( "Settings", "HIL_s_gMeter_ay_links_kz_max", 0, profileFile ) );
    putValue( HIL_s_gMeter_ay_rechts_kz_max, getProfileFloat( "Settings", "HIL_s_gMeter_ay_rechts_kz_max", 0, profileFile ) );
    putValue( ENV_UDPNM_Message_Counter_BVT, getProfileInt( "Settings", "ENV_UDPNM_Message_Counter_BVT", 0, profileFile ) );
    putValue( ENV_UDPNM_CouplewithCANNM, getProfileInt( "Settings", "ENV_UDPNM_CouplewithCANNM", 0, profileFile ) );
    putValue( ENV_UDPSynWithKombiSimulationNode, getProfileInt( "Settings", "ENV_UDPSynWithKombiSimulationNode", 0, profileFile ) );
    putValue( ENV_UDPSendKombiSimulationNMMsg, getProfileInt( "Settings", "ENV_UDPSendKombiSimulationNMMsg", 0, profileFile ) );
    putValue( ENV_UDPSendEnabled, getProfileInt( "Settings", "ENV_UDPSendEnabled", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_Gateway, getProfileInt( "Settings", "ENV_UDPSendNMH_Gateway", 0, profileFile ) );
    putValue( ENV_UDPNM_Gateway_NM_StateS, getProfileInt( "Settings", "ENV_UDPNM_Gateway_NM_StateS", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_eCall, getProfileInt( "Settings", "ENV_UDPSendNMH_eCall", 0, profileFile ) );
    putValue( ENV_UDPNM_Kombi_NM_StateD, getProfileInt( "Settings", "ENV_UDPNM_Kombi_NM_StateD", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineState, getProfileInt( "Settings", "ENV_UDPNMHStateMachineState", 0, profileFile ) );
    putValue( ENV_UDPNMHControllerNodeAwake, getProfileInt( "Settings", "ENV_UDPNMHControllerNodeAwake", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineEnabled, getProfileInt( "Settings", "ENV_UDPNMHStateMachineEnabled", 0, profileFile ) );
    putValue( ENV_UDPNMHState, getProfileInt( "Settings", "ENV_UDPNMHState", 0, profileFile ) );
    putValue( ENV_UDPNMHMode, getProfileInt( "Settings", "ENV_UDPNMHMode", 0, profileFile ) );
    putValue( ENV_UDPSendAtOnceNMH_Gateway, getProfileInt( "Settings", "ENV_UDPSendAtOnceNMH_Gateway", 0, profileFile ) );
    putValue( ENV_UDPNMHLastState, getProfileInt( "Settings", "ENV_UDPNMHLastState", 0, profileFile ) );
    putValue( ENV_ETHPingStartStop, getProfileInt( "Settings", "ENV_ETHPingStartStop", 0, profileFile ) );
    putValue( ENV_ETHPingSendCnt, getProfileInt( "Settings", "ENV_ETHPingSendCnt", 0, profileFile ) );
    putValue( ENV_ETHPingRecvCnt, getProfileInt( "Settings", "ENV_ETHPingRecvCnt", 0, profileFile ) );
    putValue( ENV_ETHPingLostCnt, getProfileInt( "Settings", "ENV_ETHPingLostCnt", 0, profileFile ) );
    putValue( ENV_UDPNM_CouplewithCANNM_ETH02, getProfileInt( "Settings", "ENV_UDPNM_CouplewithCANNM_ETH02", 0, profileFile ) );
    putValue( ENV_UDPSendKombiSimulationNMMsg_ETH02, getProfileInt( "Settings", "ENV_UDPSendKombiSimulationNMMsg_ETH02", 0, profileFile ) );
    putValue( ENV_UDPSendEnabled_ETH02, getProfileInt( "Settings", "ENV_UDPSendEnabled_ETH02", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_Gateway_ETH02, getProfileInt( "Settings", "ENV_UDPSendNMH_Gateway_ETH02", 0, profileFile ) );
    putValue( ENV_UDPNM_Gateway_NM_StateS_ETH02, getProfileInt( "Settings", "ENV_UDPNM_Gateway_NM_StateS_ETH02", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_eCall_ETH02, getProfileInt( "Settings", "ENV_UDPSendNMH_eCall_ETH02", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineState_ETH02, getProfileInt( "Settings", "ENV_UDPNMHStateMachineState_ETH02", 0, profileFile ) );
    putValue( ENV_UDPNMHControllerNodeAwake_ETH02, getProfileInt( "Settings", "ENV_UDPNMHControllerNodeAwake_ETH02", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineEnabled_ETH02, getProfileInt( "Settings", "ENV_UDPNMHStateMachineEnabled_ETH02", 0, profileFile ) );
    putValue( ENV_UDPNMHState_ETH02, getProfileInt( "Settings", "ENV_UDPNMHState_ETH02", 0, profileFile ) );
    putValue( ENV_UDPNMHMode_ETH02, getProfileInt( "Settings", "ENV_UDPNMHMode_ETH02", 0, profileFile ) );
    putValue( ENV_UDPSendAtOnceNMH_Gateway_ETH02, getProfileInt( "Settings", "ENV_UDPSendAtOnceNMH_Gateway_ETH02", 0, profileFile ) );
    putValue( ENV_ON_OFF_FSG50_2, getProfileInt( "Settings", "ENV_ON_OFF_FSG50_2", 0, profileFile ) );
    putValue( ENV_UDPNM_CouplewithCANNM_ETH03, getProfileInt( "Settings", "ENV_UDPNM_CouplewithCANNM_ETH03", 0, profileFile ) );
    putValue( ENV_UDPSendKombiSimulationNMMsg_ETH03, getProfileInt( "Settings", "ENV_UDPSendKombiSimulationNMMsg_ETH03", 0, profileFile ) );
    putValue( ENV_UDPSendEnabled_ETH03, getProfileInt( "Settings", "ENV_UDPSendEnabled_ETH03", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_Gateway_ETH03, getProfileInt( "Settings", "ENV_UDPSendNMH_Gateway_ETH03", 0, profileFile ) );
    putValue( ENV_UDPNM_Gateway_NM_StateS_ETH03, getProfileInt( "Settings", "ENV_UDPNM_Gateway_NM_StateS_ETH03", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_eCall_ETH03, getProfileInt( "Settings", "ENV_UDPSendNMH_eCall_ETH03", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineState_ETH03, getProfileInt( "Settings", "ENV_UDPNMHStateMachineState_ETH03", 0, profileFile ) );
    putValue( ENV_UDPNMHControllerNodeAwake_ETH03, getProfileInt( "Settings", "ENV_UDPNMHControllerNodeAwake_ETH03", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineEnabled_ETH03, getProfileInt( "Settings", "ENV_UDPNMHStateMachineEnabled_ETH03", 0, profileFile ) );
    putValue( ENV_UDPNMHState_ETH03, getProfileInt( "Settings", "ENV_UDPNMHState_ETH03", 0, profileFile ) );
    putValue( ENV_UDPNMHMode_ETH03, getProfileInt( "Settings", "ENV_UDPNMHMode_ETH03", 0, profileFile ) );
    putValue( ENV_UDPSendAtOnceNMH_Gateway_ETH03, getProfileInt( "Settings", "ENV_UDPSendAtOnceNMH_Gateway_ETH03", 0, profileFile ) );
    putValue( ENV_UDPNM_CouplewithCANNM_ETH04, getProfileInt( "Settings", "ENV_UDPNM_CouplewithCANNM_ETH04", 0, profileFile ) );
    putValue( ENV_UDPSendKombiSimulationNMMsg_ETH04, getProfileInt( "Settings", "ENV_UDPSendKombiSimulationNMMsg_ETH04", 0, profileFile ) );
    putValue( ENV_UDPSendEnabled_ETH04, getProfileInt( "Settings", "ENV_UDPSendEnabled_ETH04", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_Gateway_ETH04, getProfileInt( "Settings", "ENV_UDPSendNMH_Gateway_ETH04", 0, profileFile ) );
    putValue( ENV_UDPNM_Gateway_NM_StateS_ETH04, getProfileInt( "Settings", "ENV_UDPNM_Gateway_NM_StateS_ETH04", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_eCall_ETH04, getProfileInt( "Settings", "ENV_UDPSendNMH_eCall_ETH04", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineState_ETH04, getProfileInt( "Settings", "ENV_UDPNMHStateMachineState_ETH04", 0, profileFile ) );
    putValue( ENV_UDPNMHControllerNodeAwake_ETH04, getProfileInt( "Settings", "ENV_UDPNMHControllerNodeAwake_ETH04", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineEnabled_ETH04, getProfileInt( "Settings", "ENV_UDPNMHStateMachineEnabled_ETH04", 0, profileFile ) );
    putValue( ENV_UDPNMHState_ETH04, getProfileInt( "Settings", "ENV_UDPNMHState_ETH04", 0, profileFile ) );
    putValue( ENV_UDPNMHMode_ETH04, getProfileInt( "Settings", "ENV_UDPNMHMode_ETH04", 0, profileFile ) );
    putValue( ENV_UDPSendAtOnceNMH_Gateway_ETH04, getProfileInt( "Settings", "ENV_UDPSendAtOnceNMH_Gateway_ETH04", 0, profileFile ) );
    putValue( ENV_UDPNM_CouplewithCANNM_ETH05, getProfileInt( "Settings", "ENV_UDPNM_CouplewithCANNM_ETH05", 0, profileFile ) );
    putValue( ENV_UDPSendKombiSimulationNMMsg_ETH05, getProfileInt( "Settings", "ENV_UDPSendKombiSimulationNMMsg_ETH05", 0, profileFile ) );
    putValue( ENV_UDPSendEnabled_ETH05, getProfileInt( "Settings", "ENV_UDPSendEnabled_ETH05", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_Gateway_ETH05, getProfileInt( "Settings", "ENV_UDPSendNMH_Gateway_ETH05", 0, profileFile ) );
    putValue( ENV_UDPNM_Gateway_NM_StateS_ETH05, getProfileInt( "Settings", "ENV_UDPNM_Gateway_NM_StateS_ETH05", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_eCall_ETH05, getProfileInt( "Settings", "ENV_UDPSendNMH_eCall_ETH05", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineState_ETH05, getProfileInt( "Settings", "ENV_UDPNMHStateMachineState_ETH05", 0, profileFile ) );
    putValue( ENV_UDPNMHControllerNodeAwake_ETH05, getProfileInt( "Settings", "ENV_UDPNMHControllerNodeAwake_ETH05", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineEnabled_ETH05, getProfileInt( "Settings", "ENV_UDPNMHStateMachineEnabled_ETH05", 0, profileFile ) );
    putValue( ENV_UDPNMHState_ETH05, getProfileInt( "Settings", "ENV_UDPNMHState_ETH05", 0, profileFile ) );
    putValue( ENV_UDPNMHMode_ETH05, getProfileInt( "Settings", "ENV_UDPNMHMode_ETH05", 0, profileFile ) );
    putValue( ENV_UDPSendAtOnceNMH_Gateway_ETH05, getProfileInt( "Settings", "ENV_UDPSendAtOnceNMH_Gateway_ETH05", 0, profileFile ) );
    putValue( ENV_UDPNM_CouplewithCANNM_ETH06, getProfileInt( "Settings", "ENV_UDPNM_CouplewithCANNM_ETH06", 0, profileFile ) );
    putValue( ENV_UDPSendKombiSimulationNMMsg_ETH06, getProfileInt( "Settings", "ENV_UDPSendKombiSimulationNMMsg_ETH06", 0, profileFile ) );
    putValue( ENV_UDPSendEnabled_ETH06, getProfileInt( "Settings", "ENV_UDPSendEnabled_ETH06", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_Gateway_ETH06, getProfileInt( "Settings", "ENV_UDPSendNMH_Gateway_ETH06", 0, profileFile ) );
    putValue( ENV_UDPNM_Gateway_NM_StateS_ETH06, getProfileInt( "Settings", "ENV_UDPNM_Gateway_NM_StateS_ETH06", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_eCall_ETH06, getProfileInt( "Settings", "ENV_UDPSendNMH_eCall_ETH06", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineState_ETH06, getProfileInt( "Settings", "ENV_UDPNMHStateMachineState_ETH06", 0, profileFile ) );
    putValue( ENV_UDPNMHControllerNodeAwake_ETH06, getProfileInt( "Settings", "ENV_UDPNMHControllerNodeAwake_ETH06", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineEnabled_ETH06, getProfileInt( "Settings", "ENV_UDPNMHStateMachineEnabled_ETH06", 0, profileFile ) );
    putValue( ENV_UDPNMHState_ETH06, getProfileInt( "Settings", "ENV_UDPNMHState_ETH06", 0, profileFile ) );
    putValue( ENV_UDPNMHMode_ETH06, getProfileInt( "Settings", "ENV_UDPNMHMode_ETH06", 0, profileFile ) );
    putValue( ENV_UDPSendAtOnceNMH_Gateway_ETH06, getProfileInt( "Settings", "ENV_UDPSendAtOnceNMH_Gateway_ETH06", 0, profileFile ) );
    putValue( ENV_UDPNM_CouplewithCANNM_ETH07, getProfileInt( "Settings", "ENV_UDPNM_CouplewithCANNM_ETH07", 0, profileFile ) );
    putValue( ENV_UDPSendKombiSimulationNMMsg_ETH07, getProfileInt( "Settings", "ENV_UDPSendKombiSimulationNMMsg_ETH07", 0, profileFile ) );
    putValue( ENV_UDPSendEnabled_ETH07, getProfileInt( "Settings", "ENV_UDPSendEnabled_ETH07", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_Gateway_ETH07, getProfileInt( "Settings", "ENV_UDPSendNMH_Gateway_ETH07", 0, profileFile ) );
    putValue( ENV_UDPNM_Gateway_NM_StateS_ETH07, getProfileInt( "Settings", "ENV_UDPNM_Gateway_NM_StateS_ETH07", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_eCall_ETH07, getProfileInt( "Settings", "ENV_UDPSendNMH_eCall_ETH07", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineState_ETH07, getProfileInt( "Settings", "ENV_UDPNMHStateMachineState_ETH07", 0, profileFile ) );
    putValue( ENV_UDPNMHControllerNodeAwake_ETH07, getProfileInt( "Settings", "ENV_UDPNMHControllerNodeAwake_ETH07", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineEnabled_ETH07, getProfileInt( "Settings", "ENV_UDPNMHStateMachineEnabled_ETH07", 0, profileFile ) );
    putValue( ENV_UDPNMHState_ETH07, getProfileInt( "Settings", "ENV_UDPNMHState_ETH07", 0, profileFile ) );
    putValue( ENV_UDPNMHMode_ETH07, getProfileInt( "Settings", "ENV_UDPNMHMode_ETH07", 0, profileFile ) );
    putValue( ENV_UDPSendAtOnceNMH_Gateway_ETH07, getProfileInt( "Settings", "ENV_UDPSendAtOnceNMH_Gateway_ETH07", 0, profileFile ) );
    putValue( ENV_UDPNM_CouplewithCANNM_ETH08, getProfileInt( "Settings", "ENV_UDPNM_CouplewithCANNM_ETH08", 0, profileFile ) );
    putValue( ENV_UDPSendKombiSimulationNMMsg_ETH08, getProfileInt( "Settings", "ENV_UDPSendKombiSimulationNMMsg_ETH08", 0, profileFile ) );
    putValue( ENV_UDPSendEnabled_ETH08, getProfileInt( "Settings", "ENV_UDPSendEnabled_ETH08", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_Gateway_ETH08, getProfileInt( "Settings", "ENV_UDPSendNMH_Gateway_ETH08", 0, profileFile ) );
    putValue( ENV_UDPNM_Gateway_NM_StateS_ETH08, getProfileInt( "Settings", "ENV_UDPNM_Gateway_NM_StateS_ETH08", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_eCall_ETH08, getProfileInt( "Settings", "ENV_UDPSendNMH_eCall_ETH08", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineState_ETH08, getProfileInt( "Settings", "ENV_UDPNMHStateMachineState_ETH08", 0, profileFile ) );
    putValue( ENV_UDPNMHControllerNodeAwake_ETH08, getProfileInt( "Settings", "ENV_UDPNMHControllerNodeAwake_ETH08", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineEnabled_ETH08, getProfileInt( "Settings", "ENV_UDPNMHStateMachineEnabled_ETH08", 0, profileFile ) );
    putValue( ENV_UDPNMHState_ETH08, getProfileInt( "Settings", "ENV_UDPNMHState_ETH08", 0, profileFile ) );
    putValue( ENV_UDPNMHMode_ETH08, getProfileInt( "Settings", "ENV_UDPNMHMode_ETH08", 0, profileFile ) );
    putValue( ENV_UDPSendAtOnceNMH_Gateway_ETH08, getProfileInt( "Settings", "ENV_UDPSendAtOnceNMH_Gateway_ETH08", 0, profileFile ) );
    putValue( ENV_UDPNM_CouplewithCANNM_ETH09, getProfileInt( "Settings", "ENV_UDPNM_CouplewithCANNM_ETH09", 0, profileFile ) );
    putValue( ENV_UDPSendKombiSimulationNMMsg_ETH09, getProfileInt( "Settings", "ENV_UDPSendKombiSimulationNMMsg_ETH09", 0, profileFile ) );
    putValue( ENV_UDPSendEnabled_ETH09, getProfileInt( "Settings", "ENV_UDPSendEnabled_ETH09", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_Gateway_ETH09, getProfileInt( "Settings", "ENV_UDPSendNMH_Gateway_ETH09", 0, profileFile ) );
    putValue( ENV_UDPNM_Gateway_NM_StateS_ETH09, getProfileInt( "Settings", "ENV_UDPNM_Gateway_NM_StateS_ETH09", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_eCall_ETH09, getProfileInt( "Settings", "ENV_UDPSendNMH_eCall_ETH09", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineState_ETH09, getProfileInt( "Settings", "ENV_UDPNMHStateMachineState_ETH09", 0, profileFile ) );
    putValue( ENV_UDPNMHControllerNodeAwake_ETH09, getProfileInt( "Settings", "ENV_UDPNMHControllerNodeAwake_ETH09", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineEnabled_ETH09, getProfileInt( "Settings", "ENV_UDPNMHStateMachineEnabled_ETH09", 0, profileFile ) );
    putValue( ENV_UDPNMHState_ETH09, getProfileInt( "Settings", "ENV_UDPNMHState_ETH09", 0, profileFile ) );
    putValue( ENV_UDPNMHMode_ETH09, getProfileInt( "Settings", "ENV_UDPNMHMode_ETH09", 0, profileFile ) );
    putValue( ENV_UDPSendAtOnceNMH_Gateway_ETH09, getProfileInt( "Settings", "ENV_UDPSendAtOnceNMH_Gateway_ETH09", 0, profileFile ) );
    putValue( ENV_UDPNM_CouplewithCANNM_ETH10, getProfileInt( "Settings", "ENV_UDPNM_CouplewithCANNM_ETH10", 0, profileFile ) );
    putValue( ENV_UDPSendKombiSimulationNMMsg_ETH10, getProfileInt( "Settings", "ENV_UDPSendKombiSimulationNMMsg_ETH10", 0, profileFile ) );
    putValue( ENV_UDPSendEnabled_ETH10, getProfileInt( "Settings", "ENV_UDPSendEnabled_ETH10", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_Gateway_ETH10, getProfileInt( "Settings", "ENV_UDPSendNMH_Gateway_ETH10", 0, profileFile ) );
    putValue( ENV_UDPNM_Gateway_NM_StateS_ETH10, getProfileInt( "Settings", "ENV_UDPNM_Gateway_NM_StateS_ETH10", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_eCall_ETH10, getProfileInt( "Settings", "ENV_UDPSendNMH_eCall_ETH10", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineState_ETH10, getProfileInt( "Settings", "ENV_UDPNMHStateMachineState_ETH10", 0, profileFile ) );
    putValue( ENV_UDPNMHControllerNodeAwake_ETH10, getProfileInt( "Settings", "ENV_UDPNMHControllerNodeAwake_ETH10", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineEnabled_ETH10, getProfileInt( "Settings", "ENV_UDPNMHStateMachineEnabled_ETH10", 0, profileFile ) );
    putValue( ENV_UDPNMHState_ETH10, getProfileInt( "Settings", "ENV_UDPNMHState_ETH10", 0, profileFile ) );
    putValue( ENV_UDPNMHMode_ETH10, getProfileInt( "Settings", "ENV_UDPNMHMode_ETH10", 0, profileFile ) );
    putValue( ENV_UDPSendAtOnceNMH_Gateway_ETH10, getProfileInt( "Settings", "ENV_UDPSendAtOnceNMH_Gateway_ETH10", 0, profileFile ) );
    putValue( ENV_UDPNM_CouplewithCANNM_ETH11, getProfileInt( "Settings", "ENV_UDPNM_CouplewithCANNM_ETH11", 0, profileFile ) );
    putValue( ENV_UDPSendKombiSimulationNMMsg_ETH11, getProfileInt( "Settings", "ENV_UDPSendKombiSimulationNMMsg_ETH11", 0, profileFile ) );
    putValue( ENV_UDPSendEnabled_ETH11, getProfileInt( "Settings", "ENV_UDPSendEnabled_ETH11", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_Gateway_ETH11, getProfileInt( "Settings", "ENV_UDPSendNMH_Gateway_ETH11", 0, profileFile ) );
    putValue( ENV_UDPNM_Gateway_NM_StateS_ETH11, getProfileInt( "Settings", "ENV_UDPNM_Gateway_NM_StateS_ETH11", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_eCall_ETH11, getProfileInt( "Settings", "ENV_UDPSendNMH_eCall_ETH11", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineState_ETH11, getProfileInt( "Settings", "ENV_UDPNMHStateMachineState_ETH11", 0, profileFile ) );
    putValue( ENV_UDPNMHControllerNodeAwake_ETH11, getProfileInt( "Settings", "ENV_UDPNMHControllerNodeAwake_ETH11", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineEnabled_ETH11, getProfileInt( "Settings", "ENV_UDPNMHStateMachineEnabled_ETH11", 0, profileFile ) );
    putValue( ENV_UDPNMHState_ETH11, getProfileInt( "Settings", "ENV_UDPNMHState_ETH11", 0, profileFile ) );
    putValue( ENV_UDPNMHMode_ETH11, getProfileInt( "Settings", "ENV_UDPNMHMode_ETH11", 0, profileFile ) );
    putValue( ENV_UDPSendAtOnceNMH_Gateway_ETH11, getProfileInt( "Settings", "ENV_UDPSendAtOnceNMH_Gateway_ETH11", 0, profileFile ) );
    putValue( ENV_UDPNM_CouplewithCANNM_ETH12, getProfileInt( "Settings", "ENV_UDPNM_CouplewithCANNM_ETH12", 0, profileFile ) );
    putValue( ENV_UDPSendKombiSimulationNMMsg_ETH12, getProfileInt( "Settings", "ENV_UDPSendKombiSimulationNMMsg_ETH12", 0, profileFile ) );
    putValue( ENV_UDPSendEnabled_ETH12, getProfileInt( "Settings", "ENV_UDPSendEnabled_ETH12", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_Gateway_ETH12, getProfileInt( "Settings", "ENV_UDPSendNMH_Gateway_ETH12", 0, profileFile ) );
    putValue( ENV_UDPNM_Gateway_NM_StateS_ETH12, getProfileInt( "Settings", "ENV_UDPNM_Gateway_NM_StateS_ETH12", 0, profileFile ) );
    putValue( ENV_UDPSendNMH_eCall_ETH12, getProfileInt( "Settings", "ENV_UDPSendNMH_eCall_ETH12", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineState_ETH12, getProfileInt( "Settings", "ENV_UDPNMHStateMachineState_ETH12", 0, profileFile ) );
    putValue( ENV_UDPNMHControllerNodeAwake_ETH12, getProfileInt( "Settings", "ENV_UDPNMHControllerNodeAwake_ETH12", 0, profileFile ) );
    putValue( ENV_UDPNMHStateMachineEnabled_ETH12, getProfileInt( "Settings", "ENV_UDPNMHStateMachineEnabled_ETH12", 0, profileFile ) );
    putValue( ENV_UDPNMHState_ETH12, getProfileInt( "Settings", "ENV_UDPNMHState_ETH12", 0, profileFile ) );
    putValue( ENV_UDPNMHMode_ETH12, getProfileInt( "Settings", "ENV_UDPNMHMode_ETH12", 0, profileFile ) );
    putValue( ENV_UDPSendAtOnceNMH_Gateway_ETH12, getProfileInt( "Settings", "ENV_UDPSendAtOnceNMH_Gateway_ETH12", 0, profileFile ) );
    putValue( ENV_VideoType_Ch01, getProfileInt( "Settings", "ENV_VideoType_Ch01", 0, profileFile ) );
    putValue( ENV_VideoType_Ch02, getProfileInt( "Settings", "ENV_VideoType_Ch02", 0, profileFile ) );
    putValue( ENV_VideoType_Ch03, getProfileInt( "Settings", "ENV_VideoType_Ch03", 0, profileFile ) );
    putValue( ENV_VideoType_Ch04, getProfileInt( "Settings", "ENV_VideoType_Ch04", 0, profileFile ) );
    putValue( ENV_VideoType_Ch05, getProfileInt( "Settings", "ENV_VideoType_Ch05", 0, profileFile ) );
    putValue( ENV_VideoType_Ch06, getProfileInt( "Settings", "ENV_VideoType_Ch06", 0, profileFile ) );
    putValue( ENV_VideoType_Ch07, getProfileInt( "Settings", "ENV_VideoType_Ch07", 0, profileFile ) );
    putValue( ENV_VideoType_Ch08, getProfileInt( "Settings", "ENV_VideoType_Ch08", 0, profileFile ) );
    putValue( ENV_VideoType_Ch09, getProfileInt( "Settings", "ENV_VideoType_Ch09", 0, profileFile ) );
    putValue( ENV_VideoType_Ch10, getProfileInt( "Settings", "ENV_VideoType_Ch10", 0, profileFile ) );
    putValue( ENV_VideoType_Ch11, getProfileInt( "Settings", "ENV_VideoType_Ch11", 0, profileFile ) );
    putValue( ENV_VideoType_Ch12, getProfileInt( "Settings", "ENV_VideoType_Ch12", 0, profileFile ) );
    putValue( ENV_NMHControllerNodeAwake, getProfileInt( "Settings", "ENV_NMHControllerNodeAwake", 0, profileFile ) );
    putValue( ENV_EthernetLEDLinkStatus, getProfileInt( "Settings", "ENV_EthernetLEDLinkStatus", 0, profileFile ) );

}

