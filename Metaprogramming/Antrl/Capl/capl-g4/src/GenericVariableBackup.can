    putValue( KCAN__STMSGCT_Kombi_21_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Kombi_21_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Kombi_21, getProfileInt( "Settings", "KCAN__STMSG_PO_Kombi_21", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Kombi_21, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Kombi_21", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Kombi_21, getProfileInt( "Settings", "KCAN__MSG_SendNow_Kombi_21", 0, profileFile ) );
    putValue( KCAN__MSGID_Kombi_HUD_01, getProfileInt( "Settings", "KCAN__MSGID_Kombi_HUD_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Kombi_HUD_01, getProfileInt( "Settings", "KCAN__MSGDLC_Kombi_HUD_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Kombi_HUD_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Kombi_HUD_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Kombi_HUD_01, getProfileInt( "Settings", "KCAN__ALLDEF_Kombi_HUD_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Kombi_HUD_01, getProfileInt( "Settings", "KCAN__STMSG_Kombi_HUD_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Kombi_HUD_01, getProfileInt( "Settings", "KCAN__STMSGT_Kombi_HUD_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Kombi_HUD_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Kombi_HUD_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Kombi_HUD_01, getProfileInt( "Settings", "KCAN__STMSGSD_Kombi_HUD_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Kombi_HUD_01, getProfileInt( "Settings", "KCAN__STMSGCT_Kombi_HUD_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Kombi_HUD_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Kombi_HUD_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Kombi_HUD_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Kombi_HUD_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Kombi_HUD_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Kombi_HUD_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Kombi_HUD_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Kombi_HUD_01", 0, profileFile ) );
    putValue( KCAN__MSGID_KonzernrollenModus_01, getProfileInt( "Settings", "KCAN__MSGID_KonzernrollenModus_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KonzernrollenModus_01, getProfileInt( "Settings", "KCAN__MSGDLC_KonzernrollenModus_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KonzernrollenModus_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_KonzernrollenModus_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_KonzernrollenModus_01, getProfileInt( "Settings", "KCAN__ALLDEF_KonzernrollenModus_01", 0, profileFile ) );
    putValue( KCAN__STMSG_KonzernrollenModus_01, getProfileInt( "Settings", "KCAN__STMSG_KonzernrollenModus_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_KonzernrollenModus_01, getProfileInt( "Settings", "KCAN__STMSGT_KonzernrollenModus_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_KonzernrollenModus_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_KonzernrollenModus_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_KonzernrollenModus_01, getProfileInt( "Settings", "KCAN__STMSGSD_KonzernrollenModus_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KonzernrollenModus_01, getProfileInt( "Settings", "KCAN__STMSGCT_KonzernrollenModus_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KonzernrollenModus_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_KonzernrollenModus_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_KonzernrollenModus_01, getProfileInt( "Settings", "KCAN__STMSG_PO_KonzernrollenModus_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_KonzernrollenModus_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_KonzernrollenModus_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_KonzernrollenModus_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_KonzernrollenModus_01", 0, profileFile ) );
    putValue( KCAN__MSGID_KS_ICAS3Sys01_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_KS_ICAS3Sys01_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KS_ICAS3Sys01_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLC_KS_ICAS3Sys01_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KS_ICAS3Sys01_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_KS_ICAS3Sys01_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_KS_ICAS3Sys01_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_KS_ICAS3Sys01_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_KS_ICAS3Sys01_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_KS_ICAS3Sys01_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_KS_ICAS3Sys01_Req_FD, getProfileInt( "Settings", "KCAN__STMSGT_KS_ICAS3Sys01_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_KS_ICAS3Sys01_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_KS_ICAS3Sys01_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_KS_ICAS3Sys01_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_KS_ICAS3Sys01_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KS_ICAS3Sys01_Req_FD, getProfileInt( "Settings", "KCAN__STMSGCT_KS_ICAS3Sys01_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KS_ICAS3Sys01_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_KS_ICAS3Sys01_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_KS_ICAS3Sys01_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_KS_ICAS3Sys01_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_KS_ICAS3Sys01_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_KS_ICAS3Sys01_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_KS_ICAS3Sys01_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_KS_ICAS3Sys01_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_KS_ICAS3Sys01_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_KS_ICAS3Sys01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KS_ICAS3Sys01_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLC_KS_ICAS3Sys01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KS_ICAS3Sys01_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_KS_ICAS3Sys01_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_KS_ICAS3Sys01_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_KS_ICAS3Sys01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_KS_ICAS3Sys01_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_KS_ICAS3Sys01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_KS_ICAS3Sys01_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGT_KS_ICAS3Sys01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_KS_ICAS3Sys01_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_KS_ICAS3Sys01_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_KS_ICAS3Sys01_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_KS_ICAS3Sys01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KS_ICAS3Sys01_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_KS_ICAS3Sys01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KS_ICAS3Sys01_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_KS_ICAS3Sys01_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_KS_ICAS3Sys01_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_KS_ICAS3Sys01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_KS_ICAS3Sys01_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_KS_ICAS3Sys01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_KS_ICAS3Sys01_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_KS_ICAS3Sys01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_KS_Info_El_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_KS_Info_El_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KS_Info_El_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLC_KS_Info_El_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KS_Info_El_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_KS_Info_El_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_KS_Info_El_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_KS_Info_El_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_KS_Info_El_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_KS_Info_El_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_KS_Info_El_Req_FD, getProfileInt( "Settings", "KCAN__STMSGT_KS_Info_El_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_KS_Info_El_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_KS_Info_El_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_KS_Info_El_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_KS_Info_El_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KS_Info_El_Req_FD, getProfileInt( "Settings", "KCAN__STMSGCT_KS_Info_El_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KS_Info_El_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_KS_Info_El_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_KS_Info_El_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_KS_Info_El_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_KS_Info_El_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_KS_Info_El_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_KS_Info_El_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_KS_Info_El_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_KS_Info_El_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_KS_Info_El_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KS_Info_El_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLC_KS_Info_El_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KS_Info_El_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_KS_Info_El_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_KS_Info_El_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_KS_Info_El_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_KS_Info_El_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_KS_Info_El_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_KS_Info_El_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGT_KS_Info_El_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_KS_Info_El_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_KS_Info_El_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_KS_Info_El_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_KS_Info_El_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KS_Info_El_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_KS_Info_El_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KS_Info_El_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_KS_Info_El_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_KS_Info_El_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_KS_Info_El_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_KS_Info_El_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_KS_Info_El_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_KS_Info_El_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_KS_Info_El_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_KS_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_KS_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KS_Kombi_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_KS_Kombi_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KS_Kombi_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_KS_Kombi_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_KS_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_KS_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_KS_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_KS_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_KS_Kombi_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_KS_Kombi_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGT_KS_Kombi_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_KS_Kombi_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_KS_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_KS_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KS_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__STMSGCT_KS_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KS_Kombi_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_KS_Kombi_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_KS_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_KS_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_KS_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_KS_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_KS_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_KS_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_KS_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_KS_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KS_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLC_KS_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KS_Kombi_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_KS_Kombi_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_KS_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_KS_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_KS_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_KS_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_KS_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGT_KS_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_KS_Kombi_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_KS_Kombi_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_KS_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_KS_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KS_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_KS_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KS_Kombi_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_KS_Kombi_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_KS_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_KS_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_KS_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_KS_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_KS_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_KS_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_KS_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__MSGID_KS_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KS_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__MSGDLC_KS_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KS_SSN_ABT_1_Req_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_KS_SSN_ABT_1_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_KS_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__ALLDEF_KS_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__STMSG_KS_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__STMSG_KS_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_KS_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__STMSGT_KS_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_KS_SSN_ABT_1_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_KS_SSN_ABT_1_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_KS_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__STMSGSD_KS_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KS_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__STMSGCT_KS_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KS_SSN_ABT_1_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_KS_SSN_ABT_1_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_KS_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__STMSG_PO_KS_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_KS_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_KS_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_KS_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__MSG_SendNow_KS_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__MSGID_KS_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__MSGID_KS_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KS_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__MSGDLC_KS_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KS_SSN_ABT_1_Resp_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_KS_SSN_ABT_1_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_KS_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__ALLDEF_KS_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSG_KS_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__STMSG_KS_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_KS_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__STMSGT_KS_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_KS_SSN_ABT_1_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_KS_SSN_ABT_1_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_KS_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__STMSGSD_KS_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KS_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__STMSGCT_KS_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KS_SSN_ABT_1_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_KS_SSN_ABT_1_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_KS_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__STMSG_PO_KS_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_KS_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_KS_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_KS_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__MSG_SendNow_KS_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGID_LDW_02, getProfileInt( "Settings", "KCAN__MSGID_LDW_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_LDW_02, getProfileInt( "Settings", "KCAN__MSGDLC_LDW_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_LDW_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_LDW_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_LDW_02, getProfileInt( "Settings", "KCAN__ALLDEF_LDW_02", 0, profileFile ) );
    putValue( KCAN__STMSG_LDW_02, getProfileInt( "Settings", "KCAN__STMSG_LDW_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_LDW_02, getProfileInt( "Settings", "KCAN__STMSGT_LDW_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_LDW_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_LDW_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_LDW_02, getProfileInt( "Settings", "KCAN__STMSGSD_LDW_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_LDW_02, getProfileInt( "Settings", "KCAN__STMSGCT_LDW_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_LDW_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_LDW_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_LDW_02, getProfileInt( "Settings", "KCAN__STMSG_PO_LDW_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_LDW_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_LDW_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_LDW_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_LDW_02", 0, profileFile ) );
    putValue( KCAN__MSGID_LH_EPS_01, getProfileInt( "Settings", "KCAN__MSGID_LH_EPS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_LH_EPS_01, getProfileInt( "Settings", "KCAN__MSGDLC_LH_EPS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_LH_EPS_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_LH_EPS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_LH_EPS_01, getProfileInt( "Settings", "KCAN__ALLDEF_LH_EPS_01", 0, profileFile ) );
    putValue( KCAN__STMSG_LH_EPS_01, getProfileInt( "Settings", "KCAN__STMSG_LH_EPS_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_LH_EPS_01, getProfileInt( "Settings", "KCAN__STMSGT_LH_EPS_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_LH_EPS_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_LH_EPS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_LH_EPS_01, getProfileInt( "Settings", "KCAN__STMSGSD_LH_EPS_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_LH_EPS_01, getProfileInt( "Settings", "KCAN__STMSGCT_LH_EPS_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_LH_EPS_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_LH_EPS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_LH_EPS_01, getProfileInt( "Settings", "KCAN__STMSG_PO_LH_EPS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_LH_EPS_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_LH_EPS_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_LH_EPS_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_LH_EPS_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Licht_Anf_01, getProfileInt( "Settings", "KCAN__MSGID_Licht_Anf_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Licht_Anf_01, getProfileInt( "Settings", "KCAN__MSGDLC_Licht_Anf_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Licht_Anf_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Licht_Anf_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Licht_Anf_01, getProfileInt( "Settings", "KCAN__ALLDEF_Licht_Anf_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Licht_Anf_01, getProfileInt( "Settings", "KCAN__STMSG_Licht_Anf_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Licht_Anf_01, getProfileInt( "Settings", "KCAN__STMSGT_Licht_Anf_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Licht_Anf_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Licht_Anf_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Licht_Anf_01, getProfileInt( "Settings", "KCAN__STMSGSD_Licht_Anf_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Licht_Anf_01, getProfileInt( "Settings", "KCAN__STMSGCT_Licht_Anf_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Licht_Anf_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Licht_Anf_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Licht_Anf_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Licht_Anf_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Licht_Anf_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Licht_Anf_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Licht_Anf_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Licht_Anf_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Licht_hinten_01, getProfileInt( "Settings", "KCAN__MSGID_Licht_hinten_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Licht_hinten_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Licht_hinten_01_CTRL", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Licht_hinten_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Licht_hinten_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Licht_hinten_01, getProfileInt( "Settings", "KCAN__ALLDEF_Licht_hinten_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Licht_hinten_01, getProfileInt( "Settings", "KCAN__STMSG_Licht_hinten_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Licht_hinten_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Licht_hinten_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGT_Licht_hinten_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Licht_hinten_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Licht_hinten_01, getProfileInt( "Settings", "KCAN__STMSGSD_Licht_hinten_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Licht_hinten_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Licht_hinten_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Licht_hinten_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Licht_hinten_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Licht_hinten_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Licht_hinten_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Licht_hinten_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Licht_hinten_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Licht_hinten_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Licht_hinten_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Licht_vorne_01, getProfileInt( "Settings", "KCAN__MSGID_Licht_vorne_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Licht_vorne_01, getProfileInt( "Settings", "KCAN__MSGDLC_Licht_vorne_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Licht_vorne_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Licht_vorne_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Licht_vorne_01, getProfileInt( "Settings", "KCAN__ALLDEF_Licht_vorne_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Licht_vorne_01, getProfileInt( "Settings", "KCAN__STMSG_Licht_vorne_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Licht_vorne_01, getProfileInt( "Settings", "KCAN__STMSGT_Licht_vorne_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Licht_vorne_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Licht_vorne_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Licht_vorne_01, getProfileInt( "Settings", "KCAN__STMSGSD_Licht_vorne_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Licht_vorne_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Licht_vorne_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Licht_vorne_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Licht_vorne_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Licht_vorne_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Licht_vorne_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Licht_vorne_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Licht_vorne_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Licht_vorne_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Licht_vorne_01", 0, profileFile ) );
    putValue( KCAN__MSGID_LiSi_01, getProfileInt( "Settings", "KCAN__MSGID_LiSi_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_LiSi_01, getProfileInt( "Settings", "KCAN__MSGDLC_LiSi_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_LiSi_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_LiSi_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_LiSi_01, getProfileInt( "Settings", "KCAN__ALLDEF_LiSi_01", 0, profileFile ) );
    putValue( KCAN__STMSG_LiSi_01, getProfileInt( "Settings", "KCAN__STMSG_LiSi_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_LiSi_01, getProfileInt( "Settings", "KCAN__STMSGT_LiSi_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_LiSi_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_LiSi_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_LiSi_01, getProfileInt( "Settings", "KCAN__STMSGSD_LiSi_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_LiSi_01, getProfileInt( "Settings", "KCAN__STMSGCT_LiSi_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_LiSi_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_LiSi_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_LiSi_01, getProfileInt( "Settings", "KCAN__STMSG_PO_LiSi_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_LiSi_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_LiSi_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_LiSi_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_LiSi_01", 0, profileFile ) );
    putValue( KCAN__MSGID_LWI_01, getProfileInt( "Settings", "KCAN__MSGID_LWI_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_LWI_01, getProfileInt( "Settings", "KCAN__MSGDLC_LWI_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_LWI_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_LWI_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_LWI_01, getProfileInt( "Settings", "KCAN__ALLDEF_LWI_01", 0, profileFile ) );
    putValue( KCAN__STMSG_LWI_01, getProfileInt( "Settings", "KCAN__STMSG_LWI_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_LWI_01, getProfileInt( "Settings", "KCAN__STMSGT_LWI_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_LWI_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_LWI_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_LWI_01, getProfileInt( "Settings", "KCAN__STMSGSD_LWI_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_LWI_01, getProfileInt( "Settings", "KCAN__STMSGCT_LWI_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_LWI_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_LWI_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_LWI_01, getProfileInt( "Settings", "KCAN__STMSG_PO_LWI_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_LWI_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_LWI_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_LWI_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_LWI_01", 0, profileFile ) );
    putValue( KCAN__MSGID_MainUnit_01, getProfileInt( "Settings", "KCAN__MSGID_MainUnit_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_MainUnit_01, getProfileInt( "Settings", "KCAN__MSGDLC_MainUnit_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_MainUnit_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_MainUnit_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_MainUnit_01, getProfileInt( "Settings", "KCAN__ALLDEF_MainUnit_01", 0, profileFile ) );
    putValue( KCAN__STMSG_MainUnit_01, getProfileInt( "Settings", "KCAN__STMSG_MainUnit_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_MainUnit_01, getProfileInt( "Settings", "KCAN__STMSGT_MainUnit_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_MainUnit_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_MainUnit_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_MainUnit_01, getProfileInt( "Settings", "KCAN__STMSGSD_MainUnit_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_MainUnit_01, getProfileInt( "Settings", "KCAN__STMSGCT_MainUnit_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_MainUnit_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_MainUnit_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_MainUnit_01, getProfileInt( "Settings", "KCAN__STMSG_PO_MainUnit_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_MainUnit_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_MainUnit_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_MainUnit_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_MainUnit_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Mem_BFS_01, getProfileInt( "Settings", "KCAN__MSGID_Mem_BFS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Mem_BFS_01, getProfileInt( "Settings", "KCAN__MSGDLC_Mem_BFS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Mem_BFS_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Mem_BFS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Mem_BFS_01, getProfileInt( "Settings", "KCAN__ALLDEF_Mem_BFS_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Mem_BFS_01, getProfileInt( "Settings", "KCAN__STMSG_Mem_BFS_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Mem_BFS_01, getProfileInt( "Settings", "KCAN__STMSGT_Mem_BFS_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Mem_BFS_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Mem_BFS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Mem_BFS_01, getProfileInt( "Settings", "KCAN__STMSGSD_Mem_BFS_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Mem_BFS_01, getProfileInt( "Settings", "KCAN__STMSGCT_Mem_BFS_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Mem_BFS_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Mem_BFS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Mem_BFS_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Mem_BFS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Mem_BFS_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Mem_BFS_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Mem_BFS_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Mem_BFS_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Mem_FS_01, getProfileInt( "Settings", "KCAN__MSGID_Mem_FS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Mem_FS_01, getProfileInt( "Settings", "KCAN__MSGDLC_Mem_FS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Mem_FS_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Mem_FS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Mem_FS_01, getProfileInt( "Settings", "KCAN__ALLDEF_Mem_FS_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Mem_FS_01, getProfileInt( "Settings", "KCAN__STMSG_Mem_FS_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Mem_FS_01, getProfileInt( "Settings", "KCAN__STMSGT_Mem_FS_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Mem_FS_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Mem_FS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Mem_FS_01, getProfileInt( "Settings", "KCAN__STMSGSD_Mem_FS_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Mem_FS_01, getProfileInt( "Settings", "KCAN__STMSGCT_Mem_FS_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Mem_FS_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Mem_FS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Mem_FS_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Mem_FS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Mem_FS_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Mem_FS_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Mem_FS_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Mem_FS_01", 0, profileFile ) );
    putValue( KCAN__MSGID_MFG_01, getProfileInt( "Settings", "KCAN__MSGID_MFG_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_MFG_01, getProfileInt( "Settings", "KCAN__MSGDLC_MFG_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_MFG_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_MFG_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_MFG_01, getProfileInt( "Settings", "KCAN__ALLDEF_MFG_01", 0, profileFile ) );
    putValue( KCAN__STMSG_MFG_01, getProfileInt( "Settings", "KCAN__STMSG_MFG_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_MFG_01, getProfileInt( "Settings", "KCAN__STMSGT_MFG_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_MFG_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_MFG_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_MFG_01, getProfileInt( "Settings", "KCAN__STMSGSD_MFG_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_MFG_01, getProfileInt( "Settings", "KCAN__STMSGCT_MFG_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_MFG_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_MFG_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_MFG_01, getProfileInt( "Settings", "KCAN__STMSG_PO_MFG_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_MFG_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_MFG_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_MFG_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_MFG_01", 0, profileFile ) );
    putValue( KCAN__MSGID_MFL_01, getProfileInt( "Settings", "KCAN__MSGID_MFL_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_MFL_01, getProfileInt( "Settings", "KCAN__MSGDLC_MFL_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_MFL_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_MFL_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_MFL_01, getProfileInt( "Settings", "KCAN__ALLDEF_MFL_01", 0, profileFile ) );
    putValue( KCAN__STMSG_MFL_01, getProfileInt( "Settings", "KCAN__STMSG_MFL_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_MFL_01, getProfileInt( "Settings", "KCAN__STMSGT_MFL_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_MFL_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_MFL_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_MFL_01, getProfileInt( "Settings", "KCAN__STMSGSD_MFL_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_MFL_01, getProfileInt( "Settings", "KCAN__STMSGCT_MFL_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_MFL_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_MFL_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_MFL_01, getProfileInt( "Settings", "KCAN__STMSG_PO_MFL_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_MFL_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_MFL_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_MFL_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_MFL_01", 0, profileFile ) );
    putValue( KCAN__MSGID_MFL_02, getProfileInt( "Settings", "KCAN__MSGID_MFL_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_MFL_02, getProfileInt( "Settings", "KCAN__MSGDLC_MFL_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_MFL_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_MFL_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_MFL_02, getProfileInt( "Settings", "KCAN__ALLDEF_MFL_02", 0, profileFile ) );
    putValue( KCAN__STMSG_MFL_02, getProfileInt( "Settings", "KCAN__STMSG_MFL_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_MFL_02, getProfileInt( "Settings", "KCAN__STMSGT_MFL_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_MFL_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_MFL_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_MFL_02, getProfileInt( "Settings", "KCAN__STMSGSD_MFL_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_MFL_02, getProfileInt( "Settings", "KCAN__STMSGCT_MFL_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_MFL_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_MFL_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_MFL_02, getProfileInt( "Settings", "KCAN__STMSG_PO_MFL_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_MFL_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_MFL_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_MFL_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_MFL_02", 0, profileFile ) );
    putValue( KCAN__MSGID_MFL_Anf_01, getProfileInt( "Settings", "KCAN__MSGID_MFL_Anf_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_MFL_Anf_01, getProfileInt( "Settings", "KCAN__MSGDLC_MFL_Anf_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_MFL_Anf_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_MFL_Anf_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_MFL_Anf_01, getProfileInt( "Settings", "KCAN__ALLDEF_MFL_Anf_01", 0, profileFile ) );
    putValue( KCAN__STMSG_MFL_Anf_01, getProfileInt( "Settings", "KCAN__STMSG_MFL_Anf_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_MFL_Anf_01, getProfileInt( "Settings", "KCAN__STMSGT_MFL_Anf_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_MFL_Anf_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_MFL_Anf_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_MFL_Anf_01, getProfileInt( "Settings", "KCAN__STMSGSD_MFL_Anf_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_MFL_Anf_01, getProfileInt( "Settings", "KCAN__STMSGCT_MFL_Anf_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_MFL_Anf_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_MFL_Anf_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_MFL_Anf_01, getProfileInt( "Settings", "KCAN__STMSG_PO_MFL_Anf_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_MFL_Anf_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_MFL_Anf_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_MFL_Anf_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_MFL_Anf_01", 0, profileFile ) );
    putValue( KCAN__MSGID_MFL_Tasten_Kon_01, getProfileInt( "Settings", "KCAN__MSGID_MFL_Tasten_Kon_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_MFL_Tasten_Kon_01, getProfileInt( "Settings", "KCAN__MSGDLC_MFL_Tasten_Kon_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_MFL_Tasten_Kon_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_MFL_Tasten_Kon_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_MFL_Tasten_Kon_01, getProfileInt( "Settings", "KCAN__ALLDEF_MFL_Tasten_Kon_01", 0, profileFile ) );
    putValue( KCAN__STMSG_MFL_Tasten_Kon_01, getProfileInt( "Settings", "KCAN__STMSG_MFL_Tasten_Kon_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_MFL_Tasten_Kon_01, getProfileInt( "Settings", "KCAN__STMSGT_MFL_Tasten_Kon_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_MFL_Tasten_Kon_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_MFL_Tasten_Kon_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_MFL_Tasten_Kon_01, getProfileInt( "Settings", "KCAN__STMSGSD_MFL_Tasten_Kon_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_MFL_Tasten_Kon_01, getProfileInt( "Settings", "KCAN__STMSGCT_MFL_Tasten_Kon_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_MFL_Tasten_Kon_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_MFL_Tasten_Kon_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_MFL_Tasten_Kon_01, getProfileInt( "Settings", "KCAN__STMSG_PO_MFL_Tasten_Kon_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_MFL_Tasten_Kon_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_MFL_Tasten_Kon_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_MFL_Tasten_Kon_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_MFL_Tasten_Kon_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Motor_14, getProfileInt( "Settings", "KCAN__MSGID_Motor_14", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_14, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_14", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_14_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_14_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Motor_14, getProfileInt( "Settings", "KCAN__ALLDEF_Motor_14", 0, profileFile ) );
    putValue( KCAN__STMSG_Motor_14, getProfileInt( "Settings", "KCAN__STMSG_Motor_14", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_14, getProfileInt( "Settings", "KCAN__STMSGT_Motor_14", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_14_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Motor_14_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Motor_14, getProfileInt( "Settings", "KCAN__STMSGSD_Motor_14", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_14, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_14", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_14_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_14_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Motor_14, getProfileInt( "Settings", "KCAN__STMSG_PO_Motor_14", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Motor_14, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Motor_14", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Motor_14, getProfileInt( "Settings", "KCAN__MSG_SendNow_Motor_14", 0, profileFile ) );
    putValue( KCAN__MSGID_Motor_18, getProfileInt( "Settings", "KCAN__MSGID_Motor_18", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_18, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_18", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_18_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_18_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Motor_18, getProfileInt( "Settings", "KCAN__ALLDEF_Motor_18", 0, profileFile ) );
    putValue( KCAN__STMSG_Motor_18, getProfileInt( "Settings", "KCAN__STMSG_Motor_18", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_18, getProfileInt( "Settings", "KCAN__STMSGT_Motor_18", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_18_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Motor_18_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Motor_18, getProfileInt( "Settings", "KCAN__STMSGSD_Motor_18", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_18, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_18", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_18_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_18_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Motor_18, getProfileInt( "Settings", "KCAN__STMSG_PO_Motor_18", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Motor_18, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Motor_18", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Motor_18, getProfileInt( "Settings", "KCAN__MSG_SendNow_Motor_18", 0, profileFile ) );
    putValue( KCAN__MSGID_Motor_26, getProfileInt( "Settings", "KCAN__MSGID_Motor_26", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_26, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_26", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_26_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_26_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Motor_26, getProfileInt( "Settings", "KCAN__ALLDEF_Motor_26", 0, profileFile ) );
    putValue( KCAN__STMSG_Motor_26, getProfileInt( "Settings", "KCAN__STMSG_Motor_26", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_26, getProfileInt( "Settings", "KCAN__STMSGT_Motor_26", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_26_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Motor_26_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Motor_26, getProfileInt( "Settings", "KCAN__STMSGSD_Motor_26", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_26, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_26", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_26_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_26_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Motor_26, getProfileInt( "Settings", "KCAN__STMSG_PO_Motor_26", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Motor_26, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Motor_26", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Motor_26, getProfileInt( "Settings", "KCAN__MSG_SendNow_Motor_26", 0, profileFile ) );
    putValue( KCAN__MSGID_Motor_41, getProfileInt( "Settings", "KCAN__MSGID_Motor_41", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_41, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_41", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_41_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_41_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Motor_41, getProfileInt( "Settings", "KCAN__ALLDEF_Motor_41", 0, profileFile ) );
    putValue( KCAN__STMSG_Motor_41, getProfileInt( "Settings", "KCAN__STMSG_Motor_41", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_41, getProfileInt( "Settings", "KCAN__STMSGT_Motor_41", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_41_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Motor_41_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Motor_41, getProfileInt( "Settings", "KCAN__STMSGSD_Motor_41", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_41, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_41", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_41_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_41_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Motor_41, getProfileInt( "Settings", "KCAN__STMSG_PO_Motor_41", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Motor_41, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Motor_41", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Motor_41, getProfileInt( "Settings", "KCAN__MSG_SendNow_Motor_41", 0, profileFile ) );
    putValue( KCAN__MSGID_Motor_51, getProfileInt( "Settings", "KCAN__MSGID_Motor_51", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_51, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_51", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_51_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_51_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Motor_51, getProfileInt( "Settings", "KCAN__ALLDEF_Motor_51", 0, profileFile ) );
    putValue( KCAN__STMSG_Motor_51, getProfileInt( "Settings", "KCAN__STMSG_Motor_51", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_51, getProfileInt( "Settings", "KCAN__STMSGT_Motor_51", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_51_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Motor_51_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Motor_51, getProfileInt( "Settings", "KCAN__STMSGSD_Motor_51", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_51, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_51", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_51_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_51_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Motor_51, getProfileInt( "Settings", "KCAN__STMSG_PO_Motor_51", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Motor_51, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Motor_51", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Motor_51, getProfileInt( "Settings", "KCAN__MSG_SendNow_Motor_51", 0, profileFile ) );
    putValue( KCAN__MSGID_Motor_52, getProfileInt( "Settings", "KCAN__MSGID_Motor_52", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_52, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_52", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_52_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_52_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Motor_52, getProfileInt( "Settings", "KCAN__ALLDEF_Motor_52", 0, profileFile ) );
    putValue( KCAN__STMSG_Motor_52, getProfileInt( "Settings", "KCAN__STMSG_Motor_52", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_52, getProfileInt( "Settings", "KCAN__STMSGT_Motor_52", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_52_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Motor_52_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Motor_52, getProfileInt( "Settings", "KCAN__STMSGSD_Motor_52", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_52, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_52", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_52_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_52_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Motor_52, getProfileInt( "Settings", "KCAN__STMSG_PO_Motor_52", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Motor_52, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Motor_52", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Motor_52, getProfileInt( "Settings", "KCAN__MSG_SendNow_Motor_52", 0, profileFile ) );
    putValue( KCAN__MSGID_Motor_53, getProfileInt( "Settings", "KCAN__MSGID_Motor_53", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_53, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_53", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_53_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_53_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Motor_53, getProfileInt( "Settings", "KCAN__ALLDEF_Motor_53", 0, profileFile ) );
    putValue( KCAN__STMSG_Motor_53, getProfileInt( "Settings", "KCAN__STMSG_Motor_53", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_53, getProfileInt( "Settings", "KCAN__STMSGT_Motor_53", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_53_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Motor_53_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Motor_53, getProfileInt( "Settings", "KCAN__STMSGSD_Motor_53", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_53, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_53", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_53_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_53_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Motor_53, getProfileInt( "Settings", "KCAN__STMSG_PO_Motor_53", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Motor_53, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Motor_53", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Motor_53, getProfileInt( "Settings", "KCAN__MSG_SendNow_Motor_53", 0, profileFile ) );
    putValue( KCAN__MSGID_Motor_54, getProfileInt( "Settings", "KCAN__MSGID_Motor_54", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_54, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_54", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_54_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_54_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Motor_54, getProfileInt( "Settings", "KCAN__ALLDEF_Motor_54", 0, profileFile ) );
    putValue( KCAN__STMSG_Motor_54, getProfileInt( "Settings", "KCAN__STMSG_Motor_54", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_54, getProfileInt( "Settings", "KCAN__STMSGT_Motor_54", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_54_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Motor_54_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Motor_54, getProfileInt( "Settings", "KCAN__STMSGSD_Motor_54", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_54, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_54", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_54_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_54_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Motor_54, getProfileInt( "Settings", "KCAN__STMSG_PO_Motor_54", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Motor_54, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Motor_54", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Motor_54, getProfileInt( "Settings", "KCAN__MSG_SendNow_Motor_54", 0, profileFile ) );
    putValue( KCAN__MSGID_Motor_57, getProfileInt( "Settings", "KCAN__MSGID_Motor_57", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_57, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_57", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_57_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_57_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Motor_57, getProfileInt( "Settings", "KCAN__ALLDEF_Motor_57", 0, profileFile ) );
    putValue( KCAN__STMSG_Motor_57, getProfileInt( "Settings", "KCAN__STMSG_Motor_57", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_57, getProfileInt( "Settings", "KCAN__STMSGT_Motor_57", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_57_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Motor_57_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Motor_57, getProfileInt( "Settings", "KCAN__STMSGSD_Motor_57", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_57, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_57", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_57_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_57_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Motor_57, getProfileInt( "Settings", "KCAN__STMSG_PO_Motor_57", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Motor_57, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Motor_57", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Motor_57, getProfileInt( "Settings", "KCAN__MSG_SendNow_Motor_57", 0, profileFile ) );
    putValue( KCAN__MSGID_Motor_Hybrid_06, getProfileInt( "Settings", "KCAN__MSGID_Motor_Hybrid_06", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_Hybrid_06_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_Hybrid_06_CTRL", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Motor_Hybrid_06_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Motor_Hybrid_06_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Motor_Hybrid_06, getProfileInt( "Settings", "KCAN__ALLDEF_Motor_Hybrid_06", 0, profileFile ) );
    putValue( KCAN__STMSG_Motor_Hybrid_06, getProfileInt( "Settings", "KCAN__STMSG_Motor_Hybrid_06", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_Hybrid_06_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Motor_Hybrid_06_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGT_Motor_Hybrid_06_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Motor_Hybrid_06_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Motor_Hybrid_06, getProfileInt( "Settings", "KCAN__STMSGSD_Motor_Hybrid_06", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_Hybrid_06, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_Hybrid_06", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Motor_Hybrid_06_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Motor_Hybrid_06_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Motor_Hybrid_06, getProfileInt( "Settings", "KCAN__STMSG_PO_Motor_Hybrid_06", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Motor_Hybrid_06, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Motor_Hybrid_06", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Motor_Hybrid_06, getProfileInt( "Settings", "KCAN__MSG_SendNow_Motor_Hybrid_06", 0, profileFile ) );
    putValue( KCAN__MSGID_NavData_01, getProfileInt( "Settings", "KCAN__MSGID_NavData_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NavData_01, getProfileInt( "Settings", "KCAN__MSGDLC_NavData_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NavData_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_NavData_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_NavData_01, getProfileInt( "Settings", "KCAN__ALLDEF_NavData_01", 0, profileFile ) );
    putValue( KCAN__STMSG_NavData_01, getProfileInt( "Settings", "KCAN__STMSG_NavData_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_NavData_01, getProfileInt( "Settings", "KCAN__STMSGT_NavData_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_NavData_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_NavData_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_NavData_01, getProfileInt( "Settings", "KCAN__STMSGSD_NavData_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NavData_01, getProfileInt( "Settings", "KCAN__STMSGCT_NavData_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NavData_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_NavData_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_NavData_01, getProfileInt( "Settings", "KCAN__STMSG_PO_NavData_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_NavData_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_NavData_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_NavData_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_NavData_01", 0, profileFile ) );
    putValue( KCAN__MSGID_NavData_02, getProfileInt( "Settings", "KCAN__MSGID_NavData_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NavData_02, getProfileInt( "Settings", "KCAN__MSGDLC_NavData_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NavData_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_NavData_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_NavData_02, getProfileInt( "Settings", "KCAN__ALLDEF_NavData_02", 0, profileFile ) );
    putValue( KCAN__STMSG_NavData_02, getProfileInt( "Settings", "KCAN__STMSG_NavData_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_NavData_02, getProfileInt( "Settings", "KCAN__STMSGT_NavData_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_NavData_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_NavData_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_NavData_02, getProfileInt( "Settings", "KCAN__STMSGSD_NavData_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NavData_02, getProfileInt( "Settings", "KCAN__STMSGCT_NavData_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NavData_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_NavData_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_NavData_02, getProfileInt( "Settings", "KCAN__STMSG_PO_NavData_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_NavData_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_NavData_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_NavData_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_NavData_02", 0, profileFile ) );
    putValue( KCAN__MSGID_NavData_03, getProfileInt( "Settings", "KCAN__MSGID_NavData_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NavData_03, getProfileInt( "Settings", "KCAN__MSGDLC_NavData_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NavData_03_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_NavData_03_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_NavData_03, getProfileInt( "Settings", "KCAN__ALLDEF_NavData_03", 0, profileFile ) );
    putValue( KCAN__STMSG_NavData_03, getProfileInt( "Settings", "KCAN__STMSG_NavData_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_NavData_03, getProfileInt( "Settings", "KCAN__STMSGT_NavData_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_NavData_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_NavData_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_NavData_03, getProfileInt( "Settings", "KCAN__STMSGSD_NavData_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NavData_03, getProfileInt( "Settings", "KCAN__STMSGCT_NavData_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NavData_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_NavData_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_NavData_03, getProfileInt( "Settings", "KCAN__STMSG_PO_NavData_03", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_NavData_03, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_NavData_03", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_NavData_03, getProfileInt( "Settings", "KCAN__MSG_SendNow_NavData_03", 0, profileFile ) );
    putValue( KCAN__MSGID_NavData_04, getProfileInt( "Settings", "KCAN__MSGID_NavData_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NavData_04, getProfileInt( "Settings", "KCAN__MSGDLC_NavData_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NavData_04_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_NavData_04_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_NavData_04, getProfileInt( "Settings", "KCAN__ALLDEF_NavData_04", 0, profileFile ) );
    putValue( KCAN__STMSG_NavData_04, getProfileInt( "Settings", "KCAN__STMSG_NavData_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_NavData_04, getProfileInt( "Settings", "KCAN__STMSGT_NavData_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_NavData_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_NavData_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_NavData_04, getProfileInt( "Settings", "KCAN__STMSGSD_NavData_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NavData_04, getProfileInt( "Settings", "KCAN__STMSGCT_NavData_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NavData_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_NavData_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_NavData_04, getProfileInt( "Settings", "KCAN__STMSG_PO_NavData_04", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_NavData_04, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_NavData_04", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_NavData_04, getProfileInt( "Settings", "KCAN__MSG_SendNow_NavData_04", 0, profileFile ) );
    putValue( KCAN__MSGID_NavPos_01, getProfileInt( "Settings", "KCAN__MSGID_NavPos_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NavPos_01, getProfileInt( "Settings", "KCAN__MSGDLC_NavPos_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NavPos_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_NavPos_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_NavPos_01, getProfileInt( "Settings", "KCAN__ALLDEF_NavPos_01", 0, profileFile ) );
    putValue( KCAN__STMSG_NavPos_01, getProfileInt( "Settings", "KCAN__STMSG_NavPos_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_NavPos_01, getProfileInt( "Settings", "KCAN__STMSGT_NavPos_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_NavPos_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_NavPos_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_NavPos_01, getProfileInt( "Settings", "KCAN__STMSGSD_NavPos_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NavPos_01, getProfileInt( "Settings", "KCAN__STMSGCT_NavPos_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NavPos_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_NavPos_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_NavPos_01, getProfileInt( "Settings", "KCAN__STMSG_PO_NavPos_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_NavPos_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_NavPos_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_NavPos_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_NavPos_01", 0, profileFile ) );
    putValue( KCAN__MSGID_NavPos_02_Map_Matched, getProfileInt( "Settings", "KCAN__MSGID_NavPos_02_Map_Matched", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NavPos_02_Map_Matched, getProfileInt( "Settings", "KCAN__MSGDLC_NavPos_02_Map_Matched", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NavPos_02_Map_Matched_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_NavPos_02_Map_Matched_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_NavPos_02_Map_Matched, getProfileInt( "Settings", "KCAN__ALLDEF_NavPos_02_Map_Matched", 0, profileFile ) );
    putValue( KCAN__STMSG_NavPos_02_Map_Matched, getProfileInt( "Settings", "KCAN__STMSG_NavPos_02_Map_Matched", 0, profileFile ) );
    putValue( KCAN__STMSGT_NavPos_02_Map_Matched, getProfileInt( "Settings", "KCAN__STMSGT_NavPos_02_Map_Matched", 0, profileFile ) );
    putValue( KCAN__STMSGT_NavPos_02_Map_Matched_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_NavPos_02_Map_Matched_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_NavPos_02_Map_Matched, getProfileInt( "Settings", "KCAN__STMSGSD_NavPos_02_Map_Matched", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NavPos_02_Map_Matched, getProfileInt( "Settings", "KCAN__STMSGCT_NavPos_02_Map_Matched", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NavPos_02_Map_Matched_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_NavPos_02_Map_Matched_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_NavPos_02_Map_Matched, getProfileInt( "Settings", "KCAN__STMSG_PO_NavPos_02_Map_Matched", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_NavPos_02_Map_Matched, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_NavPos_02_Map_Matched", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_NavPos_02_Map_Matched, getProfileInt( "Settings", "KCAN__MSG_SendNow_NavPos_02_Map_Matched", 0, profileFile ) );
    putValue( KCAN__MSGID_NFC_01, getProfileInt( "Settings", "KCAN__MSGID_NFC_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NFC_01, getProfileInt( "Settings", "KCAN__MSGDLC_NFC_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NFC_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_NFC_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_NFC_01, getProfileInt( "Settings", "KCAN__ALLDEF_NFC_01", 0, profileFile ) );
    putValue( KCAN__STMSG_NFC_01, getProfileInt( "Settings", "KCAN__STMSG_NFC_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_NFC_01, getProfileInt( "Settings", "KCAN__STMSGT_NFC_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_NFC_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_NFC_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_NFC_01, getProfileInt( "Settings", "KCAN__STMSGSD_NFC_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NFC_01, getProfileInt( "Settings", "KCAN__STMSGCT_NFC_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NFC_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_NFC_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_NFC_01, getProfileInt( "Settings", "KCAN__STMSG_PO_NFC_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_NFC_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_NFC_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_NFC_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_NFC_01", 0, profileFile ) );
    putValue( KCAN__MSGID_NFC_MiKo_01, getProfileInt( "Settings", "KCAN__MSGID_NFC_MiKo_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NFC_MiKo_01, getProfileInt( "Settings", "KCAN__MSGDLC_NFC_MiKo_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NFC_MiKo_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_NFC_MiKo_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_NFC_MiKo_01, getProfileInt( "Settings", "KCAN__ALLDEF_NFC_MiKo_01", 0, profileFile ) );
    putValue( KCAN__STMSG_NFC_MiKo_01, getProfileInt( "Settings", "KCAN__STMSG_NFC_MiKo_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_NFC_MiKo_01, getProfileInt( "Settings", "KCAN__STMSGT_NFC_MiKo_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_NFC_MiKo_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_NFC_MiKo_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_NFC_MiKo_01, getProfileInt( "Settings", "KCAN__STMSGSD_NFC_MiKo_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NFC_MiKo_01, getProfileInt( "Settings", "KCAN__STMSGCT_NFC_MiKo_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NFC_MiKo_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_NFC_MiKo_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_NFC_MiKo_01, getProfileInt( "Settings", "KCAN__STMSG_PO_NFC_MiKo_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_NFC_MiKo_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_NFC_MiKo_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_NFC_MiKo_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_NFC_MiKo_01", 0, profileFile ) );
    putValue( KCAN__MSGID_NMH_DispKBI_FS, getProfileInt( "Settings", "KCAN__MSGID_NMH_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NMH_DispKBI_FS, getProfileInt( "Settings", "KCAN__MSGDLC_NMH_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NMH_DispKBI_FS_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_NMH_DispKBI_FS_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_NMH_DispKBI_FS, getProfileInt( "Settings", "KCAN__ALLDEF_NMH_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__STMSG_NMH_DispKBI_FS, getProfileInt( "Settings", "KCAN__STMSG_NMH_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__STMSGT_NMH_DispKBI_FS, getProfileInt( "Settings", "KCAN__STMSGT_NMH_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__STMSGT_NMH_DispKBI_FS_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_NMH_DispKBI_FS_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_NMH_DispKBI_FS, getProfileInt( "Settings", "KCAN__STMSGSD_NMH_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NMH_DispKBI_FS_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_NMH_DispKBI_FS_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NMH_DispKBI_FS_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_NMH_DispKBI_FS_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_NMH_DispKBI_FS, getProfileInt( "Settings", "KCAN__STMSG_PO_NMH_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_NMH_DispKBI_FS, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_NMH_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_NMH_DispKBI_FS, getProfileInt( "Settings", "KCAN__MSG_SendNow_NMH_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__MSGID_NMH_Gateway, getProfileInt( "Settings", "KCAN__MSGID_NMH_Gateway", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NMH_Gateway, getProfileInt( "Settings", "KCAN__MSGDLC_NMH_Gateway", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NMH_Gateway_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_NMH_Gateway_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_NMH_Gateway, getProfileInt( "Settings", "KCAN__ALLDEF_NMH_Gateway", 0, profileFile ) );
    putValue( KCAN__STMSG_NMH_Gateway, getProfileInt( "Settings", "KCAN__STMSG_NMH_Gateway", 0, profileFile ) );
    putValue( KCAN__STMSGT_NMH_Gateway, getProfileInt( "Settings", "KCAN__STMSGT_NMH_Gateway", 0, profileFile ) );
    putValue( KCAN__STMSGT_NMH_Gateway_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_NMH_Gateway_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_NMH_Gateway, getProfileInt( "Settings", "KCAN__STMSGSD_NMH_Gateway", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NMH_Gateway, getProfileInt( "Settings", "KCAN__STMSGCT_NMH_Gateway", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NMH_Gateway_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_NMH_Gateway_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_NMH_Gateway, getProfileInt( "Settings", "KCAN__STMSG_PO_NMH_Gateway", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_NMH_Gateway, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_NMH_Gateway", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_NMH_Gateway, getProfileInt( "Settings", "KCAN__MSG_SendNow_NMH_Gateway", 0, profileFile ) );
    putValue( KCAN__MSGID_NMH_HUD, getProfileInt( "Settings", "KCAN__MSGID_NMH_HUD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NMH_HUD, getProfileInt( "Settings", "KCAN__MSGDLC_NMH_HUD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NMH_HUD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_NMH_HUD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_NMH_HUD, getProfileInt( "Settings", "KCAN__ALLDEF_NMH_HUD", 0, profileFile ) );
    putValue( KCAN__STMSG_NMH_HUD, getProfileInt( "Settings", "KCAN__STMSG_NMH_HUD", 0, profileFile ) );
    putValue( KCAN__STMSGT_NMH_HUD, getProfileInt( "Settings", "KCAN__STMSGT_NMH_HUD", 0, profileFile ) );
    putValue( KCAN__STMSGT_NMH_HUD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_NMH_HUD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_NMH_HUD, getProfileInt( "Settings", "KCAN__STMSGSD_NMH_HUD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NMH_HUD, getProfileInt( "Settings", "KCAN__STMSGCT_NMH_HUD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NMH_HUD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_NMH_HUD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_NMH_HUD, getProfileInt( "Settings", "KCAN__STMSG_PO_NMH_HUD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_NMH_HUD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_NMH_HUD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_NMH_HUD, getProfileInt( "Settings", "KCAN__MSG_SendNow_NMH_HUD", 0, profileFile ) );
    putValue( KCAN__MSGID_NMH_Info_El, getProfileInt( "Settings", "KCAN__MSGID_NMH_Info_El", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NMH_Info_El, getProfileInt( "Settings", "KCAN__MSGDLC_NMH_Info_El", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NMH_Info_El_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_NMH_Info_El_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_NMH_Info_El, getProfileInt( "Settings", "KCAN__ALLDEF_NMH_Info_El", 0, profileFile ) );
    putValue( KCAN__STMSG_NMH_Info_El, getProfileInt( "Settings", "KCAN__STMSG_NMH_Info_El", 0, profileFile ) );
    putValue( KCAN__STMSGT_NMH_Info_El, getProfileInt( "Settings", "KCAN__STMSGT_NMH_Info_El", 0, profileFile ) );
    putValue( KCAN__STMSGT_NMH_Info_El_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_NMH_Info_El_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_NMH_Info_El, getProfileInt( "Settings", "KCAN__STMSGSD_NMH_Info_El", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NMH_Info_El, getProfileInt( "Settings", "KCAN__STMSGCT_NMH_Info_El", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NMH_Info_El_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_NMH_Info_El_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_NMH_Info_El, getProfileInt( "Settings", "KCAN__STMSG_PO_NMH_Info_El", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_NMH_Info_El, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_NMH_Info_El", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_NMH_Info_El, getProfileInt( "Settings", "KCAN__MSG_SendNow_NMH_Info_El", 0, profileFile ) );
    putValue( KCAN__MSGID_NMH_Kombi, getProfileInt( "Settings", "KCAN__MSGID_NMH_Kombi", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NMH_Kombi, getProfileInt( "Settings", "KCAN__MSGDLC_NMH_Kombi", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NMH_Kombi_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_NMH_Kombi_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_NMH_Kombi, getProfileInt( "Settings", "KCAN__ALLDEF_NMH_Kombi", 0, profileFile ) );
    putValue( KCAN__STMSG_NMH_Kombi, getProfileInt( "Settings", "KCAN__STMSG_NMH_Kombi", 0, profileFile ) );
    putValue( KCAN__STMSGT_NMH_Kombi, getProfileInt( "Settings", "KCAN__STMSGT_NMH_Kombi", 0, profileFile ) );
    putValue( KCAN__STMSGT_NMH_Kombi_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_NMH_Kombi_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_NMH_Kombi, getProfileInt( "Settings", "KCAN__STMSGSD_NMH_Kombi", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NMH_Kombi, getProfileInt( "Settings", "KCAN__STMSGCT_NMH_Kombi", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NMH_Kombi_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_NMH_Kombi_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_NMH_Kombi, getProfileInt( "Settings", "KCAN__STMSG_PO_NMH_Kombi", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_NMH_Kombi, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_NMH_Kombi", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_NMH_Kombi, getProfileInt( "Settings", "KCAN__MSG_SendNow_NMH_Kombi", 0, profileFile ) );
    putValue( KCAN__MSGID_NMH_SmLi_01, getProfileInt( "Settings", "KCAN__MSGID_NMH_SmLi_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NMH_SmLi_01, getProfileInt( "Settings", "KCAN__MSGDLC_NMH_SmLi_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_NMH_SmLi_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_NMH_SmLi_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_NMH_SmLi_01, getProfileInt( "Settings", "KCAN__ALLDEF_NMH_SmLi_01", 0, profileFile ) );
    putValue( KCAN__STMSG_NMH_SmLi_01, getProfileInt( "Settings", "KCAN__STMSG_NMH_SmLi_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_NMH_SmLi_01, getProfileInt( "Settings", "KCAN__STMSGT_NMH_SmLi_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_NMH_SmLi_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_NMH_SmLi_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_NMH_SmLi_01, getProfileInt( "Settings", "KCAN__STMSGSD_NMH_SmLi_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NMH_SmLi_01, getProfileInt( "Settings", "KCAN__STMSGCT_NMH_SmLi_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_NMH_SmLi_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_NMH_SmLi_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_NMH_SmLi_01, getProfileInt( "Settings", "KCAN__STMSG_PO_NMH_SmLi_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_NMH_SmLi_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_NMH_SmLi_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_NMH_SmLi_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_NMH_SmLi_01", 0, profileFile ) );
    putValue( KCAN__MSGID_OBDC_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_OBDC_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_DispKBI_FS_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_DispKBI_FS_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_OBDC_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_OBDC_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_OBDC_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_OBDC_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_DispKBI_FS_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_DispKBI_FS_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_OBDC_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_OBDC_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_DispKBI_FS_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_DispKBI_FS_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_OBDC_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_OBDC_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_OBDC_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_OBDC_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_OBDC_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_OBDC_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_OBDC_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_OBDC_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_DispKBI_FS_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_DispKBI_FS_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_OBDC_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_OBDC_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_OBDC_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_OBDC_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_DispKBI_FS_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_DispKBI_FS_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_OBDC_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_OBDC_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_DispKBI_FS_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_DispKBI_FS_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_OBDC_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_OBDC_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_OBDC_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_OBDC_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_OBDC_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_OBDC_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_OBDC_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__MSGID_OBDC_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_Funktionaler_Req_All_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_Funktionaler_Req_All_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_OBDC_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__ALLDEF_OBDC_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__STMSG_OBDC_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__STMSG_OBDC_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_Funktionaler_Req_All_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_Funktionaler_Req_All_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_OBDC_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__STMSGSD_OBDC_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_Funktionaler_Req_All_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_Funktionaler_Req_All_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_OBDC_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__STMSG_PO_OBDC_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_OBDC_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_OBDC_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_OBDC_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__MSG_SendNow_OBDC_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__MSGID_OBDC_Funktionaler_Req_All_FD, getProfileInt( "Settings", "KCAN__MSGID_OBDC_Funktionaler_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_Funktionaler_Req_All_FD, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_Funktionaler_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_Funktionaler_Req_All_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_Funktionaler_Req_All_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_OBDC_Funktionaler_Req_All_FD, getProfileInt( "Settings", "KCAN__ALLDEF_OBDC_Funktionaler_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_OBDC_Funktionaler_Req_All_FD, getProfileInt( "Settings", "KCAN__STMSG_OBDC_Funktionaler_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_Funktionaler_Req_All_FD, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_Funktionaler_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_Funktionaler_Req_All_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_Funktionaler_Req_All_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_OBDC_Funktionaler_Req_All_FD, getProfileInt( "Settings", "KCAN__STMSGSD_OBDC_Funktionaler_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_Funktionaler_Req_All_FD, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_Funktionaler_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_Funktionaler_Req_All_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_Funktionaler_Req_All_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_OBDC_Funktionaler_Req_All_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_OBDC_Funktionaler_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_OBDC_Funktionaler_Req_All_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_OBDC_Funktionaler_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_OBDC_Funktionaler_Req_All_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_OBDC_Funktionaler_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_OBDC_HUD_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_OBDC_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_HUD_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_HUD_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_HUD_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_HUD_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_OBDC_HUD_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_OBDC_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_OBDC_HUD_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_OBDC_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_HUD_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_HUD_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_HUD_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_HUD_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_OBDC_HUD_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_OBDC_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_HUD_Req_FD, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_HUD_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_HUD_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_OBDC_HUD_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_OBDC_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_OBDC_HUD_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_OBDC_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_OBDC_HUD_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_OBDC_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_OBDC_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_OBDC_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_HUD_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_HUD_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_OBDC_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_OBDC_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_OBDC_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_OBDC_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_HUD_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_HUD_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_OBDC_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_OBDC_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_HUD_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_HUD_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_OBDC_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_OBDC_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_OBDC_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_OBDC_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_OBDC_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_OBDC_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_OBDC_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_OBDC_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_Kombi_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_Kombi_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_OBDC_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_OBDC_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_OBDC_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_OBDC_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_Kombi_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_Kombi_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_OBDC_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_OBDC_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_Kombi_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_Kombi_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_OBDC_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_OBDC_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_OBDC_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_OBDC_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_OBDC_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_OBDC_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_OBDC_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_OBDC_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_Kombi_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_Kombi_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_OBDC_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_OBDC_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_OBDC_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_OBDC_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_Kombi_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_Kombi_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_OBDC_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_OBDC_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_Kombi_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_Kombi_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_OBDC_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_OBDC_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_OBDC_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_OBDC_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_OBDC_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_OBDC_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_OBDC_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_OBDC_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_SmLi_01_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_SmLi_01_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_OBDC_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_OBDC_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_OBDC_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_OBDC_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_SmLi_01_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_SmLi_01_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_OBDC_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_OBDC_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_SmLi_01_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_SmLi_01_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_OBDC_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_OBDC_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_OBDC_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_OBDC_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_OBDC_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_OBDC_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_OBDC_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_OBDC_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_SmLi_01_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_SmLi_01_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_OBDC_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_OBDC_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_OBDC_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_OBDC_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_SmLi_01_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_SmLi_01_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_OBDC_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_OBDC_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_SmLi_01_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_SmLi_01_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_OBDC_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_OBDC_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_OBDC_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_OBDC_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_OBDC_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_OBDC_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_OBDC_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__MSGID_OBDC_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_SSN_ABT_1_Req_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_SSN_ABT_1_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_OBDC_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__ALLDEF_OBDC_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__STMSG_OBDC_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__STMSG_OBDC_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_SSN_ABT_1_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_SSN_ABT_1_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_OBDC_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__STMSGSD_OBDC_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_SSN_ABT_1_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_SSN_ABT_1_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_OBDC_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__STMSG_PO_OBDC_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_OBDC_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_OBDC_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_OBDC_SSN_ABT_1_Req, getProfileInt( "Settings", "KCAN__MSG_SendNow_OBDC_SSN_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__MSGID_OBDC_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__MSGID_OBDC_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_SSN_ABT_1_Resp_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_SSN_ABT_1_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_OBDC_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__ALLDEF_OBDC_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSG_OBDC_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__STMSG_OBDC_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_SSN_ABT_1_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_SSN_ABT_1_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_OBDC_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__STMSGSD_OBDC_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_SSN_ABT_1_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_SSN_ABT_1_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_OBDC_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__STMSG_PO_OBDC_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_OBDC_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_OBDC_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_OBDC_SSN_ABT_1_Resp, getProfileInt( "Settings", "KCAN__MSG_SendNow_OBDC_SSN_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGID_OBDC_WLC1_Req, getProfileInt( "Settings", "KCAN__MSGID_OBDC_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_WLC1_Req, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_WLC1_Req_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_WLC1_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_OBDC_WLC1_Req, getProfileInt( "Settings", "KCAN__ALLDEF_OBDC_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__STMSG_OBDC_WLC1_Req, getProfileInt( "Settings", "KCAN__STMSG_OBDC_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_WLC1_Req, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_WLC1_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_WLC1_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_OBDC_WLC1_Req, getProfileInt( "Settings", "KCAN__STMSGSD_OBDC_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_WLC1_Req, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_WLC1_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_WLC1_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_OBDC_WLC1_Req, getProfileInt( "Settings", "KCAN__STMSG_PO_OBDC_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_OBDC_WLC1_Req, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_OBDC_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_OBDC_WLC1_Req, getProfileInt( "Settings", "KCAN__MSG_SendNow_OBDC_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__MSGID_OBDC_WLC1_Resp, getProfileInt( "Settings", "KCAN__MSGID_OBDC_WLC1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_WLC1_Resp, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_WLC1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDC_WLC1_Resp_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_OBDC_WLC1_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_OBDC_WLC1_Resp, getProfileInt( "Settings", "KCAN__ALLDEF_OBDC_WLC1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSG_OBDC_WLC1_Resp, getProfileInt( "Settings", "KCAN__STMSG_OBDC_WLC1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_WLC1_Resp, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_WLC1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDC_WLC1_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_OBDC_WLC1_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_OBDC_WLC1_Resp, getProfileInt( "Settings", "KCAN__STMSGSD_OBDC_WLC1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_WLC1_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_WLC1_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDC_WLC1_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_OBDC_WLC1_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_OBDC_WLC1_Resp, getProfileInt( "Settings", "KCAN__STMSG_PO_OBDC_WLC1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_OBDC_WLC1_Resp, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_OBDC_WLC1_Resp", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_OBDC_WLC1_Resp, getProfileInt( "Settings", "KCAN__MSG_SendNow_OBDC_WLC1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGID_OBDx_allOBD_Req, getProfileInt( "Settings", "KCAN__MSGID_OBDx_allOBD_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDx_allOBD_Req_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_OBDx_allOBD_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__MSGDLC_OBDx_allOBD_Req_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_OBDx_allOBD_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_OBDx_allOBD_Req, getProfileInt( "Settings", "KCAN__ALLDEF_OBDx_allOBD_Req", 0, profileFile ) );
    putValue( KCAN__STMSG_OBDx_allOBD_Req, getProfileInt( "Settings", "KCAN__STMSG_OBDx_allOBD_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDx_allOBD_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_OBDx_allOBD_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGT_OBDx_allOBD_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_OBDx_allOBD_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_OBDx_allOBD_Req, getProfileInt( "Settings", "KCAN__STMSGSD_OBDx_allOBD_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDx_allOBD_Req, getProfileInt( "Settings", "KCAN__STMSGCT_OBDx_allOBD_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_OBDx_allOBD_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_OBDx_allOBD_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_OBDx_allOBD_Req, getProfileInt( "Settings", "KCAN__STMSG_PO_OBDx_allOBD_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_OBDx_allOBD_Req, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_OBDx_allOBD_Req", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_OBDx_allOBD_Req, getProfileInt( "Settings", "KCAN__MSG_SendNow_OBDx_allOBD_Req", 0, profileFile ) );
    putValue( KCAN__MSGID_ORU_01, getProfileInt( "Settings", "KCAN__MSGID_ORU_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ORU_01, getProfileInt( "Settings", "KCAN__MSGDLC_ORU_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ORU_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ORU_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ORU_01, getProfileInt( "Settings", "KCAN__ALLDEF_ORU_01", 0, profileFile ) );
    putValue( KCAN__STMSG_ORU_01, getProfileInt( "Settings", "KCAN__STMSG_ORU_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_ORU_01, getProfileInt( "Settings", "KCAN__STMSGT_ORU_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_ORU_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ORU_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ORU_01, getProfileInt( "Settings", "KCAN__STMSGSD_ORU_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ORU_01, getProfileInt( "Settings", "KCAN__STMSGCT_ORU_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ORU_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ORU_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ORU_01, getProfileInt( "Settings", "KCAN__STMSG_PO_ORU_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ORU_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ORU_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ORU_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_ORU_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Parkhilfe_01, getProfileInt( "Settings", "KCAN__MSGID_Parkhilfe_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Parkhilfe_01, getProfileInt( "Settings", "KCAN__MSGDLC_Parkhilfe_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Parkhilfe_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Parkhilfe_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Parkhilfe_01, getProfileInt( "Settings", "KCAN__ALLDEF_Parkhilfe_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Parkhilfe_01, getProfileInt( "Settings", "KCAN__STMSG_Parkhilfe_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Parkhilfe_01, getProfileInt( "Settings", "KCAN__STMSGT_Parkhilfe_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Parkhilfe_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Parkhilfe_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Parkhilfe_01, getProfileInt( "Settings", "KCAN__STMSGSD_Parkhilfe_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Parkhilfe_01, getProfileInt( "Settings", "KCAN__STMSGCT_Parkhilfe_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Parkhilfe_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Parkhilfe_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Parkhilfe_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Parkhilfe_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Parkhilfe_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Parkhilfe_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Parkhilfe_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Parkhilfe_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Parkhilfe_04, getProfileInt( "Settings", "KCAN__MSGID_Parkhilfe_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Parkhilfe_04, getProfileInt( "Settings", "KCAN__MSGDLC_Parkhilfe_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Parkhilfe_04_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Parkhilfe_04_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Parkhilfe_04, getProfileInt( "Settings", "KCAN__ALLDEF_Parkhilfe_04", 0, profileFile ) );
    putValue( KCAN__STMSG_Parkhilfe_04, getProfileInt( "Settings", "KCAN__STMSG_Parkhilfe_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_Parkhilfe_04, getProfileInt( "Settings", "KCAN__STMSGT_Parkhilfe_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_Parkhilfe_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Parkhilfe_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Parkhilfe_04, getProfileInt( "Settings", "KCAN__STMSGSD_Parkhilfe_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Parkhilfe_04, getProfileInt( "Settings", "KCAN__STMSGCT_Parkhilfe_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Parkhilfe_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Parkhilfe_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Parkhilfe_04, getProfileInt( "Settings", "KCAN__STMSG_PO_Parkhilfe_04", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Parkhilfe_04, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Parkhilfe_04", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Parkhilfe_04, getProfileInt( "Settings", "KCAN__MSG_SendNow_Parkhilfe_04", 0, profileFile ) );
    putValue( KCAN__MSGID_Personalisierung_01, getProfileInt( "Settings", "KCAN__MSGID_Personalisierung_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Personalisierung_01, getProfileInt( "Settings", "KCAN__MSGDLC_Personalisierung_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Personalisierung_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Personalisierung_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Personalisierung_01, getProfileInt( "Settings", "KCAN__ALLDEF_Personalisierung_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Personalisierung_01, getProfileInt( "Settings", "KCAN__STMSG_Personalisierung_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Personalisierung_01, getProfileInt( "Settings", "KCAN__STMSGT_Personalisierung_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Personalisierung_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Personalisierung_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Personalisierung_01, getProfileInt( "Settings", "KCAN__STMSGSD_Personalisierung_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Personalisierung_01, getProfileInt( "Settings", "KCAN__STMSGCT_Personalisierung_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Personalisierung_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Personalisierung_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Personalisierung_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Personalisierung_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Personalisierung_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Personalisierung_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Personalisierung_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Personalisierung_01", 0, profileFile ) );
    putValue( KCAN__MSGID_PreCrash_02, getProfileInt( "Settings", "KCAN__MSGID_PreCrash_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_PreCrash_02, getProfileInt( "Settings", "KCAN__MSGDLC_PreCrash_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_PreCrash_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_PreCrash_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_PreCrash_02, getProfileInt( "Settings", "KCAN__ALLDEF_PreCrash_02", 0, profileFile ) );
    putValue( KCAN__STMSG_PreCrash_02, getProfileInt( "Settings", "KCAN__STMSG_PreCrash_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_PreCrash_02, getProfileInt( "Settings", "KCAN__STMSGT_PreCrash_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_PreCrash_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_PreCrash_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_PreCrash_02, getProfileInt( "Settings", "KCAN__STMSGSD_PreCrash_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_PreCrash_02, getProfileInt( "Settings", "KCAN__STMSGCT_PreCrash_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_PreCrash_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_PreCrash_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_PreCrash_02, getProfileInt( "Settings", "KCAN__STMSG_PO_PreCrash_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_PreCrash_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_PreCrash_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_PreCrash_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_PreCrash_02", 0, profileFile ) );
    putValue( KCAN__MSGID_PSD_04, getProfileInt( "Settings", "KCAN__MSGID_PSD_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_PSD_04, getProfileInt( "Settings", "KCAN__MSGDLC_PSD_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_PSD_04_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_PSD_04_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_PSD_04, getProfileInt( "Settings", "KCAN__ALLDEF_PSD_04", 0, profileFile ) );
    putValue( KCAN__STMSG_PSD_04, getProfileInt( "Settings", "KCAN__STMSG_PSD_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_PSD_04, getProfileInt( "Settings", "KCAN__STMSGT_PSD_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_PSD_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_PSD_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_PSD_04, getProfileInt( "Settings", "KCAN__STMSGSD_PSD_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_PSD_04, getProfileInt( "Settings", "KCAN__STMSGCT_PSD_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_PSD_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_PSD_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_PSD_04, getProfileInt( "Settings", "KCAN__STMSG_PO_PSD_04", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_PSD_04, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_PSD_04", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_PSD_04, getProfileInt( "Settings", "KCAN__MSG_SendNow_PSD_04", 0, profileFile ) );
    putValue( KCAN__MSGID_PSD_05, getProfileInt( "Settings", "KCAN__MSGID_PSD_05", 0, profileFile ) );
    putValue( KCAN__MSGDLC_PSD_05, getProfileInt( "Settings", "KCAN__MSGDLC_PSD_05", 0, profileFile ) );
    putValue( KCAN__MSGDLC_PSD_05_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_PSD_05_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_PSD_05, getProfileInt( "Settings", "KCAN__ALLDEF_PSD_05", 0, profileFile ) );
    putValue( KCAN__STMSG_PSD_05, getProfileInt( "Settings", "KCAN__STMSG_PSD_05", 0, profileFile ) );
    putValue( KCAN__STMSGT_PSD_05, getProfileInt( "Settings", "KCAN__STMSGT_PSD_05", 0, profileFile ) );
    putValue( KCAN__STMSGT_PSD_05_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_PSD_05_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_PSD_05, getProfileInt( "Settings", "KCAN__STMSGSD_PSD_05", 0, profileFile ) );
    putValue( KCAN__STMSGCT_PSD_05, getProfileInt( "Settings", "KCAN__STMSGCT_PSD_05", 0, profileFile ) );
    putValue( KCAN__STMSGCT_PSD_05_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_PSD_05_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_PSD_05, getProfileInt( "Settings", "KCAN__STMSG_PO_PSD_05", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_PSD_05, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_PSD_05", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_PSD_05, getProfileInt( "Settings", "KCAN__MSG_SendNow_PSD_05", 0, profileFile ) );
    putValue( KCAN__MSGID_PSD_06, getProfileInt( "Settings", "KCAN__MSGID_PSD_06", 0, profileFile ) );
    putValue( KCAN__MSGDLC_PSD_06, getProfileInt( "Settings", "KCAN__MSGDLC_PSD_06", 0, profileFile ) );
    putValue( KCAN__MSGDLC_PSD_06_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_PSD_06_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_PSD_06, getProfileInt( "Settings", "KCAN__ALLDEF_PSD_06", 0, profileFile ) );
    putValue( KCAN__STMSG_PSD_06, getProfileInt( "Settings", "KCAN__STMSG_PSD_06", 0, profileFile ) );
    putValue( KCAN__STMSGT_PSD_06, getProfileInt( "Settings", "KCAN__STMSGT_PSD_06", 0, profileFile ) );
    putValue( KCAN__STMSGT_PSD_06_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_PSD_06_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_PSD_06, getProfileInt( "Settings", "KCAN__STMSGSD_PSD_06", 0, profileFile ) );
    putValue( KCAN__STMSGCT_PSD_06, getProfileInt( "Settings", "KCAN__STMSGCT_PSD_06", 0, profileFile ) );
    putValue( KCAN__STMSGCT_PSD_06_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_PSD_06_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_PSD_06, getProfileInt( "Settings", "KCAN__STMSG_PO_PSD_06", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_PSD_06, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_PSD_06", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_PSD_06, getProfileInt( "Settings", "KCAN__MSG_SendNow_PSD_06", 0, profileFile ) );
    putValue( KCAN__MSGID_PSD_LR_01, getProfileInt( "Settings", "KCAN__MSGID_PSD_LR_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_PSD_LR_01, getProfileInt( "Settings", "KCAN__MSGDLC_PSD_LR_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_PSD_LR_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_PSD_LR_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_PSD_LR_01, getProfileInt( "Settings", "KCAN__ALLDEF_PSD_LR_01", 0, profileFile ) );
    putValue( KCAN__STMSG_PSD_LR_01, getProfileInt( "Settings", "KCAN__STMSG_PSD_LR_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_PSD_LR_01, getProfileInt( "Settings", "KCAN__STMSGT_PSD_LR_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_PSD_LR_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_PSD_LR_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_PSD_LR_01, getProfileInt( "Settings", "KCAN__STMSGSD_PSD_LR_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_PSD_LR_01, getProfileInt( "Settings", "KCAN__STMSGCT_PSD_LR_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_PSD_LR_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_PSD_LR_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_PSD_LR_01, getProfileInt( "Settings", "KCAN__STMSG_PO_PSD_LR_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_PSD_LR_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_PSD_LR_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_PSD_LR_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_PSD_LR_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Radio_01, getProfileInt( "Settings", "KCAN__MSGID_Radio_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Radio_01, getProfileInt( "Settings", "KCAN__MSGDLC_Radio_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Radio_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Radio_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Radio_01, getProfileInt( "Settings", "KCAN__ALLDEF_Radio_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Radio_01, getProfileInt( "Settings", "KCAN__STMSG_Radio_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Radio_01, getProfileInt( "Settings", "KCAN__STMSGT_Radio_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Radio_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Radio_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Radio_01, getProfileInt( "Settings", "KCAN__STMSGSD_Radio_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Radio_01, getProfileInt( "Settings", "KCAN__STMSGCT_Radio_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Radio_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Radio_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Radio_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Radio_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Radio_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Radio_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Radio_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Radio_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Rear_View_04, getProfileInt( "Settings", "KCAN__MSGID_Rear_View_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Rear_View_04, getProfileInt( "Settings", "KCAN__MSGDLC_Rear_View_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Rear_View_04_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Rear_View_04_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Rear_View_04, getProfileInt( "Settings", "KCAN__ALLDEF_Rear_View_04", 0, profileFile ) );
    putValue( KCAN__STMSG_Rear_View_04, getProfileInt( "Settings", "KCAN__STMSG_Rear_View_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_Rear_View_04, getProfileInt( "Settings", "KCAN__STMSGT_Rear_View_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_Rear_View_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Rear_View_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Rear_View_04, getProfileInt( "Settings", "KCAN__STMSGSD_Rear_View_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Rear_View_04, getProfileInt( "Settings", "KCAN__STMSGCT_Rear_View_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Rear_View_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Rear_View_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Rear_View_04, getProfileInt( "Settings", "KCAN__STMSG_PO_Rear_View_04", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Rear_View_04, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Rear_View_04", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Rear_View_04, getProfileInt( "Settings", "KCAN__MSG_SendNow_Rear_View_04", 0, profileFile ) );
    putValue( KCAN__MSGID_Rear_View_06, getProfileInt( "Settings", "KCAN__MSGID_Rear_View_06", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Rear_View_06, getProfileInt( "Settings", "KCAN__MSGDLC_Rear_View_06", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Rear_View_06_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Rear_View_06_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Rear_View_06, getProfileInt( "Settings", "KCAN__ALLDEF_Rear_View_06", 0, profileFile ) );
    putValue( KCAN__STMSG_Rear_View_06, getProfileInt( "Settings", "KCAN__STMSG_Rear_View_06", 0, profileFile ) );
    putValue( KCAN__STMSGT_Rear_View_06, getProfileInt( "Settings", "KCAN__STMSGT_Rear_View_06", 0, profileFile ) );
    putValue( KCAN__STMSGT_Rear_View_06_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Rear_View_06_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Rear_View_06, getProfileInt( "Settings", "KCAN__STMSGSD_Rear_View_06", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Rear_View_06, getProfileInt( "Settings", "KCAN__STMSGCT_Rear_View_06", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Rear_View_06_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Rear_View_06_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Rear_View_06, getProfileInt( "Settings", "KCAN__STMSG_PO_Rear_View_06", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Rear_View_06, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Rear_View_06", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Rear_View_06, getProfileInt( "Settings", "KCAN__MSG_SendNow_Rear_View_06", 0, profileFile ) );
    putValue( KCAN__MSGID_Reichweite_01, getProfileInt( "Settings", "KCAN__MSGID_Reichweite_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Reichweite_01, getProfileInt( "Settings", "KCAN__MSGDLC_Reichweite_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Reichweite_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Reichweite_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Reichweite_01, getProfileInt( "Settings", "KCAN__ALLDEF_Reichweite_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Reichweite_01, getProfileInt( "Settings", "KCAN__STMSG_Reichweite_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Reichweite_01, getProfileInt( "Settings", "KCAN__STMSGT_Reichweite_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Reichweite_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Reichweite_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Reichweite_01, getProfileInt( "Settings", "KCAN__STMSGSD_Reichweite_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Reichweite_01, getProfileInt( "Settings", "KCAN__STMSGCT_Reichweite_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Reichweite_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Reichweite_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Reichweite_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Reichweite_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Reichweite_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Reichweite_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Reichweite_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Reichweite_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Reichweite_02, getProfileInt( "Settings", "KCAN__MSGID_Reichweite_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Reichweite_02, getProfileInt( "Settings", "KCAN__MSGDLC_Reichweite_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Reichweite_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Reichweite_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Reichweite_02, getProfileInt( "Settings", "KCAN__ALLDEF_Reichweite_02", 0, profileFile ) );
    putValue( KCAN__STMSG_Reichweite_02, getProfileInt( "Settings", "KCAN__STMSG_Reichweite_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_Reichweite_02, getProfileInt( "Settings", "KCAN__STMSGT_Reichweite_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_Reichweite_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Reichweite_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Reichweite_02, getProfileInt( "Settings", "KCAN__STMSGSD_Reichweite_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Reichweite_02, getProfileInt( "Settings", "KCAN__STMSGCT_Reichweite_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Reichweite_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Reichweite_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Reichweite_02, getProfileInt( "Settings", "KCAN__STMSG_PO_Reichweite_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Reichweite_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Reichweite_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Reichweite_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_Reichweite_02", 0, profileFile ) );
    putValue( KCAN__MSGID_Reichweite_03, getProfileInt( "Settings", "KCAN__MSGID_Reichweite_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Reichweite_03, getProfileInt( "Settings", "KCAN__MSGDLC_Reichweite_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Reichweite_03_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Reichweite_03_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Reichweite_03, getProfileInt( "Settings", "KCAN__ALLDEF_Reichweite_03", 0, profileFile ) );
    putValue( KCAN__STMSG_Reichweite_03, getProfileInt( "Settings", "KCAN__STMSG_Reichweite_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_Reichweite_03, getProfileInt( "Settings", "KCAN__STMSGT_Reichweite_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_Reichweite_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Reichweite_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Reichweite_03, getProfileInt( "Settings", "KCAN__STMSGSD_Reichweite_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Reichweite_03, getProfileInt( "Settings", "KCAN__STMSGCT_Reichweite_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Reichweite_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Reichweite_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Reichweite_03, getProfileInt( "Settings", "KCAN__STMSG_PO_Reichweite_03", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Reichweite_03, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Reichweite_03", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Reichweite_03, getProfileInt( "Settings", "KCAN__MSG_SendNow_Reichweite_03", 0, profileFile ) );
    putValue( KCAN__MSGID_RKA_01, getProfileInt( "Settings", "KCAN__MSGID_RKA_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_RKA_01, getProfileInt( "Settings", "KCAN__MSGDLC_RKA_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_RKA_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_RKA_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_RKA_01, getProfileInt( "Settings", "KCAN__ALLDEF_RKA_01", 0, profileFile ) );
    putValue( KCAN__STMSG_RKA_01, getProfileInt( "Settings", "KCAN__STMSG_RKA_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_RKA_01, getProfileInt( "Settings", "KCAN__STMSGT_RKA_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_RKA_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_RKA_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_RKA_01, getProfileInt( "Settings", "KCAN__STMSGSD_RKA_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_RKA_01, getProfileInt( "Settings", "KCAN__STMSGCT_RKA_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_RKA_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_RKA_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_RKA_01, getProfileInt( "Settings", "KCAN__STMSG_PO_RKA_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_RKA_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_RKA_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_RKA_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_RKA_01", 0, profileFile ) );
    putValue( KCAN__MSGID_RLS_01, getProfileInt( "Settings", "KCAN__MSGID_RLS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_RLS_01, getProfileInt( "Settings", "KCAN__MSGDLC_RLS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_RLS_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_RLS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_RLS_01, getProfileInt( "Settings", "KCAN__ALLDEF_RLS_01", 0, profileFile ) );
    putValue( KCAN__STMSG_RLS_01, getProfileInt( "Settings", "KCAN__STMSG_RLS_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_RLS_01, getProfileInt( "Settings", "KCAN__STMSGT_RLS_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_RLS_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_RLS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_RLS_01, getProfileInt( "Settings", "KCAN__STMSGSD_RLS_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_RLS_01, getProfileInt( "Settings", "KCAN__STMSGCT_RLS_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_RLS_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_RLS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_RLS_01, getProfileInt( "Settings", "KCAN__STMSG_PO_RLS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_RLS_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_RLS_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_RLS_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_RLS_01", 0, profileFile ) );
    putValue( KCAN__MSGID_RLS_02, getProfileInt( "Settings", "KCAN__MSGID_RLS_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_RLS_02, getProfileInt( "Settings", "KCAN__MSGDLC_RLS_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_RLS_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_RLS_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_RLS_02, getProfileInt( "Settings", "KCAN__ALLDEF_RLS_02", 0, profileFile ) );
    putValue( KCAN__STMSG_RLS_02, getProfileInt( "Settings", "KCAN__STMSG_RLS_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_RLS_02, getProfileInt( "Settings", "KCAN__STMSGT_RLS_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_RLS_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_RLS_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_RLS_02, getProfileInt( "Settings", "KCAN__STMSGSD_RLS_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_RLS_02, getProfileInt( "Settings", "KCAN__STMSGCT_RLS_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_RLS_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_RLS_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_RLS_02, getProfileInt( "Settings", "KCAN__STMSG_PO_RLS_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_RLS_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_RLS_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_RLS_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_RLS_02", 0, profileFile ) );
    putValue( KCAN__MSGID_SAL_01, getProfileInt( "Settings", "KCAN__MSGID_SAL_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_SAL_01, getProfileInt( "Settings", "KCAN__MSGDLC_SAL_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_SAL_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_SAL_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_SAL_01, getProfileInt( "Settings", "KCAN__ALLDEF_SAL_01", 0, profileFile ) );
    putValue( KCAN__STMSG_SAL_01, getProfileInt( "Settings", "KCAN__STMSG_SAL_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_SAL_01, getProfileInt( "Settings", "KCAN__STMSGT_SAL_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_SAL_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_SAL_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_SAL_01, getProfileInt( "Settings", "KCAN__STMSGSD_SAL_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_SAL_01, getProfileInt( "Settings", "KCAN__STMSGCT_SAL_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_SAL_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_SAL_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_SAL_01, getProfileInt( "Settings", "KCAN__STMSG_PO_SAL_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_SAL_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_SAL_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_SAL_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_SAL_01", 0, profileFile ) );
    putValue( KCAN__MSGID_SAM_01, getProfileInt( "Settings", "KCAN__MSGID_SAM_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_SAM_01, getProfileInt( "Settings", "KCAN__MSGDLC_SAM_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_SAM_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_SAM_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_SAM_01, getProfileInt( "Settings", "KCAN__ALLDEF_SAM_01", 0, profileFile ) );
    putValue( KCAN__STMSG_SAM_01, getProfileInt( "Settings", "KCAN__STMSG_SAM_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_SAM_01, getProfileInt( "Settings", "KCAN__STMSGT_SAM_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_SAM_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_SAM_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_SAM_01, getProfileInt( "Settings", "KCAN__STMSGSD_SAM_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_SAM_01, getProfileInt( "Settings", "KCAN__STMSGCT_SAM_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_SAM_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_SAM_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_SAM_01, getProfileInt( "Settings", "KCAN__STMSG_PO_SAM_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_SAM_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_SAM_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_SAM_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_SAM_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Sensorik_Dimmung_01, getProfileInt( "Settings", "KCAN__MSGID_Sensorik_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Sensorik_Dimmung_01, getProfileInt( "Settings", "KCAN__MSGDLC_Sensorik_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Sensorik_Dimmung_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Sensorik_Dimmung_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Sensorik_Dimmung_01, getProfileInt( "Settings", "KCAN__ALLDEF_Sensorik_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Sensorik_Dimmung_01, getProfileInt( "Settings", "KCAN__STMSG_Sensorik_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Sensorik_Dimmung_01, getProfileInt( "Settings", "KCAN__STMSGT_Sensorik_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Sensorik_Dimmung_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Sensorik_Dimmung_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Sensorik_Dimmung_01, getProfileInt( "Settings", "KCAN__STMSGSD_Sensorik_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Sensorik_Dimmung_01, getProfileInt( "Settings", "KCAN__STMSGCT_Sensorik_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Sensorik_Dimmung_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Sensorik_Dimmung_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Sensorik_Dimmung_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Sensorik_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Sensorik_Dimmung_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Sensorik_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Sensorik_Dimmung_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Sensorik_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__MSGID_SmaLi_Control_Frame_01, getProfileInt( "Settings", "KCAN__MSGID_SmaLi_Control_Frame_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_SmaLi_Control_Frame_01, getProfileInt( "Settings", "KCAN__MSGDLC_SmaLi_Control_Frame_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_SmaLi_Control_Frame_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_SmaLi_Control_Frame_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_SmaLi_Control_Frame_01, getProfileInt( "Settings", "KCAN__ALLDEF_SmaLi_Control_Frame_01", 0, profileFile ) );
    putValue( KCAN__STMSG_SmaLi_Control_Frame_01, getProfileInt( "Settings", "KCAN__STMSG_SmaLi_Control_Frame_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_SmaLi_Control_Frame_01, getProfileInt( "Settings", "KCAN__STMSGT_SmaLi_Control_Frame_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_SmaLi_Control_Frame_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_SmaLi_Control_Frame_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_SmaLi_Control_Frame_01, getProfileInt( "Settings", "KCAN__STMSGSD_SmaLi_Control_Frame_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_SmaLi_Control_Frame_01, getProfileInt( "Settings", "KCAN__STMSGCT_SmaLi_Control_Frame_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_SmaLi_Control_Frame_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_SmaLi_Control_Frame_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_SmaLi_Control_Frame_01, getProfileInt( "Settings", "KCAN__STMSG_PO_SmaLi_Control_Frame_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_SmaLi_Control_Frame_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_SmaLi_Control_Frame_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_SmaLi_Control_Frame_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_SmaLi_Control_Frame_01", 0, profileFile ) );
    putValue( KCAN__MSGID_SmaLi_Daten_Frame_01, getProfileInt( "Settings", "KCAN__MSGID_SmaLi_Daten_Frame_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_SmaLi_Daten_Frame_01, getProfileInt( "Settings", "KCAN__MSGDLC_SmaLi_Daten_Frame_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_SmaLi_Daten_Frame_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_SmaLi_Daten_Frame_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_SmaLi_Daten_Frame_01, getProfileInt( "Settings", "KCAN__ALLDEF_SmaLi_Daten_Frame_01", 0, profileFile ) );
    putValue( KCAN__STMSG_SmaLi_Daten_Frame_01, getProfileInt( "Settings", "KCAN__STMSG_SmaLi_Daten_Frame_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_SmaLi_Daten_Frame_01, getProfileInt( "Settings", "KCAN__STMSGT_SmaLi_Daten_Frame_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_SmaLi_Daten_Frame_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_SmaLi_Daten_Frame_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_SmaLi_Daten_Frame_01, getProfileInt( "Settings", "KCAN__STMSGSD_SmaLi_Daten_Frame_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_SmaLi_Daten_Frame_01, getProfileInt( "Settings", "KCAN__STMSGCT_SmaLi_Daten_Frame_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_SmaLi_Daten_Frame_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_SmaLi_Daten_Frame_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_SmaLi_Daten_Frame_01, getProfileInt( "Settings", "KCAN__STMSG_PO_SmaLi_Daten_Frame_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_SmaLi_Daten_Frame_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_SmaLi_Daten_Frame_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_SmaLi_Daten_Frame_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_SmaLi_Daten_Frame_01", 0, profileFile ) );
    putValue( KCAN__MSGID_SmaLi_Daten_Frame_02, getProfileInt( "Settings", "KCAN__MSGID_SmaLi_Daten_Frame_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_SmaLi_Daten_Frame_02, getProfileInt( "Settings", "KCAN__MSGDLC_SmaLi_Daten_Frame_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_SmaLi_Daten_Frame_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_SmaLi_Daten_Frame_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_SmaLi_Daten_Frame_02, getProfileInt( "Settings", "KCAN__ALLDEF_SmaLi_Daten_Frame_02", 0, profileFile ) );
    putValue( KCAN__STMSG_SmaLi_Daten_Frame_02, getProfileInt( "Settings", "KCAN__STMSG_SmaLi_Daten_Frame_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_SmaLi_Daten_Frame_02, getProfileInt( "Settings", "KCAN__STMSGT_SmaLi_Daten_Frame_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_SmaLi_Daten_Frame_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_SmaLi_Daten_Frame_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_SmaLi_Daten_Frame_02, getProfileInt( "Settings", "KCAN__STMSGSD_SmaLi_Daten_Frame_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_SmaLi_Daten_Frame_02, getProfileInt( "Settings", "KCAN__STMSGCT_SmaLi_Daten_Frame_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_SmaLi_Daten_Frame_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_SmaLi_Daten_Frame_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_SmaLi_Daten_Frame_02, getProfileInt( "Settings", "KCAN__STMSG_PO_SmaLi_Daten_Frame_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_SmaLi_Daten_Frame_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_SmaLi_Daten_Frame_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_SmaLi_Daten_Frame_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_SmaLi_Daten_Frame_02", 0, profileFile ) );
    putValue( KCAN__MSGID_SmaLi_Daten_Frame_03, getProfileInt( "Settings", "KCAN__MSGID_SmaLi_Daten_Frame_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_SmaLi_Daten_Frame_03, getProfileInt( "Settings", "KCAN__MSGDLC_SmaLi_Daten_Frame_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_SmaLi_Daten_Frame_03_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_SmaLi_Daten_Frame_03_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_SmaLi_Daten_Frame_03, getProfileInt( "Settings", "KCAN__ALLDEF_SmaLi_Daten_Frame_03", 0, profileFile ) );
    putValue( KCAN__STMSG_SmaLi_Daten_Frame_03, getProfileInt( "Settings", "KCAN__STMSG_SmaLi_Daten_Frame_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_SmaLi_Daten_Frame_03, getProfileInt( "Settings", "KCAN__STMSGT_SmaLi_Daten_Frame_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_SmaLi_Daten_Frame_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_SmaLi_Daten_Frame_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_SmaLi_Daten_Frame_03, getProfileInt( "Settings", "KCAN__STMSGSD_SmaLi_Daten_Frame_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_SmaLi_Daten_Frame_03, getProfileInt( "Settings", "KCAN__STMSGCT_SmaLi_Daten_Frame_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_SmaLi_Daten_Frame_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_SmaLi_Daten_Frame_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_SmaLi_Daten_Frame_03, getProfileInt( "Settings", "KCAN__STMSG_PO_SmaLi_Daten_Frame_03", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_SmaLi_Daten_Frame_03, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_SmaLi_Daten_Frame_03", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_SmaLi_Daten_Frame_03, getProfileInt( "Settings", "KCAN__MSG_SendNow_SmaLi_Daten_Frame_03", 0, profileFile ) );
    putValue( KCAN__MSGID_SmaLi_Daten_Frame_04, getProfileInt( "Settings", "KCAN__MSGID_SmaLi_Daten_Frame_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_SmaLi_Daten_Frame_04, getProfileInt( "Settings", "KCAN__MSGDLC_SmaLi_Daten_Frame_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_SmaLi_Daten_Frame_04_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_SmaLi_Daten_Frame_04_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_SmaLi_Daten_Frame_04, getProfileInt( "Settings", "KCAN__ALLDEF_SmaLi_Daten_Frame_04", 0, profileFile ) );
    putValue( KCAN__STMSG_SmaLi_Daten_Frame_04, getProfileInt( "Settings", "KCAN__STMSG_SmaLi_Daten_Frame_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_SmaLi_Daten_Frame_04, getProfileInt( "Settings", "KCAN__STMSGT_SmaLi_Daten_Frame_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_SmaLi_Daten_Frame_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_SmaLi_Daten_Frame_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_SmaLi_Daten_Frame_04, getProfileInt( "Settings", "KCAN__STMSGSD_SmaLi_Daten_Frame_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_SmaLi_Daten_Frame_04, getProfileInt( "Settings", "KCAN__STMSGCT_SmaLi_Daten_Frame_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_SmaLi_Daten_Frame_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_SmaLi_Daten_Frame_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_SmaLi_Daten_Frame_04, getProfileInt( "Settings", "KCAN__STMSG_PO_SmaLi_Daten_Frame_04", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_SmaLi_Daten_Frame_04, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_SmaLi_Daten_Frame_04", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_SmaLi_Daten_Frame_04, getProfileInt( "Settings", "KCAN__MSG_SendNow_SmaLi_Daten_Frame_04", 0, profileFile ) );
    putValue( KCAN__MSGID_SmaLi_Response_Frame_01, getProfileInt( "Settings", "KCAN__MSGID_SmaLi_Response_Frame_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_SmaLi_Response_Frame_01, getProfileInt( "Settings", "KCAN__MSGDLC_SmaLi_Response_Frame_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_SmaLi_Response_Frame_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_SmaLi_Response_Frame_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_SmaLi_Response_Frame_01, getProfileInt( "Settings", "KCAN__ALLDEF_SmaLi_Response_Frame_01", 0, profileFile ) );
    putValue( KCAN__STMSG_SmaLi_Response_Frame_01, getProfileInt( "Settings", "KCAN__STMSG_SmaLi_Response_Frame_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_SmaLi_Response_Frame_01, getProfileInt( "Settings", "KCAN__STMSGT_SmaLi_Response_Frame_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_SmaLi_Response_Frame_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_SmaLi_Response_Frame_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_SmaLi_Response_Frame_01, getProfileInt( "Settings", "KCAN__STMSGSD_SmaLi_Response_Frame_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_SmaLi_Response_Frame_01, getProfileInt( "Settings", "KCAN__STMSGCT_SmaLi_Response_Frame_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_SmaLi_Response_Frame_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_SmaLi_Response_Frame_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_SmaLi_Response_Frame_01, getProfileInt( "Settings", "KCAN__STMSG_PO_SmaLi_Response_Frame_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_SmaLi_Response_Frame_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_SmaLi_Response_Frame_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_SmaLi_Response_Frame_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_SmaLi_Response_Frame_01", 0, profileFile ) );
    putValue( KCAN__MSGID_SMLS_01, getProfileInt( "Settings", "KCAN__MSGID_SMLS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_SMLS_01, getProfileInt( "Settings", "KCAN__MSGDLC_SMLS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_SMLS_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_SMLS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_SMLS_01, getProfileInt( "Settings", "KCAN__ALLDEF_SMLS_01", 0, profileFile ) );
    putValue( KCAN__STMSG_SMLS_01, getProfileInt( "Settings", "KCAN__STMSG_SMLS_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_SMLS_01, getProfileInt( "Settings", "KCAN__STMSGT_SMLS_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_SMLS_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_SMLS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_SMLS_01, getProfileInt( "Settings", "KCAN__STMSGSD_SMLS_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_SMLS_01, getProfileInt( "Settings", "KCAN__STMSGCT_SMLS_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_SMLS_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_SMLS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_SMLS_01, getProfileInt( "Settings", "KCAN__STMSG_PO_SMLS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_SMLS_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_SMLS_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_SMLS_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_SMLS_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Systeminfo_01, getProfileInt( "Settings", "KCAN__MSGID_Systeminfo_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Systeminfo_01, getProfileInt( "Settings", "KCAN__MSGDLC_Systeminfo_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Systeminfo_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Systeminfo_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Systeminfo_01, getProfileInt( "Settings", "KCAN__ALLDEF_Systeminfo_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Systeminfo_01, getProfileInt( "Settings", "KCAN__STMSG_Systeminfo_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Systeminfo_01, getProfileInt( "Settings", "KCAN__STMSGT_Systeminfo_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Systeminfo_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Systeminfo_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Systeminfo_01, getProfileInt( "Settings", "KCAN__STMSGSD_Systeminfo_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Systeminfo_01, getProfileInt( "Settings", "KCAN__STMSGCT_Systeminfo_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Systeminfo_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Systeminfo_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Systeminfo_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Systeminfo_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Systeminfo_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Systeminfo_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Systeminfo_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Systeminfo_01", 0, profileFile ) );
    putValue( KCAN__MSGID_TA_01, getProfileInt( "Settings", "KCAN__MSGID_TA_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_TA_01, getProfileInt( "Settings", "KCAN__MSGDLC_TA_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_TA_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_TA_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_TA_01, getProfileInt( "Settings", "KCAN__ALLDEF_TA_01", 0, profileFile ) );
    putValue( KCAN__STMSG_TA_01, getProfileInt( "Settings", "KCAN__STMSG_TA_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_TA_01, getProfileInt( "Settings", "KCAN__STMSGT_TA_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_TA_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_TA_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_TA_01, getProfileInt( "Settings", "KCAN__STMSGSD_TA_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_TA_01, getProfileInt( "Settings", "KCAN__STMSGCT_TA_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_TA_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_TA_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_TA_01, getProfileInt( "Settings", "KCAN__STMSG_PO_TA_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_TA_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_TA_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_TA_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_TA_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Temperaturen_01, getProfileInt( "Settings", "KCAN__MSGID_Temperaturen_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Temperaturen_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Temperaturen_01_CTRL", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Temperaturen_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Temperaturen_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Temperaturen_01, getProfileInt( "Settings", "KCAN__ALLDEF_Temperaturen_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Temperaturen_01, getProfileInt( "Settings", "KCAN__STMSG_Temperaturen_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Temperaturen_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Temperaturen_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGT_Temperaturen_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Temperaturen_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Temperaturen_01, getProfileInt( "Settings", "KCAN__STMSGSD_Temperaturen_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Temperaturen_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Temperaturen_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Temperaturen_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Temperaturen_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Temperaturen_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Temperaturen_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Temperaturen_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Temperaturen_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Temperaturen_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Temperaturen_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Thermo_Verbrauch_01, getProfileInt( "Settings", "KCAN__MSGID_Thermo_Verbrauch_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Thermo_Verbrauch_01, getProfileInt( "Settings", "KCAN__MSGDLC_Thermo_Verbrauch_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Thermo_Verbrauch_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Thermo_Verbrauch_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Thermo_Verbrauch_01, getProfileInt( "Settings", "KCAN__ALLDEF_Thermo_Verbrauch_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Thermo_Verbrauch_01, getProfileInt( "Settings", "KCAN__STMSG_Thermo_Verbrauch_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Thermo_Verbrauch_01, getProfileInt( "Settings", "KCAN__STMSGT_Thermo_Verbrauch_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Thermo_Verbrauch_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Thermo_Verbrauch_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Thermo_Verbrauch_01, getProfileInt( "Settings", "KCAN__STMSGSD_Thermo_Verbrauch_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Thermo_Verbrauch_01, getProfileInt( "Settings", "KCAN__STMSGCT_Thermo_Verbrauch_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Thermo_Verbrauch_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Thermo_Verbrauch_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Thermo_Verbrauch_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Thermo_Verbrauch_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Thermo_Verbrauch_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Thermo_Verbrauch_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Thermo_Verbrauch_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Thermo_Verbrauch_01", 0, profileFile ) );
    putValue( KCAN__MSGID_TM_01, getProfileInt( "Settings", "KCAN__MSGID_TM_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_TM_01, getProfileInt( "Settings", "KCAN__MSGDLC_TM_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_TM_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_TM_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_TM_01, getProfileInt( "Settings", "KCAN__ALLDEF_TM_01", 0, profileFile ) );
    putValue( KCAN__STMSG_TM_01, getProfileInt( "Settings", "KCAN__STMSG_TM_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_TM_01, getProfileInt( "Settings", "KCAN__STMSGT_TM_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_TM_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_TM_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_TM_01, getProfileInt( "Settings", "KCAN__STMSGSD_TM_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_TM_01, getProfileInt( "Settings", "KCAN__STMSGCT_TM_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_TM_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_TM_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_TM_01, getProfileInt( "Settings", "KCAN__STMSG_PO_TM_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_TM_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_TM_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_TM_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_TM_01", 0, profileFile ) );
    putValue( KCAN__MSGID_TSG_BT_01, getProfileInt( "Settings", "KCAN__MSGID_TSG_BT_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_TSG_BT_01, getProfileInt( "Settings", "KCAN__MSGDLC_TSG_BT_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_TSG_BT_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_TSG_BT_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_TSG_BT_01, getProfileInt( "Settings", "KCAN__ALLDEF_TSG_BT_01", 0, profileFile ) );
    putValue( KCAN__STMSG_TSG_BT_01, getProfileInt( "Settings", "KCAN__STMSG_TSG_BT_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_TSG_BT_01, getProfileInt( "Settings", "KCAN__STMSGT_TSG_BT_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_TSG_BT_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_TSG_BT_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_TSG_BT_01, getProfileInt( "Settings", "KCAN__STMSGSD_TSG_BT_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_TSG_BT_01, getProfileInt( "Settings", "KCAN__STMSGCT_TSG_BT_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_TSG_BT_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_TSG_BT_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_TSG_BT_01, getProfileInt( "Settings", "KCAN__STMSG_PO_TSG_BT_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_TSG_BT_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_TSG_BT_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_TSG_BT_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_TSG_BT_01", 0, profileFile ) );
    putValue( KCAN__MSGID_TSG_FT_01, getProfileInt( "Settings", "KCAN__MSGID_TSG_FT_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_TSG_FT_01, getProfileInt( "Settings", "KCAN__MSGDLC_TSG_FT_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_TSG_FT_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_TSG_FT_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_TSG_FT_01, getProfileInt( "Settings", "KCAN__ALLDEF_TSG_FT_01", 0, profileFile ) );
    putValue( KCAN__STMSG_TSG_FT_01, getProfileInt( "Settings", "KCAN__STMSG_TSG_FT_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_TSG_FT_01, getProfileInt( "Settings", "KCAN__STMSGT_TSG_FT_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_TSG_FT_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_TSG_FT_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_TSG_FT_01, getProfileInt( "Settings", "KCAN__STMSGSD_TSG_FT_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_TSG_FT_01, getProfileInt( "Settings", "KCAN__STMSGCT_TSG_FT_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_TSG_FT_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_TSG_FT_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_TSG_FT_01, getProfileInt( "Settings", "KCAN__STMSG_PO_TSG_FT_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_TSG_FT_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_TSG_FT_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_TSG_FT_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_TSG_FT_01", 0, profileFile ) );
    putValue( KCAN__MSGID_TSG_FT_02, getProfileInt( "Settings", "KCAN__MSGID_TSG_FT_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_TSG_FT_02, getProfileInt( "Settings", "KCAN__MSGDLC_TSG_FT_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_TSG_FT_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_TSG_FT_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_TSG_FT_02, getProfileInt( "Settings", "KCAN__ALLDEF_TSG_FT_02", 0, profileFile ) );
    putValue( KCAN__STMSG_TSG_FT_02, getProfileInt( "Settings", "KCAN__STMSG_TSG_FT_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_TSG_FT_02, getProfileInt( "Settings", "KCAN__STMSGT_TSG_FT_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_TSG_FT_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_TSG_FT_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_TSG_FT_02, getProfileInt( "Settings", "KCAN__STMSGSD_TSG_FT_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_TSG_FT_02, getProfileInt( "Settings", "KCAN__STMSGCT_TSG_FT_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_TSG_FT_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_TSG_FT_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_TSG_FT_02, getProfileInt( "Settings", "KCAN__STMSG_PO_TSG_FT_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_TSG_FT_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_TSG_FT_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_TSG_FT_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_TSG_FT_02", 0, profileFile ) );
    putValue( KCAN__MSGID_TSG_HBFS_01, getProfileInt( "Settings", "KCAN__MSGID_TSG_HBFS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_TSG_HBFS_01, getProfileInt( "Settings", "KCAN__MSGDLC_TSG_HBFS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_TSG_HBFS_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_TSG_HBFS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_TSG_HBFS_01, getProfileInt( "Settings", "KCAN__ALLDEF_TSG_HBFS_01", 0, profileFile ) );
    putValue( KCAN__STMSG_TSG_HBFS_01, getProfileInt( "Settings", "KCAN__STMSG_TSG_HBFS_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_TSG_HBFS_01, getProfileInt( "Settings", "KCAN__STMSGT_TSG_HBFS_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_TSG_HBFS_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_TSG_HBFS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_TSG_HBFS_01, getProfileInt( "Settings", "KCAN__STMSGSD_TSG_HBFS_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_TSG_HBFS_01, getProfileInt( "Settings", "KCAN__STMSGCT_TSG_HBFS_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_TSG_HBFS_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_TSG_HBFS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_TSG_HBFS_01, getProfileInt( "Settings", "KCAN__STMSG_PO_TSG_HBFS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_TSG_HBFS_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_TSG_HBFS_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_TSG_HBFS_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_TSG_HBFS_01", 0, profileFile ) );
    putValue( KCAN__MSGID_TSG_HFS_01, getProfileInt( "Settings", "KCAN__MSGID_TSG_HFS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_TSG_HFS_01, getProfileInt( "Settings", "KCAN__MSGDLC_TSG_HFS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_TSG_HFS_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_TSG_HFS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_TSG_HFS_01, getProfileInt( "Settings", "KCAN__ALLDEF_TSG_HFS_01", 0, profileFile ) );
    putValue( KCAN__STMSG_TSG_HFS_01, getProfileInt( "Settings", "KCAN__STMSG_TSG_HFS_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_TSG_HFS_01, getProfileInt( "Settings", "KCAN__STMSGT_TSG_HFS_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_TSG_HFS_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_TSG_HFS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_TSG_HFS_01, getProfileInt( "Settings", "KCAN__STMSGSD_TSG_HFS_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_TSG_HFS_01, getProfileInt( "Settings", "KCAN__STMSGCT_TSG_HFS_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_TSG_HFS_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_TSG_HFS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_TSG_HFS_01, getProfileInt( "Settings", "KCAN__STMSG_PO_TSG_HFS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_TSG_HFS_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_TSG_HFS_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_TSG_HFS_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_TSG_HFS_01", 0, profileFile ) );
    putValue( KCAN__MSGID_UserStateServer_01, getProfileInt( "Settings", "KCAN__MSGID_UserStateServer_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_UserStateServer_01, getProfileInt( "Settings", "KCAN__MSGDLC_UserStateServer_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_UserStateServer_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_UserStateServer_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_UserStateServer_01, getProfileInt( "Settings", "KCAN__ALLDEF_UserStateServer_01", 0, profileFile ) );
    putValue( KCAN__STMSG_UserStateServer_01, getProfileInt( "Settings", "KCAN__STMSG_UserStateServer_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_UserStateServer_01, getProfileInt( "Settings", "KCAN__STMSGT_UserStateServer_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_UserStateServer_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_UserStateServer_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_UserStateServer_01, getProfileInt( "Settings", "KCAN__STMSGSD_UserStateServer_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_UserStateServer_01, getProfileInt( "Settings", "KCAN__STMSGCT_UserStateServer_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_UserStateServer_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_UserStateServer_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_UserStateServer_01, getProfileInt( "Settings", "KCAN__STMSG_PO_UserStateServer_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_UserStateServer_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_UserStateServer_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_UserStateServer_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_UserStateServer_01", 0, profileFile ) );
    putValue( KCAN__MSGID_VIN_01, getProfileInt( "Settings", "KCAN__MSGID_VIN_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_VIN_01, getProfileInt( "Settings", "KCAN__MSGDLC_VIN_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_VIN_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_VIN_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_VIN_01, getProfileInt( "Settings", "KCAN__ALLDEF_VIN_01", 0, profileFile ) );
    putValue( KCAN__STMSG_VIN_01, getProfileInt( "Settings", "KCAN__STMSG_VIN_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_VIN_01, getProfileInt( "Settings", "KCAN__STMSGT_VIN_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_VIN_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_VIN_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_VIN_01, getProfileInt( "Settings", "KCAN__STMSGSD_VIN_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_VIN_01, getProfileInt( "Settings", "KCAN__STMSGCT_VIN_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_VIN_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_VIN_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_VIN_01, getProfileInt( "Settings", "KCAN__STMSG_PO_VIN_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_VIN_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_VIN_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_VIN_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_VIN_01", 0, profileFile ) );
    putValue( KCAN__MSGID_VLK_01, getProfileInt( "Settings", "KCAN__MSGID_VLK_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_VLK_01, getProfileInt( "Settings", "KCAN__MSGDLC_VLK_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_VLK_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_VLK_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_VLK_01, getProfileInt( "Settings", "KCAN__ALLDEF_VLK_01", 0, profileFile ) );
    putValue( KCAN__STMSG_VLK_01, getProfileInt( "Settings", "KCAN__STMSG_VLK_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_VLK_01, getProfileInt( "Settings", "KCAN__STMSGT_VLK_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_VLK_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_VLK_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_VLK_01, getProfileInt( "Settings", "KCAN__STMSGSD_VLK_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_VLK_01, getProfileInt( "Settings", "KCAN__STMSGCT_VLK_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_VLK_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_VLK_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_VLK_01, getProfileInt( "Settings", "KCAN__STMSG_PO_VLK_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_VLK_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_VLK_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_VLK_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_VLK_01", 0, profileFile ) );
    putValue( KCAN__MSGID_VZE_04, getProfileInt( "Settings", "KCAN__MSGID_VZE_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_VZE_04, getProfileInt( "Settings", "KCAN__MSGDLC_VZE_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_VZE_04_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_VZE_04_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_VZE_04, getProfileInt( "Settings", "KCAN__ALLDEF_VZE_04", 0, profileFile ) );
    putValue( KCAN__STMSG_VZE_04, getProfileInt( "Settings", "KCAN__STMSG_VZE_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_VZE_04, getProfileInt( "Settings", "KCAN__STMSGT_VZE_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_VZE_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_VZE_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_VZE_04, getProfileInt( "Settings", "KCAN__STMSGSD_VZE_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_VZE_04, getProfileInt( "Settings", "KCAN__STMSGCT_VZE_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_VZE_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_VZE_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_VZE_04, getProfileInt( "Settings", "KCAN__STMSG_PO_VZE_04", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_VZE_04, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_VZE_04", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_VZE_04, getProfileInt( "Settings", "KCAN__MSG_SendNow_VZE_04", 0, profileFile ) );
    putValue( KCAN__MSGID_WBA_03, getProfileInt( "Settings", "KCAN__MSGID_WBA_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_WBA_03, getProfileInt( "Settings", "KCAN__MSGDLC_WBA_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_WBA_03_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_WBA_03_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_WBA_03, getProfileInt( "Settings", "KCAN__ALLDEF_WBA_03", 0, profileFile ) );
    putValue( KCAN__STMSG_WBA_03, getProfileInt( "Settings", "KCAN__STMSG_WBA_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_WBA_03, getProfileInt( "Settings", "KCAN__STMSGT_WBA_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_WBA_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_WBA_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_WBA_03, getProfileInt( "Settings", "KCAN__STMSGSD_WBA_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_WBA_03, getProfileInt( "Settings", "KCAN__STMSGCT_WBA_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_WBA_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_WBA_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_WBA_03, getProfileInt( "Settings", "KCAN__STMSG_PO_WBA_03", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_WBA_03, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_WBA_03", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_WBA_03, getProfileInt( "Settings", "KCAN__MSG_SendNow_WBA_03", 0, profileFile ) );
    putValue( KCAN__MSGID_WFS_01, getProfileInt( "Settings", "KCAN__MSGID_WFS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_WFS_01, getProfileInt( "Settings", "KCAN__MSGDLC_WFS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_WFS_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_WFS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_WFS_01, getProfileInt( "Settings", "KCAN__ALLDEF_WFS_01", 0, profileFile ) );
    putValue( KCAN__STMSG_WFS_01, getProfileInt( "Settings", "KCAN__STMSG_WFS_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_WFS_01, getProfileInt( "Settings", "KCAN__STMSGT_WFS_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_WFS_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_WFS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_WFS_01, getProfileInt( "Settings", "KCAN__STMSGSD_WFS_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_WFS_01, getProfileInt( "Settings", "KCAN__STMSGCT_WFS_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_WFS_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_WFS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_WFS_01, getProfileInt( "Settings", "KCAN__STMSG_PO_WFS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_WFS_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_WFS_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_WFS_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_WFS_01", 0, profileFile ) );
    putValue( KCAN__MSGID_WFS_Transponder_Req_02, getProfileInt( "Settings", "KCAN__MSGID_WFS_Transponder_Req_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_WFS_Transponder_Req_02, getProfileInt( "Settings", "KCAN__MSGDLC_WFS_Transponder_Req_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_WFS_Transponder_Req_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_WFS_Transponder_Req_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_WFS_Transponder_Req_02, getProfileInt( "Settings", "KCAN__ALLDEF_WFS_Transponder_Req_02", 0, profileFile ) );
    putValue( KCAN__STMSG_WFS_Transponder_Req_02, getProfileInt( "Settings", "KCAN__STMSG_WFS_Transponder_Req_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_WFS_Transponder_Req_02, getProfileInt( "Settings", "KCAN__STMSGT_WFS_Transponder_Req_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_WFS_Transponder_Req_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_WFS_Transponder_Req_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_WFS_Transponder_Req_02, getProfileInt( "Settings", "KCAN__STMSGSD_WFS_Transponder_Req_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_WFS_Transponder_Req_02, getProfileInt( "Settings", "KCAN__STMSGCT_WFS_Transponder_Req_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_WFS_Transponder_Req_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_WFS_Transponder_Req_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_WFS_Transponder_Req_02, getProfileInt( "Settings", "KCAN__STMSG_PO_WFS_Transponder_Req_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_WFS_Transponder_Req_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_WFS_Transponder_Req_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_WFS_Transponder_Req_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_WFS_Transponder_Req_02", 0, profileFile ) );
    putValue( KCAN__MSGID_WFS_Transponder_Resp_02, getProfileInt( "Settings", "KCAN__MSGID_WFS_Transponder_Resp_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_WFS_Transponder_Resp_02, getProfileInt( "Settings", "KCAN__MSGDLC_WFS_Transponder_Resp_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_WFS_Transponder_Resp_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_WFS_Transponder_Resp_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_WFS_Transponder_Resp_02, getProfileInt( "Settings", "KCAN__ALLDEF_WFS_Transponder_Resp_02", 0, profileFile ) );
    putValue( KCAN__STMSG_WFS_Transponder_Resp_02, getProfileInt( "Settings", "KCAN__STMSG_WFS_Transponder_Resp_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_WFS_Transponder_Resp_02, getProfileInt( "Settings", "KCAN__STMSGT_WFS_Transponder_Resp_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_WFS_Transponder_Resp_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_WFS_Transponder_Resp_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_WFS_Transponder_Resp_02, getProfileInt( "Settings", "KCAN__STMSGSD_WFS_Transponder_Resp_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_WFS_Transponder_Resp_02, getProfileInt( "Settings", "KCAN__STMSGCT_WFS_Transponder_Resp_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_WFS_Transponder_Resp_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_WFS_Transponder_Resp_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_WFS_Transponder_Resp_02, getProfileInt( "Settings", "KCAN__STMSG_PO_WFS_Transponder_Resp_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_WFS_Transponder_Resp_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_WFS_Transponder_Resp_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_WFS_Transponder_Resp_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_WFS_Transponder_Resp_02", 0, profileFile ) );
    putValue( KCAN__MSGID_WFS_Transponder_Status_02, getProfileInt( "Settings", "KCAN__MSGID_WFS_Transponder_Status_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_WFS_Transponder_Status_02, getProfileInt( "Settings", "KCAN__MSGDLC_WFS_Transponder_Status_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_WFS_Transponder_Status_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_WFS_Transponder_Status_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_WFS_Transponder_Status_02, getProfileInt( "Settings", "KCAN__ALLDEF_WFS_Transponder_Status_02", 0, profileFile ) );
    putValue( KCAN__STMSG_WFS_Transponder_Status_02, getProfileInt( "Settings", "KCAN__STMSG_WFS_Transponder_Status_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_WFS_Transponder_Status_02, getProfileInt( "Settings", "KCAN__STMSGT_WFS_Transponder_Status_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_WFS_Transponder_Status_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_WFS_Transponder_Status_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_WFS_Transponder_Status_02, getProfileInt( "Settings", "KCAN__STMSGSD_WFS_Transponder_Status_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_WFS_Transponder_Status_02, getProfileInt( "Settings", "KCAN__STMSGCT_WFS_Transponder_Status_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_WFS_Transponder_Status_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_WFS_Transponder_Status_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_WFS_Transponder_Status_02, getProfileInt( "Settings", "KCAN__STMSG_PO_WFS_Transponder_Status_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_WFS_Transponder_Status_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_WFS_Transponder_Status_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_WFS_Transponder_Status_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_WFS_Transponder_Status_02", 0, profileFile ) );
    putValue( KCAN__MSGID_Wischer_01, getProfileInt( "Settings", "KCAN__MSGID_Wischer_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Wischer_01, getProfileInt( "Settings", "KCAN__MSGDLC_Wischer_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Wischer_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Wischer_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Wischer_01, getProfileInt( "Settings", "KCAN__ALLDEF_Wischer_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Wischer_01, getProfileInt( "Settings", "KCAN__STMSG_Wischer_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Wischer_01, getProfileInt( "Settings", "KCAN__STMSGT_Wischer_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Wischer_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Wischer_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Wischer_01, getProfileInt( "Settings", "KCAN__STMSGSD_Wischer_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Wischer_01, getProfileInt( "Settings", "KCAN__STMSGCT_Wischer_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Wischer_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Wischer_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Wischer_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Wischer_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Wischer_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Wischer_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Wischer_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Wischer_01", 0, profileFile ) );
    putValue( KCAN__MSGID_WLC1_01, getProfileInt( "Settings", "KCAN__MSGID_WLC1_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_WLC1_01, getProfileInt( "Settings", "KCAN__MSGDLC_WLC1_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_WLC1_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_WLC1_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_WLC1_01, getProfileInt( "Settings", "KCAN__ALLDEF_WLC1_01", 0, profileFile ) );
    putValue( KCAN__STMSG_WLC1_01, getProfileInt( "Settings", "KCAN__STMSG_WLC1_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_WLC1_01, getProfileInt( "Settings", "KCAN__STMSGT_WLC1_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_WLC1_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_WLC1_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_WLC1_01, getProfileInt( "Settings", "KCAN__STMSGSD_WLC1_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_WLC1_01, getProfileInt( "Settings", "KCAN__STMSGCT_WLC1_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_WLC1_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_WLC1_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_WLC1_01, getProfileInt( "Settings", "KCAN__STMSG_PO_WLC1_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_WLC1_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_WLC1_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_WLC1_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_WLC1_01", 0, profileFile ) );
    putValue( KCAN__MSGID_XCP_SmaLi_CRO_01, getProfileInt( "Settings", "KCAN__MSGID_XCP_SmaLi_CRO_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_XCP_SmaLi_CRO_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_XCP_SmaLi_CRO_01_CTRL", 0, profileFile ) );
    putValue( KCAN__MSGDLC_XCP_SmaLi_CRO_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_XCP_SmaLi_CRO_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_XCP_SmaLi_CRO_01, getProfileInt( "Settings", "KCAN__ALLDEF_XCP_SmaLi_CRO_01", 0, profileFile ) );
    putValue( KCAN__STMSG_XCP_SmaLi_CRO_01, getProfileInt( "Settings", "KCAN__STMSG_XCP_SmaLi_CRO_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_XCP_SmaLi_CRO_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_XCP_SmaLi_CRO_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGT_XCP_SmaLi_CRO_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_XCP_SmaLi_CRO_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_XCP_SmaLi_CRO_01, getProfileInt( "Settings", "KCAN__STMSGSD_XCP_SmaLi_CRO_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_XCP_SmaLi_CRO_01, getProfileInt( "Settings", "KCAN__STMSGCT_XCP_SmaLi_CRO_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_XCP_SmaLi_CRO_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_XCP_SmaLi_CRO_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_XCP_SmaLi_CRO_01, getProfileInt( "Settings", "KCAN__STMSG_PO_XCP_SmaLi_CRO_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_XCP_SmaLi_CRO_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_XCP_SmaLi_CRO_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_XCP_SmaLi_CRO_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_XCP_SmaLi_CRO_01", 0, profileFile ) );
    putValue( KCAN__MSGID_XCP_SmaLi_DTO_01, getProfileInt( "Settings", "KCAN__MSGID_XCP_SmaLi_DTO_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_XCP_SmaLi_DTO_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_XCP_SmaLi_DTO_01_CTRL", 0, profileFile ) );
    putValue( KCAN__MSGDLC_XCP_SmaLi_DTO_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_XCP_SmaLi_DTO_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_XCP_SmaLi_DTO_01, getProfileInt( "Settings", "KCAN__ALLDEF_XCP_SmaLi_DTO_01", 0, profileFile ) );
    putValue( KCAN__STMSG_XCP_SmaLi_DTO_01, getProfileInt( "Settings", "KCAN__STMSG_XCP_SmaLi_DTO_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_XCP_SmaLi_DTO_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_XCP_SmaLi_DTO_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGT_XCP_SmaLi_DTO_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_XCP_SmaLi_DTO_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_XCP_SmaLi_DTO_01, getProfileInt( "Settings", "KCAN__STMSGSD_XCP_SmaLi_DTO_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_XCP_SmaLi_DTO_01, getProfileInt( "Settings", "KCAN__STMSGCT_XCP_SmaLi_DTO_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_XCP_SmaLi_DTO_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_XCP_SmaLi_DTO_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_XCP_SmaLi_DTO_01, getProfileInt( "Settings", "KCAN__STMSG_PO_XCP_SmaLi_DTO_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_XCP_SmaLi_DTO_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_XCP_SmaLi_DTO_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_XCP_SmaLi_DTO_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_XCP_SmaLi_DTO_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Zeitmaster_02, getProfileInt( "Settings", "KCAN__MSGID_Zeitmaster_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Zeitmaster_02, getProfileInt( "Settings", "KCAN__MSGDLC_Zeitmaster_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Zeitmaster_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Zeitmaster_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Zeitmaster_02, getProfileInt( "Settings", "KCAN__ALLDEF_Zeitmaster_02", 0, profileFile ) );
    putValue( KCAN__STMSG_Zeitmaster_02, getProfileInt( "Settings", "KCAN__STMSG_Zeitmaster_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_Zeitmaster_02, getProfileInt( "Settings", "KCAN__STMSGT_Zeitmaster_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_Zeitmaster_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Zeitmaster_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Zeitmaster_02, getProfileInt( "Settings", "KCAN__STMSGSD_Zeitmaster_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Zeitmaster_02, getProfileInt( "Settings", "KCAN__STMSGCT_Zeitmaster_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Zeitmaster_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Zeitmaster_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Zeitmaster_02, getProfileInt( "Settings", "KCAN__STMSG_PO_Zeitmaster_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Zeitmaster_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Zeitmaster_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Zeitmaster_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_Zeitmaster_02", 0, profileFile ) );
    putValue( KCAN__MSGID_Zentralrechner_01, getProfileInt( "Settings", "KCAN__MSGID_Zentralrechner_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Zentralrechner_01, getProfileInt( "Settings", "KCAN__MSGDLC_Zentralrechner_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Zentralrechner_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Zentralrechner_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Zentralrechner_01, getProfileInt( "Settings", "KCAN__ALLDEF_Zentralrechner_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Zentralrechner_01, getProfileInt( "Settings", "KCAN__STMSG_Zentralrechner_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Zentralrechner_01, getProfileInt( "Settings", "KCAN__STMSGT_Zentralrechner_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Zentralrechner_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Zentralrechner_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Zentralrechner_01, getProfileInt( "Settings", "KCAN__STMSGSD_Zentralrechner_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Zentralrechner_01, getProfileInt( "Settings", "KCAN__STMSGCT_Zentralrechner_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Zentralrechner_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Zentralrechner_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Zentralrechner_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Zentralrechner_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Zentralrechner_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Zentralrechner_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Zentralrechner_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Zentralrechner_01", 0, profileFile ) );
    putValue( KCAN__MSGID_ZV_02, getProfileInt( "Settings", "KCAN__MSGID_ZV_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ZV_02, getProfileInt( "Settings", "KCAN__MSGDLC_ZV_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ZV_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ZV_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ZV_02, getProfileInt( "Settings", "KCAN__ALLDEF_ZV_02", 0, profileFile ) );
    putValue( KCAN__STMSG_ZV_02, getProfileInt( "Settings", "KCAN__STMSG_ZV_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_ZV_02, getProfileInt( "Settings", "KCAN__STMSGT_ZV_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_ZV_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ZV_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ZV_02, getProfileInt( "Settings", "KCAN__STMSGSD_ZV_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ZV_02, getProfileInt( "Settings", "KCAN__STMSGCT_ZV_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ZV_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ZV_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ZV_02, getProfileInt( "Settings", "KCAN__STMSG_PO_ZV_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ZV_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ZV_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ZV_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_ZV_02", 0, profileFile ) );
    putValue( KCAN__MSGID_ZV_04, getProfileInt( "Settings", "KCAN__MSGID_ZV_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ZV_04, getProfileInt( "Settings", "KCAN__MSGDLC_ZV_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ZV_04_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ZV_04_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ZV_04, getProfileInt( "Settings", "KCAN__ALLDEF_ZV_04", 0, profileFile ) );
    putValue( KCAN__STMSG_ZV_04, getProfileInt( "Settings", "KCAN__STMSG_ZV_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_ZV_04, getProfileInt( "Settings", "KCAN__STMSGT_ZV_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_ZV_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ZV_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ZV_04, getProfileInt( "Settings", "KCAN__STMSGSD_ZV_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ZV_04, getProfileInt( "Settings", "KCAN__STMSGCT_ZV_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ZV_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ZV_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ZV_04, getProfileInt( "Settings", "KCAN__STMSG_PO_ZV_04", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ZV_04, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ZV_04", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ZV_04, getProfileInt( "Settings", "KCAN__MSG_SendNow_ZV_04", 0, profileFile ) );
    putValue( KCAN__NMH_Fahrerdisplay_Kombi_NM_Request, getProfileInt( "Settings", "KCAN__NMH_Fahrerdisplay_Kombi_NM_Request", 0, profileFile ) );
    putValue( KCAN__NMH_Fahrerdisplay_Kombi_AutomaticModeActive, getProfileInt( "Settings", "KCAN__NMH_Fahrerdisplay_Kombi_AutomaticModeActive", 0, profileFile ) );
    putValue( KCAN__NMH_Fahrerdisplay_Kombi_CommActive, getProfileInt( "Settings", "KCAN__NMH_Fahrerdisplay_Kombi_CommActive", 0, profileFile ) );
    putValue( KCAN__NMH_Fahrerdisplay_Kombi_RequestBusCom, getProfileInt( "Settings", "KCAN__NMH_Fahrerdisplay_Kombi_RequestBusCom", 0, profileFile ) );
    putValue( KCAN__STOP_Fahrerdisplay_Kombi_MESSAGES_OFF, getProfileInt( "Settings", "KCAN__STOP_Fahrerdisplay_Kombi_MESSAGES_OFF", 0, profileFile ) );
    putValue( KCAN__STOP_Fahrerdisplay_Kombi_MESSAGES_ON, getProfileInt( "Settings", "KCAN__STOP_Fahrerdisplay_Kombi_MESSAGES_ON", 0, profileFile ) );
    putValue( KCAN__STMSG_NMH_Fahrerdisplay_Kombi, getProfileInt( "Settings", "KCAN__STMSG_NMH_Fahrerdisplay_Kombi", 0, profileFile ) );
    putValue( KCAN__STMSGT_NMH_Fahrerdisplay_Kombi, getProfileInt( "Settings", "KCAN__STMSGT_NMH_Fahrerdisplay_Kombi", 0, profileFile ) );
    putValue( KCAN__NMH_Fahrerdisplay_Kombi_Manually_Request_NM, getProfileInt( "Settings", "KCAN__NMH_Fahrerdisplay_Kombi_Manually_Request_NM", 0, profileFile ) );
    putValue( KCAN__NMH_Fahrerdisplay_Kombi_RequestID, getProfileInt( "Settings", "KCAN__NMH_Fahrerdisplay_Kombi_RequestID", 0, profileFile ) );
    putValue( KCAN__NMH_Fahrerdisplay_Kombi_Remote_SetCommRequest, getProfileInt( "Settings", "KCAN__NMH_Fahrerdisplay_Kombi_Remote_SetCommRequest", 0, profileFile ) );
    putValue( KCAN__NMH_Fahrerdisplay_Kombi_Remote_ReleaseCommRequest, getProfileInt( "Settings", "KCAN__NMH_Fahrerdisplay_Kombi_Remote_ReleaseCommRequest", 0, profileFile ) );
    putValue( KCAN__NMH_ICAS1_Gateway_NM_Request, getProfileInt( "Settings", "KCAN__NMH_ICAS1_Gateway_NM_Request", 0, profileFile ) );
    putValue( KCAN__NMH_ICAS1_Gateway_AutomaticModeActive, getProfileInt( "Settings", "KCAN__NMH_ICAS1_Gateway_AutomaticModeActive", 0, profileFile ) );
    putValue( KCAN__NMH_ICAS1_Gateway_CommActive, getProfileInt( "Settings", "KCAN__NMH_ICAS1_Gateway_CommActive", 0, profileFile ) );
    putValue( KCAN__NMH_ICAS1_Gateway_RequestBusCom, getProfileInt( "Settings", "KCAN__NMH_ICAS1_Gateway_RequestBusCom", 0, profileFile ) );
    putValue( KCAN__STOP_ICAS1_Gateway_MESSAGES_OFF, getProfileInt( "Settings", "KCAN__STOP_ICAS1_Gateway_MESSAGES_OFF", 0, profileFile ) );
    putValue( KCAN__STOP_ICAS1_Gateway_MESSAGES_ON, getProfileInt( "Settings", "KCAN__STOP_ICAS1_Gateway_MESSAGES_ON", 0, profileFile ) );
    putValue( KCAN__STMSG_NMH_ICAS1_Gateway, getProfileInt( "Settings", "KCAN__STMSG_NMH_ICAS1_Gateway", 0, profileFile ) );
    putValue( KCAN__STMSGT_NMH_ICAS1_Gateway, getProfileInt( "Settings", "KCAN__STMSGT_NMH_ICAS1_Gateway", 0, profileFile ) );
    putValue( KCAN__NMH_ICAS1_Gateway_Manually_Request_NM, getProfileInt( "Settings", "KCAN__NMH_ICAS1_Gateway_Manually_Request_NM", 0, profileFile ) );
    putValue( KCAN__NMH_ICAS1_Gateway_RequestID, getProfileInt( "Settings", "KCAN__NMH_ICAS1_Gateway_RequestID", 0, profileFile ) );
    putValue( KCAN__NMH_ICAS1_Gateway_Remote_SetCommRequest, getProfileInt( "Settings", "KCAN__NMH_ICAS1_Gateway_Remote_SetCommRequest", 0, profileFile ) );
    putValue( KCAN__NMH_ICAS1_Gateway_Remote_ReleaseCommRequest, getProfileInt( "Settings", "KCAN__NMH_ICAS1_Gateway_Remote_ReleaseCommRequest", 0, profileFile ) );
    putValue( KCAN__NMH_HUD_NM_Request, getProfileInt( "Settings", "KCAN__NMH_HUD_NM_Request", 0, profileFile ) );
    putValue( KCAN__NMH_HUD_AutomaticModeActive, getProfileInt( "Settings", "KCAN__NMH_HUD_AutomaticModeActive", 0, profileFile ) );
    putValue( KCAN__NMH_HUD_CommActive, getProfileInt( "Settings", "KCAN__NMH_HUD_CommActive", 0, profileFile ) );
    putValue( KCAN__NMH_HUD_RequestBusCom, getProfileInt( "Settings", "KCAN__NMH_HUD_RequestBusCom", 0, profileFile ) );
    putValue( KCAN__STOP_HUD_MESSAGES_OFF, getProfileInt( "Settings", "KCAN__STOP_HUD_MESSAGES_OFF", 0, profileFile ) );
    putValue( KCAN__STOP_HUD_MESSAGES_ON, getProfileInt( "Settings", "KCAN__STOP_HUD_MESSAGES_ON", 0, profileFile ) );
    putValue( KCAN__NMH_HUD_Manually_Request_NM, getProfileInt( "Settings", "KCAN__NMH_HUD_Manually_Request_NM", 0, profileFile ) );
    putValue( KCAN__NMH_HUD_RequestID, getProfileInt( "Settings", "KCAN__NMH_HUD_RequestID", 0, profileFile ) );
    putValue( KCAN__NMH_HUD_Remote_SetCommRequest, getProfileInt( "Settings", "KCAN__NMH_HUD_Remote_SetCommRequest", 0, profileFile ) );
    putValue( KCAN__NMH_HUD_Remote_ReleaseCommRequest, getProfileInt( "Settings", "KCAN__NMH_HUD_Remote_ReleaseCommRequest", 0, profileFile ) );
    putValue( KCAN__NMH_ICAS3_Gateway_NM_Request, getProfileInt( "Settings", "KCAN__NMH_ICAS3_Gateway_NM_Request", 0, profileFile ) );
    putValue( KCAN__NMH_ICAS3_Gateway_AutomaticModeActive, getProfileInt( "Settings", "KCAN__NMH_ICAS3_Gateway_AutomaticModeActive", 0, profileFile ) );
    putValue( KCAN__NMH_ICAS3_Gateway_CommActive, getProfileInt( "Settings", "KCAN__NMH_ICAS3_Gateway_CommActive", 0, profileFile ) );
    putValue( KCAN__NMH_ICAS3_Gateway_RequestBusCom, getProfileInt( "Settings", "KCAN__NMH_ICAS3_Gateway_RequestBusCom", 0, profileFile ) );
    putValue( KCAN__STOP_ICAS3_Gateway_MESSAGES_OFF, getProfileInt( "Settings", "KCAN__STOP_ICAS3_Gateway_MESSAGES_OFF", 0, profileFile ) );
    putValue( KCAN__STOP_ICAS3_Gateway_MESSAGES_ON, getProfileInt( "Settings", "KCAN__STOP_ICAS3_Gateway_MESSAGES_ON", 0, profileFile ) );
    putValue( KCAN__STMSG_NMH_ICAS3_Gateway, getProfileInt( "Settings", "KCAN__STMSG_NMH_ICAS3_Gateway", 0, profileFile ) );
    putValue( KCAN__STMSGT_NMH_ICAS3_Gateway, getProfileInt( "Settings", "KCAN__STMSGT_NMH_ICAS3_Gateway", 0, profileFile ) );
    putValue( KCAN__NMH_ICAS3_Gateway_Manually_Request_NM, getProfileInt( "Settings", "KCAN__NMH_ICAS3_Gateway_Manually_Request_NM", 0, profileFile ) );
    putValue( KCAN__NMH_ICAS3_Gateway_RequestID, getProfileInt( "Settings", "KCAN__NMH_ICAS3_Gateway_RequestID", 0, profileFile ) );
    putValue( KCAN__NMH_ICAS3_Gateway_Remote_SetCommRequest, getProfileInt( "Settings", "KCAN__NMH_ICAS3_Gateway_Remote_SetCommRequest", 0, profileFile ) );
    putValue( KCAN__NMH_ICAS3_Gateway_Remote_ReleaseCommRequest, getProfileInt( "Settings", "KCAN__NMH_ICAS3_Gateway_Remote_ReleaseCommRequest", 0, profileFile ) );
    putValue( KCAN__NMH_ZR_MIB_TOP_ab_Gen3_NM_Request, getProfileInt( "Settings", "KCAN__NMH_ZR_MIB_TOP_ab_Gen3_NM_Request", 0, profileFile ) );
    putValue( KCAN__NMH_ZR_MIB_TOP_ab_Gen3_AutomaticModeActive, getProfileInt( "Settings", "KCAN__NMH_ZR_MIB_TOP_ab_Gen3_AutomaticModeActive", 0, profileFile ) );
    putValue( KCAN__NMH_ZR_MIB_TOP_ab_Gen3_CommActive, getProfileInt( "Settings", "KCAN__NMH_ZR_MIB_TOP_ab_Gen3_CommActive", 0, profileFile ) );
    putValue( KCAN__NMH_ZR_MIB_TOP_ab_Gen3_RequestBusCom, getProfileInt( "Settings", "KCAN__NMH_ZR_MIB_TOP_ab_Gen3_RequestBusCom", 0, profileFile ) );
    putValue( KCAN__STOP_ZR_MIB_TOP_ab_Gen3_MESSAGES_OFF, getProfileInt( "Settings", "KCAN__STOP_ZR_MIB_TOP_ab_Gen3_MESSAGES_OFF", 0, profileFile ) );
    putValue( KCAN__STOP_ZR_MIB_TOP_ab_Gen3_MESSAGES_ON, getProfileInt( "Settings", "KCAN__STOP_ZR_MIB_TOP_ab_Gen3_MESSAGES_ON", 0, profileFile ) );
    putValue( KCAN__STMSG_NMH_ZR_MIB_TOP_ab_Gen3, getProfileInt( "Settings", "KCAN__STMSG_NMH_ZR_MIB_TOP_ab_Gen3", 0, profileFile ) );
    putValue( KCAN__STMSGT_NMH_ZR_MIB_TOP_ab_Gen3, getProfileInt( "Settings", "KCAN__STMSGT_NMH_ZR_MIB_TOP_ab_Gen3", 0, profileFile ) );
    putValue( KCAN__NMH_ZR_MIB_TOP_ab_Gen3_Manually_Request_NM, getProfileInt( "Settings", "KCAN__NMH_ZR_MIB_TOP_ab_Gen3_Manually_Request_NM", 0, profileFile ) );
    putValue( KCAN__NMH_ZR_MIB_TOP_ab_Gen3_RequestID, getProfileInt( "Settings", "KCAN__NMH_ZR_MIB_TOP_ab_Gen3_RequestID", 0, profileFile ) );
    putValue( KCAN__NMH_ZR_MIB_TOP_ab_Gen3_Remote_SetCommRequest, getProfileInt( "Settings", "KCAN__NMH_ZR_MIB_TOP_ab_Gen3_Remote_SetCommRequest", 0, profileFile ) );
    putValue( KCAN__NMH_ZR_MIB_TOP_ab_Gen3_Remote_ReleaseCommRequest, getProfileInt( "Settings", "KCAN__NMH_ZR_MIB_TOP_ab_Gen3_Remote_ReleaseCommRequest", 0, profileFile ) );
    putValue( KCAN__NMH_Kombi_NM_Request, getProfileInt( "Settings", "KCAN__NMH_Kombi_NM_Request", 0, profileFile ) );
    putValue( KCAN__NMH_Kombi_AutomaticModeActive, getProfileInt( "Settings", "KCAN__NMH_Kombi_AutomaticModeActive", 0, profileFile ) );
    putValue( KCAN__NMH_Kombi_CommActive, getProfileInt( "Settings", "KCAN__NMH_Kombi_CommActive", 0, profileFile ) );
    putValue( KCAN__NMH_Kombi_RequestBusCom, getProfileInt( "Settings", "KCAN__NMH_Kombi_RequestBusCom", 0, profileFile ) );
    putValue( KCAN__STOP_Kombi_MESSAGES_OFF, getProfileInt( "Settings", "KCAN__STOP_Kombi_MESSAGES_OFF", 0, profileFile ) );
    putValue( KCAN__STOP_Kombi_MESSAGES_ON, getProfileInt( "Settings", "KCAN__STOP_Kombi_MESSAGES_ON", 0, profileFile ) );
    putValue( KCAN__NMH_Kombi_Manually_Request_NM, getProfileInt( "Settings", "KCAN__NMH_Kombi_Manually_Request_NM", 0, profileFile ) );
    putValue( KCAN__NMH_Kombi_RequestID, getProfileInt( "Settings", "KCAN__NMH_Kombi_RequestID", 0, profileFile ) );
    putValue( KCAN__NMH_Kombi_Remote_SetCommRequest, getProfileInt( "Settings", "KCAN__NMH_Kombi_Remote_SetCommRequest", 0, profileFile ) );
    putValue( KCAN__NMH_Kombi_Remote_ReleaseCommRequest, getProfileInt( "Settings", "KCAN__NMH_Kombi_Remote_ReleaseCommRequest", 0, profileFile ) );
    putValue( KCAN__NMH_SmartLight_01_NM_Request, getProfileInt( "Settings", "KCAN__NMH_SmartLight_01_NM_Request", 0, profileFile ) );
    putValue( KCAN__NMH_SmartLight_01_AutomaticModeActive, getProfileInt( "Settings", "KCAN__NMH_SmartLight_01_AutomaticModeActive", 0, profileFile ) );
    putValue( KCAN__NMH_SmartLight_01_CommActive, getProfileInt( "Settings", "KCAN__NMH_SmartLight_01_CommActive", 0, profileFile ) );
    putValue( KCAN__NMH_SmartLight_01_RequestBusCom, getProfileInt( "Settings", "KCAN__NMH_SmartLight_01_RequestBusCom", 0, profileFile ) );
    putValue( KCAN__STOP_SmartLight_01_MESSAGES_OFF, getProfileInt( "Settings", "KCAN__STOP_SmartLight_01_MESSAGES_OFF", 0, profileFile ) );
    putValue( KCAN__STOP_SmartLight_01_MESSAGES_ON, getProfileInt( "Settings", "KCAN__STOP_SmartLight_01_MESSAGES_ON", 0, profileFile ) );
    putValue( KCAN__STMSG_NMH_SmartLight_01, getProfileInt( "Settings", "KCAN__STMSG_NMH_SmartLight_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_NMH_SmartLight_01, getProfileInt( "Settings", "KCAN__STMSGT_NMH_SmartLight_01", 0, profileFile ) );
    putValue( KCAN__NMH_SmartLight_01_Manually_Request_NM, getProfileInt( "Settings", "KCAN__NMH_SmartLight_01_Manually_Request_NM", 0, profileFile ) );
    putValue( KCAN__NMH_SmartLight_01_RequestID, getProfileInt( "Settings", "KCAN__NMH_SmartLight_01_RequestID", 0, profileFile ) );
    putValue( KCAN__NMH_SmartLight_01_Remote_SetCommRequest, getProfileInt( "Settings", "KCAN__NMH_SmartLight_01_Remote_SetCommRequest", 0, profileFile ) );
    putValue( KCAN__NMH_SmartLight_01_Remote_ReleaseCommRequest, getProfileInt( "Settings", "KCAN__NMH_SmartLight_01_Remote_ReleaseCommRequest", 0, profileFile ) );
    putValue( eAllVol, getProfileInt( "Settings", "eAllVol", 0, profileFile ) );
    putValue( ENV_SI_CAB_14_Active, getProfileInt( "Settings", "ENV_SI_CAB_14_Active", 0, profileFile ) );
    putValue( ENV_SI_CAB_13_Active, getProfileInt( "Settings", "ENV_SI_CAB_13_Active", 0, profileFile ) );
    putValue( ENV_SI_CAB_12_Active, getProfileInt( "Settings", "ENV_SI_CAB_12_Active", 0, profileFile ) );
    putValue( ENV_SI_CAB_11_Active, getProfileInt( "Settings", "ENV_SI_CAB_11_Active", 0, profileFile ) );
    putValue( ENV_SI_CAB_10_Active, getProfileInt( "Settings", "ENV_SI_CAB_10_Active", 0, profileFile ) );
    putValue( ENV_SI_CAB_09_Active, getProfileInt( "Settings", "ENV_SI_CAB_09_Active", 0, profileFile ) );
    putValue( ENV_SI_CAB_08_Active, getProfileInt( "Settings", "ENV_SI_CAB_08_Active", 0, profileFile ) );
    putValue( ENV_SI_CAB_07_Active, getProfileInt( "Settings", "ENV_SI_CAB_07_Active", 0, profileFile ) );
    putValue( ENV_SI_CAB_06_Active, getProfileInt( "Settings", "ENV_SI_CAB_06_Active", 0, profileFile ) );
    putValue( ENV_SI_CAB_05_Active, getProfileInt( "Settings", "ENV_SI_CAB_05_Active", 0, profileFile ) );
    putValue( ENV_SI_CAB_04_Active, getProfileInt( "Settings", "ENV_SI_CAB_04_Active", 0, profileFile ) );
    putValue( ENV_SI_CAB_03_Active, getProfileInt( "Settings", "ENV_SI_CAB_03_Active", 0, profileFile ) );
    putValue( ENV_SI_CAB_02_Active, getProfileInt( "Settings", "ENV_SI_CAB_02_Active", 0, profileFile ) );
    putValue( ENV_SI_CAB_01_Active, getProfileInt( "Settings", "ENV_SI_CAB_01_Active", 0, profileFile ) );
    putValue( ENV_PowermeterStart, getProfileFloat( "Settings", "ENV_PowermeterStart", 0, profileFile ) );
    putValue( ENV_PowermeterSteps, getProfileInt( "Settings", "ENV_PowermeterSteps", 0, profileFile ) );
    putValue( ENV_PowermeterSweep, getProfileInt( "Settings", "ENV_PowermeterSweep", 0, profileFile ) );
    putValue( ENV_PowermeterRandom, getProfileInt( "Settings", "ENV_PowermeterRandom", 0, profileFile ) );
    putValue( ENV_PowermeterEnd, getProfileFloat( "Settings", "ENV_PowermeterEnd", 0, profileFile ) );
    putValue( ENV_PowermeterTime, getProfileInt( "Settings", "ENV_PowermeterTime", 0, profileFile ) );
    putValue( ENV_All_Test, getProfileInt( "Settings", "ENV_All_Test", 0, profileFile ) );
    putValue( ENV_AllVol, getProfileInt( "Settings", "ENV_AllVol", 0, profileFile ) );
    putValue( ENV_AllWarn, getProfileInt( "Settings", "ENV_AllWarn", 0, profileFile ) );
    putValue( ENV_AllWarnLightComf, getProfileInt( "Settings", "ENV_AllWarnLightComf", 0, profileFile ) );
    putValue( ENV_BAPLoadSettings, getProfileInt( "Settings", "ENV_BAPLoadSettings", 0, profileFile ) );
    putValue( ENV_BAPSaveSettings, getProfileInt( "Settings", "ENV_BAPSaveSettings", 0, profileFile ) );
    putValue( ENV_BoosterDelay, getProfileInt( "Settings", "ENV_BoosterDelay", 0, profileFile ) );
    putValue( ENV_BoosterOff, getProfileInt( "Settings", "ENV_BoosterOff", 0, profileFile ) );
    putValue( ENV_BoosterOn, getProfileInt( "Settings", "ENV_BoosterOn", 0, profileFile ) );
    putValue( ENV_BoosterRepetitions, getProfileInt( "Settings", "ENV_BoosterRepetitions", 0, profileFile ) );
    putValue( ENV_CalculateKl58d, getProfileInt( "Settings", "ENV_CalculateKl58d", 0, profileFile ) );
    putValue( ENV_Case, getProfileInt( "Settings", "ENV_Case", 0, profileFile ) );
    putValue( ENV_Case_SpeedRPM, getProfileInt( "Settings", "ENV_Case_SpeedRPM", 0, profileFile ) );
    putValue( ENV_Channel, getProfileInt( "Settings", "ENV_Channel", 0, profileFile ) );
    putValue( ENV_Consumption, getProfileFloat( "Settings", "ENV_Consumption", 0, profileFile ) );
    putValue( ENV_Consumption_BMS, getProfileFloat( "Settings", "ENV_Consumption_BMS", 0, profileFile ) );
    putValue( ENV_Consumption_BMS_Rekuperation, getProfileFloat( "Settings", "ENV_Consumption_BMS_Rekuperation", 0, profileFile ) );
    putValue( ENV_Consumption_DC, getProfileFloat( "Settings", "ENV_Consumption_DC", 0, profileFile ) );
    putValue( ENV_Consumption_EM, getProfileFloat( "Settings", "ENV_Consumption_EM", 0, profileFile ) );
    putValue( ENV_Consumption_EM_Rekuperation, getProfileFloat( "Settings", "ENV_Consumption_EM_Rekuperation", 0, profileFile ) );
    putValue( ENV_Consumption_Thermo, getProfileFloat( "Settings", "ENV_Consumption_Thermo", 0, profileFile ) );
    putValue( ENV_Consumption_Thermo_BTL, getProfileFloat( "Settings", "ENV_Consumption_Thermo_BTL", 0, profileFile ) );
    putValue( ENV_ConsumptionSendOnceButton, getProfileInt( "Settings", "ENV_ConsumptionSendOnceButton", 0, profileFile ) );
    putValue( ENV_DisplaySpeed, getProfileFloat( "Settings", "ENV_DisplaySpeed", 0, profileFile ) );
    putValue( ENV_DistanceAccu, getProfileFloat( "Settings", "ENV_DistanceAccu", 0, profileFile ) );
    putValue( ENV_DistanceAccuReset, getProfileInt( "Settings", "ENV_DistanceAccuReset", 0, profileFile ) );
    putValue( ENV_DistancePulseAccu, getProfileInt( "Settings", "ENV_DistancePulseAccu", 0, profileFile ) );
    putValue( ENV_EntVol, getProfileInt( "Settings", "ENV_EntVol", 0, profileFile ) );
    putValue( ENV_ESP_imp_var, getProfileFloat( "Settings", "ENV_ESP_imp_var", 0, profileFile ) );
    putValue( ENV_FunctionAAG, getProfileInt( "Settings", "ENV_FunctionAAG", 0, profileFile ) );
    putValue( ENV_FunctionACC, getProfileInt( "Settings", "ENV_FunctionACC", 0, profileFile ) );
    putValue( ENV_FunctionAirbag, getProfileInt( "Settings", "ENV_FunctionAirbag", 0, profileFile ) );
    putValue( ENV_FunctionBCM1, getProfileInt( "Settings", "ENV_FunctionBCM1", 0, profileFile ) );
    putValue( ENV_FunctionBFS, getProfileInt( "Settings", "ENV_FunctionBFS", 0, profileFile ) );
    putValue( ENV_FunctionBremse, getProfileInt( "Settings", "ENV_FunctionBremse", 0, profileFile ) );
    putValue( ENV_FunctionDaempfer, getProfileInt( "Settings", "ENV_FunctionDaempfer", 0, profileFile ) );
    putValue( ENV_FunctionELV, getProfileInt( "Settings", "ENV_FunctionELV", 0, profileFile ) );
    putValue( ENV_FunctionEPB, getProfileInt( "Settings", "ENV_FunctionEPB", 0, profileFile ) );
    putValue( ENV_FunctionEPS, getProfileInt( "Settings", "ENV_FunctionEPS", 0, profileFile ) );
    putValue( ENV_FunctionFS, getProfileInt( "Settings", "ENV_FunctionFS", 0, profileFile ) );
    putValue( ENV_FunctionGateway, getProfileInt( "Settings", "ENV_FunctionGateway", 0, profileFile ) );
    putValue( ENV_FunctionKessy, getProfileInt( "Settings", "ENV_FunctionKessy", 0, profileFile ) );
    putValue( ENV_FunctionLDW, getProfileInt( "Settings", "ENV_FunctionLDW", 0, profileFile ) );
    putValue( ENV_FunctionLWR_AFS, getProfileInt( "Settings", "ENV_FunctionLWR_AFS", 0, profileFile ) );
    putValue( ENV_FunctionMFG, getProfileInt( "Settings", "ENV_FunctionMFG", 0, profileFile ) );
    putValue( ENV_FunctionMotor, getProfileInt( "Settings", "ENV_FunctionMotor", 0, profileFile ) );
    putValue( ENV_FunctionPLA, getProfileInt( "Settings", "ENV_FunctionPLA", 0, profileFile ) );
    putValue( ENV_FunctionRDK, getProfileInt( "Settings", "ENV_FunctionRDK", 0, profileFile ) );
    putValue( ENV_FunctionRKA, getProfileInt( "Settings", "ENV_FunctionRKA", 0, profileFile ) );
    putValue( ENV_FunctionSMLS, getProfileInt( "Settings", "ENV_FunctionSMLS", 0, profileFile ) );
    putValue( ENV_FunctionSTS, getProfileInt( "Settings", "ENV_FunctionSTS", 0, profileFile ) );
    putValue( ENV_FunctionSWA, getProfileInt( "Settings", "ENV_FunctionSWA", 0, profileFile ) );
    putValue( ENV_FunctionTCO, getProfileInt( "Settings", "ENV_FunctionTCO", 0, profileFile ) );
    putValue( ENV_FunctionTSG_FT, getProfileInt( "Settings", "ENV_FunctionTSG_FT", 0, profileFile ) );
    putValue( ENV_FunctionWBA, getProfileInt( "Settings", "ENV_FunctionWBA", 0, profileFile ) );
    putValue( ENV_GasConsumption, getProfileFloat( "Settings", "ENV_GasConsumption", 0, profileFile ) );
    putValue( ENV_Generic, getProfileInt( "Settings", "ENV_Generic", 0, profileFile ) );
    putValue( ENV_IndicatorOffTime, getProfileInt( "Settings", "ENV_IndicatorOffTime", 0, profileFile ) );
    putValue( ENV_IndicatorOnTime, getProfileInt( "Settings", "ENV_IndicatorOnTime", 0, profileFile ) );
    putValue( ENV_InputSelection, getProfileInt( "Settings", "ENV_InputSelection", 0, profileFile ) );
    putValue( ENV_KBI_SystemstatusD, getProfileInt( "Settings", "ENV_KBI_SystemstatusD", 0, profileFile ) );
    putValue( ENV_KBI_Tankwarnung_ungueltigD, getProfileInt( "Settings", "ENV_KBI_Tankwarnung_ungueltigD", 0, profileFile ) );
    putValue( ENV_KeyADownState, getProfileInt( "Settings", "ENV_KeyADownState", 0, profileFile ) );
    putValue( ENV_KeyAudioSourceState, getProfileInt( "Settings", "ENV_KeyAudioSourceState", 0, profileFile ) );
    putValue( ENV_KeyAUpState, getProfileInt( "Settings", "ENV_KeyAUpState", 0, profileFile ) );
    putValue( ENV_KeyBDownState, getProfileInt( "Settings", "ENV_KeyBDownState", 0, profileFile ) );
    putValue( ENV_KeyBUpState, getProfileInt( "Settings", "ENV_KeyBUpState", 0, profileFile ) );
    putValue( ENV_KeyCancelState, getProfileInt( "Settings", "ENV_KeyCancelState", 0, profileFile ) );
    putValue( ENV_KeyDownState, getProfileInt( "Settings", "ENV_KeyDownState", 0, profileFile ) );
    putValue( ENV_KeyDriveSelectbuttonState, getProfileInt( "Settings", "ENV_KeyDriveSelectbuttonState", 0, profileFile ) );
    putValue( ENV_KeyESPDriftSelectionState, getProfileInt( "Settings", "ENV_KeyESPDriftSelectionState", 0, profileFile ) );
    putValue( ENV_KeyExhaustSoundState, getProfileInt( "Settings", "ENV_KeyExhaustSoundState", 0, profileFile ) );
    putValue( ENV_KeyFAS_Taster, getProfileInt( "Settings", "ENV_KeyFAS_Taster", 0, profileFile ) );
    putValue( ENV_KeyHangUpState, getProfileInt( "Settings", "ENV_KeyHangUpState", 0, profileFile ) );
    putValue( ENV_KeyHookState, getProfileInt( "Settings", "ENV_KeyHookState", 0, profileFile ) );
    putValue( ENV_KeyJoker1State, getProfileInt( "Settings", "ENV_KeyJoker1State", 0, profileFile ) );
    putValue( ENV_KeyJoker2State, getProfileInt( "Settings", "ENV_KeyJoker2State", 0, profileFile ) );
    putValue( ENV_KeyLightOnOffState, getProfileInt( "Settings", "ENV_KeyLightOnOffState", 0, profileFile ) );
    putValue( ENV_KeyMainMenuState, getProfileInt( "Settings", "ENV_KeyMainMenuState", 0, profileFile ) );
    putValue( ENV_KeyMenuDownState, getProfileInt( "Settings", "ENV_KeyMenuDownState", 0, profileFile ) );
    putValue( ENV_KeyMenuState, getProfileInt( "Settings", "ENV_KeyMenuState", 0, profileFile ) );
    putValue( ENV_KeyMenuUpState, getProfileInt( "Settings", "ENV_KeyMenuUpState", 0, profileFile ) );
    putValue( ENV_KeyMuteState, getProfileInt( "Settings", "ENV_KeyMuteState", 0, profileFile ) );
    putValue( ENV_KeyOffHookState, getProfileInt( "Settings", "ENV_KeyOffHookState", 0, profileFile ) );
    putValue( ENV_KeyOkWheelLeftState, getProfileInt( "Settings", "ENV_KeyOkWheelLeftState", 0, profileFile ) );
    putValue( ENV_KeyOkWheelRightState, getProfileInt( "Settings", "ENV_KeyOkWheelRightState", 0, profileFile ) );
    putValue( ENV_KeyPttCancelState, getProfileInt( "Settings", "ENV_KeyPttCancelState", 0, profileFile ) );
    putValue( ENV_KeyPttState, getProfileInt( "Settings", "ENV_KeyPttState", 0, profileFile ) );
    putValue( ENV_KeyRouteInfoState, getProfileInt( "Settings", "ENV_KeyRouteInfoState", 0, profileFile ) );
    putValue( ENV_KeySideMenuleftState, getProfileInt( "Settings", "ENV_KeySideMenuleftState", 0, profileFile ) );
    putValue( ENV_KeySideMenurightState, getProfileInt( "Settings", "ENV_KeySideMenurightState", 0, profileFile ) );
    putValue( ENV_KeySportbuttonState, getProfileInt( "Settings", "ENV_KeySportbuttonState", 0, profileFile ) );
    putValue( ENV_KeyUpState, getProfileInt( "Settings", "ENV_KeyUpState", 0, profileFile ) );
    putValue( ENV_KeyView, getProfileInt( "Settings", "ENV_KeyView", 0, profileFile ) );
    putValue( ENV_KeyVolDownState, getProfileInt( "Settings", "ENV_KeyVolDownState", 0, profileFile ) );
    putValue( ENV_KeyVolUpState, getProfileInt( "Settings", "ENV_KeyVolUpState", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeLeft_M1, getProfileInt( "Settings", "ENV_KeyWheelEventCodeLeft_M1", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeLeft_M2, getProfileInt( "Settings", "ENV_KeyWheelEventCodeLeft_M2", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeLeft_M3, getProfileInt( "Settings", "ENV_KeyWheelEventCodeLeft_M3", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeLeft_M4, getProfileInt( "Settings", "ENV_KeyWheelEventCodeLeft_M4", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeLeft_M5, getProfileInt( "Settings", "ENV_KeyWheelEventCodeLeft_M5", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeLeft_M6, getProfileInt( "Settings", "ENV_KeyWheelEventCodeLeft_M6", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeLeft_M7, getProfileInt( "Settings", "ENV_KeyWheelEventCodeLeft_M7", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeLeft_P1, getProfileInt( "Settings", "ENV_KeyWheelEventCodeLeft_P1", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeLeft_P2, getProfileInt( "Settings", "ENV_KeyWheelEventCodeLeft_P2", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeLeft_P3, getProfileInt( "Settings", "ENV_KeyWheelEventCodeLeft_P3", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeLeft_P4, getProfileInt( "Settings", "ENV_KeyWheelEventCodeLeft_P4", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeLeft_P5, getProfileInt( "Settings", "ENV_KeyWheelEventCodeLeft_P5", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeLeft_P6, getProfileInt( "Settings", "ENV_KeyWheelEventCodeLeft_P6", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeLeft_P7, getProfileInt( "Settings", "ENV_KeyWheelEventCodeLeft_P7", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeRight_M1, getProfileInt( "Settings", "ENV_KeyWheelEventCodeRight_M1", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeRight_M2, getProfileInt( "Settings", "ENV_KeyWheelEventCodeRight_M2", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeRight_M3, getProfileInt( "Settings", "ENV_KeyWheelEventCodeRight_M3", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeRight_M4, getProfileInt( "Settings", "ENV_KeyWheelEventCodeRight_M4", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeRight_M5, getProfileInt( "Settings", "ENV_KeyWheelEventCodeRight_M5", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeRight_M6, getProfileInt( "Settings", "ENV_KeyWheelEventCodeRight_M6", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeRight_M7, getProfileInt( "Settings", "ENV_KeyWheelEventCodeRight_M7", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeRight_P1, getProfileInt( "Settings", "ENV_KeyWheelEventCodeRight_P1", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeRight_P2, getProfileInt( "Settings", "ENV_KeyWheelEventCodeRight_P2", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeRight_P3, getProfileInt( "Settings", "ENV_KeyWheelEventCodeRight_P3", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeRight_P4, getProfileInt( "Settings", "ENV_KeyWheelEventCodeRight_P4", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeRight_P5, getProfileInt( "Settings", "ENV_KeyWheelEventCodeRight_P5", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeRight_P6, getProfileInt( "Settings", "ENV_KeyWheelEventCodeRight_P6", 0, profileFile ) );
    putValue( ENV_KeyWheelEventCodeRight_P7, getProfileInt( "Settings", "ENV_KeyWheelEventCodeRight_P7", 0, profileFile ) );
    putValue( ENV_KL_15_dT, getProfileInt( "Settings", "ENV_KL_15_dT", 0, profileFile ) );
    putValue( ENV_KL_15_KL_S_Test, getProfileInt( "Settings", "ENV_KL_15_KL_S_Test", 0, profileFile ) );
    putValue( ENV_KL_15_T1, getProfileInt( "Settings", "ENV_KL_15_T1", 0, profileFile ) );
    putValue( ENV_KL_15_T2, getProfileInt( "Settings", "ENV_KL_15_T2", 0, profileFile ) );
    putValue( ENV_KL_15_Test, getProfileInt( "Settings", "ENV_KL_15_Test", 0, profileFile ) );
    putValue( ENV_KL_S_dT, getProfileInt( "Settings", "ENV_KL_S_dT", 0, profileFile ) );
    putValue( ENV_KL_S_NMH_Test, getProfileInt( "Settings", "ENV_KL_S_NMH_Test", 0, profileFile ) );
    putValue( ENV_KL_S_T1, getProfileInt( "Settings", "ENV_KL_S_T1", 0, profileFile ) );
    putValue( ENV_KL_S_T2, getProfileInt( "Settings", "ENV_KL_S_T2", 0, profileFile ) );
    putValue( ENV_KL_S_Test, getProfileInt( "Settings", "ENV_KL_S_Test", 0, profileFile ) );
    putValue( ENV_KN_KBI_DiagPfadD, getProfileInt( "Settings", "ENV_KN_KBI_DiagPfadD", 0, profileFile ) );
    putValue( ENV_LoadAllSettings, getProfileInt( "Settings", "ENV_LoadAllSettings", 0, profileFile ) );
    putValue( ENV_LoadSettings, getProfileInt( "Settings", "ENV_LoadSettings", 0, profileFile ) );
    putValue( ENV_LogInterval, getProfileInt( "Settings", "ENV_LogInterval", 0, profileFile ) );
    putValue( ENV_MenuCtrl, getProfileInt( "Settings", "ENV_MenuCtrl", 0, profileFile ) );
    putValue( ENV_MenuLevelsChange, getProfileInt( "Settings", "ENV_MenuLevelsChange", 0, profileFile ) );
    putValue( ENV_MenuLevelsCycleTime, getProfileInt( "Settings", "ENV_MenuLevelsCycleTime", 0, profileFile ) );
    putValue( ENV_MenuLevelsLeftRight, getProfileInt( "Settings", "ENV_MenuLevelsLeftRight", 0, profileFile ) );
    putValue( ENV_MenuLevelsUpDown, getProfileInt( "Settings", "ENV_MenuLevelsUpDown", 0, profileFile ) );
    putValue( ENV_MessageList, getProfileInt( "Settings", "ENV_MessageList", 0, profileFile ) );
    putValue( ENV_MfaResetState, getProfileInt( "Settings", "ENV_MfaResetState", 0, profileFile ) );
    putValue( ENV_MFL_LSS_Shortcut, getProfileInt( "Settings", "ENV_MFL_LSS_Shortcut", 0, profileFile ) );
    putValue( ENV_MFL_LSS_switch, getProfileInt( "Settings", "ENV_MFL_LSS_switch", 0, profileFile ) );
    putValue( ENV_NaviVol, getProfileInt( "Settings", "ENV_NaviVol", 0, profileFile ) );
    putValue( ENV_NMH_dT, getProfileInt( "Settings", "ENV_NMH_dT", 0, profileFile ) );
    putValue( ENV_NMH_KL_15_Test, getProfileInt( "Settings", "ENV_NMH_KL_15_Test", 0, profileFile ) );
    putValue( ENV_NMH_T1, getProfileInt( "Settings", "ENV_NMH_T1", 0, profileFile ) );
    putValue( ENV_NMH_T2, getProfileInt( "Settings", "ENV_NMH_T2", 0, profileFile ) );
    putValue( ENV_NMH_Test, getProfileInt( "Settings", "ENV_NMH_Test", 0, profileFile ) );
    putValue( ENV_NMHLastState, getProfileInt( "Settings", "ENV_NMHLastState", 0, profileFile ) );
    putValue( ENV_NMHMode, getProfileInt( "Settings", "ENV_NMHMode", 0, profileFile ) );
    putValue( ENV_NMHState, getProfileInt( "Settings", "ENV_NMHState", 0, profileFile ) );
    putValue( ENV_NMHStateMachineEnabled, getProfileInt( "Settings", "ENV_NMHStateMachineEnabled", 0, profileFile ) );
    putValue( ENV_NMHStateMachineState, getProfileInt( "Settings", "ENV_NMHStateMachineState", 0, profileFile ) );
    putValue( ENV_NodeList, getProfileInt( "Settings", "ENV_NodeList", 0, profileFile ) );
    putValue( ENV_NoWarn, getProfileInt( "Settings", "ENV_NoWarn", 0, profileFile ) );
    putValue( ENV_NoWarnLightComf, getProfileInt( "Settings", "ENV_NoWarnLightComf", 0, profileFile ) );
    putValue( ENV_ParameterCheck, getProfileInt( "Settings", "ENV_ParameterCheck", 0, profileFile ) );
    putValue( ENV_PeckSwitchStat, getProfileInt( "Settings", "ENV_PeckSwitchStat", 0, profileFile ) );
    putValue( ENV_PhoneVol, getProfileInt( "Settings", "ENV_PhoneVol", 0, profileFile ) );
    putValue( ENV_Production_alarm, getProfileInt( "Settings", "ENV_Production_alarm", 0, profileFile ) );
    putValue( ENV_ProductionMode, getProfileInt( "Settings", "ENV_ProductionMode", 0, profileFile ) );
    putValue( ENV_RPMEnd, getProfileInt( "Settings", "ENV_RPMEnd", 0, profileFile ) );
    putValue( ENV_RPMRandom, getProfileInt( "Settings", "ENV_RPMRandom", 0, profileFile ) );
    putValue( ENV_RPMRaw, getProfileInt( "Settings", "ENV_RPMRaw", 0, profileFile ) );
    putValue( ENV_RPMSpeedTestTimer, getProfileInt( "Settings", "ENV_RPMSpeedTestTimer", 0, profileFile ) );
    putValue( ENV_RPMStart, getProfileInt( "Settings", "ENV_RPMStart", 0, profileFile ) );
    putValue( ENV_RPMSteps, getProfileInt( "Settings", "ENV_RPMSteps", 0, profileFile ) );
    putValue( ENV_RPMSweep, getProfileInt( "Settings", "ENV_RPMSweep", 0, profileFile ) );
    putValue( ENV_RPMTime, getProfileInt( "Settings", "ENV_RPMTime", 0, profileFile ) );
    putValue( ENV_SaveAllSettings, getProfileInt( "Settings", "ENV_SaveAllSettings", 0, profileFile ) );
    putValue( ENV_SaveSettings, getProfileInt( "Settings", "ENV_SaveSettings", 0, profileFile ) );
    putValue( ENV_SDSVol, getProfileInt( "Settings", "ENV_SDSVol", 0, profileFile ) );
    putValue( ENV_SendAtOnceMFL_Tasten_Kon_01, getProfileInt( "Settings", "ENV_SendAtOnceMFL_Tasten_Kon_01", 0, profileFile ) );
    putValue( ENV_SendAtOnceNMH_eCall, getProfileInt( "Settings", "ENV_SendAtOnceNMH_eCall", 0, profileFile ) );
    putValue( ENV_SendAtOnceNMH_Gateway, getProfileInt( "Settings", "ENV_SendAtOnceNMH_Gateway", 0, profileFile ) );
    putValue( ENV_SendMfl, getProfileInt( "Settings", "ENV_SendMfl", 0, profileFile ) );
    putValue( ENV_SendMflChannelState, getProfileInt( "Settings", "ENV_SendMflChannelState", 0, profileFile ) );
    putValue( ENV_SendMflPermanent1, getProfileInt( "Settings", "ENV_SendMflPermanent1", 0, profileFile ) );
    putValue( ENV_SendMflPermanent2, getProfileInt( "Settings", "ENV_SendMflPermanent2", 0, profileFile ) );
    putValue( ENV_SendWbaEingGang02, getProfileInt( "Settings", "ENV_SendWbaEingGang02", 0, profileFile ) );
    putValue( ENV_SendWbaFahrstufe02, getProfileInt( "Settings", "ENV_SendWbaFahrstufe02", 0, profileFile ) );
    putValue( ENV_SI_Bus_01_Active, getProfileInt( "Settings", "ENV_SI_Bus_01_Active", 0, profileFile ) );
    putValue( ENV_SI_Bus_04_Active, getProfileInt( "Settings", "ENV_SI_Bus_04_Active", 0, profileFile ) );
    putValue( ENV_SI_Bus_06_Active, getProfileInt( "Settings", "ENV_SI_Bus_06_Active", 0, profileFile ) );
    putValue( ENV_Speed, getProfileFloat( "Settings", "ENV_Speed", 0, profileFile ) );
    putValue( ENV_SpeedDistanceButton, getProfileInt( "Settings", "ENV_SpeedDistanceButton", 0, profileFile ) );
    putValue( ENV_SpeedDistanceInput, getProfileFloat( "Settings", "ENV_SpeedDistanceInput", 0, profileFile ) );
    putValue( ENV_SpeedEnd, getProfileFloat( "Settings", "ENV_SpeedEnd", 0, profileFile ) );
    putValue( ENV_SpeedInput, getProfileFloat( "Settings", "ENV_SpeedInput", 0, profileFile ) );
    putValue( ENV_SpeedInputIsMetric, getProfileInt( "Settings", "ENV_SpeedInputIsMetric", 0, profileFile ) );
    putValue( ENV_SpeedOverfeedFactor, getProfileFloat( "Settings", "ENV_SpeedOverfeedFactor", 0, profileFile ) );
    putValue( ENV_SpeedPulseCorrelation, getProfileInt( "Settings", "ENV_SpeedPulseCorrelation", 0, profileFile ) );
    putValue( ENV_SpeedPulses, getProfileFloat( "Settings", "ENV_SpeedPulses", 0, profileFile ) );
    putValue( ENV_SpeedPulsesButton, getProfileInt( "Settings", "ENV_SpeedPulsesButton", 0, profileFile ) );
    putValue( ENV_SpeedPulsesInput, getProfileInt( "Settings", "ENV_SpeedPulsesInput", 0, profileFile ) );
    putValue( ENV_SpeedRandom, getProfileInt( "Settings", "ENV_SpeedRandom", 0, profileFile ) );
    putValue( ENV_SpeedRPMCorrelation, getProfileInt( "Settings", "ENV_SpeedRPMCorrelation", 0, profileFile ) );
    putValue( ENV_SpeedSendOnceButton, getProfileInt( "Settings", "ENV_SpeedSendOnceButton", 0, profileFile ) );
    putValue( ENV_SpeedSingleSteps, getProfileInt( "Settings", "ENV_SpeedSingleSteps", 0, profileFile ) );
    putValue( ENV_SpeedStart, getProfileFloat( "Settings", "ENV_SpeedStart", 0, profileFile ) );
    putValue( ENV_SpeedSteps, getProfileInt( "Settings", "ENV_SpeedSteps", 0, profileFile ) );
    putValue( ENV_SpeedSweep, getProfileInt( "Settings", "ENV_SpeedSweep", 0, profileFile ) );
    putValue( ENV_SpeedTime, getProfileInt( "Settings", "ENV_SpeedTime", 0, profileFile ) );
    putValue( ENV_Startup_AAG, getProfileInt( "Settings", "ENV_Startup_AAG", 0, profileFile ) );
    putValue( ENV_Startup_ACC, getProfileInt( "Settings", "ENV_Startup_ACC", 0, profileFile ) );
    putValue( ENV_Startup_Airbag, getProfileInt( "Settings", "ENV_Startup_Airbag", 0, profileFile ) );
    putValue( ENV_Startup_BAP_BC_ASG_02, getProfileInt( "Settings", "ENV_Startup_BAP_BC_ASG_02", 0, profileFile ) );
    putValue( ENV_Startup_BCM1, getProfileInt( "Settings", "ENV_Startup_BCM1", 0, profileFile ) );
    putValue( ENV_Startup_BFS, getProfileInt( "Settings", "ENV_Startup_BFS", 0, profileFile ) );
    putValue( ENV_Startup_Bremse, getProfileInt( "Settings", "ENV_Startup_Bremse", 0, profileFile ) );
    putValue( ENV_Startup_Daempfer, getProfileInt( "Settings", "ENV_Startup_Daempfer", 0, profileFile ) );
    putValue( ENV_Startup_ELV, getProfileInt( "Settings", "ENV_Startup_ELV", 0, profileFile ) );
    putValue( ENV_Startup_EPB, getProfileInt( "Settings", "ENV_Startup_EPB", 0, profileFile ) );
    putValue( ENV_Startup_EPS, getProfileInt( "Settings", "ENV_Startup_EPS", 0, profileFile ) );
    putValue( ENV_Startup_FS, getProfileInt( "Settings", "ENV_Startup_FS", 0, profileFile ) );
    putValue( ENV_Startup_Gateway, getProfileInt( "Settings", "ENV_Startup_Gateway", 0, profileFile ) );
    putValue( ENV_Startup_HVEM, getProfileInt( "Settings", "ENV_Startup_HVEM", 0, profileFile ) );
    putValue( ENV_Startup_HVLM, getProfileInt( "Settings", "ENV_Startup_HVLM", 0, profileFile ) );
    putValue( ENV_Startup_Kessy, getProfileInt( "Settings", "ENV_Startup_Kessy", 0, profileFile ) );
    putValue( ENV_Startup_Kombi, getProfileInt( "Settings", "ENV_Startup_Kombi", 0, profileFile ) );
    putValue( ENV_Startup_LDW, getProfileInt( "Settings", "ENV_Startup_LDW", 0, profileFile ) );
    putValue( ENV_Startup_LWR_AFS, getProfileInt( "Settings", "ENV_Startup_LWR_AFS", 0, profileFile ) );
    putValue( ENV_Startup_MainUnit_01, getProfileInt( "Settings", "ENV_Startup_MainUnit_01", 0, profileFile ) );
    putValue( ENV_Startup_MFG, getProfileInt( "Settings", "ENV_Startup_MFG", 0, profileFile ) );
    putValue( ENV_Startup_Motor, getProfileInt( "Settings", "ENV_Startup_Motor", 0, profileFile ) );
    putValue( ENV_Startup_PLA, getProfileInt( "Settings", "ENV_Startup_PLA", 0, profileFile ) );
    putValue( ENV_Startup_RDK, getProfileInt( "Settings", "ENV_Startup_RDK", 0, profileFile ) );
    putValue( ENV_Startup_Reichweite, getProfileInt( "Settings", "ENV_Startup_Reichweite", 0, profileFile ) );
    putValue( ENV_Startup_RKA, getProfileInt( "Settings", "ENV_Startup_RKA", 0, profileFile ) );
    putValue( ENV_Startup_SMLS, getProfileInt( "Settings", "ENV_Startup_SMLS", 0, profileFile ) );
    putValue( ENV_Startup_STS, getProfileInt( "Settings", "ENV_Startup_STS", 0, profileFile ) );
    putValue( ENV_Startup_SWA, getProfileInt( "Settings", "ENV_Startup_SWA", 0, profileFile ) );
    putValue( ENV_Startup_TCO, getProfileInt( "Settings", "ENV_Startup_TCO", 0, profileFile ) );
    putValue( ENV_Startup_TSG_FT, getProfileInt( "Settings", "ENV_Startup_TSG_FT", 0, profileFile ) );
    putValue( ENV_Startup_WBA, getProfileInt( "Settings", "ENV_Startup_WBA", 0, profileFile ) );
    putValue( ENV_StartWriteLog, getProfileInt( "Settings", "ENV_StartWriteLog", 0, profileFile ) );
    putValue( ENV_STH_Consumption, getProfileFloat( "Settings", "ENV_STH_Consumption", 0, profileFile ) );
    putValue( ENV_StopWriteLog, getProfileInt( "Settings", "ENV_StopWriteLog", 0, profileFile ) );
    putValue( ENV_Systeminfo_01_BusActive, getProfileInt( "Settings", "ENV_Systeminfo_01_BusActive", 0, profileFile ) );
    putValue( ENV_TAVol, getProfileInt( "Settings", "ENV_TAVol", 0, profileFile ) );
    putValue( ENV_TestPanels, getProfileInt( "Settings", "ENV_TestPanels", 0, profileFile ) );
    putValue( ENV_TestStates, getProfileInt( "Settings", "ENV_TestStates", 0, profileFile ) );
    putValue( ENV_TimerType, getProfileInt( "Settings", "ENV_TimerType", 0, profileFile ) );
    putValue( ENV_WarnAll, getProfileInt( "Settings", "ENV_WarnAll", 0, profileFile ) );
    putValue( ENV_WarnBlue, getProfileInt( "Settings", "ENV_WarnBlue", 0, profileFile ) );
    putValue( ENV_WarnGreen, getProfileInt( "Settings", "ENV_WarnGreen", 0, profileFile ) );
    putValue( ENV_Warnings, getProfileInt( "Settings", "ENV_Warnings", 0, profileFile ) );
    putValue( ENV_WarnNone, getProfileInt( "Settings", "ENV_WarnNone", 0, profileFile ) );
    putValue( ENV_WarnRed, getProfileInt( "Settings", "ENV_WarnRed", 0, profileFile ) );
    putValue( ENV_WarnYellow, getProfileInt( "Settings", "ENV_WarnYellow", 0, profileFile ) );
    putValue( ENV_WBA_mode, getProfileInt( "Settings", "ENV_WBA_mode", 0, profileFile ) );
    putValue( ENV_WBAChangeCycleTime1, getProfileInt( "Settings", "ENV_WBAChangeCycleTime1", 0, profileFile ) );
    putValue( ENV_WBAChangeCycleTime2, getProfileInt( "Settings", "ENV_WBAChangeCycleTime2", 0, profileFile ) );
    putValue( ENV_WheelCircumferenceAvg, getProfileInt( "Settings", "ENV_WheelCircumferenceAvg", 0, profileFile ) );
    putValue( ENV_WheelCircumferenceMax, getProfileInt( "Settings", "ENV_WheelCircumferenceMax", 0, profileFile ) );
    putValue( ENV_Write_ISO_Kombi_Resp_Data, getProfileInt( "Settings", "ENV_Write_ISO_Kombi_Resp_Data", 0, profileFile ) );
    putValue( ENV_Write_KBI_ABS_Lampe, getProfileInt( "Settings", "ENV_Write_KBI_ABS_Lampe", 0, profileFile ) );
    putValue( ENV_Write_KBI_Airbag_Lampe, getProfileInt( "Settings", "ENV_Write_KBI_Airbag_Lampe", 0, profileFile ) );
    putValue( ENV_Write_KBI_angez_Geschw, getProfileInt( "Settings", "ENV_Write_KBI_angez_Geschw", 0, profileFile ) );
    putValue( ENV_Write_KBI_Anzeigefehler_LDW, getProfileInt( "Settings", "ENV_Write_KBI_Anzeigefehler_LDW", 0, profileFile ) );
    putValue( ENV_Write_KBI_Anzeigefehler_NV, getProfileInt( "Settings", "ENV_Write_KBI_Anzeigefehler_NV", 0, profileFile ) );
    putValue( ENV_Write_KBI_Anzeigefehler_SWA, getProfileInt( "Settings", "ENV_Write_KBI_Anzeigefehler_SWA", 0, profileFile ) );
    putValue( ENV_Write_KBI_Anzeigestatus_ACC, getProfileInt( "Settings", "ENV_Write_KBI_Anzeigestatus_ACC", 0, profileFile ) );
    putValue( ENV_Write_KBI_Anzeigestatus_GRA, getProfileInt( "Settings", "ENV_Write_KBI_Anzeigestatus_GRA", 0, profileFile ) );
    putValue( ENV_Write_KBI_Anzeigestatus_LIM, getProfileInt( "Settings", "ENV_Write_KBI_Anzeigestatus_LIM", 0, profileFile ) );
    putValue( ENV_Write_KBI_Aussen_Temp_gef, getProfileInt( "Settings", "ENV_Write_KBI_Aussen_Temp_gef", 0, profileFile ) );
    putValue( ENV_Write_KBI_BCmE_aktiv, getProfileInt( "Settings", "ENV_Write_KBI_BCmE_aktiv", 0, profileFile ) );
    putValue( ENV_Write_KBI_BKL_Lampe, getProfileInt( "Settings", "ENV_Write_KBI_BKL_Lampe", 0, profileFile ) );
    putValue( ENV_Write_KBI_Dimmpoti, getProfileInt( "Settings", "ENV_Write_KBI_Dimmpoti", 0, profileFile ) );
    putValue( ENV_Write_KBI_Einheit_Datum, getProfileInt( "Settings", "ENV_Write_KBI_Einheit_Datum", 0, profileFile ) );
    putValue( ENV_Write_KBI_Einheit_Druck, getProfileInt( "Settings", "ENV_Write_KBI_Einheit_Druck", 0, profileFile ) );
    putValue( ENV_Write_KBI_Einheit_Sprache, getProfileInt( "Settings", "ENV_Write_KBI_Einheit_Sprache", 0, profileFile ) );
    putValue( ENV_Write_KBI_Einheit_Streckenanz, getProfileInt( "Settings", "ENV_Write_KBI_Einheit_Streckenanz", 0, profileFile ) );
    putValue( ENV_Write_KBI_Einheit_Tacho, getProfileInt( "Settings", "ENV_Write_KBI_Einheit_Tacho", 0, profileFile ) );
    putValue( ENV_Write_KBI_Einheit_Temp, getProfileInt( "Settings", "ENV_Write_KBI_Einheit_Temp", 0, profileFile ) );
    putValue( ENV_Write_KBI_Einheit_Uhrzeit, getProfileInt( "Settings", "ENV_Write_KBI_Einheit_Uhrzeit", 0, profileFile ) );
    putValue( ENV_Write_KBI_Einheit_Verbrauch, getProfileInt( "Settings", "ENV_Write_KBI_Einheit_Verbrauch", 0, profileFile ) );
    putValue( ENV_Write_KBI_Einheit_Volumen, getProfileInt( "Settings", "ENV_Write_KBI_Einheit_Volumen", 0, profileFile ) );
    putValue( ENV_Write_KBI_ESP_Lampe, getProfileInt( "Settings", "ENV_Write_KBI_ESP_Lampe", 0, profileFile ) );
    putValue( ENV_Write_KBI_Fehler_Anzeige_ACC, getProfileInt( "Settings", "ENV_Write_KBI_Fehler_Anzeige_ACC", 0, profileFile ) );
    putValue( ENV_Write_KBI_FStatus_Tank, getProfileInt( "Settings", "ENV_Write_KBI_FStatus_Tank", 0, profileFile ) );
    putValue( ENV_Write_KBI_Handbremse, getProfileInt( "Settings", "ENV_Write_KBI_Handbremse", 0, profileFile ) );
    putValue( ENV_Write_KBI_im_Stellgliedtest, getProfileInt( "Settings", "ENV_Write_KBI_im_Stellgliedtest", 0, profileFile ) );
    putValue( ENV_Write_KBI_Inhalt_Tank, getProfileInt( "Settings", "ENV_Write_KBI_Inhalt_Tank", 0, profileFile ) );
    putValue( ENV_Write_KBI_KD_Fehler, getProfileInt( "Settings", "ENV_Write_KBI_KD_Fehler", 0, profileFile ) );
    putValue( ENV_Write_KBI_Kilometerstand_0, getProfileInt( "Settings", "ENV_Write_KBI_Kilometerstand_0", 0, profileFile ) );
    putValue( ENV_Write_KBI_Konsistenz_ACC, getProfileInt( "Settings", "ENV_Write_KBI_Konsistenz_ACC", 0, profileFile ) );
    putValue( ENV_Write_KBI_Lenkung_Lampe, getProfileInt( "Settings", "ENV_Write_KBI_Lenkung_Lampe", 0, profileFile ) );
    putValue( ENV_Write_KBI_MFA_v_Einheit_01, getProfileInt( "Settings", "ENV_Write_KBI_MFA_v_Einheit_01", 0, profileFile ) );
    putValue( ENV_Write_KBI_MFA_v_Einheit_02, getProfileInt( "Settings", "ENV_Write_KBI_MFA_v_Einheit_02", 0, profileFile ) );
    putValue( ENV_Write_KBI_NV_in_Anzeige, getProfileInt( "Settings", "ENV_Write_KBI_NV_in_Anzeige", 0, profileFile ) );
    putValue( ENV_Write_KBI_Oeldruck_Schalter, getProfileInt( "Settings", "ENV_Write_KBI_Oeldruck_Schalter", 0, profileFile ) );
    putValue( ENV_Write_KBI_Oeldruckwarnung, getProfileInt( "Settings", "ENV_Write_KBI_Oeldruckwarnung", 0, profileFile ) );
    putValue( ENV_Write_KBI_Phototransistor, getProfileInt( "Settings", "ENV_Write_KBI_Phototransistor", 0, profileFile ) );
    putValue( ENV_Write_KBI_PLA_in_Anzeige, getProfileInt( "Settings", "ENV_Write_KBI_PLA_in_Anzeige", 0, profileFile ) );
    putValue( ENV_Write_KBI_QBit_Aussen_Temp_gef, getProfileInt( "Settings", "ENV_Write_KBI_QBit_Aussen_Temp_gef", 0, profileFile ) );
    putValue( ENV_Write_KBI_Reifenumfang, getProfileInt( "Settings", "ENV_Write_KBI_Reifenumfang", 0, profileFile ) );
    putValue( ENV_Write_KBI_SILA_gueltig, getProfileInt( "Settings", "ENV_Write_KBI_SILA_gueltig", 0, profileFile ) );
    putValue( ENV_Write_KBI_Sparhinweis_quittiert, getProfileInt( "Settings", "ENV_Write_KBI_Sparhinweis_quittiert", 0, profileFile ) );
    putValue( ENV_Write_KBI_Standzeit_02, getProfileInt( "Settings", "ENV_Write_KBI_Standzeit_02", 0, profileFile ) );
    putValue( ENV_Write_KBI_Systemstatus, getProfileInt( "Settings", "ENV_Write_KBI_Systemstatus", 0, profileFile ) );
    putValue( ENV_Write_KBI_Tankwarnung, getProfileInt( "Settings", "ENV_Write_KBI_Tankwarnung", 0, profileFile ) );
    putValue( ENV_Write_KBI_Tankwarnung_ungueltig, getProfileInt( "Settings", "ENV_Write_KBI_Tankwarnung_ungueltig", 0, profileFile ) );
    putValue( ENV_Write_KBI_V_Digital, getProfileInt( "Settings", "ENV_Write_KBI_V_Digital", 0, profileFile ) );
    putValue( ENV_Write_KBI_Variante_USA, getProfileInt( "Settings", "ENV_Write_KBI_Variante_USA", 0, profileFile ) );
    putValue( ENV_Write_KBI_Vorglueh_System_Lampe, getProfileInt( "Settings", "ENV_Write_KBI_Vorglueh_System_Lampe", 0, profileFile ) );
    putValue( ENV_Write_KN_KBI_DiagPfad, getProfileInt( "Settings", "ENV_Write_KN_KBI_DiagPfad", 0, profileFile ) );
    putValue( ENV_Write_Kombi_01_BZ, getProfileInt( "Settings", "ENV_Write_Kombi_01_BZ", 0, profileFile ) );
    putValue( ENV_Write_Kombi_Nachlauftyp, getProfileInt( "Settings", "ENV_Write_Kombi_Nachlauftyp", 0, profileFile ) );
    putValue( ENV_Write_KS_Geheimnis_1, getProfileInt( "Settings", "ENV_Write_KS_Geheimnis_1", 0, profileFile ) );
    putValue( ENV_Write_KS_Geheimnis_2, getProfileInt( "Settings", "ENV_Write_KS_Geheimnis_2", 0, profileFile ) );
    putValue( ENV_Write_KS_Geheimnis_3, getProfileInt( "Settings", "ENV_Write_KS_Geheimnis_3", 0, profileFile ) );
    putValue( ENV_Write_KS_Geheimnis_4, getProfileInt( "Settings", "ENV_Write_KS_Geheimnis_4", 0, profileFile ) );
    putValue( ENV_Write_KS_Kombi_Resp_Data, getProfileInt( "Settings", "ENV_Write_KS_Kombi_Resp_Data", 0, profileFile ) );
    putValue( ENV_Write_KY_ID_Geb_autorisiert, getProfileInt( "Settings", "ENV_Write_KY_ID_Geb_autorisiert", 0, profileFile ) );
    putValue( ENV_Write_KY_ID_Geb_steckt, getProfileInt( "Settings", "ENV_Write_KY_ID_Geb_steckt", 0, profileFile ) );
    putValue( ENV_Write_KY_LF_Aktiv, getProfileInt( "Settings", "ENV_Write_KY_LF_Aktiv", 0, profileFile ) );
    putValue( ENV_Write_KY_Schluessel_Ist, getProfileInt( "Settings", "ENV_Write_KY_Schluessel_Ist", 0, profileFile ) );
    putValue( ENV_Write_KY_Schluessel_Soll, getProfileInt( "Settings", "ENV_Write_KY_Schluessel_Soll", 0, profileFile ) );
    putValue( ENV_Write_KY_WFS_LZ, getProfileInt( "Settings", "ENV_Write_KY_WFS_LZ", 0, profileFile ) );
    putValue( ENV_Write_KY_WFS_Safe, getProfileInt( "Settings", "ENV_Write_KY_WFS_Safe", 0, profileFile ) );
    putValue( ENV_Write_Log_Kombi_Resp_Data, getProfileInt( "Settings", "ENV_Write_Log_Kombi_Resp_Data", 0, profileFile ) );
    putValue( ENV_Write_NM_Kombi_Car_Wakeup, getProfileInt( "Settings", "ENV_Write_NM_Kombi_Car_Wakeup", 0, profileFile ) );
    putValue( ENV_Write_NM_Kombi_NM_State, getProfileInt( "Settings", "ENV_Write_NM_Kombi_NM_State", 0, profileFile ) );
    putValue( ENV_Write_OBD_TG_F_Status_1, getProfileInt( "Settings", "ENV_Write_OBD_TG_F_Status_1", 0, profileFile ) );
    putValue( ENV_Write_OBD_TG_F_Status_2, getProfileInt( "Settings", "ENV_Write_OBD_TG_F_Status_2", 0, profileFile ) );
    putValue( ENV_Write_OBD_TG_F_Status_3, getProfileInt( "Settings", "ENV_Write_OBD_TG_F_Status_3", 0, profileFile ) );
    putValue( ENV_Write_OBD_TG_F_Status_4, getProfileInt( "Settings", "ENV_Write_OBD_TG_F_Status_4", 0, profileFile ) );
    putValue( ENV_Write_OBD_TG_Sens_Rohwert_1, getProfileInt( "Settings", "ENV_Write_OBD_TG_Sens_Rohwert_1", 0, profileFile ) );
    putValue( ENV_Write_OBD_TG_Sens_Rohwert_2, getProfileInt( "Settings", "ENV_Write_OBD_TG_Sens_Rohwert_2", 0, profileFile ) );
    putValue( ENV_Write_OBD_TG_Sens_Rohwert_3, getProfileInt( "Settings", "ENV_Write_OBD_TG_Sens_Rohwert_3", 0, profileFile ) );
    putValue( ENV_Write_OBD_TG_Sens_Rohwert_4, getProfileInt( "Settings", "ENV_Write_OBD_TG_Sens_Rohwert_4", 0, profileFile ) );
    putValue( ENV_Write_RES_TripReset, getProfileInt( "Settings", "ENV_Write_RES_TripReset", 0, profileFile ) );
    putValue( ENV_Write_SK1_Key_Data_1, getProfileInt( "Settings", "ENV_Write_SK1_Key_Data_1", 0, profileFile ) );
    putValue( ENV_Write_SK1_Key_Data_2, getProfileInt( "Settings", "ENV_Write_SK1_Key_Data_2", 0, profileFile ) );
    putValue( ENV_Write_SK1_Key_Data_3, getProfileInt( "Settings", "ENV_Write_SK1_Key_Data_3", 0, profileFile ) );
    putValue( ENV_Write_SK1_Key_Data_4, getProfileInt( "Settings", "ENV_Write_SK1_Key_Data_4", 0, profileFile ) );
    putValue( ENV_Write_SK1_Key_Data_5, getProfileInt( "Settings", "ENV_Write_SK1_Key_Data_5", 0, profileFile ) );
    putValue( ENV_Write_SK1_Key_Data_6, getProfileInt( "Settings", "ENV_Write_SK1_Key_Data_6", 0, profileFile ) );
    putValue( ENV_Write_SK1_Key_Data_7, getProfileInt( "Settings", "ENV_Write_SK1_Key_Data_7", 0, profileFile ) );
    putValue( ENV_Write_SK1_Key_Data_8, getProfileInt( "Settings", "ENV_Write_SK1_Key_Data_8", 0, profileFile ) );
    putValue( ENV_Write_SK1_Key_Data_9, getProfileInt( "Settings", "ENV_Write_SK1_Key_Data_9", 0, profileFile ) );
    putValue( ENV_Write_SK1_MUX, getProfileInt( "Settings", "ENV_Write_SK1_MUX", 0, profileFile ) );
    putValue( ENV_Write_UH_Jahr_0, getProfileInt( "Settings", "ENV_Write_UH_Jahr_0", 0, profileFile ) );
    putValue( ENV_Write_UH_Minute_0, getProfileInt( "Settings", "ENV_Write_UH_Minute_0", 0, profileFile ) );
    putValue( ENV_Write_UH_Monat_0, getProfileInt( "Settings", "ENV_Write_UH_Monat_0", 0, profileFile ) );
    putValue( ENV_Write_UH_Sekunde_0, getProfileInt( "Settings", "ENV_Write_UH_Sekunde_0", 0, profileFile ) );
    putValue( ENV_Write_UH_Stunde_0, getProfileInt( "Settings", "ENV_Write_UH_Stunde_0", 0, profileFile ) );
    putValue( ENV_Write_UH_Tag_0, getProfileInt( "Settings", "ENV_Write_UH_Tag_0", 0, profileFile ) );
    putValue( ENV_Write_VIN_01_MUX, getProfileInt( "Settings", "ENV_Write_VIN_01_MUX", 0, profileFile ) );
    putValue( ENV_Write_VIN_10, getProfileInt( "Settings", "ENV_Write_VIN_10", 0, profileFile ) );
    putValue( ENV_Write_VIN_11, getProfileInt( "Settings", "ENV_Write_VIN_11", 0, profileFile ) );
    putValue( ENV_Write_VIN_12, getProfileInt( "Settings", "ENV_Write_VIN_12", 0, profileFile ) );
    putValue( ENV_Write_VIN_13, getProfileInt( "Settings", "ENV_Write_VIN_13", 0, profileFile ) );
    putValue( ENV_Write_VIN_14, getProfileInt( "Settings", "ENV_Write_VIN_14", 0, profileFile ) );
    putValue( ENV_Write_VIN_15, getProfileInt( "Settings", "ENV_Write_VIN_15", 0, profileFile ) );
    putValue( ENV_Write_VIN_16, getProfileInt( "Settings", "ENV_Write_VIN_16", 0, profileFile ) );
    putValue( ENV_Write_VIN_17, getProfileInt( "Settings", "ENV_Write_VIN_17", 0, profileFile ) );
    putValue( ENV_Write_VIN_1, getProfileInt( "Settings", "ENV_Write_VIN_1", 0, profileFile ) );
    putValue( ENV_Write_VIN_2, getProfileInt( "Settings", "ENV_Write_VIN_2", 0, profileFile ) );
    putValue( ENV_Write_VIN_3, getProfileInt( "Settings", "ENV_Write_VIN_3", 0, profileFile ) );
    putValue( ENV_Write_VIN_4, getProfileInt( "Settings", "ENV_Write_VIN_4", 0, profileFile ) );
    putValue( ENV_Write_VIN_5, getProfileInt( "Settings", "ENV_Write_VIN_5", 0, profileFile ) );
    putValue( ENV_Write_VIN_6, getProfileInt( "Settings", "ENV_Write_VIN_6", 0, profileFile ) );
    putValue( ENV_Write_VIN_7, getProfileInt( "Settings", "ENV_Write_VIN_7", 0, profileFile ) );
    putValue( ENV_Write_VIN_8, getProfileInt( "Settings", "ENV_Write_VIN_8", 0, profileFile ) );
    putValue( ENV_Write_VIN_9, getProfileInt( "Settings", "ENV_Write_VIN_9", 0, profileFile ) );
    putValue( ENV_Write_WFS_Betrieb_Lesespule, getProfileInt( "Settings", "ENV_Write_WFS_Betrieb_Lesespule", 0, profileFile ) );
    putValue( ENV_Write_WFS_Challenge, getProfileInt( "Settings", "ENV_Write_WFS_Challenge", 0, profileFile ) );
    putValue( ENV_Write_WFS_ELV_authorisiert, getProfileInt( "Settings", "ENV_Write_WFS_ELV_authorisiert", 0, profileFile ) );
    putValue( ENV_Write_WFS_GoTrigger, getProfileInt( "Settings", "ENV_Write_WFS_GoTrigger", 0, profileFile ) );
    putValue( ENV_Write_WFS_ID_Geb_autorisiert_in_Kl15, getProfileInt( "Settings", "ENV_Write_WFS_ID_Geb_autorisiert_in_Kl15", 0, profileFile ) );
    putValue( ENV_Write_WFS_IMMO_ELV_CRC, getProfileInt( "Settings", "ENV_Write_WFS_IMMO_ELV_CRC", 0, profileFile ) );
    putValue( ENV_Write_WFS_IMMO_ELV_Status, getProfileInt( "Settings", "ENV_Write_WFS_IMMO_ELV_Status", 0, profileFile ) );
    putValue( ENV_Write_WFS_IMMO_GSG_CRC, getProfileInt( "Settings", "ENV_Write_WFS_IMMO_GSG_CRC", 0, profileFile ) );
    putValue( ENV_Write_WFS_IMMO_GSG_Status, getProfileInt( "Settings", "ENV_Write_WFS_IMMO_GSG_Status", 0, profileFile ) );
    putValue( ENV_Write_WFS_IMMO_MSG1_CRC, getProfileInt( "Settings", "ENV_Write_WFS_IMMO_MSG1_CRC", 0, profileFile ) );
    putValue( ENV_Write_WFS_IMMO_MSG1_Status, getProfileInt( "Settings", "ENV_Write_WFS_IMMO_MSG1_Status", 0, profileFile ) );
    putValue( ENV_Write_WFS_IMMO_MSG2_CRC, getProfileInt( "Settings", "ENV_Write_WFS_IMMO_MSG2_CRC", 0, profileFile ) );
    putValue( ENV_Write_WFS_IMMO_MSG2_Status, getProfileInt( "Settings", "ENV_Write_WFS_IMMO_MSG2_Status", 0, profileFile ) );
    putValue( ENV_Write_WFS_IMMO_MSG3_CRC, getProfileInt( "Settings", "ENV_Write_WFS_IMMO_MSG3_CRC", 0, profileFile ) );
    putValue( ENV_Write_WFS_IMMO_MSG3_Status, getProfileInt( "Settings", "ENV_Write_WFS_IMMO_MSG3_Status", 0, profileFile ) );
    putValue( ENV_Write_WFS_IMMO_MSG4_CRC, getProfileInt( "Settings", "ENV_Write_WFS_IMMO_MSG4_CRC", 0, profileFile ) );
    putValue( ENV_Write_WFS_IMMO_MSG4_Status, getProfileInt( "Settings", "ENV_Write_WFS_IMMO_MSG4_Status", 0, profileFile ) );
    putValue( ENV_Write_WFS_Kombi_Resp_Data, getProfileInt( "Settings", "ENV_Write_WFS_Kombi_Resp_Data", 0, profileFile ) );
    putValue( ENV_Write_WFS_Nr_ID_Geber, getProfileInt( "Settings", "ENV_Write_WFS_Nr_ID_Geber", 0, profileFile ) );
    putValue( ENV_Write_WFS_Schluessel_Fahrberecht, getProfileInt( "Settings", "ENV_Write_WFS_Schluessel_Fahrberecht", 0, profileFile ) );
    putValue( ENV_Write_WFS_Trigger_TranspID, getProfileInt( "Settings", "ENV_Write_WFS_Trigger_TranspID", 0, profileFile ) );
    putValue( ENV_Write_WFS_Zufallszahl, getProfileInt( "Settings", "ENV_Write_WFS_Zufallszahl", 0, profileFile ) );
    putValue( ON_OFF_BAP_LoadSave_INI, getProfileInt( "Settings", "ON_OFF_BAP_LoadSave_INI", 0, profileFile ) );
    putValue( ON_OFF_BAP_Main, getProfileInt( "Settings", "ON_OFF_BAP_Main", 0, profileFile ) );
    putValue( ENV_PERF_CarModel, getProfileInt( "Settings", "ENV_PERF_CarModel", 0, profileFile ) );
    putValue( ENV_PERF_Logging, getProfileInt( "Settings", "ENV_PERF_Logging", 0, profileFile ) );
    putValue( ENV_PERF_ScenarioTableBox, getProfileInt( "Settings", "ENV_PERF_ScenarioTableBox", 0, profileFile ) );
    putValue( ENV_PERF_BasicLoadSwitch, getProfileInt( "Settings", "ENV_PERF_BasicLoadSwitch", 0, profileFile ) );
    putValue( ENV_PERF_DimmingSweepSwitch, getProfileInt( "Settings", "ENV_PERF_DimmingSweepSwitch", 0, profileFile ) );
    putValue( ENV_PERF_TankKmtSwitch, getProfileInt( "Settings", "ENV_PERF_TankKmtSwitch", 0, profileFile ) );
    putValue( ENV_PERF_TurnLightsSwitch, getProfileInt( "Settings", "ENV_PERF_TurnLightsSwitch", 0, profileFile ) );
    putValue( ENV_PERF_RadioListSwitch, getProfileInt( "Settings", "ENV_PERF_RadioListSwitch", 0, profileFile ) );
    putValue( ENV_PERF_PointerSweepSwitch, getProfileInt( "Settings", "ENV_PERF_PointerSweepSwitch", 0, profileFile ) );
    putValue( ENV_PERF_StartSwitch, getProfileInt( "Settings", "ENV_PERF_StartSwitch", 0, profileFile ) );
    putValue( ENV_NGSM_Support, getProfileInt( "Settings", "ENV_NGSM_Support", 0, profileFile ) );
    putValue( ENV_NGSM_OnStopEnable, getProfileInt( "Settings", "ENV_NGSM_OnStopEnable", 0, profileFile ) );
    putValue( ENV_NGSM_OnStartEnable, getProfileInt( "Settings", "ENV_NGSM_OnStartEnable", 0, profileFile ) );
    putValue( ENV_NGSM_ActualVoltageDisplay, getProfileFloat( "Settings", "ENV_NGSM_ActualVoltageDisplay", 0, profileFile ) );
    putValue( ENV_NGSM_OutputState, getProfileInt( "Settings", "ENV_NGSM_OutputState", 0, profileFile ) );
    putValue( ENV_NGSM_PowerSupplyState, getProfileInt( "Settings", "ENV_NGSM_PowerSupplyState", 0, profileFile ) );
    putValue( ENV_NGSM_VoltageDisplay, getProfileFloat( "Settings", "ENV_NGSM_VoltageDisplay", 0, profileFile ) );
    putValue( ENV_NGSM_MaxCurrent, getProfileInt( "Settings", "ENV_NGSM_MaxCurrent", 0, profileFile ) );
    putValue( ENV_NGSM_SetCurveSelector, getProfileInt( "Settings", "ENV_NGSM_SetCurveSelector", 0, profileFile ) );
    putValue( ENV_NGSM_OutputControl, getProfileInt( "Settings", "ENV_NGSM_OutputControl", 0, profileFile ) );
    putValue( ENV_NGSM_ActualCurrentDisplay, getProfileFloat( "Settings", "ENV_NGSM_ActualCurrentDisplay", 0, profileFile ) );
    putValue( ENV_NGSM_VoltageSliderControl, getProfileFloat( "Settings", "ENV_NGSM_VoltageSliderControl", 0, profileFile ) );
    putValue( ENV_NGSM_PowerSwitch, getProfileInt( "Settings", "ENV_NGSM_PowerSwitch", 0, profileFile ) );
    putValue( ENV_NGSM_CurveRetry, getProfileInt( "Settings", "ENV_NGSM_CurveRetry", 0, profileFile ) );
    putValue( ENV_INTEGR_DisVoltageCurves, getProfileInt( "Settings", "ENV_INTEGR_DisVoltageCurves", 0, profileFile ) );
    putValue( ENV_INTEGR_Logging, getProfileInt( "Settings", "ENV_INTEGR_Logging", 0, profileFile ) );
    putValue( ENV_INTEGR_TimerResetControl, getProfileInt( "Settings", "ENV_INTEGR_TimerResetControl", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase, getProfileInt( "Settings", "ENV_INTEGR_TestCase", 0, profileFile ) );
    putValue( ENV_INTEGR_TestMode, getProfileInt( "Settings", "ENV_INTEGR_TestMode", 0, profileFile ) );
    putValue( HIL_b_SI_BUS_01, getProfileInt( "Settings", "HIL_b_SI_BUS_01", 0, profileFile ) );
    putValue( HIL_b_SI_BUS_02, getProfileInt( "Settings", "HIL_b_SI_BUS_02", 0, profileFile ) );
    putValue( HIL_b_SI_BUS_03, getProfileInt( "Settings", "HIL_b_SI_BUS_03", 0, profileFile ) );
    putValue( HIL_b_SI_BUS_04, getProfileInt( "Settings", "HIL_b_SI_BUS_04", 0, profileFile ) );
    putValue( HIL_b_SI_BUS_06, getProfileInt( "Settings", "HIL_b_SI_BUS_06", 0, profileFile ) );
    putValue( HIL_b_SI_BUS_10, getProfileInt( "Settings", "HIL_b_SI_BUS_10", 0, profileFile ) );
    putValue( HIL_b_SI_BUS_14, getProfileInt( "Settings", "HIL_b_SI_BUS_14", 0, profileFile ) );
    putValue( HIL_s_ara_DLC_fehler, getProfileInt( "Settings", "HIL_s_ara_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_ara_falsch_codiert, getProfileInt( "Settings", "HIL_s_ara_falsch_codiert", 0, profileFile ) );
    putValue( HIL_s_ara_timeout_fehler, getProfileInt( "Settings", "HIL_s_ara_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_bcm1_DLC_fehler, getProfileInt( "Settings", "HIL_s_bcm1_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_bcm1_timeout, getProfileInt( "Settings", "HIL_s_bcm1_timeout", 0, profileFile ) );
    putValue( HIL_s_bcm1_timeout_fehler, getProfileInt( "Settings", "HIL_s_bcm1_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_daempfer_DLC_fehler, getProfileInt( "Settings", "HIL_s_daempfer_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_daempfer_falsch_codiert, getProfileInt( "Settings", "HIL_s_daempfer_falsch_codiert", 0, profileFile ) );
    putValue( HIL_s_daempfer_timeout, getProfileInt( "Settings", "HIL_s_daempfer_timeout", 0, profileFile ) );
    putValue( HIL_s_daempfer_timeout_fehler, getProfileInt( "Settings", "HIL_s_daempfer_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_DCDC_02_DLC_fehler, getProfileInt( "Settings", "HIL_s_DCDC_02_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_DCDC_02_timeout, getProfileInt( "Settings", "HIL_s_DCDC_02_timeout", 0, profileFile ) );
    putValue( HIL_s_DCDC_02_timeout_fehler, getProfileInt( "Settings", "HIL_s_DCDC_02_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_eCall_timeout_fehler, getProfileInt( "Settings", "HIL_s_eCall_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_elv_DLC_fehler, getProfileInt( "Settings", "HIL_s_elv_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_elv_falsch_codiert, getProfileInt( "Settings", "HIL_s_elv_falsch_codiert", 0, profileFile ) );
    putValue( HIL_s_elv_timeout, getProfileInt( "Settings", "HIL_s_elv_timeout", 0, profileFile ) );
    putValue( HIL_s_elv_timeout_fehler, getProfileInt( "Settings", "HIL_s_elv_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_epb_falsch_codiert, getProfileInt( "Settings", "HIL_s_epb_falsch_codiert", 0, profileFile ) );
    putValue( HIL_s_EPS_01_fifo_safe_state, getProfileInt( "Settings", "HIL_s_EPS_01_fifo_safe_state", 0, profileFile ) );
    putValue( HIL_s_eps_falsch_codiert, getProfileInt( "Settings", "HIL_s_eps_falsch_codiert", 0, profileFile ) );
    putValue( HIL_s_ESP_24_fifo_safe_state, getProfileInt( "Settings", "HIL_s_ESP_24_fifo_safe_state", 0, profileFile ) );
    putValue( HIL_s_gateway_DLC_fehler, getProfileInt( "Settings", "HIL_s_gateway_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_gateway_timeout, getProfileInt( "Settings", "HIL_s_gateway_timeout", 0, profileFile ) );
    putValue( HIL_s_gateway_timeout_fehler, getProfileInt( "Settings", "HIL_s_gateway_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_HVLM_05_timeout, getProfileInt( "Settings", "HIL_s_HVLM_05_timeout", 0, profileFile ) );
    putValue( HIL_s_kessy_timeout, getProfileInt( "Settings", "HIL_s_kessy_timeout", 0, profileFile ) );
    putValue( HIL_s_KFG_DLC_fehler, getProfileInt( "Settings", "HIL_s_KFG_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_KFG_timeout, getProfileInt( "Settings", "HIL_s_KFG_timeout", 0, profileFile ) );
    putValue( HIL_s_KFG_timeout_fehler, getProfileInt( "Settings", "HIL_s_KFG_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_Klima_12_timeout, getProfileInt( "Settings", "HIL_s_Klima_12_timeout", 0, profileFile ) );
    putValue( HIL_s_ldw_DLC_fehler, getProfileInt( "Settings", "HIL_s_ldw_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_ldw_timeout, getProfileInt( "Settings", "HIL_s_ldw_timeout", 0, profileFile ) );
    putValue( HIL_s_ldw_timeout_fehler, getProfileInt( "Settings", "HIL_s_ldw_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_mainunit_DLC_fehler, getProfileInt( "Settings", "HIL_s_mainunit_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_mainunit_timeout, getProfileInt( "Settings", "HIL_s_mainunit_timeout", 0, profileFile ) );
    putValue( HIL_s_mainunit_timeout_fehler, getProfileInt( "Settings", "HIL_s_mainunit_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_mem_bfs_timeout, getProfileInt( "Settings", "HIL_s_mem_bfs_timeout", 0, profileFile ) );
    putValue( HIL_s_mem_fs_timeout, getProfileInt( "Settings", "HIL_s_mem_fs_timeout", 0, profileFile ) );
    putValue( HIL_s_motor_DLC_fehler, getProfileInt( "Settings", "HIL_s_motor_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_motor_timeout, getProfileInt( "Settings", "HIL_s_motor_timeout", 0, profileFile ) );
    putValue( HIL_s_motor_timeout_fehler, getProfileInt( "Settings", "HIL_s_motor_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_MVK_01_CRC_fehler2, getProfileInt( "Settings", "HIL_s_MVK_01_CRC_fehler2", 0, profileFile ) );
    putValue( HIL_s_MVK_01_fifo_bz_fehler, getProfileInt( "Settings", "HIL_s_MVK_01_fifo_bz_fehler", 0, profileFile ) );
    putValue( HIL_s_MVK_01_fifo_safe_state, getProfileInt( "Settings", "HIL_s_MVK_01_fifo_safe_state", 0, profileFile ) );
    putValue( HIL_s_MVK_01_fifo_to_fehler, getProfileInt( "Settings", "HIL_s_MVK_01_fifo_to_fehler", 0, profileFile ) );
    putValue( HIL_s_ocu_timeout, getProfileInt( "Settings", "HIL_s_ocu_timeout", 0, profileFile ) );
    putValue( HIL_s_perso_DLC_fehler, getProfileInt( "Settings", "HIL_s_perso_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_perso_timeout, getProfileInt( "Settings", "HIL_s_perso_timeout", 0, profileFile ) );
    putValue( HIL_s_perso_timeout_fehler, getProfileInt( "Settings", "HIL_s_perso_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_pla_DLC_fehler, getProfileInt( "Settings", "HIL_s_pla_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_pla_timeout, getProfileInt( "Settings", "HIL_s_pla_timeout", 0, profileFile ) );
    putValue( HIL_s_pla_timeout_fehler, getProfileInt( "Settings", "HIL_s_pla_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_TSL_timeout, getProfileInt( "Settings", "HIL_s_TSL_timeout", 0, profileFile ) );
    putValue( HIL_s_TSR_timeout, getProfileInt( "Settings", "HIL_s_TSR_timeout", 0, profileFile ) );
    putValue( HIL_s_acc_DLC_fehler, getProfileInt( "Settings", "HIL_s_acc_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_acc_timeout, getProfileInt( "Settings", "HIL_s_acc_timeout", 0, profileFile ) );
    putValue( HIL_s_acc_timeout_fehler, getProfileInt( "Settings", "HIL_s_acc_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_afs_DLC_fehler, getProfileInt( "Settings", "HIL_s_afs_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_afs_timeout, getProfileInt( "Settings", "HIL_s_afs_timeout", 0, profileFile ) );
    putValue( HIL_s_afs_timeout_fehler, getProfileInt( "Settings", "HIL_s_afs_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_aga_DLC_fehler, getProfileInt( "Settings", "HIL_s_aga_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_aga_timeout, getProfileInt( "Settings", "HIL_s_aga_timeout", 0, profileFile ) );
    putValue( HIL_s_aga_timeout_fehler, getProfileInt( "Settings", "HIL_s_aga_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_Airbag_01_DLC_fehler, getProfileInt( "Settings", "HIL_s_Airbag_01_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_Airbag_01_fifo_safe_state, getProfileInt( "Settings", "HIL_s_Airbag_01_fifo_safe_state", 0, profileFile ) );
    putValue( HIL_s_anhaenger_timeout, getProfileInt( "Settings", "HIL_s_anhaenger_timeout", 0, profileFile ) );
    putValue( HIL_s_ara_timeout, getProfileInt( "Settings", "HIL_s_ara_timeout", 0, profileFile ) );
    putValue( HIL_s_awv_DLC_fehler, getProfileInt( "Settings", "HIL_s_awv_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_awv_timeout, getProfileInt( "Settings", "HIL_s_awv_timeout", 0, profileFile ) );
    putValue( HIL_s_awv_timeout_fehler, getProfileInt( "Settings", "HIL_s_awv_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_BEM_06_CRC_fehler2, getProfileInt( "Settings", "HIL_s_BEM_06_CRC_fehler2", 0, profileFile ) );
    putValue( HIL_s_BEM_06_fifo_safe_state, getProfileInt( "Settings", "HIL_s_BEM_06_fifo_safe_state", 0, profileFile ) );
    putValue( HIL_s_bus_off_fehler, getProfileInt( "Settings", "HIL_s_bus_off_fehler", 0, profileFile ) );
    putValue( HIL_s_can_ram_check_fehler, getProfileInt( "Settings", "HIL_s_can_ram_check_fehler", 0, profileFile ) );
    putValue( HIL_s_feststellbremse_konv, getProfileInt( "Settings", "HIL_s_feststellbremse_konv", 0, profileFile ) );
    putValue( HIL_s_rdk_DLC_fehler, getProfileInt( "Settings", "HIL_s_rdk_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_rdk_falsch_codiert, getProfileInt( "Settings", "HIL_s_rdk_falsch_codiert", 0, profileFile ) );
    putValue( HIL_s_rdk_timeout, getProfileInt( "Settings", "HIL_s_rdk_timeout", 0, profileFile ) );
    putValue( HIL_s_rdk_timeout_fehler, getProfileInt( "Settings", "HIL_s_rdk_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_rka_DLC_fehler, getProfileInt( "Settings", "HIL_s_rka_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_rka_falsch_codiert, getProfileInt( "Settings", "HIL_s_rka_falsch_codiert", 0, profileFile ) );
    putValue( HIL_s_rka_timeout, getProfileInt( "Settings", "HIL_s_rka_timeout", 0, profileFile ) );
    putValue( HIL_s_rka_timeout_fehler, getProfileInt( "Settings", "HIL_s_rka_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_SCR_timeout, getProfileInt( "Settings", "HIL_s_SCR_timeout", 0, profileFile ) );
    putValue( HIL_s_SMLS_01_timeout, getProfileInt( "Settings", "HIL_s_SMLS_01_timeout", 0, profileFile ) );
    putValue( HIL_s_STH_01_timeout, getProfileInt( "Settings", "HIL_s_STH_01_timeout", 0, profileFile ) );
    putValue( HIL_s_swa_DLC_fehler, getProfileInt( "Settings", "HIL_s_swa_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_swa_falsch_codiert, getProfileInt( "Settings", "HIL_s_swa_falsch_codiert", 0, profileFile ) );
    putValue( HIL_s_swa_timeout, getProfileInt( "Settings", "HIL_s_swa_timeout", 0, profileFile ) );
    putValue( HIL_s_swa_timeout_fehler, getProfileInt( "Settings", "HIL_s_swa_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_TCO_01_DLC_fehler, getProfileInt( "Settings", "HIL_s_TCO_01_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_TCO_01_timeout, getProfileInt( "Settings", "HIL_s_TCO_01_timeout", 0, profileFile ) );
    putValue( HIL_s_TCO_01_timeout_fehler, getProfileInt( "Settings", "HIL_s_TCO_01_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_verdeck_01_timeout, getProfileInt( "Settings", "HIL_s_verdeck_01_timeout", 0, profileFile ) );
    putValue( HIL_s_Wischer_timeout, getProfileInt( "Settings", "HIL_s_Wischer_timeout", 0, profileFile ) );
    putValue( HIL_b_SI_CAB_V09, getProfileInt( "Settings", "HIL_b_SI_CAB_V09", 0, profileFile ) );
    putValue( HIL_s_Airbag_01_CRC_fehler2, getProfileInt( "Settings", "HIL_s_Airbag_01_CRC_fehler2", 0, profileFile ) );
    putValue( HIL_s_Airbag_01_fifo_bz_fehler, getProfileInt( "Settings", "HIL_s_Airbag_01_fifo_bz_fehler", 0, profileFile ) );
    putValue( HIL_s_Airbag_01_fifo_to_fehler, getProfileInt( "Settings", "HIL_s_Airbag_01_fifo_to_fehler", 0, profileFile ) );
    putValue( HIL_s_BEM_06_fifo_bz_fehler, getProfileInt( "Settings", "HIL_s_BEM_06_fifo_bz_fehler", 0, profileFile ) );
    putValue( HIL_s_BEM_06_fifo_to_fehler, getProfileInt( "Settings", "HIL_s_BEM_06_fifo_to_fehler", 0, profileFile ) );
    putValue( HIL_s_BMS_DLC_fehler, getProfileInt( "Settings", "HIL_s_BMS_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_BMS_timeout, getProfileInt( "Settings", "HIL_s_BMS_timeout", 0, profileFile ) );
    putValue( HIL_s_BMS_timeout_fehler, getProfileInt( "Settings", "HIL_s_BMS_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_EPB_03_CRC_fehler2, getProfileInt( "Settings", "HIL_s_EPB_03_CRC_fehler2", 0, profileFile ) );
    putValue( HIL_s_EPB_03_fifo_bz_fehler, getProfileInt( "Settings", "HIL_s_EPB_03_fifo_bz_fehler", 0, profileFile ) );
    putValue( HIL_s_EPB_03_fifo_to_fehler, getProfileInt( "Settings", "HIL_s_EPB_03_fifo_to_fehler", 0, profileFile ) );
    putValue( HIL_s_EPS_01_CRC_fehler2, getProfileInt( "Settings", "HIL_s_EPS_01_CRC_fehler2", 0, profileFile ) );
    putValue( HIL_s_EPS_01_fifo_bz_fehler, getProfileInt( "Settings", "HIL_s_EPS_01_fifo_bz_fehler", 0, profileFile ) );
    putValue( HIL_s_EPS_01_fifo_to_fehler, getProfileInt( "Settings", "HIL_s_EPS_01_fifo_to_fehler", 0, profileFile ) );
    putValue( HIL_s_ESP_24_CRC_fehler2, getProfileInt( "Settings", "HIL_s_ESP_24_CRC_fehler2", 0, profileFile ) );
    putValue( HIL_s_ESP_24_fifo_bz_fehler, getProfileInt( "Settings", "HIL_s_ESP_24_fifo_bz_fehler", 0, profileFile ) );
    putValue( HIL_s_ESP_24_fifo_to_fehler, getProfileInt( "Settings", "HIL_s_ESP_24_fifo_to_fehler", 0, profileFile ) );
    putValue( HIL_s_ESP_30_CRC_fehler2, getProfileInt( "Settings", "HIL_s_ESP_30_CRC_fehler2", 0, profileFile ) );
    putValue( HIL_s_ESP_30_fifo_bz_fehler, getProfileInt( "Settings", "HIL_s_ESP_30_fifo_bz_fehler", 0, profileFile ) );
    putValue( HIL_s_ESP_30_fifo_safe_state, getProfileInt( "Settings", "HIL_s_ESP_30_fifo_safe_state", 0, profileFile ) );
    putValue( HIL_s_ESP_30_fifo_to_fehler, getProfileInt( "Settings", "HIL_s_ESP_30_fifo_to_fehler", 0, profileFile ) );
    putValue( HIL_s_LSH_timeout, getProfileInt( "Settings", "HIL_s_LSH_timeout", 0, profileFile ) );
    putValue( HIL_s_TSG_FT_DLC_fehler, getProfileInt( "Settings", "HIL_s_TSG_FT_DLC_fehler", 0, profileFile ) );
    putValue( HIL_s_TSG_FT_timeout, getProfileInt( "Settings", "HIL_s_TSG_FT_timeout", 0, profileFile ) );
    putValue( HIL_s_TSG_FT_timeout_fehler, getProfileInt( "Settings", "HIL_s_TSG_FT_timeout_fehler", 0, profileFile ) );
    putValue( HIL_s_WBA_03_CRC_fehler2, getProfileInt( "Settings", "HIL_s_WBA_03_CRC_fehler2", 0, profileFile ) );
    putValue( HIL_s_WBA_03_fifo_bz_fehler, getProfileInt( "Settings", "HIL_s_WBA_03_fifo_bz_fehler", 0, profileFile ) );
    putValue( HIL_s_WBA_03_fifo_safe_state, getProfileInt( "Settings", "HIL_s_WBA_03_fifo_safe_state", 0, profileFile ) );
    putValue( HIL_s_WBA_03_fifo_to_fehler, getProfileInt( "Settings", "HIL_s_WBA_03_fifo_to_fehler", 0, profileFile ) );
    putValue( HIL_b_BCM_Anf_AAW_MoLaWa, getProfileInt( "Settings", "HIL_b_BCM_Anf_AAW_MoLaWa", 0, profileFile ) );
    putValue( HIL_b_BCM_anf_VLW, getProfileInt( "Settings", "HIL_b_BCM_anf_VLW", 0, profileFile ) );
    putValue( HIL_b_BCM_Handbremse_Hinweis, getProfileInt( "Settings", "HIL_b_BCM_Handbremse_Hinweis", 0, profileFile ) );
    putValue( HIL_b_BCM_Remotestart_KL15_Anf, getProfileInt( "Settings", "HIL_b_BCM_Remotestart_KL15_Anf", 0, profileFile ) );
    putValue( HIL_b_BCM_Waehlhebel_P_Hinweis, getProfileInt( "Settings", "HIL_b_BCM_Waehlhebel_P_Hinweis", 0, profileFile ) );
    putValue( HIL_b_ELV_LED_Rot, getProfileInt( "Settings", "HIL_b_ELV_LED_Rot", 0, profileFile ) );
    putValue( HIL_b_ELV_Txt_Defekt, getProfileInt( "Settings", "HIL_b_ELV_Txt_Defekt", 0, profileFile ) );
    putValue( HIL_b_ELV_Txt_Lkg_Bewegen, getProfileInt( "Settings", "HIL_b_ELV_Txt_Lkg_Bewegen", 0, profileFile ) );
    putValue( HIL_b_ELV_Txt_Werkstatt, getProfileInt( "Settings", "HIL_b_ELV_Txt_Werkstatt", 0, profileFile ) );
    putValue( HIL_b_FBS_Warn_Schluessel_Batt, getProfileInt( "Settings", "HIL_b_FBS_Warn_Schluessel_Batt", 0, profileFile ) );
    putValue( HIL_b_GE_Tipschaltempfehlung_verfuegbar, getProfileInt( "Settings", "HIL_b_GE_Tipschaltempfehlung_verfuegbar", 0, profileFile ) );
    putValue( HIL_b_KL_Geblaese_Status, getProfileInt( "Settings", "HIL_b_KL_Geblaese_Status", 0, profileFile ) );
    putValue( HIL_b_KST_Fahrerhinweis_6, getProfileInt( "Settings", "HIL_b_KST_Fahrerhinweis_6", 0, profileFile ) );
    putValue( HIL_b_KST_Txt_Komfortabschaltung, getProfileInt( "Settings", "HIL_b_KST_Txt_Komfortabschaltung", 0, profileFile ) );
    putValue( HIL_b_KST_Txt_P_Gang, getProfileInt( "Settings", "HIL_b_KST_Txt_P_Gang", 0, profileFile ) );
    putValue( HIL_b_KST_Txt_Panikabschaltung, getProfileInt( "Settings", "HIL_b_KST_Txt_Panikabschaltung", 0, profileFile ) );
    putValue( HIL_b_KST_Txt_Werkstatt, getProfileInt( "Settings", "HIL_b_KST_Txt_Werkstatt", 0, profileFile ) );
    putValue( HIL_b_KST_Warn_P2_ZST_def, getProfileInt( "Settings", "HIL_b_KST_Warn_P2_ZST_def", 0, profileFile ) );
    putValue( HIL_b_KST_Zuendungswarnung, getProfileInt( "Settings", "HIL_b_KST_Zuendungswarnung", 0, profileFile ) );
    putValue( HIL_b_RSt_Fahrerhinweise, getProfileInt( "Settings", "HIL_b_RSt_Fahrerhinweise", 0, profileFile ) );
    putValue( HIL_b_ZV_SafeFunktion_aktiv, getProfileInt( "Settings", "HIL_b_ZV_SafeFunktion_aktiv", 0, profileFile ) );
    putValue( HIL_hmi_wba_fahrstufe_anzeigen, getProfileInt( "Settings", "HIL_hmi_wba_fahrstufe_anzeigen", 0, profileFile ) );
    putValue( HIL_s_kanal1_belegt, getProfileInt( "Settings", "HIL_s_kanal1_belegt", 0, profileFile ) );
    putValue( HIL_s_kanal2_belegt, getProfileInt( "Settings", "HIL_s_kanal2_belegt", 0, profileFile ) );
    putValue( HIL_s_KBI_Audioabsenkung_MIB, getProfileInt( "Settings", "HIL_s_KBI_Audioabsenkung_MIB", 0, profileFile ) );
    putValue( HIL_s_schluesselwarnung, getProfileInt( "Settings", "HIL_s_schluesselwarnung", 0, profileFile ) );
    putValue( HIL_s_zpm_akustik_grundlautstaerke, getProfileInt( "Settings", "HIL_s_zpm_akustik_grundlautstaerke", 0, profileFile ) );
    putValue( HIL_s_zpm_akustik_ID, getProfileInt( "Settings", "HIL_s_zpm_akustik_ID", 0, profileFile ) );
    putValue( HIL_s_zpm_akustik_kennfeld_ID, getProfileInt( "Settings", "HIL_s_zpm_akustik_kennfeld_ID", 0, profileFile ) );
    putValue( HIL_s_zpm_akustik_sync, getProfileInt( "Settings", "HIL_s_zpm_akustik_sync", 0, profileFile ) );
    putValue( HIL_b_GE_Sollgang, getProfileInt( "Settings", "HIL_b_GE_Sollgang", 0, profileFile ) );
    putValue( HIL_b_GE_Sumpftemperatur, getProfileInt( "Settings", "HIL_b_GE_Sumpftemperatur", 0, profileFile ) );
    putValue( HIL_b_Getriebe_14_alt, getProfileInt( "Settings", "HIL_b_Getriebe_14_alt", 0, profileFile ) );
    putValue( HIL_b_MO_Antriebsstrang_Warnung_HS, getProfileInt( "Settings", "HIL_b_MO_Antriebsstrang_Warnung_HS", 0, profileFile ) );
    putValue( HIL_b_MO_WH_Texte, getProfileInt( "Settings", "HIL_b_MO_WH_Texte", 0, profileFile ) );
    putValue( HIL_b_WBA_Anforderung_Akustik, getProfileInt( "Settings", "HIL_b_WBA_Anforderung_Akustik", 0, profileFile ) );
    putValue( HIL_b_WBA_eing_Gang_02, getProfileInt( "Settings", "HIL_b_WBA_eing_Gang_02", 0, profileFile ) );
    putValue( HIL_b_WBA_Fahrstufe_02, getProfileInt( "Settings", "HIL_b_WBA_Fahrstufe_02", 0, profileFile ) );
    putValue( HIL_b_WBA_GE_Texte, getProfileInt( "Settings", "HIL_b_WBA_GE_Texte", 0, profileFile ) );
    putValue( HIL_b_WBA_GE_Texte_02, getProfileInt( "Settings", "HIL_b_WBA_GE_Texte_02", 0, profileFile ) );
    putValue( HIL_b_WBA_GE_Warnung_02, getProfileInt( "Settings", "HIL_b_WBA_GE_Warnung_02", 0, profileFile ) );
    putValue( HIL_b_WBA_GE_Zusatzwarnungen, getProfileInt( "Settings", "HIL_b_WBA_GE_Zusatzwarnungen", 0, profileFile ) );
    putValue( HIL_b_WBA_Schaltschema_02, getProfileInt( "Settings", "HIL_b_WBA_Schaltschema_02", 0, profileFile ) );
    putValue( HIL_b_WBA_Schaltschema_Fahreraktion, getProfileInt( "Settings", "HIL_b_WBA_Schaltschema_Fahreraktion", 0, profileFile ) );
    putValue( HIL_b_WBA_Schaltschema_FS_inaktiv, getProfileInt( "Settings", "HIL_b_WBA_Schaltschema_FS_inaktiv", 0, profileFile ) );
    putValue( HIL_b_WBA_Schaltschema_FS_vorwaerts, getProfileInt( "Settings", "HIL_b_WBA_Schaltschema_FS_vorwaerts", 0, profileFile ) );
    putValue( HIL_b_WBA_Schaltschema_Tippgasse, getProfileInt( "Settings", "HIL_b_WBA_Schaltschema_Tippgasse", 0, profileFile ) );
    putValue( HIL_b_WBA_Segeln_aktiv, getProfileInt( "Settings", "HIL_b_WBA_Segeln_aktiv", 0, profileFile ) );
    putValue( HIL_b_WBA_Shiftlock_Lampe, getProfileInt( "Settings", "HIL_b_WBA_Shiftlock_Lampe", 0, profileFile ) );
    putValue( HIL_b_WH_Verbau_Entsperrtaste, getProfileInt( "Settings", "HIL_b_WH_Verbau_Entsperrtaste", 0, profileFile ) );
    putValue( HIL_b_WH_Warnung_02, getProfileInt( "Settings", "HIL_b_WH_Warnung_02", 0, profileFile ) );
    putValue( HIL_hmi_bc_getriebetemperatur_anzeigen, getProfileInt( "Settings", "HIL_hmi_bc_getriebetemperatur_anzeigen", 0, profileFile ) );
    putValue( HIL_hmi_Tipschaltempfehlung_anzeigen, getProfileInt( "Settings", "HIL_hmi_Tipschaltempfehlung_anzeigen", 0, profileFile ) );
    putValue( HIL_hmi_wba_eingelegter_gang_anzeigen, getProfileInt( "Settings", "HIL_hmi_wba_eingelegter_gang_anzeigen", 0, profileFile ) );
    putValue( HIL_s_LED_Shiftlock, getProfileInt( "Settings", "HIL_s_LED_Shiftlock", 0, profileFile ) );
    putValue( HIL_hmi_Uhrzeit_Format, getProfileInt( "Settings", "HIL_hmi_Uhrzeit_Format", 0, profileFile ) );
    putValue( HIL_s_laptimer_aktuelle_rundenzeit, getProfileFloat( "Settings", "HIL_s_laptimer_aktuelle_rundenzeit", 0, profileFile ) );
    putValue( HIL_s_laptimer_gesamtzeit, getProfileFloat( "Settings", "HIL_s_laptimer_gesamtzeit", 0, profileFile ) );
    putValue( HIL_s_manuell_zeit_uhrzeit_minute, getProfileInt( "Settings", "HIL_s_manuell_zeit_uhrzeit_minute", 0, profileFile ) );
    putValue( HIL_s_Zeit_Uhrzeit_Minute, getProfileInt( "Settings", "HIL_s_Zeit_Uhrzeit_Minute", 0, profileFile ) );
    putValue( HIL_s_Zeit_Uhrzeit_Sekunde, getProfileInt( "Settings", "HIL_s_Zeit_Uhrzeit_Sekunde", 0, profileFile ) );
    putValue( HIL_hmi_Uhrzeit_Minute, getProfileInt( "Settings", "HIL_hmi_Uhrzeit_Minute", 0, profileFile ) );
    putValue( HIL_s_laptimer_abbruch, getProfileInt( "Settings", "HIL_s_laptimer_abbruch", 0, profileFile ) );
    putValue( HIL_s_laptimer_loeschen, getProfileInt( "Settings", "HIL_s_laptimer_loeschen", 0, profileFile ) );
    putValue( HIL_s_laptimer_pause, getProfileInt( "Settings", "HIL_s_laptimer_pause", 0, profileFile ) );
    putValue( HIL_s_laptimer_rundenzahl, getProfileInt( "Settings", "HIL_s_laptimer_rundenzahl", 0, profileFile ) );
    putValue( HIL_s_laptimer_schnellste_rundenzeit, getProfileFloat( "Settings", "HIL_s_laptimer_schnellste_rundenzeit", 0, profileFile ) );
    putValue( HIL_s_laptimer_start, getProfileInt( "Settings", "HIL_s_laptimer_start", 0, profileFile ) );
    putValue( HIL_s_laptimer_stop, getProfileInt( "Settings", "HIL_s_laptimer_stop", 0, profileFile ) );
    putValue( HIL_s_laptimer_zwischen, getProfileInt( "Settings", "HIL_s_laptimer_zwischen", 0, profileFile ) );
    putValue( HIL_s_laptimer_zwischenzeit, getProfileFloat( "Settings", "HIL_s_laptimer_zwischenzeit", 0, profileFile ) );
    putValue( HIL_s_manuell_zeit_set, getProfileInt( "Settings", "HIL_s_manuell_zeit_set", 0, profileFile ) );
    putValue( HIL_hmi_Datum_Wochentag, getProfileInt( "Settings", "HIL_hmi_Datum_Wochentag", 0, profileFile ) );
    putValue( HIL_hmi_Uhrzeit_Stunde, getProfileInt( "Settings", "HIL_hmi_Uhrzeit_Stunde", 0, profileFile ) );
    putValue( HIL_s_laptimer_durchschnitt_rundenzeit, getProfileFloat( "Settings", "HIL_s_laptimer_durchschnitt_rundenzeit", 0, profileFile ) );
    putValue( HIL_s_laptimer_langsamste_rundenzeit, getProfileFloat( "Settings", "HIL_s_laptimer_langsamste_rundenzeit", 0, profileFile ) );
    putValue( HIL_s_manuell_zeit_uhrzeit_stunde, getProfileInt( "Settings", "HIL_s_manuell_zeit_uhrzeit_stunde", 0, profileFile ) );
    putValue( HIL_s_symbol_uhrzeitquelle, getProfileInt( "Settings", "HIL_s_symbol_uhrzeitquelle", 0, profileFile ) );
    putValue( HIL_s_Zeit_Uhrzeit_Stunde, getProfileInt( "Settings", "HIL_s_Zeit_Uhrzeit_Stunde", 0, profileFile ) );
    putValue( HIL_hmi_symbol_uhrzeitquelle, getProfileInt( "Settings", "HIL_hmi_symbol_uhrzeitquelle", 0, profileFile ) );
    putValue( HIL_hmi_uhrzeit_blinktakt, getProfileInt( "Settings", "HIL_hmi_uhrzeit_blinktakt", 0, profileFile ) );
    putValue( HIL_hmi_uhrzeit_verstellmodus_minuten_anzeigen, getProfileInt( "Settings", "HIL_hmi_uhrzeit_verstellmodus_minuten_anzeigen", 0, profileFile ) );
    putValue( HIL_hmi_uhrzeit_verstellmodus_stunden_anzeigen, getProfileInt( "Settings", "HIL_hmi_uhrzeit_verstellmodus_stunden_anzeigen", 0, profileFile ) );
    putValue( HIL_s_betriebszeit, getProfileFloat( "Settings", "HIL_s_betriebszeit", 0, profileFile ) );
    putValue( HIL_s_Gueltigkeit_Synchzeit, getProfileInt( "Settings", "HIL_s_Gueltigkeit_Synchzeit", 0, profileFile ) );
    putValue( HIL_s_KBI_Einheit_Uhrzeit, getProfileInt( "Settings", "HIL_s_KBI_Einheit_Uhrzeit", 0, profileFile ) );
    putValue( HIL_s_laptimer_abStart_wartet, getProfileInt( "Settings", "HIL_s_laptimer_abStart_wartet", 0, profileFile ) );
    putValue( HIL_s_manuell_datum_set, getProfileInt( "Settings", "HIL_s_manuell_datum_set", 0, profileFile ) );
    putValue( HIL_s_UH_Jahr, getProfileInt( "Settings", "HIL_s_UH_Jahr", 0, profileFile ) );
    putValue( HIL_s_UH_Monat, getProfileInt( "Settings", "HIL_s_UH_Monat", 0, profileFile ) );
    putValue( HIL_s_UH_Sekunde, getProfileInt( "Settings", "HIL_s_UH_Sekunde", 0, profileFile ) );
    putValue( HIL_s_UH_Tag, getProfileInt( "Settings", "HIL_s_UH_Tag", 0, profileFile ) );
    putValue( HIL_s_AuthTime_Trigger_Distribution, getProfileInt( "Settings", "HIL_s_AuthTime_Trigger_Distribution", 0, profileFile ) );
    putValue( HIL_s_laptimer_runde, getProfileInt( "Settings", "HIL_s_laptimer_runde", 0, profileFile ) );
    putValue( HIL_s_laptimer_rundenzeiten_n_, getProfileFloat( "Settings", "HIL_s_laptimer_rundenzeiten_n_", 0, profileFile ) );
    putValue( HIL_s_laptimer_zustand, getProfileInt( "Settings", "HIL_s_laptimer_zustand", 0, profileFile ) );
    putValue( HIL_s_Motor_gelaufen, getProfileInt( "Settings", "HIL_s_Motor_gelaufen", 0, profileFile ) );
    putValue( HIL_s_UH_Minute, getProfileInt( "Settings", "HIL_s_UH_Minute", 0, profileFile ) );
    putValue( HIL_s_UH_Stunde, getProfileInt( "Settings", "HIL_s_UH_Stunde", 0, profileFile ) );
    putValue( HIL_s_UH_Typ, getProfileInt( "Settings", "HIL_s_UH_Typ", 0, profileFile ) );
    putValue( HIL_s_Zeit_Datum_Jahr, getProfileInt( "Settings", "HIL_s_Zeit_Datum_Jahr", 0, profileFile ) );
    putValue( HIL_s_Zeit_Datum_Monat, getProfileInt( "Settings", "HIL_s_Zeit_Datum_Monat", 0, profileFile ) );
    putValue( HIL_s_Zeit_Datum_Tag, getProfileInt( "Settings", "HIL_s_Zeit_Datum_Tag", 0, profileFile ) );
    putValue( HIL_b_AFS_Fehlertext, getProfileInt( "Settings", "HIL_b_AFS_Fehlertext", 0, profileFile ) );
    putValue( HIL_b_AFS_Lampe, getProfileInt( "Settings", "HIL_b_AFS_Lampe", 0, profileFile ) );
    putValue( HIL_b_AFS_LED_Blinkmode, getProfileInt( "Settings", "HIL_b_AFS_LED_Blinkmode", 0, profileFile ) );
    putValue( HIL_b_BCM1_Fahrlicht_Hinweis, getProfileInt( "Settings", "HIL_b_BCM1_Fahrlicht_Hinweis", 0, profileFile ) );
    putValue( HIL_b_BCM1_Hinweis_Lichtnachlauf, getProfileInt( "Settings", "HIL_b_BCM1_Hinweis_Lichtnachlauf", 0, profileFile ) );
    putValue( HIL_b_BCM1_Lichtwarn_Texte, getProfileInt( "Settings", "HIL_b_BCM1_Lichtwarn_Texte", 0, profileFile ) );
    putValue( HIL_b_BCM_LTM_Allwetterl_Status, getProfileInt( "Settings", "HIL_b_BCM_LTM_Allwetterl_Status", 0, profileFile ) );
    putValue( HIL_b_BCM_LTM_Nebell_Status, getProfileInt( "Settings", "HIL_b_BCM_LTM_Nebell_Status", 0, profileFile ) );
    putValue( HIL_b_BCM_LTM_Nebelschluss_Status, getProfileInt( "Settings", "HIL_b_BCM_LTM_Nebelschluss_Status", 0, profileFile ) );
    putValue( HIL_b_BCM_LTM_PopUp_Anf, getProfileInt( "Settings", "HIL_b_BCM_LTM_PopUp_Anf", 0, profileFile ) );
    putValue( HIL_b_BCM_LTM_PopUp_Inhalt, getProfileInt( "Settings", "HIL_b_BCM_LTM_PopUp_Inhalt", 0, profileFile ) );
    putValue( HIL_b_BCM_LTM_PopUp_Status, getProfileInt( "Settings", "HIL_b_BCM_LTM_PopUp_Status", 0, profileFile ) );
    putValue( HIL_b_BCM_Rueckfahrlicht_Anf, getProfileInt( "Settings", "HIL_b_BCM_Rueckfahrlicht_Anf", 0, profileFile ) );
    putValue( HIL_b_BM_Warnblinken, getProfileInt( "Settings", "HIL_b_BM_Warnblinken", 0, profileFile ) );
    putValue( HIL_b_Gong_TFL_Umschaltung, getProfileInt( "Settings", "HIL_b_Gong_TFL_Umschaltung", 0, profileFile ) );
    putValue( HIL_b_LH_Aussenlicht_def, getProfileInt( "Settings", "HIL_b_LH_Aussenlicht_def", 0, profileFile ) );
    putValue( HIL_b_LV_Abblendlicht_Anzeige, getProfileInt( "Settings", "HIL_b_LV_Abblendlicht_Anzeige", 0, profileFile ) );
    putValue( HIL_b_LV_AFL_defekt, getProfileInt( "Settings", "HIL_b_LV_AFL_defekt", 0, profileFile ) );
    putValue( HIL_b_LV_Aussenlicht_def, getProfileInt( "Settings", "HIL_b_LV_Aussenlicht_def", 0, profileFile ) );
    putValue( HIL_b_LV_Fernlicht_Anzeige, getProfileInt( "Settings", "HIL_b_LV_Fernlicht_Anzeige", 0, profileFile ) );
    putValue( HIL_b_LV_FLA_aktiv_Anzeige, getProfileInt( "Settings", "HIL_b_LV_FLA_aktiv_Anzeige", 0, profileFile ) );
    putValue( HIL_b_LV_FLA_defekt, getProfileInt( "Settings", "HIL_b_LV_FLA_defekt", 0, profileFile ) );
    putValue( HIL_b_LV_FLA_Sensor_blockiert, getProfileInt( "Settings", "HIL_b_LV_FLA_Sensor_blockiert", 0, profileFile ) );
    putValue( HIL_b_LV_Nebellicht_Anzeige, getProfileInt( "Settings", "HIL_b_LV_Nebellicht_Anzeige", 0, profileFile ) );
    putValue( HIL_b_LV_Nebelschlusslicht_Anzeige, getProfileInt( "Settings", "HIL_b_LV_Nebelschlusslicht_Anzeige", 0, profileFile ) );
    putValue( HIL_b_LWR_Lampe, getProfileInt( "Settings", "HIL_b_LWR_Lampe", 0, profileFile ) );
    putValue( HIL_b_LWR_Reisemodus_Texte, getProfileInt( "Settings", "HIL_b_LWR_Reisemodus_Texte", 0, profileFile ) );
    putValue( HIL_s_LED_Abblendlicht, getProfileInt( "Settings", "HIL_s_LED_Abblendlicht", 0, profileFile ) );
    putValue( HIL_s_LED_Fernlicht, getProfileInt( "Settings", "HIL_s_LED_Fernlicht", 0, profileFile ) );
    putValue( HIL_s_LED_FLA, getProfileInt( "Settings", "HIL_s_LED_FLA", 0, profileFile ) );
    putValue( HIL_s_LED_Nebellicht, getProfileInt( "Settings", "HIL_s_LED_Nebellicht", 0, profileFile ) );
    putValue( HIL_s_LED_Nebelschlusslicht, getProfileInt( "Settings", "HIL_s_LED_Nebelschlusslicht", 0, profileFile ) );
    putValue( HIL_s_LED_Standlicht, getProfileInt( "Settings", "HIL_s_LED_Standlicht", 0, profileFile ) );
    putValue( HIL_b_AAG_Blinker_H_aktiv, getProfileInt( "Settings", "HIL_b_AAG_Blinker_H_aktiv", 0, profileFile ) );
    putValue( HIL_b_AAG_Blinker_HL_def, getProfileInt( "Settings", "HIL_b_AAG_Blinker_HL_def", 0, profileFile ) );
    putValue( HIL_b_AAG_Blinker_HR_def, getProfileInt( "Settings", "HIL_b_AAG_Blinker_HR_def", 0, profileFile ) );
    putValue( HIL_b_AAG_Bremslicht_H_def, getProfileInt( "Settings", "HIL_b_AAG_Bremslicht_H_def", 0, profileFile ) );
    putValue( HIL_b_AAG_Schlusslicht_HL_def, getProfileInt( "Settings", "HIL_b_AAG_Schlusslicht_HL_def", 0, profileFile ) );
    putValue( HIL_b_AAG_Schlusslicht_HR_def, getProfileInt( "Settings", "HIL_b_AAG_Schlusslicht_HR_def", 0, profileFile ) );
    putValue( HIL_b_Blinken_li_Kombi_Takt, getProfileInt( "Settings", "HIL_b_Blinken_li_Kombi_Takt", 0, profileFile ) );
    putValue( HIL_b_Blinken_re_Kombi_Takt, getProfileInt( "Settings", "HIL_b_Blinken_re_Kombi_Takt", 0, profileFile ) );
    putValue( HIL_b_LH_3_Bremsl_def, getProfileInt( "Settings", "HIL_b_LH_3_Bremsl_def", 0, profileFile ) );
    putValue( HIL_b_LH_Blinker_li_def, getProfileInt( "Settings", "HIL_b_LH_Blinker_li_def", 0, profileFile ) );
    putValue( HIL_b_LH_Blinker_re_def, getProfileInt( "Settings", "HIL_b_LH_Blinker_re_def", 0, profileFile ) );
    putValue( HIL_b_LH_Brems_Blk_li_def, getProfileInt( "Settings", "HIL_b_LH_Brems_Blk_li_def", 0, profileFile ) );
    putValue( HIL_b_LH_Brems_Blk_re_def, getProfileInt( "Settings", "HIL_b_LH_Brems_Blk_re_def", 0, profileFile ) );
    putValue( HIL_b_LH_Bremsl_li_def, getProfileInt( "Settings", "HIL_b_LH_Bremsl_li_def", 0, profileFile ) );
    putValue( HIL_b_LH_Bremsl_li_ges_def, getProfileInt( "Settings", "HIL_b_LH_Bremsl_li_ges_def", 0, profileFile ) );
    putValue( HIL_b_LH_Bremsl_re_def, getProfileInt( "Settings", "HIL_b_LH_Bremsl_re_def", 0, profileFile ) );
    putValue( HIL_b_LH_Bremsl_re_ges_def, getProfileInt( "Settings", "HIL_b_LH_Bremsl_re_ges_def", 0, profileFile ) );
    putValue( HIL_b_LH_Kennzl_def, getProfileInt( "Settings", "HIL_b_LH_Kennzl_def", 0, profileFile ) );
    putValue( HIL_b_LH_Nebel_li_def, getProfileInt( "Settings", "HIL_b_LH_Nebel_li_def", 0, profileFile ) );
    putValue( HIL_b_LH_Nebel_mi_def, getProfileInt( "Settings", "HIL_b_LH_Nebel_mi_def", 0, profileFile ) );
    putValue( HIL_b_LH_Nebel_re_def, getProfileInt( "Settings", "HIL_b_LH_Nebel_re_def", 0, profileFile ) );
    putValue( HIL_b_LH_Rueckf_li_def, getProfileInt( "Settings", "HIL_b_LH_Rueckf_li_def", 0, profileFile ) );
    putValue( HIL_b_LH_Rueckf_mi_def, getProfileInt( "Settings", "HIL_b_LH_Rueckf_mi_def", 0, profileFile ) );
    putValue( HIL_b_LH_Rueckf_re_def, getProfileInt( "Settings", "HIL_b_LH_Rueckf_re_def", 0, profileFile ) );
    putValue( HIL_b_LH_Schluss_Brems_li_def, getProfileInt( "Settings", "HIL_b_LH_Schluss_Brems_li_def", 0, profileFile ) );
    putValue( HIL_b_LH_Schluss_Brems_Nebel_li_def, getProfileInt( "Settings", "HIL_b_LH_Schluss_Brems_Nebel_li_def", 0, profileFile ) );
    putValue( HIL_b_LH_Schluss_Brems_Nebel_re_def, getProfileInt( "Settings", "HIL_b_LH_Schluss_Brems_Nebel_re_def", 0, profileFile ) );
    putValue( HIL_b_LH_Schluss_Brems_re_def, getProfileInt( "Settings", "HIL_b_LH_Schluss_Brems_re_def", 0, profileFile ) );
    putValue( HIL_b_LH_Schluss_Nebel_li_def, getProfileInt( "Settings", "HIL_b_LH_Schluss_Nebel_li_def", 0, profileFile ) );
    putValue( HIL_b_LH_Schluss_Nebel_re_def, getProfileInt( "Settings", "HIL_b_LH_Schluss_Nebel_re_def", 0, profileFile ) );
    putValue( HIL_b_LH_Schlusslicht_li_def, getProfileInt( "Settings", "HIL_b_LH_Schlusslicht_li_def", 0, profileFile ) );
    putValue( HIL_b_LH_Schlusslicht_re_def, getProfileInt( "Settings", "HIL_b_LH_Schlusslicht_re_def", 0, profileFile ) );
    putValue( HIL_b_LH_SL_BRL_BLK_li_def, getProfileInt( "Settings", "HIL_b_LH_SL_BRL_BLK_li_def", 0, profileFile ) );
    putValue( HIL_b_LH_SL_BRL_BLK_re_def, getProfileInt( "Settings", "HIL_b_LH_SL_BRL_BLK_re_def", 0, profileFile ) );
    putValue( HIL_b_LV_Abbiegelicht_li_def, getProfileInt( "Settings", "HIL_b_LV_Abbiegelicht_li_def", 0, profileFile ) );
    putValue( HIL_b_LV_Abbiegelicht_re_def, getProfileInt( "Settings", "HIL_b_LV_Abbiegelicht_re_def", 0, profileFile ) );
    putValue( HIL_b_LV_Abblend_Fernlicht_li_def, getProfileInt( "Settings", "HIL_b_LV_Abblend_Fernlicht_li_def", 0, profileFile ) );
    putValue( HIL_b_LV_Abblend_Fernlicht_re_def, getProfileInt( "Settings", "HIL_b_LV_Abblend_Fernlicht_re_def", 0, profileFile ) );
    putValue( HIL_b_LV_Abblendlicht_li_def, getProfileInt( "Settings", "HIL_b_LV_Abblendlicht_li_def", 0, profileFile ) );
    putValue( HIL_b_LV_Abblendlicht_re_def, getProfileInt( "Settings", "HIL_b_LV_Abblendlicht_re_def", 0, profileFile ) );
    putValue( HIL_b_LV_Abblendlicht_TFL_li_def, getProfileInt( "Settings", "HIL_b_LV_Abblendlicht_TFL_li_def", 0, profileFile ) );
    putValue( HIL_b_LV_Abblendlicht_TFL_re_def, getProfileInt( "Settings", "HIL_b_LV_Abblendlicht_TFL_re_def", 0, profileFile ) );
    putValue( HIL_b_LV_Blinker_li_def, getProfileInt( "Settings", "HIL_b_LV_Blinker_li_def", 0, profileFile ) );
    putValue( HIL_b_LV_Blinker_re_def, getProfileInt( "Settings", "HIL_b_LV_Blinker_re_def", 0, profileFile ) );
    putValue( HIL_b_LV_Blk_li_Seite_def, getProfileInt( "Settings", "HIL_b_LV_Blk_li_Seite_def", 0, profileFile ) );
    putValue( HIL_b_LV_Blk_re_Seite_def, getProfileInt( "Settings", "HIL_b_LV_Blk_re_Seite_def", 0, profileFile ) );
    putValue( HIL_b_LV_Fernlicht_li_def, getProfileInt( "Settings", "HIL_b_LV_Fernlicht_li_def", 0, profileFile ) );
    putValue( HIL_b_LV_Fernlicht_re_def, getProfileInt( "Settings", "HIL_b_LV_Fernlicht_re_def", 0, profileFile ) );
    putValue( HIL_b_LV_LED_Scheinwerfer_li_def, getProfileInt( "Settings", "HIL_b_LV_LED_Scheinwerfer_li_def", 0, profileFile ) );
    putValue( HIL_b_LV_LED_Scheinwerfer_re_def, getProfileInt( "Settings", "HIL_b_LV_LED_Scheinwerfer_re_def", 0, profileFile ) );
    putValue( HIL_b_LV_Nebellicht_li_def, getProfileInt( "Settings", "HIL_b_LV_Nebellicht_li_def", 0, profileFile ) );
    putValue( HIL_b_LV_Nebellicht_re_def, getProfileInt( "Settings", "HIL_b_LV_Nebellicht_re_def", 0, profileFile ) );
    putValue( HIL_b_LV_Nebellicht_TFL_li_def, getProfileInt( "Settings", "HIL_b_LV_Nebellicht_TFL_li_def", 0, profileFile ) );
    putValue( HIL_b_LV_Nebellicht_TFL_re_def, getProfileInt( "Settings", "HIL_b_LV_Nebellicht_TFL_re_def", 0, profileFile ) );
    putValue( HIL_b_LV_Standlicht_Anzeige, getProfileInt( "Settings", "HIL_b_LV_Standlicht_Anzeige", 0, profileFile ) );
    putValue( HIL_b_LV_Standlicht_li_def, getProfileInt( "Settings", "HIL_b_LV_Standlicht_li_def", 0, profileFile ) );
    putValue( HIL_b_LV_Standlicht_re_def, getProfileInt( "Settings", "HIL_b_LV_Standlicht_re_def", 0, profileFile ) );
    putValue( HIL_b_LV_Standlicht_TFL_li_def, getProfileInt( "Settings", "HIL_b_LV_Standlicht_TFL_li_def", 0, profileFile ) );
    putValue( HIL_b_LV_Standlicht_TFL_re_def, getProfileInt( "Settings", "HIL_b_LV_Standlicht_TFL_re_def", 0, profileFile ) );
    putValue( HIL_b_LV_Tagfahrlicht_li_def, getProfileInt( "Settings", "HIL_b_LV_Tagfahrlicht_li_def", 0, profileFile ) );
    putValue( HIL_b_LV_Tagfahrlicht_re_def, getProfileInt( "Settings", "HIL_b_LV_Tagfahrlicht_re_def", 0, profileFile ) );
    putValue( HIL_s_LED_AnhaengerBlinker, getProfileInt( "Settings", "HIL_s_LED_AnhaengerBlinker", 0, profileFile ) );
    putValue( HIL_s_LED_Blinker_links, getProfileInt( "Settings", "HIL_s_LED_Blinker_links", 0, profileFile ) );
    putValue( HIL_s_LED_Blinker_rechts, getProfileInt( "Settings", "HIL_s_LED_Blinker_rechts", 0, profileFile ) );
    putValue( HIL_b_BCM_RGB_Blau, getProfileInt( "Settings", "HIL_b_BCM_RGB_Blau", 0, profileFile ) );
    putValue( HIL_b_BCM_RGB_Gruen, getProfileInt( "Settings", "HIL_b_BCM_RGB_Gruen", 0, profileFile ) );
    putValue( HIL_b_BCM_RGB_Rot, getProfileInt( "Settings", "HIL_b_BCM_RGB_Rot", 0, profileFile ) );
    putValue( HIL_s_Ambientelicht_aktiv, getProfileInt( "Settings", "HIL_s_Ambientelicht_aktiv", 0, profileFile ) );
    putValue( HIL_s_BCM_RGB_Blau, getProfileInt( "Settings", "HIL_s_BCM_RGB_Blau", 0, profileFile ) );
    putValue( HIL_s_BCM_RGB_Gruen, getProfileInt( "Settings", "HIL_s_BCM_RGB_Gruen", 0, profileFile ) );
    putValue( HIL_s_BCM_RGB_Rot, getProfileInt( "Settings", "HIL_s_BCM_RGB_Rot", 0, profileFile ) );
    putValue( HIL_b_BCM_Ausparken_Betrieb, getProfileInt( "Settings", "HIL_b_BCM_Ausparken_Betrieb", 0, profileFile ) );
    putValue( HIL_s_aufpruefung_aktiv, getProfileInt( "Settings", "HIL_s_aufpruefung_aktiv", 0, profileFile ) );
    putValue( HIL_s_aufpruefung_pilopa_aktiv, getProfileInt( "Settings", "HIL_s_aufpruefung_pilopa_aktiv", 0, profileFile ) );
    putValue( HIL_s_LED_Abstandswarnung, getProfileInt( "Settings", "HIL_s_LED_Abstandswarnung", 0, profileFile ) );
    putValue( HIL_s_LED_ACA_Quer_aktiv, getProfileInt( "Settings", "HIL_s_LED_ACA_Quer_aktiv", 0, profileFile ) );
    putValue( HIL_s_LED_ACA_Quer_passiv, getProfileInt( "Settings", "HIL_s_LED_ACA_Quer_passiv", 0, profileFile ) );
    putValue( HIL_s_LED_ACA_Quer_Warnung, getProfileInt( "Settings", "HIL_s_LED_ACA_Quer_Warnung", 0, profileFile ) );
    putValue( HIL_s_LED_ACC_Ego_weiss, getProfileInt( "Settings", "HIL_s_LED_ACC_Ego_weiss", 0, profileFile ) );
    putValue( HIL_s_LED_ACC_Radar_gruen, getProfileInt( "Settings", "HIL_s_LED_ACC_Radar_gruen", 0, profileFile ) );
    putValue( HIL_s_LED_ACC_Radar_rot_blinken, getProfileInt( "Settings", "HIL_s_LED_ACC_Radar_rot_blinken", 0, profileFile ) );
    putValue( HIL_s_LED_ACC_Radar_weiss, getProfileInt( "Settings", "HIL_s_LED_ACC_Radar_weiss", 0, profileFile ) );
    putValue( HIL_s_LED_ACC_VorFzg_gruen, getProfileInt( "Settings", "HIL_s_LED_ACC_VorFzg_gruen", 0, profileFile ) );
    putValue( HIL_s_LED_ACC_VorFzg_rot_blinken1, getProfileInt( "Settings", "HIL_s_LED_ACC_VorFzg_rot_blinken1", 0, profileFile ) );
    putValue( HIL_s_LED_ACC_VorFzg_weiss, getProfileInt( "Settings", "HIL_s_LED_ACC_VorFzg_weiss", 0, profileFile ) );
    putValue( HIL_s_LED_AEB, getProfileInt( "Settings", "HIL_s_LED_AEB", 0, profileFile ) );
    putValue( HIL_s_LED_aLDW_li_erkannt, getProfileInt( "Settings", "HIL_s_LED_aLDW_li_erkannt", 0, profileFile ) );
    putValue( HIL_s_LED_aLDW_li_nicht_erkannt, getProfileInt( "Settings", "HIL_s_LED_aLDW_li_nicht_erkannt", 0, profileFile ) );
    putValue( HIL_s_LED_aLDW_li_Warnung, getProfileInt( "Settings", "HIL_s_LED_aLDW_li_Warnung", 0, profileFile ) );
    putValue( HIL_s_LED_aLDW_re_erkannt, getProfileInt( "Settings", "HIL_s_LED_aLDW_re_erkannt", 0, profileFile ) );
    putValue( HIL_s_LED_aLDW_re_nicht_erkannt, getProfileInt( "Settings", "HIL_s_LED_aLDW_re_nicht_erkannt", 0, profileFile ) );
    putValue( HIL_s_LED_aLDW_re_Warnung, getProfileInt( "Settings", "HIL_s_LED_aLDW_re_Warnung", 0, profileFile ) );
    putValue( HIL_s_LED_Antriebsart_weiss, getProfileInt( "Settings", "HIL_s_LED_Antriebsart_weiss", 0, profileFile ) );
    putValue( HIL_s_LED_CNG_Betrieb, getProfileInt( "Settings", "HIL_s_LED_CNG_Betrieb", 0, profileFile ) );
    putValue( HIL_s_LED_EPB_NAR_gruen, getProfileInt( "Settings", "HIL_s_LED_EPB_NAR_gruen", 0, profileFile ) );
    putValue( HIL_s_LED_EPB_RDW_gruen, getProfileInt( "Settings", "HIL_s_LED_EPB_RDW_gruen", 0, profileFile ) );
    putValue( HIL_s_LED_FLA_auto, getProfileInt( "Settings", "HIL_s_LED_FLA_auto", 0, profileFile ) );
    putValue( HIL_s_LED_GRA_weiss, getProfileInt( "Settings", "HIL_s_LED_GRA_weiss", 0, profileFile ) );
    putValue( HIL_s_LED_Hands_Off, getProfileInt( "Settings", "HIL_s_LED_Hands_Off", 0, profileFile ) );
    putValue( HIL_s_LED_LIM_weiss, getProfileInt( "Settings", "HIL_s_LED_LIM_weiss", 0, profileFile ) );
    putValue( HIL_s_LED_Querfuehrung_aktiv, getProfileInt( "Settings", "HIL_s_LED_Querfuehrung_aktiv", 0, profileFile ) );
    putValue( HIL_s_LED_Querfuehrung_passiv, getProfileInt( "Settings", "HIL_s_LED_Querfuehrung_passiv", 0, profileFile ) );
    putValue( HIL_s_LED_Querfuehrung_Warnung, getProfileInt( "Settings", "HIL_s_LED_Querfuehrung_Warnung", 0, profileFile ) );
    putValue( HIL_b_FAS_Taster, getProfileInt( "Settings", "HIL_b_FAS_Taster", 0, profileFile ) );
    putValue( HIL_b_FAS_Taster_Fehler, getProfileInt( "Settings", "HIL_b_FAS_Taster_Fehler", 0, profileFile ) );
    putValue( HIL_b_LSS_Tastencode, getProfileInt( "Settings", "HIL_b_LSS_Tastencode", 0, profileFile ) );
    putValue( HIL_b_MFL_Eventcode_1, getProfileInt( "Settings", "HIL_b_MFL_Eventcode_1", 0, profileFile ) );
    putValue( HIL_b_MFL_Eventcode_2, getProfileInt( "Settings", "HIL_b_MFL_Eventcode_2", 0, profileFile ) );
    putValue( HIL_b_MFL_Marke, getProfileInt( "Settings", "HIL_b_MFL_Marke", 0, profileFile ) );
    putValue( HIL_b_MFL_Tastencode_1, getProfileInt( "Settings", "HIL_b_MFL_Tastencode_1", 0, profileFile ) );
    putValue( HIL_b_MFL_Tastencode_2, getProfileInt( "Settings", "HIL_b_MFL_Tastencode_2", 0, profileFile ) );
    putValue( HIL_b_MFL_Variante, getProfileInt( "Settings", "HIL_b_MFL_Variante", 0, profileFile ) );
    putValue( HIL_b_ZV_STSG_eKiSi_defekt, getProfileInt( "Settings", "HIL_b_ZV_STSG_eKiSi_defekt", 0, profileFile ) );
    putValue( HIL_hmi_data_wheel_ticks, getProfileInt( "Settings", "HIL_hmi_data_wheel_ticks", 0, profileFile ) );
    putValue( HIL_hmi_event_wheel_ticks, getProfileInt( "Settings", "HIL_hmi_event_wheel_ticks", 0, profileFile ) );
    putValue( HIL_hmi_FAS_Taster_long_press, getProfileInt( "Settings", "HIL_hmi_FAS_Taster_long_press", 0, profileFile ) );
    putValue( HIL_hmi_FAS_Taster_short_press, getProfileInt( "Settings", "HIL_hmi_FAS_Taster_short_press", 0, profileFile ) );
    putValue( HIL_hmi_mfl_marke, getProfileInt( "Settings", "HIL_hmi_mfl_marke", 0, profileFile ) );
    putValue( HIL_hmi_mfl_variante, getProfileInt( "Settings", "HIL_hmi_mfl_variante", 0, profileFile ) );
    putValue( HIL_hmi_ok_long_press, getProfileInt( "Settings", "HIL_hmi_ok_long_press", 0, profileFile ) );
    putValue( HIL_hmi_up_short_press, getProfileInt( "Settings", "HIL_hmi_up_short_press", 0, profileFile ) );
    putValue( HIL_s_mfl_gueltig, getProfileInt( "Settings", "HIL_s_mfl_gueltig", 0, profileFile ) );
    putValue( HIL_b_AAG_ASTA_Status, getProfileInt( "Settings", "HIL_b_AAG_ASTA_Status", 0, profileFile ) );
    putValue( HIL_b_AAG_AVS_Fehler_02, getProfileInt( "Settings", "HIL_b_AAG_AVS_Fehler_02", 0, profileFile ) );
    putValue( HIL_b_ASTA_Anhaengerlast, getProfileInt( "Settings", "HIL_b_ASTA_Anhaengerlast", 0, profileFile ) );
    putValue( HIL_b_ASTA_Einheit, getProfileInt( "Settings", "HIL_b_ASTA_Einheit", 0, profileFile ) );
    putValue( HIL_b_ASTA_Stuetzlast, getProfileInt( "Settings", "HIL_b_ASTA_Stuetzlast", 0, profileFile ) );
    putValue( HIL_b_ASTAs_01_alt, getProfileInt( "Settings", "HIL_b_ASTAs_01_alt", 0, profileFile ) );
    putValue( HIL_b_BCM1_MH_Schalter, getProfileInt( "Settings", "HIL_b_BCM1_MH_Schalter", 0, profileFile ) );
    putValue( HIL_b_MF_2BatSOCzugering, getProfileInt( "Settings", "HIL_b_MF_2BatSOCzugering", 0, profileFile ) );
    putValue( HIL_b_MF_NotStartAktiv, getProfileInt( "Settings", "HIL_b_MF_NotStartAktiv", 0, profileFile ) );
    putValue( HIL_b_VSG_Meldungen, getProfileInt( "Settings", "HIL_b_VSG_Meldungen", 0, profileFile ) );
    putValue( HIL_b_ZV_BT_offen, getProfileInt( "Settings", "HIL_b_ZV_BT_offen", 0, profileFile ) );
    putValue( HIL_b_ZV_FT_offen, getProfileInt( "Settings", "HIL_b_ZV_FT_offen", 0, profileFile ) );
    putValue( HIL_b_ZV_HBFS_offen, getProfileInt( "Settings", "HIL_b_ZV_HBFS_offen", 0, profileFile ) );
    putValue( HIL_b_ZV_HD_offen, getProfileInt( "Settings", "HIL_b_ZV_HD_offen", 0, profileFile ) );
    putValue( HIL_b_ZV_HFS_offen, getProfileInt( "Settings", "HIL_b_ZV_HFS_offen", 0, profileFile ) );
    putValue( HIL_b_ZV_HS_offen, getProfileInt( "Settings", "HIL_b_ZV_HS_offen", 0, profileFile ) );
    putValue( HIL_b_ZV_Tankklappe_offen, getProfileInt( "Settings", "HIL_b_ZV_Tankklappe_offen", 0, profileFile ) );
    putValue( HIL_b_ZV_verriegelt_extern_ist, getProfileInt( "Settings", "HIL_b_ZV_verriegelt_extern_ist", 0, profileFile ) );
    putValue( HIL_hmi_anhaengerlast_anzeigen, getProfileInt( "Settings", "HIL_hmi_anhaengerlast_anzeigen", 0, profileFile ) );
    putValue( HIL_hmi_anhaengerlast_fehler, getProfileInt( "Settings", "HIL_hmi_anhaengerlast_fehler", 0, profileFile ) );
    putValue( HIL_hmi_caroutlineunterdrueckung, getProfileInt( "Settings", "HIL_hmi_caroutlineunterdrueckung", 0, profileFile ) );
    putValue( HIL_hmi_stuetzlast_anzeigen, getProfileInt( "Settings", "HIL_hmi_stuetzlast_anzeigen", 0, profileFile ) );
    putValue( HIL_hmi_stuetzlast_fehler, getProfileInt( "Settings", "HIL_hmi_stuetzlast_fehler", 0, profileFile ) );
    putValue( HIL_hmi_variante, getProfileInt( "Settings", "HIL_hmi_variante", 0, profileFile ) );
    putValue( HIL_s_car_outline_aktiv, getProfileInt( "Settings", "HIL_s_car_outline_aktiv", 0, profileFile ) );
    putValue( HIL_s_car_outline_hochprior, getProfileInt( "Settings", "HIL_s_car_outline_hochprior", 0, profileFile ) );
    putValue( HIL_s_car_outline_trigger_v_hinweis, getProfileInt( "Settings", "HIL_s_car_outline_trigger_v_hinweis", 0, profileFile ) );
    putValue( HIL_s_event_car_outline_trigger, getProfileInt( "Settings", "HIL_s_event_car_outline_trigger", 0, profileFile ) );
    putValue( HIL_s_LED_Tankdeckel, getProfileInt( "Settings", "HIL_s_LED_Tankdeckel", 0, profileFile ) );
    putValue( HIL_s_LED_Verdeck, getProfileInt( "Settings", "HIL_s_LED_Verdeck", 0, profileFile ) );
    putValue( HIL_s_motorhaube_offen_hinweis, getProfileInt( "Settings", "HIL_s_motorhaube_offen_hinweis", 0, profileFile ) );
    putValue( HIL_s_tuerzustand_hinten_links, getProfileInt( "Settings", "HIL_s_tuerzustand_hinten_links", 0, profileFile ) );
    putValue( HIL_s_tuerzustand_hinten_rechts, getProfileInt( "Settings", "HIL_s_tuerzustand_hinten_rechts", 0, profileFile ) );
    putValue( HIL_s_tuerzustand_vorne_links, getProfileInt( "Settings", "HIL_s_tuerzustand_vorne_links", 0, profileFile ) );
    putValue( HIL_s_tuerzustand_vorne_rechts, getProfileInt( "Settings", "HIL_s_tuerzustand_vorne_rechts", 0, profileFile ) );
    putValue( HIL_b_AB_wSBR_Batteriestatus, getProfileInt( "Settings", "HIL_b_AB_wSBR_Batteriestatus", 0, profileFile ) );
    putValue( HIL_b_ACC_Tempolimit_Einheit, getProfileInt( "Settings", "HIL_b_ACC_Tempolimit_Einheit", 0, profileFile ) );
    putValue( HIL_b_BCM_ValetTaster_Fkts_LED, getProfileInt( "Settings", "HIL_b_BCM_ValetTaster_Fkts_LED", 0, profileFile ) );
    putValue( HIL_b_BCM_Waschwasser_Sensor, getProfileInt( "Settings", "HIL_b_BCM_Waschwasser_Sensor", 0, profileFile ) );
    putValue( HIL_b_BFS_MMB_storage_beep, getProfileInt( "Settings", "HIL_b_BFS_MMB_storage_beep", 0, profileFile ) );
    putValue( HIL_b_eCall_Mute_Anf, getProfileInt( "Settings", "HIL_b_eCall_Mute_Anf", 0, profileFile ) );
    putValue( HIL_b_FS_MMB_storage_beep, getProfileInt( "Settings", "HIL_b_FS_MMB_storage_beep", 0, profileFile ) );
    putValue( HIL_b_FT_Kisi_Fehler, getProfileInt( "Settings", "HIL_b_FT_Kisi_Fehler", 0, profileFile ) );
    putValue( HIL_b_KL_LRH_Stufe, getProfileInt( "Settings", "HIL_b_KL_LRH_Stufe", 0, profileFile ) );
    putValue( HIL_b_KL_VoKo_LED, getProfileInt( "Settings", "HIL_b_KL_VoKo_LED", 0, profileFile ) );
    putValue( HIL_b_LRH_on_off, getProfileInt( "Settings", "HIL_b_LRH_on_off", 0, profileFile ) );
    putValue( HIL_b_MF_2BattAb, getProfileInt( "Settings", "HIL_b_MF_2BattAb", 0, profileFile ) );
    putValue( HIL_b_MF_2BattLadWarn, getProfileInt( "Settings", "HIL_b_MF_2BattLadWarn", 0, profileFile ) );
    putValue( HIL_b_MF_ExterneLadungWarn, getProfileInt( "Settings", "HIL_b_MF_ExterneLadungWarn", 0, profileFile ) );
    putValue( HIL_b_MF_Fahrerhinweis, getProfileInt( "Settings", "HIL_b_MF_Fahrerhinweis", 0, profileFile ) );
    putValue( HIL_b_MF_Motorweiterlauf, getProfileInt( "Settings", "HIL_b_MF_Motorweiterlauf", 0, profileFile ) );
    putValue( HIL_b_MF_Summer, getProfileInt( "Settings", "HIL_b_MF_Summer", 0, profileFile ) );
    putValue( HIL_b_MO_Kuehlmittel_Temp, getProfileFloat( "Settings", "HIL_b_MO_Kuehlmittel_Temp", 0, profileFile ) );
    putValue( HIL_b_PEA_Ereignisanzeige_temporaer, getProfileInt( "Settings", "HIL_b_PEA_Ereignisanzeige_temporaer", 0, profileFile ) );
    putValue( HIL_b_RS_defekt, getProfileInt( "Settings", "HIL_b_RS_defekt", 0, profileFile ) );
    putValue( HIL_b_STH_Texte, getProfileInt( "Settings", "HIL_b_STH_Texte", 0, profileFile ) );
    putValue( HIL_b_Wischer_vorne_defekt, getProfileInt( "Settings", "HIL_b_Wischer_vorne_defekt", 0, profileFile ) );
    putValue( HIL_b_ZV_STSG_Crashzustand, getProfileInt( "Settings", "HIL_b_ZV_STSG_Crashzustand", 0, profileFile ) );
    putValue( HIL_hmi_down_short_press, getProfileInt( "Settings", "HIL_hmi_down_short_press", 0, profileFile ) );
    putValue( HIL_hmi_FAS_Taster_long_release, getProfileInt( "Settings", "HIL_hmi_FAS_Taster_long_release", 0, profileFile ) );
    putValue( HIL_hmi_FAS_Taster_short_release, getProfileInt( "Settings", "HIL_hmi_FAS_Taster_short_release", 0, profileFile ) );
    putValue( HIL_s_Anzahl_belegte_Fondsitze, getProfileInt( "Settings", "HIL_s_Anzahl_belegte_Fondsitze", 0, profileFile ) );
    putValue( HIL_s_Anzahl_gesteckte_Fondgurte, getProfileInt( "Settings", "HIL_s_Anzahl_gesteckte_Fondgurte", 0, profileFile ) );
    putValue( HIL_s_Anzeige_Anzahl_Fondsitze, getProfileInt( "Settings", "HIL_s_Anzeige_Anzahl_Fondsitze", 0, profileFile ) );
    putValue( HIL_s_KL_VoKo_LED, getProfileInt( "Settings", "HIL_s_KL_VoKo_LED", 0, profileFile ) );
    putValue( HIL_s_LED_Lenkradheizung_0, getProfileInt( "Settings", "HIL_s_LED_Lenkradheizung_0", 0, profileFile ) );
    putValue( HIL_s_LED_Lenkradheizung_1, getProfileInt( "Settings", "HIL_s_LED_Lenkradheizung_1", 0, profileFile ) );
    putValue( HIL_s_LED_Lenkradheizung_2, getProfileInt( "Settings", "HIL_s_LED_Lenkradheizung_2", 0, profileFile ) );
    putValue( HIL_s_LED_Standheizung, getProfileInt( "Settings", "HIL_s_LED_Standheizung", 0, profileFile ) );
    putValue( HIL_s_warnfall_fond_ohne_SBR, getProfileInt( "Settings", "HIL_s_warnfall_fond_ohne_SBR", 0, profileFile ) );
    putValue( HIL_s_warnsequenz_ende, getProfileInt( "Settings", "HIL_s_warnsequenz_ende", 0, profileFile ) );
    putValue( HIL_s_waschwassermangel_warn, getProfileInt( "Settings", "HIL_s_waschwassermangel_warn", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtwarn_Reihe2_BF, getProfileInt( "Settings", "HIL_b_AB_Gurtwarn_Reihe2_BF", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtwarn_Reihe2_FA, getProfileInt( "Settings", "HIL_b_AB_Gurtwarn_Reihe2_FA", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtwarn_Reihe2_MI, getProfileInt( "Settings", "HIL_b_AB_Gurtwarn_Reihe2_MI", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtwarn_Reihe3_BF, getProfileInt( "Settings", "HIL_b_AB_Gurtwarn_Reihe3_BF", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtwarn_Reihe3_FA, getProfileInt( "Settings", "HIL_b_AB_Gurtwarn_Reihe3_FA", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtwarn_Reihe3_MI, getProfileInt( "Settings", "HIL_b_AB_Gurtwarn_Reihe3_MI", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtwarn_VB, getProfileInt( "Settings", "HIL_b_AB_Gurtwarn_VB", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtwarn_VF, getProfileInt( "Settings", "HIL_b_AB_Gurtwarn_VF", 0, profileFile ) );
    putValue( HIL_b_AB_SBR_hinten_verbau, getProfileInt( "Settings", "HIL_b_AB_SBR_hinten_verbau", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe2_links_blinken, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe2_links_blinken", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe2_links_gesteckt, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe2_links_gesteckt", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe2_links_verbaut, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe2_links_verbaut", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe2_mitte_blinken, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe2_mitte_blinken", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe2_mitte_gesteckt, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe2_mitte_gesteckt", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe2_mitte_verbaut, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe2_mitte_verbaut", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe2_rechts_blinken, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe2_rechts_blinken", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe2_rechts_gesteckt, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe2_rechts_gesteckt", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe2_rechts_verbaut, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe2_rechts_verbaut", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe3_links_blinken, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe3_links_blinken", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe3_links_gesteckt, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe3_links_gesteckt", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe3_links_verbaut, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe3_links_verbaut", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe3_mitte_blinken, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe3_mitte_blinken", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe3_mitte_gesteckt, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe3_mitte_gesteckt", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe3_mitte_verbaut, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe3_mitte_verbaut", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe3_rechts_blinken, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe3_rechts_blinken", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe3_rechts_gesteckt, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe3_rechts_gesteckt", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe3_rechts_verbaut, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe3_rechts_verbaut", 0, profileFile ) );
    putValue( HIL_hmi_Gurtschloss_anzeigen, getProfileInt( "Settings", "HIL_hmi_Gurtschloss_anzeigen", 0, profileFile ) );
    putValue( HIL_s_Anzahl_Fondsitze, getProfileInt( "Settings", "HIL_s_Anzahl_Fondsitze", 0, profileFile ) );
    putValue( HIL_s_gurt_fond_gong, getProfileInt( "Settings", "HIL_s_gurt_fond_gong", 0, profileFile ) );
    putValue( HIL_s_gurtschloss_optisch_2_links, getProfileInt( "Settings", "HIL_s_gurtschloss_optisch_2_links", 0, profileFile ) );
    putValue( HIL_s_gurtschloss_optisch_2_mitte, getProfileInt( "Settings", "HIL_s_gurtschloss_optisch_2_mitte", 0, profileFile ) );
    putValue( HIL_s_gurtschloss_optisch_2_rechts, getProfileInt( "Settings", "HIL_s_gurtschloss_optisch_2_rechts", 0, profileFile ) );
    putValue( HIL_s_gurtschloss_optisch_3_links, getProfileInt( "Settings", "HIL_s_gurtschloss_optisch_3_links", 0, profileFile ) );
    putValue( HIL_s_gurtschloss_optisch_3_mitte, getProfileInt( "Settings", "HIL_s_gurtschloss_optisch_3_mitte", 0, profileFile ) );
    putValue( HIL_s_gurtschloss_optisch_3_rechts, getProfileInt( "Settings", "HIL_s_gurtschloss_optisch_3_rechts", 0, profileFile ) );
    putValue( HIL_s_gurtwarnung_akustisch_1, getProfileInt( "Settings", "HIL_s_gurtwarnung_akustisch_1", 0, profileFile ) );
    putValue( HIL_s_gurtwarnung_akustisch_2, getProfileInt( "Settings", "HIL_s_gurtwarnung_akustisch_2", 0, profileFile ) );
    putValue( HIL_s_gurtwarnung_akustisch_3, getProfileInt( "Settings", "HIL_s_gurtwarnung_akustisch_3", 0, profileFile ) );
    putValue( HIL_s_gurtwarnung_akustisch_US, getProfileInt( "Settings", "HIL_s_gurtwarnung_akustisch_US", 0, profileFile ) );
    putValue( HIL_s_gurtwarnung_optisch, getProfileInt( "Settings", "HIL_s_gurtwarnung_optisch", 0, profileFile ) );
    putValue( HIL_s_LED_Gurtwarnung, getProfileInt( "Settings", "HIL_s_LED_Gurtwarnung", 0, profileFile ) );
    putValue( HIL_b_AB_Anzeige_Fussg, getProfileInt( "Settings", "HIL_b_AB_Anzeige_Fussg", 0, profileFile ) );
    putValue( HIL_b_AB_Deaktiviert, getProfileInt( "Settings", "HIL_b_AB_Deaktiviert", 0, profileFile ) );
    putValue( HIL_b_AB_Erh_Auf_VB, getProfileInt( "Settings", "HIL_b_AB_Erh_Auf_VB", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtschloss_Reihe2_BF, getProfileInt( "Settings", "HIL_b_AB_Gurtschloss_Reihe2_BF", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtschloss_Reihe2_FA, getProfileInt( "Settings", "HIL_b_AB_Gurtschloss_Reihe2_FA", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtschloss_Reihe2_MI, getProfileInt( "Settings", "HIL_b_AB_Gurtschloss_Reihe2_MI", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtschloss_Reihe3_BF, getProfileInt( "Settings", "HIL_b_AB_Gurtschloss_Reihe3_BF", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtschloss_Reihe3_FA, getProfileInt( "Settings", "HIL_b_AB_Gurtschloss_Reihe3_FA", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtschloss_Reihe3_MI, getProfileInt( "Settings", "HIL_b_AB_Gurtschloss_Reihe3_MI", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtschloss_Reihe4_BF, getProfileInt( "Settings", "HIL_b_AB_Gurtschloss_Reihe4_BF", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtschloss_Reihe4_FA, getProfileInt( "Settings", "HIL_b_AB_Gurtschloss_Reihe4_FA", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtschloss_Reihe4_MI, getProfileInt( "Settings", "HIL_b_AB_Gurtschloss_Reihe4_MI", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtwarn_Reihe4_BF, getProfileInt( "Settings", "HIL_b_AB_Gurtwarn_Reihe4_BF", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtwarn_Reihe4_FA, getProfileInt( "Settings", "HIL_b_AB_Gurtwarn_Reihe4_FA", 0, profileFile ) );
    putValue( HIL_b_AB_Gurtwarn_Reihe4_MI, getProfileInt( "Settings", "HIL_b_AB_Gurtwarn_Reihe4_MI", 0, profileFile ) );
    putValue( HIL_b_AB_Lampe, getProfileInt( "Settings", "HIL_b_AB_Lampe", 0, profileFile ) );
    putValue( HIL_b_AB_Systemfehler, getProfileInt( "Settings", "HIL_b_AB_Systemfehler", 0, profileFile ) );
    putValue( HIL_b_AB_Versorgungsspannung, getProfileInt( "Settings", "HIL_b_AB_Versorgungsspannung", 0, profileFile ) );
    putValue( HIL_b_eCall_Funktionsstatus, getProfileInt( "Settings", "HIL_b_eCall_Funktionsstatus", 0, profileFile ) );
    putValue( HIL_b_SC_PreCrash_Texte, getProfileInt( "Settings", "HIL_b_SC_PreCrash_Texte", 0, profileFile ) );
    putValue( HIL_b_SC_PreCrash_Warnung, getProfileInt( "Settings", "HIL_b_SC_PreCrash_Warnung", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe4_links_blinken, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe4_links_blinken", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe4_links_gesteckt, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe4_links_gesteckt", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe4_links_verbaut, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe4_links_verbaut", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe4_mitte_blinken, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe4_mitte_blinken", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe4_mitte_gesteckt, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe4_mitte_gesteckt", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe4_mitte_verbaut, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe4_mitte_verbaut", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe4_rechts_blinken, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe4_rechts_blinken", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe4_rechts_gesteckt, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe4_rechts_gesteckt", 0, profileFile ) );
    putValue( HIL_hmi_AB_Gurtschloss_Reihe4_rechts_verbaut, getProfileInt( "Settings", "HIL_hmi_AB_Gurtschloss_Reihe4_rechts_verbaut", 0, profileFile ) );
    putValue( HIL_s_gurtschloss_optisch_4_links, getProfileInt( "Settings", "HIL_s_gurtschloss_optisch_4_links", 0, profileFile ) );
    putValue( HIL_s_gurtschloss_optisch_4_mitte, getProfileInt( "Settings", "HIL_s_gurtschloss_optisch_4_mitte", 0, profileFile ) );
    putValue( HIL_s_gurtschloss_optisch_4_rechts, getProfileInt( "Settings", "HIL_s_gurtschloss_optisch_4_rechts", 0, profileFile ) );
    putValue( HIL_s_LED_Airbag, getProfileInt( "Settings", "HIL_s_LED_Airbag", 0, profileFile ) );
    putValue( HIL_s_warnfall_fond_retrigger_event, getProfileInt( "Settings", "HIL_s_warnfall_fond_retrigger_event", 0, profileFile ) );
    putValue( HIL_b_RW_Gesamt_Reichweite, getProfileInt( "Settings", "HIL_b_RW_Gesamt_Reichweite", 0, profileFile ) );
    putValue( HIL_b_RW_Primaer_Reichweite, getProfileInt( "Settings", "HIL_b_RW_Primaer_Reichweite", 0, profileFile ) );
    putValue( HIL_b_RW_Primaer_Reichweite_Anzeige, getProfileInt( "Settings", "HIL_b_RW_Primaer_Reichweite_Anzeige", 0, profileFile ) );
    putValue( HIL_b_RW_Reichweite_Einheit_Anzeige, getProfileInt( "Settings", "HIL_b_RW_Reichweite_Einheit_Anzeige", 0, profileFile ) );
    putValue( HIL_b_RW_Sekundaer_Reichweite, getProfileInt( "Settings", "HIL_b_RW_Sekundaer_Reichweite", 0, profileFile ) );
    putValue( HIL_b_RW_Sekundaer_Reichweite_Anzeige, getProfileInt( "Settings", "HIL_b_RW_Sekundaer_Reichweite_Anzeige", 0, profileFile ) );
    putValue( HIL_hmi_CANRW_Gesamt_Max_sonderbehandlung, getProfileInt( "Settings", "HIL_hmi_CANRW_Gesamt_Max_sonderbehandlung", 0, profileFile ) );
    putValue( HIL_hmi_CANRW_Gesamt_sonderbehandlung, getProfileInt( "Settings", "HIL_hmi_CANRW_Gesamt_sonderbehandlung", 0, profileFile ) );
    putValue( HIL_hmi_CANRW_Primaer_sonderbehandlung, getProfileInt( "Settings", "HIL_hmi_CANRW_Primaer_sonderbehandlung", 0, profileFile ) );
    putValue( HIL_hmi_CANRW_Sekundaer_sonderbehandlung, getProfileInt( "Settings", "HIL_hmi_CANRW_Sekundaer_sonderbehandlung", 0, profileFile ) );
    putValue( HIL_hmi_reichweite_e1_available, getProfileInt( "Settings", "HIL_hmi_reichweite_e1_available", 0, profileFile ) );
    putValue( HIL_s_CANRW_Primaer_Anzeigefreigabe_Bargraph, getProfileInt( "Settings", "HIL_s_CANRW_Primaer_Anzeigefreigabe_Bargraph", 0, profileFile ) );
    putValue( HIL_s_CANRW_Sekundaer_Anzeigefreigabe_Bargraph, getProfileInt( "Settings", "HIL_s_CANRW_Sekundaer_Anzeigefreigabe_Bargraph", 0, profileFile ) );
    putValue( HIL_s_CANRW_Systemfehler, getProfileInt( "Settings", "HIL_s_CANRW_Systemfehler", 0, profileFile ) );
    putValue( HIL_b_RW_Gesamt_Reichweite_Anzeige, getProfileInt( "Settings", "HIL_b_RW_Gesamt_Reichweite_Anzeige", 0, profileFile ) );
    putValue( HIL_b_RW_Gesamt_Reichweite_Max_Anzeige, getProfileInt( "Settings", "HIL_b_RW_Gesamt_Reichweite_Max_Anzeige", 0, profileFile ) );
    putValue( HIL_b_STH_Heizleistung, getProfileInt( "Settings", "HIL_b_STH_Heizleistung", 0, profileFile ) );
    putValue( HIL_hmi_CANRW_Gesamt_Reichweite, getProfileInt( "Settings", "HIL_hmi_CANRW_Gesamt_Reichweite", 0, profileFile ) );
    putValue( HIL_hmi_CANRW_Primaer_Reichweite, getProfileInt( "Settings", "HIL_hmi_CANRW_Primaer_Reichweite", 0, profileFile ) );
    putValue( HIL_hmi_CANRW_Sekundaer_Reichweite, getProfileInt( "Settings", "HIL_hmi_CANRW_Sekundaer_Reichweite", 0, profileFile ) );
    putValue( HIL_hmi_reichweite_e2_available, getProfileInt( "Settings", "HIL_hmi_reichweite_e2_available", 0, profileFile ) );
    putValue( HIL_hmi_reichweite_e3_available, getProfileInt( "Settings", "HIL_hmi_reichweite_e3_available", 0, profileFile ) );
    putValue( HIL_b_BCM1_Aussen_Temp_ungef, getProfileFloat( "Settings", "HIL_b_BCM1_Aussen_Temp_ungef", 0, profileFile ) );
    putValue( HIL_hmi_aussentemperatur, getProfileFloat( "Settings", "HIL_hmi_aussentemperatur", 0, profileFile ) );
    putValue( HIL_hmi_aussentemperatur_einheit, getProfileInt( "Settings", "HIL_hmi_aussentemperatur_einheit", 0, profileFile ) );
    putValue( HIL_hmi_aussentemperatur_eisstern, getProfileInt( "Settings", "HIL_hmi_aussentemperatur_eisstern", 0, profileFile ) );
    putValue( HIL_hmi_aussentemperatur_fehler, getProfileInt( "Settings", "HIL_hmi_aussentemperatur_fehler", 0, profileFile ) );
    putValue( HIL_hmi_CANRW_Gesamt_Reichweite_Max, getProfileInt( "Settings", "HIL_hmi_CANRW_Gesamt_Reichweite_Max", 0, profileFile ) );
    putValue( HIL_hmi_CANRW_Gesamt_Reichweite_Norm, getProfileFloat( "Settings", "HIL_hmi_CANRW_Gesamt_Reichweite_Norm", 0, profileFile ) );
    putValue( HIL_s_aussentemp_letzter_wert, getProfileFloat( "Settings", "HIL_s_aussentemp_letzter_wert", 0, profileFile ) );
    putValue( HIL_s_aussentemperatur_anzeige_temp, getProfileFloat( "Settings", "HIL_s_aussentemperatur_anzeige_temp", 0, profileFile ) );
    putValue( HIL_s_eiswarnung, getProfileInt( "Settings", "HIL_s_eiswarnung", 0, profileFile ) );
    putValue( HIL_s_motor_warm, getProfileInt( "Settings", "HIL_s_motor_warm", 0, profileFile ) );
    putValue( HIL_s_w_blockierung, getProfileInt( "Settings", "HIL_s_w_blockierung", 0, profileFile ) );
    putValue( HIL_s_z_blockierung, getProfileInt( "Settings", "HIL_s_z_blockierung", 0, profileFile ) );
    putValue( HIL_b_BCM1_FStatus_Aussentemp_ungef, getProfileInt( "Settings", "HIL_b_BCM1_FStatus_Aussentemp_ungef", 0, profileFile ) );
    putValue( HIL_b_EFF_Verbrauch_STH, getProfileFloat( "Settings", "HIL_b_EFF_Verbrauch_STH", 0, profileFile ) );
    putValue( HIL_b_LSH_Heizleistung, getProfileInt( "Settings", "HIL_b_LSH_Heizleistung", 0, profileFile ) );
    putValue( HIL_b_LSH_KVS, getProfileInt( "Settings", "HIL_b_LSH_KVS", 0, profileFile ) );
    putValue( HIL_b_LSH_KVS_Ueberlauf, getProfileInt( "Settings", "HIL_b_LSH_KVS_Ueberlauf", 0, profileFile ) );
    putValue( HIL_b_STH_KVS, getProfileInt( "Settings", "HIL_b_STH_KVS", 0, profileFile ) );
    putValue( HIL_b_STH_KVS_Ueberlauf, getProfileInt( "Settings", "HIL_b_STH_KVS_Ueberlauf", 0, profileFile ) );
    putValue( HIL_s_aussentemp_in_anzeige, getProfileInt( "Settings", "HIL_s_aussentemp_in_anzeige", 0, profileFile ) );
    putValue( HIL_s_EFF_Verbrauch_STH, getProfileFloat( "Settings", "HIL_s_EFF_Verbrauch_STH", 0, profileFile ) );
    putValue( HIL_s_STH_KVS, getProfileInt( "Settings", "HIL_s_STH_KVS", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsgeschwindigkeit_e1_available, getProfileInt( "Settings", "HIL_hmi_durchschnittsgeschwindigkeit_e1_available", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsgeschwindigkeit_e2_available, getProfileInt( "Settings", "HIL_hmi_durchschnittsgeschwindigkeit_e2_available", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsgeschwindigkeit_e3, getProfileInt( "Settings", "HIL_hmi_durchschnittsgeschwindigkeit_e3", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsgeschwindigkeit_e3_available, getProfileInt( "Settings", "HIL_hmi_durchschnittsgeschwindigkeit_e3_available", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsgeschwindigkeit_einheit, getProfileInt( "Settings", "HIL_hmi_durchschnittsgeschwindigkeit_einheit", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsgeschwindigkeit_sonderbehandlung_e1, getProfileInt( "Settings", "HIL_hmi_durchschnittsgeschwindigkeit_sonderbehandlung_e1", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsgeschwindigkeit_sonderbehandlung_e2, getProfileInt( "Settings", "HIL_hmi_durchschnittsgeschwindigkeit_sonderbehandlung_e2", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsgeschwindigkeit_sonderbehandlung_e3, getProfileInt( "Settings", "HIL_hmi_durchschnittsgeschwindigkeit_sonderbehandlung_e3", 0, profileFile ) );
    putValue( HIL_s_durchschnittsgeschwindigkeit_e1, getProfileFloat( "Settings", "HIL_s_durchschnittsgeschwindigkeit_e1", 0, profileFile ) );
    putValue( HIL_s_durchschnittsgeschwindigkeit_e2, getProfileFloat( "Settings", "HIL_s_durchschnittsgeschwindigkeit_e2", 0, profileFile ) );
    putValue( HIL_s_durchschnittsgeschwindigkeit_e3, getProfileFloat( "Settings", "HIL_s_durchschnittsgeschwindigkeit_e3", 0, profileFile ) );
    putValue( HIL_b_BMS_Ladevorgang_aktiv, getProfileInt( "Settings", "HIL_b_BMS_Ladevorgang_aktiv", 0, profileFile ) );
    putValue( HIL_b_MO_Freilauf_Status, getProfileInt( "Settings", "HIL_b_MO_Freilauf_Status", 0, profileFile ) );
    putValue( HIL_hmi_bc_e3_auto_reset, getProfileInt( "Settings", "HIL_hmi_bc_e3_auto_reset", 0, profileFile ) );
    putValue( HIL_hmi_bc_momentanverbrauch_einheit_gas, getProfileInt( "Settings", "HIL_hmi_bc_momentanverbrauch_einheit_gas", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsgeschwindigkeit_e1, getProfileInt( "Settings", "HIL_hmi_durchschnittsgeschwindigkeit_e1", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsgeschwindigkeit_e2, getProfileInt( "Settings", "HIL_hmi_durchschnittsgeschwindigkeit_e2", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_e1_available, getProfileInt( "Settings", "HIL_hmi_durchschnittsverbrauch_e1_available", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_e2_available, getProfileInt( "Settings", "HIL_hmi_durchschnittsverbrauch_e2_available", 0, profileFile ) );
    putValue( HIL_s_at_zeitkonstante, getProfileInt( "Settings", "HIL_s_at_zeitkonstante", 0, profileFile ) );
    putValue( HIL_s_bc_reset_durchschnittsgeschwindigkeit_e1, getProfileInt( "Settings", "HIL_s_bc_reset_durchschnittsgeschwindigkeit_e1", 0, profileFile ) );
    putValue( HIL_s_bc_reset_durchschnittsgeschwindigkeit_e2, getProfileInt( "Settings", "HIL_s_bc_reset_durchschnittsgeschwindigkeit_e2", 0, profileFile ) );
    putValue( HIL_s_bc_reset_durchschnittsgeschwindigkeit_e3, getProfileInt( "Settings", "HIL_s_bc_reset_durchschnittsgeschwindigkeit_e3", 0, profileFile ) );
    putValue( HIL_s_bc_reset_durchschnittsverbrauch_e1, getProfileInt( "Settings", "HIL_s_bc_reset_durchschnittsverbrauch_e1", 0, profileFile ) );
    putValue( HIL_s_bc_reset_durchschnittsverbrauch_e2, getProfileInt( "Settings", "HIL_s_bc_reset_durchschnittsverbrauch_e2", 0, profileFile ) );
    putValue( HIL_s_bc_reset_durchschnittsverbrauch_e3, getProfileInt( "Settings", "HIL_s_bc_reset_durchschnittsverbrauch_e3", 0, profileFile ) );
    putValue( HIL_s_bc_reset_e1, getProfileInt( "Settings", "HIL_s_bc_reset_e1", 0, profileFile ) );
    putValue( HIL_s_bc_reset_e2, getProfileInt( "Settings", "HIL_s_bc_reset_e2", 0, profileFile ) );
    putValue( HIL_s_bc_reset_e3, getProfileInt( "Settings", "HIL_s_bc_reset_e3", 0, profileFile ) );
    putValue( HIL_s_bc_reset_fahrstrecke_e1, getProfileInt( "Settings", "HIL_s_bc_reset_fahrstrecke_e1", 0, profileFile ) );
    putValue( HIL_s_bc_reset_fahrstrecke_e2, getProfileInt( "Settings", "HIL_s_bc_reset_fahrstrecke_e2", 0, profileFile ) );
    putValue( HIL_s_bc_reset_fahrstrecke_e3, getProfileInt( "Settings", "HIL_s_bc_reset_fahrstrecke_e3", 0, profileFile ) );
    putValue( HIL_s_bc_reset_fahrzeit_e1, getProfileInt( "Settings", "HIL_s_bc_reset_fahrzeit_e1", 0, profileFile ) );
    putValue( HIL_s_bc_reset_fahrzeit_e2, getProfileInt( "Settings", "HIL_s_bc_reset_fahrzeit_e2", 0, profileFile ) );
    putValue( HIL_s_bc_reset_fahrzeit_e3, getProfileInt( "Settings", "HIL_s_bc_reset_fahrzeit_e3", 0, profileFile ) );
    putValue( HIL_s_fallende_tendenz, getProfileInt( "Settings", "HIL_s_fallende_tendenz", 0, profileFile ) );
    putValue( HIL_s_KBI_BC_Reset_E1, getProfileInt( "Settings", "HIL_s_KBI_BC_Reset_E1", 0, profileFile ) );
    putValue( HIL_s_KBI_BC_Reset_E2, getProfileInt( "Settings", "HIL_s_KBI_BC_Reset_E2", 0, profileFile ) );
    putValue( HIL_s_KBI_BC_Reset_E3, getProfileInt( "Settings", "HIL_s_KBI_BC_Reset_E3", 0, profileFile ) );
    putValue( HIL_s_KBI_QBit_Aussen_Temp_gef, getProfileInt( "Settings", "HIL_s_KBI_QBit_Aussen_Temp_gef", 0, profileFile ) );
    putValue( HIL_s_kurzzeit_altwert_ende, getProfileInt( "Settings", "HIL_s_kurzzeit_altwert_ende", 0, profileFile ) );
    putValue( HIL_s_kurzzeit_reset, getProfileInt( "Settings", "HIL_s_kurzzeit_reset", 0, profileFile ) );
    putValue( HIL_s_tankstop_altwert_ende, getProfileInt( "Settings", "HIL_s_tankstop_altwert_ende", 0, profileFile ) );
    putValue( HIL_s_tankstop_reset, getProfileInt( "Settings", "HIL_s_tankstop_reset", 0, profileFile ) );
    putValue( HIL_set_hmi_e1_reset, getProfileInt( "Settings", "HIL_set_hmi_e1_reset", 0, profileFile ) );
    putValue( HIL_set_hmi_e2_reset, getProfileInt( "Settings", "HIL_set_hmi_e2_reset", 0, profileFile ) );
    putValue( HIL_set_hmi_e3_reset, getProfileInt( "Settings", "HIL_set_hmi_e3_reset", 0, profileFile ) );
    putValue( HIL_b_MO_CNG_Ueberlauf, getProfileInt( "Settings", "HIL_b_MO_CNG_Ueberlauf", 0, profileFile ) );
    putValue( HIL_b_MO_KVS, getProfileInt( "Settings", "HIL_b_MO_KVS", 0, profileFile ) );
    putValue( HIL_b_MO_KVS_Ueberlauf, getProfileInt( "Settings", "HIL_b_MO_KVS_Ueberlauf", 0, profileFile ) );
    putValue( HIL_b_MO_LPG_Ueberlauf, getProfileInt( "Settings", "HIL_b_MO_LPG_Ueberlauf", 0, profileFile ) );
    putValue( HIL_b_MO_Verbrauch_CNG, getProfileInt( "Settings", "HIL_b_MO_Verbrauch_CNG", 0, profileFile ) );
    putValue( HIL_b_MO_Verbrauch_LPG, getProfileInt( "Settings", "HIL_b_MO_Verbrauch_LPG", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_e1_sonderbehandlung, getProfileInt( "Settings", "HIL_hmi_durchschnittsverbrauch_e1_sonderbehandlung", 0, profileFile ) );
    putValue( HIL_s_durchschnittsverbrauch_e1, getProfileFloat( "Settings", "HIL_s_durchschnittsverbrauch_e1", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_e2_sonderbehandlung, getProfileInt( "Settings", "HIL_hmi_durchschnittsverbrauch_e2_sonderbehandlung", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_e3_sonderbehandlung, getProfileInt( "Settings", "HIL_hmi_durchschnittsverbrauch_e3_sonderbehandlung", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_gas_e1_sonderbehandlung, getProfileInt( "Settings", "HIL_hmi_durchschnittsverbrauch_gas_e1_sonderbehandlung", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_gas_e2_sonderbehandlung, getProfileInt( "Settings", "HIL_hmi_durchschnittsverbrauch_gas_e2_sonderbehandlung", 0, profileFile ) );
    putValue( HIL_s_durchschnittsverbrauch_e2, getProfileFloat( "Settings", "HIL_s_durchschnittsverbrauch_e2", 0, profileFile ) );
    putValue( HIL_s_durchschnittsverbrauch_e3, getProfileFloat( "Settings", "HIL_s_durchschnittsverbrauch_e3", 0, profileFile ) );
    putValue( HIL_s_durchschnittsverbrauch_gas_e1, getProfileFloat( "Settings", "HIL_s_durchschnittsverbrauch_gas_e1", 0, profileFile ) );
    putValue( HIL_s_durchschnittsverbrauch_gas_e2, getProfileFloat( "Settings", "HIL_s_durchschnittsverbrauch_gas_e2", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_e1, getProfileFloat( "Settings", "HIL_hmi_durchschnittsverbrauch_e1", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_e2, getProfileFloat( "Settings", "HIL_hmi_durchschnittsverbrauch_e2", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_e3, getProfileFloat( "Settings", "HIL_hmi_durchschnittsverbrauch_e3", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_gas_e1, getProfileFloat( "Settings", "HIL_hmi_durchschnittsverbrauch_gas_e1", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_gas_e3_sonderbehandlung, getProfileInt( "Settings", "HIL_hmi_durchschnittsverbrauch_gas_e3_sonderbehandlung", 0, profileFile ) );
    putValue( HIL_s_durchschnittsverbrauch_gas_e3, getProfileFloat( "Settings", "HIL_s_durchschnittsverbrauch_gas_e3", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_einheit, getProfileInt( "Settings", "HIL_hmi_durchschnittsverbrauch_einheit", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_gas_e2, getProfileFloat( "Settings", "HIL_hmi_durchschnittsverbrauch_gas_e2", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_gas_e3, getProfileFloat( "Settings", "HIL_hmi_durchschnittsverbrauch_gas_e3", 0, profileFile ) );
    putValue( HIL_s_KBI_Aussen_Temp_gef, getProfileFloat( "Settings", "HIL_s_KBI_Aussen_Temp_gef", 0, profileFile ) );
    putValue( HIL_s_momentanverbrauch_lpro100km, getProfileFloat( "Settings", "HIL_s_momentanverbrauch_lpro100km", 0, profileFile ) );
    putValue( HIL_s_momentanverbrauch_lproh, getProfileFloat( "Settings", "HIL_s_momentanverbrauch_lproh", 0, profileFile ) );
    putValue( HIL_hmi_bc_momentanverbrauch, getProfileFloat( "Settings", "HIL_hmi_bc_momentanverbrauch", 0, profileFile ) );
    putValue( HIL_hmi_bc_momentanverbrauch_bargraph, getProfileFloat( "Settings", "HIL_hmi_bc_momentanverbrauch_bargraph", 0, profileFile ) );
    putValue( HIL_hmi_bc_momentanverbrauch_einheit, getProfileInt( "Settings", "HIL_hmi_bc_momentanverbrauch_einheit", 0, profileFile ) );
    putValue( HIL_hmi_bc_momentanverbrauch_einheit_bargraph, getProfileInt( "Settings", "HIL_hmi_bc_momentanverbrauch_einheit_bargraph", 0, profileFile ) );
    putValue( HIL_hmi_bc_momentanverbrauch_einheit_gas_bargraph, getProfileInt( "Settings", "HIL_hmi_bc_momentanverbrauch_einheit_gas_bargraph", 0, profileFile ) );
    putValue( HIL_hmi_bc_momentanverbrauch_gas, getProfileFloat( "Settings", "HIL_hmi_bc_momentanverbrauch_gas", 0, profileFile ) );
    putValue( HIL_hmi_bc_momentanverbrauch_gas_bargraph, getProfileFloat( "Settings", "HIL_hmi_bc_momentanverbrauch_gas_bargraph", 0, profileFile ) );
    putValue( HIL_hmi_bc_momentanverbrauch_gas_not_a_number_bargraph, getProfileInt( "Settings", "HIL_hmi_bc_momentanverbrauch_gas_not_a_number_bargraph", 0, profileFile ) );
    putValue( HIL_hmi_bc_momentanverbrauch_not_a_number, getProfileInt( "Settings", "HIL_hmi_bc_momentanverbrauch_not_a_number", 0, profileFile ) );
    putValue( HIL_hmi_bc_momentanverbrauch_not_a_number_bargraph, getProfileInt( "Settings", "HIL_hmi_bc_momentanverbrauch_not_a_number_bargraph", 0, profileFile ) );
    putValue( HIL_hmi_bc_momentanverbrauch_not_a_number_gas, getProfileInt( "Settings", "HIL_hmi_bc_momentanverbrauch_not_a_number_gas", 0, profileFile ) );
    putValue( HIL_hmi_momentanverbrauch_e1_available, getProfileInt( "Settings", "HIL_hmi_momentanverbrauch_e1_available", 0, profileFile ) );
    putValue( HIL_hmi_momentanverbrauch_e2_available, getProfileInt( "Settings", "HIL_hmi_momentanverbrauch_e2_available", 0, profileFile ) );
    putValue( HIL_hmi_momentanverbrauch_e3_available, getProfileInt( "Settings", "HIL_hmi_momentanverbrauch_e3_available", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_einheit_gas, getProfileInt( "Settings", "HIL_hmi_durchschnittsverbrauch_einheit_gas", 0, profileFile ) );
    putValue( HIL_s_acc_laeufer, getProfileInt( "Settings", "HIL_s_acc_laeufer", 0, profileFile ) );
    putValue( HIL_s_acc_laeufer_hist_negativ, getProfileInt( "Settings", "HIL_s_acc_laeufer_hist_negativ", 0, profileFile ) );
    putValue( HIL_s_acc_laeufer_hist_positiv, getProfileInt( "Settings", "HIL_s_acc_laeufer_hist_positiv", 0, profileFile ) );
    putValue( HIL_s_momentanverbrauch_gas_pro100km, getProfileFloat( "Settings", "HIL_s_momentanverbrauch_gas_pro100km", 0, profileFile ) );
    putValue( HIL_s_momentanverbrauch_gas_proh, getProfileFloat( "Settings", "HIL_s_momentanverbrauch_gas_proh", 0, profileFile ) );
    putValue( HIL_s_schubabschaltung, getProfileInt( "Settings", "HIL_s_schubabschaltung", 0, profileFile ) );
    putValue( HIL_s_schubabschaltung_gas, getProfileInt( "Settings", "HIL_s_schubabschaltung_gas", 0, profileFile ) );
    putValue( HIL_hmi_bc_fahrstrecke_e1, getProfileFloat( "Settings", "HIL_hmi_bc_fahrstrecke_e1", 0, profileFile ) );
    putValue( HIL_hmi_bc_gesamt_reichweite_symbol, getProfileInt( "Settings", "HIL_hmi_bc_gesamt_reichweite_symbol", 0, profileFile ) );
    putValue( HIL_hmi_bc_sekundaer_reichweite_symbol, getProfileInt( "Settings", "HIL_hmi_bc_sekundaer_reichweite_symbol", 0, profileFile ) );
    putValue( HIL_hmi_durchschnittsverbrauch_e3_available, getProfileInt( "Settings", "HIL_hmi_durchschnittsverbrauch_e3_available", 0, profileFile ) );
    putValue( HIL_hmi_fahrzeit_e1_available, getProfileInt( "Settings", "HIL_hmi_fahrzeit_e1_available", 0, profileFile ) );
    putValue( HIL_hmi_fahrzeit_e2_available, getProfileInt( "Settings", "HIL_hmi_fahrzeit_e2_available", 0, profileFile ) );
    putValue( HIL_hmi_fahrzeit_e3_available, getProfileInt( "Settings", "HIL_hmi_fahrzeit_e3_available", 0, profileFile ) );
    putValue( HIL_s_fahrstrecke_e3, getProfileInt( "Settings", "HIL_s_fahrstrecke_e3", 0, profileFile ) );
    putValue( HIL_hmi_fahrstrecke_e1_available, getProfileInt( "Settings", "HIL_hmi_fahrstrecke_e1_available", 0, profileFile ) );
    putValue( HIL_hmi_fahrstrecke_e2_available, getProfileInt( "Settings", "HIL_hmi_fahrstrecke_e2_available", 0, profileFile ) );
    putValue( HIL_hmi_fahrstrecke_e3_available, getProfileInt( "Settings", "HIL_hmi_fahrstrecke_e3_available", 0, profileFile ) );
    putValue( HIL_hmi_fahrstrecke_einheit, getProfileInt( "Settings", "HIL_hmi_fahrstrecke_einheit", 0, profileFile ) );
    putValue( HIL_s_fahrstrecke_e1, getProfileInt( "Settings", "HIL_s_fahrstrecke_e1", 0, profileFile ) );
    putValue( HIL_s_fahrstrecke_e2, getProfileInt( "Settings", "HIL_s_fahrstrecke_e2", 0, profileFile ) );
    putValue( HIL_b_RW_Prim_rRWB_aktiv, getProfileInt( "Settings", "HIL_b_RW_Prim_rRWB_aktiv", 0, profileFile ) );
    putValue( HIL_b_RW_Prim_rRWB_Reichw_Gesamt_Anz, getProfileInt( "Settings", "HIL_b_RW_Prim_rRWB_Reichw_Gesamt_Anz", 0, profileFile ) );
    putValue( HIL_hmi_bc_fahrstrecke_e2, getProfileFloat( "Settings", "HIL_hmi_bc_fahrstrecke_e2", 0, profileFile ) );
    putValue( HIL_hmi_bc_fahrstrecke_e3, getProfileFloat( "Settings", "HIL_hmi_bc_fahrstrecke_e3", 0, profileFile ) );
    putValue( HIL_hmi_bc_primaer_reichweite_symbol, getProfileInt( "Settings", "HIL_hmi_bc_primaer_reichweite_symbol", 0, profileFile ) );
    putValue( HIL_b_MO_Anzeige_StSt_Symbol, getProfileInt( "Settings", "HIL_b_MO_Anzeige_StSt_Symbol", 0, profileFile ) );
    putValue( HIL_b_MO_Anzeige_StSt_Text, getProfileInt( "Settings", "HIL_b_MO_Anzeige_StSt_Text", 0, profileFile ) );
    putValue( HIL_b_MO_AnzeigeGasbetrieb, getProfileInt( "Settings", "HIL_b_MO_AnzeigeGasbetrieb", 0, profileFile ) );
    putValue( HIL_b_MO_Effizienzmodus, getProfileInt( "Settings", "HIL_b_MO_Effizienzmodus", 0, profileFile ) );
    putValue( HIL_b_MO_EPCL, getProfileInt( "Settings", "HIL_b_MO_EPCL", 0, profileFile ) );
    putValue( HIL_b_MO_Erdgasqualitaet, getProfileInt( "Settings", "HIL_b_MO_Erdgasqualitaet", 0, profileFile ) );
    putValue( HIL_b_MO_Ethanol_BS_Texte, getProfileInt( "Settings", "HIL_b_MO_Ethanol_BS_Texte", 0, profileFile ) );
    putValue( HIL_b_MO_Istgang, getProfileInt( "Settings", "HIL_b_MO_Istgang", 0, profileFile ) );
    putValue( HIL_b_MO_KJS_nicht_bereit, getProfileInt( "Settings", "HIL_b_MO_KJS_nicht_bereit", 0, profileFile ) );
    putValue( HIL_b_MO_Motor_laeuft, getProfileInt( "Settings", "HIL_b_MO_Motor_laeuft", 0, profileFile ) );
    putValue( HIL_b_MO_Schaltempf_verfbar, getProfileInt( "Settings", "HIL_b_MO_Schaltempf_verfbar", 0, profileFile ) );
    putValue( HIL_b_MO_Sollgang, getProfileInt( "Settings", "HIL_b_MO_Sollgang", 0, profileFile ) );
    putValue( HIL_b_MO_StartStopp_Codiert, getProfileInt( "Settings", "HIL_b_MO_StartStopp_Codiert", 0, profileFile ) );
    putValue( HIL_b_MO_StartStopp_PopUp, getProfileInt( "Settings", "HIL_b_MO_StartStopp_PopUp", 0, profileFile ) );
    putValue( HIL_b_MO_Tankbereitschaft_Status, getProfileInt( "Settings", "HIL_b_MO_Tankbereitschaft_Status", 0, profileFile ) );
    putValue( HIL_b_MO_Tankmasse_CNG, getProfileFloat( "Settings", "HIL_b_MO_Tankmasse_CNG", 0, profileFile ) );
    putValue( HIL_b_MO_Text_Motorstart, getProfileInt( "Settings", "HIL_b_MO_Text_Motorstart", 0, profileFile ) );
    putValue( HIL_b_MO_Text_Partikelfil_Reg, getProfileInt( "Settings", "HIL_b_MO_Text_Partikelfil_Reg", 0, profileFile ) );
    putValue( HIL_b_MO_Vorglueh_Lampe, getProfileInt( "Settings", "HIL_b_MO_Vorglueh_Lampe", 0, profileFile ) );
    putValue( HIL_hmi_motorstarttexte, getProfileInt( "Settings", "HIL_hmi_motorstarttexte", 0, profileFile ) );
    putValue( HIL_s_LED_EPC, getProfileInt( "Settings", "HIL_s_LED_EPC", 0, profileFile ) );
    putValue( HIL_s_LED_Vorgluehlampe, getProfileInt( "Settings", "HIL_s_LED_Vorgluehlampe", 0, profileFile ) );
    putValue( HIL_s_MO_akt_Betrieb, getProfileInt( "Settings", "HIL_s_MO_akt_Betrieb", 0, profileFile ) );
    putValue( HIL_s_MO_AnzeigeGasbetrieb, getProfileInt( "Settings", "HIL_s_MO_AnzeigeGasbetrieb", 0, profileFile ) );
    putValue( HIL_s_MO_Erdgasqualitaet, getProfileInt( "Settings", "HIL_s_MO_Erdgasqualitaet", 0, profileFile ) );
    putValue( HIL_b_WIV_Russindex, getProfileInt( "Settings", "HIL_b_WIV_Russindex", 0, profileFile ) );
    putValue( HIL_b_WIV_t_max, getProfileInt( "Settings", "HIL_b_WIV_t_max", 0, profileFile ) );
    putValue( HIL_b_WIV_t_min, getProfileInt( "Settings", "HIL_b_WIV_t_min", 0, profileFile ) );
    putValue( HIL_b_WIV_Verschleissindex, getProfileInt( "Settings", "HIL_b_WIV_Verschleissindex", 0, profileFile ) );
    putValue( HIL_b_WIV_W_max, getProfileInt( "Settings", "HIL_b_WIV_W_max", 0, profileFile ) );
    putValue( HIL_b_WIV_W_min, getProfileInt( "Settings", "HIL_b_WIV_W_min", 0, profileFile ) );
    putValue( HIL_s_insp_reset_stelltaster, getProfileInt( "Settings", "HIL_s_insp_reset_stelltaster", 0, profileFile ) );
    putValue( HIL_s_oel_vorwarnung_in_km, getProfileInt( "Settings", "HIL_s_oel_vorwarnung_in_km", 0, profileFile ) );
    putValue( HIL_s_oel_vorwarnung_in_tagen, getProfileInt( "Settings", "HIL_s_oel_vorwarnung_in_tagen", 0, profileFile ) );
    putValue( HIL_s_oil_insp_reset_stelltaster, getProfileInt( "Settings", "HIL_s_oil_insp_reset_stelltaster", 0, profileFile ) );
    putValue( HIL_s_service_vorwarnung_aktiv, getProfileInt( "Settings", "HIL_s_service_vorwarnung_aktiv", 0, profileFile ) );
    putValue( HIL_s_service_warnung_aktiv, getProfileInt( "Settings", "HIL_s_service_warnung_aktiv", 0, profileFile ) );
    putValue( HIL_hmi_oil_restlauf_strecke, getProfileInt( "Settings", "HIL_hmi_oil_restlauf_strecke", 0, profileFile ) );
    putValue( HIL_hmi_service_restlauf_strecke, getProfileInt( "Settings", "HIL_hmi_service_restlauf_strecke", 0, profileFile ) );
    putValue( HIL_s_insp_faellig_km, getProfileInt( "Settings", "HIL_s_insp_faellig_km", 0, profileFile ) );
    putValue( HIL_s_insp_faellig_tage, getProfileInt( "Settings", "HIL_s_insp_faellig_tage", 0, profileFile ) );
    putValue( HIL_s_insp_praediktion_aktiv, getProfileInt( "Settings", "HIL_s_insp_praediktion_aktiv", 0, profileFile ) );
    putValue( HIL_s_insp_praediktion_aktiv_km, getProfileInt( "Settings", "HIL_s_insp_praediktion_aktiv_km", 0, profileFile ) );
    putValue( HIL_s_insp_praediktion_aktiv_tage, getProfileInt( "Settings", "HIL_s_insp_praediktion_aktiv_tage", 0, profileFile ) );
    putValue( HIL_s_insp_reset_km_DIAG_event, getProfileInt( "Settings", "HIL_s_insp_reset_km_DIAG_event", 0, profileFile ) );
    putValue( HIL_s_insp_reset_km_HMI_event, getProfileInt( "Settings", "HIL_s_insp_reset_km_HMI_event", 0, profileFile ) );
    putValue( HIL_s_insp_reset_tage_DIAG_event, getProfileInt( "Settings", "HIL_s_insp_reset_tage_DIAG_event", 0, profileFile ) );
    putValue( HIL_s_insp_vorwarnung_in_km, getProfileInt( "Settings", "HIL_s_insp_vorwarnung_in_km", 0, profileFile ) );
    putValue( HIL_s_insp_vorwarnung_in_tagen, getProfileInt( "Settings", "HIL_s_insp_vorwarnung_in_tagen", 0, profileFile ) );
    putValue( HIL_s_insp_warnung, getProfileInt( "Settings", "HIL_s_insp_warnung", 0, profileFile ) );
    putValue( HIL_s_KBI_Oil_dis, getProfileInt( "Settings", "HIL_s_KBI_Oil_dis", 0, profileFile ) );
    putValue( HIL_s_KBI_Oil_dis_status, getProfileInt( "Settings", "HIL_s_KBI_Oil_dis_status", 0, profileFile ) );
    putValue( HIL_s_KBI_Oil_dis_unit, getProfileInt( "Settings", "HIL_s_KBI_Oil_dis_unit", 0, profileFile ) );
    putValue( HIL_s_oel_insp_vorwarnung_in_km, getProfileInt( "Settings", "HIL_s_oel_insp_vorwarnung_in_km", 0, profileFile ) );
    putValue( HIL_s_oel_insp_vorwarnung_in_tagen, getProfileInt( "Settings", "HIL_s_oel_insp_vorwarnung_in_tagen", 0, profileFile ) );
    putValue( HIL_s_oel_insp_warnung, getProfileInt( "Settings", "HIL_s_oel_insp_warnung", 0, profileFile ) );
    putValue( HIL_s_oel_warnung, getProfileInt( "Settings", "HIL_s_oel_warnung", 0, profileFile ) );
    putValue( HIL_s_oil_faellig_km, getProfileInt( "Settings", "HIL_s_oil_faellig_km", 0, profileFile ) );
    putValue( HIL_s_oil_faellig_tage, getProfileInt( "Settings", "HIL_s_oil_faellig_tage", 0, profileFile ) );
    putValue( HIL_s_oil_praediktion_aktiv, getProfileInt( "Settings", "HIL_s_oil_praediktion_aktiv", 0, profileFile ) );
    putValue( HIL_s_oil_praediktion_aktiv_km, getProfileInt( "Settings", "HIL_s_oil_praediktion_aktiv_km", 0, profileFile ) );
    putValue( HIL_s_oil_praediktion_aktiv_tage, getProfileInt( "Settings", "HIL_s_oil_praediktion_aktiv_tage", 0, profileFile ) );
    putValue( HIL_s_oil_reset_DIAG_event, getProfileInt( "Settings", "HIL_s_oil_reset_DIAG_event", 0, profileFile ) );
    putValue( HIL_s_oil_reset_HMI_event, getProfileInt( "Settings", "HIL_s_oil_reset_HMI_event", 0, profileFile ) );
    putValue( HIL_s_oil_restlauf_nyc, getProfileInt( "Settings", "HIL_s_oil_restlauf_nyc", 0, profileFile ) );
    putValue( HIL_s_praediktion_aktiv, getProfileInt( "Settings", "HIL_s_praediktion_aktiv", 0, profileFile ) );
    putValue( HIL_b_MO_Kraftstofffilter_Wasser, getProfileInt( "Settings", "HIL_b_MO_Kraftstofffilter_Wasser", 0, profileFile ) );
    putValue( HIL_b_MO_OBD2_Lampe, getProfileInt( "Settings", "HIL_b_MO_OBD2_Lampe", 0, profileFile ) );
    putValue( HIL_b_MO_Text_Tankdeckelwarn, getProfileInt( "Settings", "HIL_b_MO_Text_Tankdeckelwarn", 0, profileFile ) );
    putValue( HIL_hmi_insp_restlauf_strecke, getProfileInt( "Settings", "HIL_hmi_insp_restlauf_strecke", 0, profileFile ) );
    putValue( HIL_hmi_wiv_Oelmenge, getProfileFloat( "Settings", "HIL_hmi_wiv_Oelmenge", 0, profileFile ) );
    putValue( HIL_hmi_wiv_Oelmenge_Einheit, getProfileInt( "Settings", "HIL_hmi_wiv_Oelmenge_Einheit", 0, profileFile ) );
    putValue( HIL_s_insp_reset_tage_HMI_event, getProfileInt( "Settings", "HIL_s_insp_reset_tage_HMI_event", 0, profileFile ) );
    putValue( HIL_s_KBI_Insp_dis, getProfileInt( "Settings", "HIL_s_KBI_Insp_dis", 0, profileFile ) );
    putValue( HIL_s_KBI_Insp_time, getProfileInt( "Settings", "HIL_s_KBI_Insp_time", 0, profileFile ) );
    putValue( HIL_s_KBI_Oil_time, getProfileInt( "Settings", "HIL_s_KBI_Oil_time", 0, profileFile ) );
    putValue( HIL_s_LED_OBD, getProfileInt( "Settings", "HIL_s_LED_OBD", 0, profileFile ) );
    putValue( HIL_s_MO_OBD2_Lampe_warn, getProfileInt( "Settings", "HIL_s_MO_OBD2_Lampe_warn", 0, profileFile ) );
    putValue( HIL_s_wiv_daten_unplausibel, getProfileInt( "Settings", "HIL_s_wiv_daten_unplausibel", 0, profileFile ) );
    putValue( HIL_s_WIV_Russindex_fehler, getProfileInt( "Settings", "HIL_s_WIV_Russindex_fehler", 0, profileFile ) );
    putValue( HIL_s_WIV_Verschleissindex_fehler, getProfileInt( "Settings", "HIL_s_WIV_Verschleissindex_fehler", 0, profileFile ) );
    putValue( HIL_b_MO_Anzeige_Leistung_Max, getProfileFloat( "Settings", "HIL_b_MO_Anzeige_Leistung_Max", 0, profileFile ) );
    putValue( HIL_b_MO_Ladedruck, getProfileFloat( "Settings", "HIL_b_MO_Ladedruck", 0, profileFile ) );
    putValue( HIL_b_MO_Leistung, getProfileInt( "Settings", "HIL_b_MO_Leistung", 0, profileFile ) );
    putValue( HIL_b_MO_max_Ladedruck, getProfileFloat( "Settings", "HIL_b_MO_max_Ladedruck", 0, profileFile ) );
    putValue( HIL_b_MO_rel_Ladedruck, getProfileFloat( "Settings", "HIL_b_MO_rel_Ladedruck", 0, profileFile ) );
    putValue( HIL_b_TSK_Status_vMax_FahrerInfo, getProfileInt( "Settings", "HIL_b_TSK_Status_vMax_FahrerInfo", 0, profileFile ) );
    putValue( HIL_hmi_Ladedruck, getProfileFloat( "Settings", "HIL_hmi_Ladedruck", 0, profileFile ) );
    putValue( HIL_hmi_wiv_Oelstand, getProfileFloat( "Settings", "HIL_hmi_wiv_Oelstand", 0, profileFile ) );
    putValue( HIL_s_KBI_Vorglueh_System_Lampe, getProfileInt( "Settings", "HIL_s_KBI_Vorglueh_System_Lampe", 0, profileFile ) );
    putValue( HIL_s_MO_CNG_LPG, getProfileInt( "Settings", "HIL_s_MO_CNG_LPG", 0, profileFile ) );
    putValue( HIL_b_MO_Anzahl_Zyl, getProfileInt( "Settings", "HIL_b_MO_Anzahl_Zyl", 0, profileFile ) );
    putValue( HIL_b_MO_Anzeige_Drehmoment, getProfileInt( "Settings", "HIL_b_MO_Anzeige_Drehmoment", 0, profileFile ) );
    putValue( HIL_b_MO_Anzeige_Drehmoment_Max, getProfileInt( "Settings", "HIL_b_MO_Anzeige_Drehmoment_Max", 0, profileFile ) );
    putValue( HIL_b_MO_MKB_01, getProfileInt( "Settings", "HIL_b_MO_MKB_01", 0, profileFile ) );
    putValue( HIL_b_MO_MKB_02, getProfileInt( "Settings", "HIL_b_MO_MKB_02", 0, profileFile ) );
    putValue( HIL_b_MO_MKB_03, getProfileInt( "Settings", "HIL_b_MO_MKB_03", 0, profileFile ) );
    putValue( HIL_b_MO_MKB_04, getProfileInt( "Settings", "HIL_b_MO_MKB_04", 0, profileFile ) );
    putValue( HIL_b_MO_Zylabsch_Texte_02, getProfileInt( "Settings", "HIL_b_MO_Zylabsch_Texte_02", 0, profileFile ) );
    putValue( HIL_hmi_anzahl_aktiver_zylinder, getProfileInt( "Settings", "HIL_hmi_anzahl_aktiver_zylinder", 0, profileFile ) );
    putValue( HIL_hmi_anzahl_zylinder, getProfileInt( "Settings", "HIL_hmi_anzahl_zylinder", 0, profileFile ) );
    putValue( HIL_hmi_zylinderabschaltung_anzeigen, getProfileInt( "Settings", "HIL_hmi_zylinderabschaltung_anzeigen", 0, profileFile ) );
    putValue( HIL_hmi_zylinderabschaltung_stoerung, getProfileInt( "Settings", "HIL_hmi_zylinderabschaltung_stoerung", 0, profileFile ) );
    putValue( HIL_hmi_zylinderabschaltung_uebergangsbetrieb, getProfileInt( "Settings", "HIL_hmi_zylinderabschaltung_uebergangsbetrieb", 0, profileFile ) );
    putValue( HIL_b_MO_ITM_Warnung_Pumpe, getProfileInt( "Settings", "HIL_b_MO_ITM_Warnung_Pumpe", 0, profileFile ) );
    putValue( HIL_b_SCR_Einheit, getProfileInt( "Settings", "HIL_b_SCR_Einheit", 0, profileFile ) );
    putValue( HIL_b_SCR_Nachfuellmenge_Einheit, getProfileInt( "Settings", "HIL_b_SCR_Nachfuellmenge_Einheit", 0, profileFile ) );
    putValue( HIL_b_SCR_Nachfuellmenge_max, getProfileFloat( "Settings", "HIL_b_SCR_Nachfuellmenge_max", 0, profileFile ) );
    putValue( HIL_b_SCR_Nachfuellmenge_min, getProfileFloat( "Settings", "HIL_b_SCR_Nachfuellmenge_min", 0, profileFile ) );
    putValue( HIL_b_SCR_Restreichweite, getProfileInt( "Settings", "HIL_b_SCR_Restreichweite", 0, profileFile ) );
    putValue( HIL_b_SCR_Retriggersignal, getProfileInt( "Settings", "HIL_b_SCR_Retriggersignal", 0, profileFile ) );
    putValue( HIL_b_SCR_verbaut, getProfileInt( "Settings", "HIL_b_SCR_verbaut", 0, profileFile ) );
    putValue( HIL_b_SCR_Zustand, getProfileInt( "Settings", "HIL_b_SCR_Zustand", 0, profileFile ) );
    putValue( HIL_hmi_bc_oeltemperatur, getProfileInt( "Settings", "HIL_hmi_bc_oeltemperatur", 0, profileFile ) );
    putValue( HIL_hmi_scr_reichweite, getProfileInt( "Settings", "HIL_hmi_scr_reichweite", 0, profileFile ) );
    putValue( HIL_b_MO_Anzeige_Fahrbereitschaft, getProfileInt( "Settings", "HIL_b_MO_Anzeige_Fahrbereitschaft", 0, profileFile ) );
    putValue( HIL_b_MO_Anzeige_FMAus_Text, getProfileInt( "Settings", "HIL_b_MO_Anzeige_FMAus_Text", 0, profileFile ) );
    putValue( HIL_b_MO_Anzeigedrehz, getProfileInt( "Settings", "HIL_b_MO_Anzeigedrehz", 0, profileFile ) );
    putValue( HIL_b_MO_Drehzahl_Warnung, getProfileInt( "Settings", "HIL_b_MO_Drehzahl_Warnung", 0, profileFile ) );
    putValue( HIL_b_MO_EFLEX_Lampe, getProfileInt( "Settings", "HIL_b_MO_EFLEX_Lampe", 0, profileFile ) );
    putValue( HIL_b_MO_Fehler_Oeldrucksensor, getProfileInt( "Settings", "HIL_b_MO_Fehler_Oeldrucksensor", 0, profileFile ) );
    putValue( HIL_b_MO_obere_Drehzahlgrenze, getProfileInt( "Settings", "HIL_b_MO_obere_Drehzahlgrenze", 0, profileFile ) );
    putValue( HIL_b_MO_Oelwarnung_max, getProfileInt( "Settings", "HIL_b_MO_Oelwarnung_max", 0, profileFile ) );
    putValue( HIL_b_MO_Verbau_StartSys_Q_Diode, getProfileInt( "Settings", "HIL_b_MO_Verbau_StartSys_Q_Diode", 0, profileFile ) );
    putValue( HIL_b_WIV_nachfuellanzeige_ein, getProfileInt( "Settings", "HIL_b_WIV_nachfuellanzeige_ein", 0, profileFile ) );
    putValue( HIL_b_WIV_Oeldr_Warn_Motor, getProfileInt( "Settings", "HIL_b_WIV_Oeldr_Warn_Motor", 0, profileFile ) );
    putValue( HIL_b_WIV_Oelmenge, getProfileInt( "Settings", "HIL_b_WIV_Oelmenge", 0, profileFile ) );
    putValue( HIL_b_WIV_Oelmin_Warn, getProfileInt( "Settings", "HIL_b_WIV_Oelmin_Warn", 0, profileFile ) );
    putValue( HIL_b_WIV_Oelstand, getProfileFloat( "Settings", "HIL_b_WIV_Oelstand", 0, profileFile ) );
    putValue( HIL_b_WIV_Oelsystem_aktiv, getProfileInt( "Settings", "HIL_b_WIV_Oelsystem_aktiv", 0, profileFile ) );
    putValue( HIL_b_WIV_Sensorfehler, getProfileInt( "Settings", "HIL_b_WIV_Sensorfehler", 0, profileFile ) );
    putValue( HIL_b_WIV_Ueberfuell_deaktiv, getProfileInt( "Settings", "HIL_b_WIV_Ueberfuell_deaktiv", 0, profileFile ) );
    putValue( HIL_b_WIV_Ueberfuell_Warn, getProfileInt( "Settings", "HIL_b_WIV_Ueberfuell_Warn", 0, profileFile ) );
    putValue( HIL_b_WIV_Unterfuell_Warn, getProfileInt( "Settings", "HIL_b_WIV_Unterfuell_Warn", 0, profileFile ) );
    putValue( HIL_s_drehzahl_displayanzeige, getProfileInt( "Settings", "HIL_s_drehzahl_displayanzeige", 0, profileFile ) );
    putValue( HIL_s_dzm_zeigerposition, getProfileInt( "Settings", "HIL_s_dzm_zeigerposition", 0, profileFile ) );
    putValue( HIL_s_LED_Vorgluehlampe_blinken, getProfileInt( "Settings", "HIL_s_LED_Vorgluehlampe_blinken", 0, profileFile ) );
    putValue( HIL_s_MO_MKB_MUX, getProfileInt( "Settings", "HIL_s_MO_MKB_MUX", 0, profileFile ) );
    putValue( HIL_s_MO_Oel_Temp_Client_vorhanden, getProfileInt( "Settings", "HIL_s_MO_Oel_Temp_Client_vorhanden", 0, profileFile ) );
    putValue( HIL_s_MO_Oel_Temp_Werte_vorhanden, getProfileInt( "Settings", "HIL_s_MO_Oel_Temp_Werte_vorhanden", 0, profileFile ) );
    putValue( HIL_b_BCM_Kuehlmittel_Sensor, getProfileInt( "Settings", "HIL_b_BCM_Kuehlmittel_Sensor", 0, profileFile ) );
    putValue( HIL_b_BCM_Kuehlmittel_Sensor_02, getProfileInt( "Settings", "HIL_b_BCM_Kuehlmittel_Sensor_02", 0, profileFile ) );
    putValue( HIL_b_MO_Heissleuchte, getProfileInt( "Settings", "HIL_b_MO_Heissleuchte", 0, profileFile ) );
    putValue( HIL_b_MO_ITM_Kuehlmittel_Temp, getProfileFloat( "Settings", "HIL_b_MO_ITM_Kuehlmittel_Temp", 0, profileFile ) );
    putValue( HIL_b_MO_Oel_Temp, getProfileInt( "Settings", "HIL_b_MO_Oel_Temp", 0, profileFile ) );
    putValue( HIL_b_OLEV_Oelstand_nicht_vorhanden, getProfileInt( "Settings", "HIL_b_OLEV_Oelstand_nicht_vorhanden", 0, profileFile ) );
    putValue( HIL_b_OLEV_Systemstoerung, getProfileInt( "Settings", "HIL_b_OLEV_Systemstoerung", 0, profileFile ) );
    putValue( HIL_b_WIV_Anzeige_aktiv, getProfileInt( "Settings", "HIL_b_WIV_Anzeige_aktiv", 0, profileFile ) );
    putValue( HIL_hmi_bc_kuehlmitteltemperatur, getProfileInt( "Settings", "HIL_hmi_bc_kuehlmitteltemperatur", 0, profileFile ) );
    putValue( HIL_s_kuehlmittel_kalt_warn, getProfileInt( "Settings", "HIL_s_kuehlmittel_kalt_warn", 0, profileFile ) );
    putValue( HIL_s_kuehlmittelmangel_warn, getProfileInt( "Settings", "HIL_s_kuehlmittelmangel_warn", 0, profileFile ) );
    putValue( HIL_s_kuehlmitteltemp, getProfileFloat( "Settings", "HIL_s_kuehlmitteltemp", 0, profileFile ) );
    putValue( HIL_s_kuehlmitteltemp_analog, getProfileFloat( "Settings", "HIL_s_kuehlmitteltemp_analog", 0, profileFile ) );
    putValue( HIL_s_kuehlmitteltemp_displayanzeige, getProfileFloat( "Settings", "HIL_s_kuehlmitteltemp_displayanzeige", 0, profileFile ) );
    putValue( HIL_s_LED_Kaltleuchte, getProfileInt( "Settings", "HIL_s_LED_Kaltleuchte", 0, profileFile ) );
    putValue( HIL_s_LED_Kuehlmittelmangel_blinken, getProfileInt( "Settings", "HIL_s_LED_Kuehlmittelmangel_blinken", 0, profileFile ) );
    putValue( HIL_s_MO_Kuehl_Temp_Werte_vorhanden, getProfileInt( "Settings", "HIL_s_MO_Kuehl_Temp_Werte_vorhanden", 0, profileFile ) );
    putValue( HIL_s_MO_Oel_Temp, getProfileInt( "Settings", "HIL_s_MO_Oel_Temp", 0, profileFile ) );
    putValue( HIL_b_BCM_Bremsfluessigkeit_Sensor, getProfileInt( "Settings", "HIL_b_BCM_Bremsfluessigkeit_Sensor", 0, profileFile ) );
    putValue( HIL_b_CHA_Kombi_Texte, getProfileInt( "Settings", "HIL_b_CHA_Kombi_Texte", 0, profileFile ) );
    putValue( HIL_b_CHA_Kombi_Texte_02, getProfileInt( "Settings", "HIL_b_CHA_Kombi_Texte_02", 0, profileFile ) );
    putValue( HIL_b_CHA_Offroad_LED, getProfileInt( "Settings", "HIL_b_CHA_Offroad_LED", 0, profileFile ) );
    putValue( HIL_b_ESC_Lernfreigabe_Abrollumfang, getProfileInt( "Settings", "HIL_b_ESC_Lernfreigabe_Abrollumfang", 0, profileFile ) );
    putValue( HIL_b_ESP_Meldungen, getProfileInt( "Settings", "HIL_b_ESP_Meldungen", 0, profileFile ) );
    putValue( HIL_b_ESP_Textanzeigen_03, getProfileInt( "Settings", "HIL_b_ESP_Textanzeigen_03", 0, profileFile ) );
    putValue( HIL_b_MO_Anz_Kuehlerluefter, getProfileInt( "Settings", "HIL_b_MO_Anz_Kuehlerluefter", 0, profileFile ) );
    putValue( HIL_b_MO_Schaltblitz_Anz, getProfileInt( "Settings", "HIL_b_MO_Schaltblitz_Anz", 0, profileFile ) );
    putValue( HIL_dah_schaltblitz_blinkfrequenz, getProfileFloat( "Settings", "HIL_dah_schaltblitz_blinkfrequenz", 0, profileFile ) );
    putValue( HIL_hmi_analoggeschwindigkeit_digital_einheit, getProfileFloat( "Settings", "HIL_hmi_analoggeschwindigkeit_digital_einheit", 0, profileFile ) );
    putValue( HIL_s_Bremsbelag_RdW, getProfileInt( "Settings", "HIL_s_Bremsbelag_RdW", 0, profileFile ) );
    putValue( HIL_s_gap_mfa, getProfileInt( "Settings", "HIL_s_gap_mfa", 0, profileFile ) );
    putValue( HIL_s_gap_texte, getProfileInt( "Settings", "HIL_s_gap_texte", 0, profileFile ) );
    putValue( HIL_s_LED_RDK, getProfileInt( "Settings", "HIL_s_LED_RDK", 0, profileFile ) );
    putValue( HIL_s_LED_RDK_blinken, getProfileInt( "Settings", "HIL_s_LED_RDK_blinken", 0, profileFile ) );
    putValue( HIL_b_ESP_Wegimp_VA, getProfileInt( "Settings", "HIL_b_ESP_Wegimp_VA", 0, profileFile ) );
    putValue( HIL_b_ESP_Zaehnezahl, getProfileInt( "Settings", "HIL_b_ESP_Zaehnezahl", 0, profileFile ) );
    putValue( HIL_s_gesamtwegstrecke, getProfileFloat( "Settings", "HIL_s_gesamtwegstrecke", 0, profileFile ) );
    putValue( HIL_s_tageswegstrecke_reset_rueckgaengig, getProfileInt( "Settings", "HIL_s_tageswegstrecke_reset_rueckgaengig", 0, profileFile ) );
    putValue( HIL_b_BCM_Bremsbelag_Sensor, getProfileInt( "Settings", "HIL_b_BCM_Bremsbelag_Sensor", 0, profileFile ) );
    putValue( HIL_b_EPB_Autoholdlampe_02, getProfileInt( "Settings", "HIL_b_EPB_Autoholdlampe_02", 0, profileFile ) );
    putValue( HIL_b_EPB_Funktionslampe_02, getProfileInt( "Settings", "HIL_b_EPB_Funktionslampe_02", 0, profileFile ) );
    putValue( HIL_b_EPB_Texte_02, getProfileInt( "Settings", "HIL_b_EPB_Texte_02", 0, profileFile ) );
    putValue( HIL_b_ESP_Wegimp_Ueberlauf, getProfileInt( "Settings", "HIL_b_ESP_Wegimp_Ueberlauf", 0, profileFile ) );
    putValue( HIL_b_RDK_FMVSS138_MIL, getProfileInt( "Settings", "HIL_b_RDK_FMVSS138_MIL", 0, profileFile ) );
    putValue( HIL_hmi_gesamtwegstrecke, getProfileInt( "Settings", "HIL_hmi_gesamtwegstrecke", 0, profileFile ) );
    putValue( HIL_hmi_gesamtwegstrecke_einheit, getProfileInt( "Settings", "HIL_hmi_gesamtwegstrecke_einheit", 0, profileFile ) );
    putValue( HIL_hmi_tageswegstrecke, getProfileFloat( "Settings", "HIL_hmi_tageswegstrecke", 0, profileFile ) );
    putValue( HIL_hmi_tageswegstrecke_einheit, getProfileInt( "Settings", "HIL_hmi_tageswegstrecke_einheit", 0, profileFile ) );
    putValue( HIL_s_Bremsbelag_US, getProfileInt( "Settings", "HIL_s_Bremsbelag_US", 0, profileFile ) );
    putValue( HIL_s_feststellbremse_warnung, getProfileInt( "Settings", "HIL_s_feststellbremse_warnung", 0, profileFile ) );
    putValue( HIL_s_gws_teilfehler, getProfileInt( "Settings", "HIL_s_gws_teilfehler", 0, profileFile ) );
    putValue( HIL_s_gws_totalfehler, getProfileInt( "Settings", "HIL_s_gws_totalfehler", 0, profileFile ) );
    putValue( HIL_s_LED_BVA, getProfileInt( "Settings", "HIL_s_LED_BVA", 0, profileFile ) );
    putValue( HIL_s_LED_EPB_gruen, getProfileInt( "Settings", "HIL_s_LED_EPB_gruen", 0, profileFile ) );
    putValue( HIL_s_RDK_mil, getProfileInt( "Settings", "HIL_s_RDK_mil", 0, profileFile ) );
    putValue( HIL_s_RDK_Systemstoerung, getProfileInt( "Settings", "HIL_s_RDK_Systemstoerung", 0, profileFile ) );
    putValue( HIL_b_ESP_m_Raddrehz, getProfileFloat( "Settings", "HIL_b_ESP_m_Raddrehz", 0, profileFile ) );
    putValue( HIL_s_geschwindigkeit_analog, getProfileFloat( "Settings", "HIL_s_geschwindigkeit_analog", 0, profileFile ) );
    putValue( HIL_s_geschwindigkeit_plaus2, getProfileInt( "Settings", "HIL_s_geschwindigkeit_plaus2", 0, profileFile ) );
    putValue( HIL_s_KBI_angez_Geschw, getProfileFloat( "Settings", "HIL_s_KBI_angez_Geschw", 0, profileFile ) );
    putValue( HIL_s_kombi_tachokennlinie_fehler, getProfileInt( "Settings", "HIL_s_kombi_tachokennlinie_fehler", 0, profileFile ) );
    putValue( HIL_s_radumfang_max, getProfileInt( "Settings", "HIL_s_radumfang_max", 0, profileFile ) );
    putValue( HIL_b_ABS_Lampe, getProfileInt( "Settings", "HIL_b_ABS_Lampe", 0, profileFile ) );
    putValue( HIL_b_CHA_Current_Mode_FPA, getProfileInt( "Settings", "HIL_b_CHA_Current_Mode_FPA", 0, profileFile ) );
    putValue( HIL_b_DR_Gelbe_Warnlampe, getProfileInt( "Settings", "HIL_b_DR_Gelbe_Warnlampe", 0, profileFile ) );
    putValue( HIL_b_EPB_Autohold_Standbyanzeige, getProfileInt( "Settings", "HIL_b_EPB_Autohold_Standbyanzeige", 0, profileFile ) );
    putValue( HIL_b_Quersperre_Anz_Sperre_Auslegen, getProfileInt( "Settings", "HIL_b_Quersperre_Anz_Sperre_Auslegen", 0, profileFile ) );
    putValue( HIL_b_Quersperre_Anz_Sperre_Einlegen, getProfileInt( "Settings", "HIL_b_Quersperre_Anz_Sperre_Einlegen", 0, profileFile ) );
    putValue( HIL_b_Quersperre_Anz_Sperre_Geschl, getProfileInt( "Settings", "HIL_b_Quersperre_Anz_Sperre_Geschl", 0, profileFile ) );
    putValue( HIL_b_RDK_Warnungen_02, getProfileInt( "Settings", "HIL_b_RDK_Warnungen_02", 0, profileFile ) );
    putValue( HIL_b_TC_Lampe, getProfileInt( "Settings", "HIL_b_TC_Lampe", 0, profileFile ) );
    putValue( HIL_hmi_analoggeschwindigkeit, getProfileFloat( "Settings", "HIL_hmi_analoggeschwindigkeit", 0, profileFile ) );
    putValue( HIL_hmi_analoggeschwindigkeit_einheit, getProfileInt( "Settings", "HIL_hmi_analoggeschwindigkeit_einheit", 0, profileFile ) );
    putValue( HIL_hmi_digital_zweitgeschwindigkeit, getProfileInt( "Settings", "HIL_hmi_digital_zweitgeschwindigkeit", 0, profileFile ) );
    putValue( HIL_hmi_digital_zweitgeschwindigkeit_einheit, getProfileInt( "Settings", "HIL_hmi_digital_zweitgeschwindigkeit_einheit", 0, profileFile ) );
    putValue( HIL_s_bremsfluessigkeitsmangel_warn, getProfileInt( "Settings", "HIL_s_bremsfluessigkeitsmangel_warn", 0, profileFile ) );
    putValue( HIL_s_geschwindigkeit_berechnet, getProfileFloat( "Settings", "HIL_s_geschwindigkeit_berechnet", 0, profileFile ) );
    putValue( HIL_s_LED_ABS, getProfileInt( "Settings", "HIL_s_LED_ABS", 0, profileFile ) );
    putValue( HIL_s_LED_ABS_US, getProfileInt( "Settings", "HIL_s_LED_ABS_US", 0, profileFile ) );
    putValue( HIL_s_LED_Autohold_Standby_weiss, getProfileInt( "Settings", "HIL_s_LED_Autohold_Standby_weiss", 0, profileFile ) );
    putValue( HIL_s_LED_Quersperre, getProfileInt( "Settings", "HIL_s_LED_Quersperre", 0, profileFile ) );
    putValue( HIL_s_LED_Quersperre_blinken, getProfileInt( "Settings", "HIL_s_LED_Quersperre_blinken", 0, profileFile ) );
    putValue( HIL_s_LED_TC, getProfileInt( "Settings", "HIL_s_LED_TC", 0, profileFile ) );
    putValue( HIL_s_mittlere_raddrehzahl_fehler, getProfileInt( "Settings", "HIL_s_mittlere_raddrehzahl_fehler", 0, profileFile ) );
    putValue( HIL_b_BK_Lampe_02, getProfileInt( "Settings", "HIL_b_BK_Lampe_02", 0, profileFile ) );
    putValue( HIL_b_BR_Systemart, getProfileInt( "Settings", "HIL_b_BR_Systemart", 0, profileFile ) );
    putValue( HIL_b_EPS_Warnungen, getProfileInt( "Settings", "HIL_b_EPS_Warnungen", 0, profileFile ) );
    putValue( HIL_b_ESP_BKV_Warnung, getProfileInt( "Settings", "HIL_b_ESP_BKV_Warnung", 0, profileFile ) );
    putValue( HIL_b_ESP_Lampe, getProfileInt( "Settings", "HIL_b_ESP_Lampe", 0, profileFile ) );
    putValue( HIL_b_ESP_Off_Lampe, getProfileInt( "Settings", "HIL_b_ESP_Off_Lampe", 0, profileFile ) );
    putValue( HIL_b_GNSS_Ortung_2D_Geschw_ue_Grund, getProfileFloat( "Settings", "HIL_b_GNSS_Ortung_2D_Geschw_ue_Grund", 0, profileFile ) );
    putValue( HIL_b_LWI_Lenkradwinkel, getProfileFloat( "Settings", "HIL_b_LWI_Lenkradwinkel", 0, profileFile ) );
    putValue( HIL_b_LWI_VZ_Lenkradwinkel, getProfileInt( "Settings", "HIL_b_LWI_VZ_Lenkradwinkel", 0, profileFile ) );
    putValue( HIL_b_RDK_FMVSS138_Lampe, getProfileInt( "Settings", "HIL_b_RDK_FMVSS138_Lampe", 0, profileFile ) );
    putValue( HIL_b_RDK_Kalibrierung, getProfileInt( "Settings", "HIL_b_RDK_Kalibrierung", 0, profileFile ) );
    putValue( HIL_b_RKA_FMVSS138_Lampe, getProfileInt( "Settings", "HIL_b_RKA_FMVSS138_Lampe", 0, profileFile ) );
    putValue( HIL_b_RKA_FMVSS138_MIL, getProfileInt( "Settings", "HIL_b_RKA_FMVSS138_MIL", 0, profileFile ) );
    putValue( HIL_b_RKA_Warnungen_02, getProfileInt( "Settings", "HIL_b_RKA_Warnungen_02", 0, profileFile ) );
    putValue( HIL_b_RLE_Anzeigen, getProfileInt( "Settings", "HIL_b_RLE_Anzeigen", 0, profileFile ) );
    putValue( HIL_s_ESP_Lampe, getProfileInt( "Settings", "HIL_s_ESP_Lampe", 0, profileFile ) );
    putValue( HIL_s_LED_BKL, getProfileInt( "Settings", "HIL_s_LED_BKL", 0, profileFile ) );
    putValue( HIL_s_LED_BKL_US, getProfileInt( "Settings", "HIL_s_LED_BKL_US", 0, profileFile ) );
    putValue( HIL_s_LED_ESP, getProfileInt( "Settings", "HIL_s_LED_ESP", 0, profileFile ) );
    putValue( HIL_s_LED_ESP_OFF, getProfileInt( "Settings", "HIL_s_LED_ESP_OFF", 0, profileFile ) );
    putValue( HIL_s_LED_Lenkhilfe_gelb, getProfileInt( "Settings", "HIL_s_LED_Lenkhilfe_gelb", 0, profileFile ) );
    putValue( HIL_s_LED_Lenkhilfe_gelb_blinken, getProfileInt( "Settings", "HIL_s_LED_Lenkhilfe_gelb_blinken", 0, profileFile ) );
    putValue( HIL_s_LED_Lenkhilfe_rot, getProfileInt( "Settings", "HIL_s_LED_Lenkhilfe_rot", 0, profileFile ) );
    putValue( HIL_s_RKA_mil, getProfileInt( "Settings", "HIL_s_RKA_mil", 0, profileFile ) );
    putValue( HIL_s_RKA_Systemstoerung, getProfileInt( "Settings", "HIL_s_RKA_Systemstoerung", 0, profileFile ) );
    putValue( HIL_s_tank_beschl_x_vorgefiltert, getProfileFloat( "Settings", "HIL_s_tank_beschl_x_vorgefiltert", 0, profileFile ) );
    putValue( HIL_s_tank_beschl_y_vorgefiltert, getProfileFloat( "Settings", "HIL_s_tank_beschl_y_vorgefiltert", 0, profileFile ) );
    putValue( HIL_s_tank_nte_log_error_n, getProfileInt( "Settings", "HIL_s_tank_nte_log_error_n", 0, profileFile ) );
    putValue( HIL_s_tank_tankstop, getProfileInt( "Settings", "HIL_s_tank_tankstop", 0, profileFile ) );
    putValue( HIL_s_tank_tanksystemwarnung, getProfileInt( "Settings", "HIL_s_tank_tanksystemwarnung", 0, profileFile ) );
    putValue( HIL_s_tank_tankwarnung, getProfileInt( "Settings", "HIL_s_tank_tankwarnung", 0, profileFile ) );
    putValue( HIL_s_tank_vol_geber_avrg_ntb_log_n, getProfileFloat( "Settings", "HIL_s_tank_vol_geber_avrg_ntb_log_n", 0, profileFile ) );
    putValue( HIL_s_tank_wsa_log_n, getProfileInt( "Settings", "HIL_s_tank_wsa_log_n", 0, profileFile ) );
    putValue( HIL_b_ESP_QBit_Laengsbeschl, getProfileInt( "Settings", "HIL_b_ESP_QBit_Laengsbeschl", 0, profileFile ) );
    putValue( HIL_b_ESP_QBit_Querb, getProfileInt( "Settings", "HIL_b_ESP_QBit_Querb", 0, profileFile ) );
    putValue( HIL_b_MO_akt_Betrieb, getProfileInt( "Settings", "HIL_b_MO_akt_Betrieb", 0, profileFile ) );
    putValue( HIL_s_bargraph_extern_an, getProfileInt( "Settings", "HIL_s_bargraph_extern_an", 0, profileFile ) );
    putValue( HIL_s_bargraph_tnk_aktiv, getProfileInt( "Settings", "HIL_s_bargraph_tnk_aktiv", 0, profileFile ) );
    putValue( HIL_s_bargraph_tnk_intern_an, getProfileInt( "Settings", "HIL_s_bargraph_tnk_intern_an", 0, profileFile ) );
    putValue( HIL_s_gastank_anzeige_dyn_Rotbereich, getProfileFloat( "Settings", "HIL_s_gastank_anzeige_dyn_Rotbereich", 0, profileFile ) );
    putValue( HIL_s_gastank_anzeige_winkel, getProfileFloat( "Settings", "HIL_s_gastank_anzeige_winkel", 0, profileFile ) );
    putValue( HIL_s_tank_anzeige_relativ, getProfileFloat( "Settings", "HIL_s_tank_anzeige_relativ", 0, profileFile ) );
    putValue( HIL_s_tank_anzeigefreigabe, getProfileInt( "Settings", "HIL_s_tank_anzeigefreigabe", 0, profileFile ) );
    putValue( HIL_s_tank_delta_event, getProfileInt( "Settings", "HIL_s_tank_delta_event", 0, profileFile ) );
    putValue( HIL_s_tank_geber_kopplung_beschl_x, getProfileFloat( "Settings", "HIL_s_tank_geber_kopplung_beschl_x", 0, profileFile ) );
    putValue( HIL_s_tank_lookup_vol_nte_zu, getProfileInt( "Settings", "HIL_s_tank_lookup_vol_nte_zu", 0, profileFile ) );
    putValue( HIL_s_tank_obd_warnung, getProfileInt( "Settings", "HIL_s_tank_obd_warnung", 0, profileFile ) );
    putValue( HIL_s_tank_ottodiesel_anzeigefreigabe, getProfileInt( "Settings", "HIL_s_tank_ottodiesel_anzeigefreigabe", 0, profileFile ) );
    putValue( HIL_s_tank_zustand_v_gr_0, getProfileInt( "Settings", "HIL_s_tank_zustand_v_gr_0", 0, profileFile ) );
    putValue( HIL_hmi_bc_nachtankmenge_sonderbehandlung, getProfileInt( "Settings", "HIL_hmi_bc_nachtankmenge_sonderbehandlung", 0, profileFile ) );
    putValue( HIL_hmi_bc_nachtankmenge_vorhanden, getProfileInt( "Settings", "HIL_hmi_bc_nachtankmenge_vorhanden", 0, profileFile ) );
    putValue( HIL_s_gastank_anzeige_prozent, getProfileFloat( "Settings", "HIL_s_gastank_anzeige_prozent", 0, profileFile ) );
    putValue( HIL_s_nachtankvolumen, getProfileFloat( "Settings", "HIL_s_nachtankvolumen", 0, profileFile ) );
    putValue( HIL_s_tank_anzeige_dyn_Rotbereich, getProfileFloat( "Settings", "HIL_s_tank_anzeige_dyn_Rotbereich", 0, profileFile ) );
    putValue( HIL_s_tank_anzeige_prozent, getProfileFloat( "Settings", "HIL_s_tank_anzeige_prozent", 0, profileFile ) );
    putValue( HIL_s_tank_anzeige_winkel, getProfileFloat( "Settings", "HIL_s_tank_anzeige_winkel", 0, profileFile ) );
    putValue( HIL_b_MO_CNG_LPG, getProfileInt( "Settings", "HIL_b_MO_CNG_LPG", 0, profileFile ) );
    putValue( HIL_b_MO_CNG_Tankstopp, getProfileInt( "Settings", "HIL_b_MO_CNG_Tankstopp", 0, profileFile ) );
    putValue( HIL_b_MO_Fuellungsgrad_CNG, getProfileFloat( "Settings", "HIL_b_MO_Fuellungsgrad_CNG", 0, profileFile ) );
    putValue( HIL_b_MO_Fuellungsgrad_LPG, getProfileFloat( "Settings", "HIL_b_MO_Fuellungsgrad_LPG", 0, profileFile ) );
    putValue( HIL_b_MO_LPG_Tankstopp, getProfileInt( "Settings", "HIL_b_MO_LPG_Tankstopp", 0, profileFile ) );
    putValue( HIL_s_bargraph_gastnk_aktiv, getProfileInt( "Settings", "HIL_s_bargraph_gastnk_aktiv", 0, profileFile ) );
    putValue( HIL_s_bargraph_gastnk_intern_an, getProfileInt( "Settings", "HIL_s_bargraph_gastnk_intern_an", 0, profileFile ) );
    putValue( HIL_s_gasbargraph_extern_an, getProfileInt( "Settings", "HIL_s_gasbargraph_extern_an", 0, profileFile ) );
    putValue( HIL_s_gastank_anzeige_relativ, getProfileFloat( "Settings", "HIL_s_gastank_anzeige_relativ", 0, profileFile ) );
    putValue( HIL_s_gastank_anzeigefreigabe, getProfileInt( "Settings", "HIL_s_gastank_anzeigefreigabe", 0, profileFile ) );
    putValue( HIL_s_gastank_fuellungsgrad, getProfileFloat( "Settings", "HIL_s_gastank_fuellungsgrad", 0, profileFile ) );
    putValue( HIL_s_gastank_systemfehler_cng, getProfileInt( "Settings", "HIL_s_gastank_systemfehler_cng", 0, profileFile ) );
    putValue( HIL_s_gastank_systemfehler_lpg, getProfileInt( "Settings", "HIL_s_gastank_systemfehler_lpg", 0, profileFile ) );
    putValue( HIL_s_gastank_warnung_cng_LED, getProfileInt( "Settings", "HIL_s_gastank_warnung_cng_LED", 0, profileFile ) );
    putValue( HIL_s_gastank_warnung_lpg, getProfileInt( "Settings", "HIL_s_gastank_warnung_lpg", 0, profileFile ) );
    putValue( HIL_s_LED_CNG_Reserve, getProfileInt( "Settings", "HIL_s_LED_CNG_Reserve", 0, profileFile ) );
    putValue( HIL_s_adc_guete_g3, getProfileInt( "Settings", "HIL_s_adc_guete_g3", 0, profileFile ) );
    putValue( HIL_s_adc_guete_g4, getProfileInt( "Settings", "HIL_s_adc_guete_g4", 0, profileFile ) );
    putValue( HIL_s_adc_ohmwert_skaliert_g2, getProfileInt( "Settings", "HIL_s_adc_ohmwert_skaliert_g2", 0, profileFile ) );
    putValue( HIL_s_adc_ohmwert_skaliert_g3, getProfileInt( "Settings", "HIL_s_adc_ohmwert_skaliert_g3", 0, profileFile ) );
    putValue( HIL_s_adc_r1s, getProfileInt( "Settings", "HIL_s_adc_r1s", 0, profileFile ) );
    putValue( HIL_s_adc_r12_gemessen, getProfileInt( "Settings", "HIL_s_adc_r12_gemessen", 0, profileFile ) );
    putValue( HIL_s_adc_r32_gemessen, getProfileInt( "Settings", "HIL_s_adc_r32_gemessen", 0, profileFile ) );
    putValue( HIL_s_adc_guete_g1, getProfileInt( "Settings", "HIL_s_adc_guete_g1", 0, profileFile ) );
    putValue( HIL_s_adc_ohmwert_skaliert_g4, getProfileInt( "Settings", "HIL_s_adc_ohmwert_skaliert_g4", 0, profileFile ) );
    putValue( HIL_s_adc_r2s, getProfileInt( "Settings", "HIL_s_adc_r2s", 0, profileFile ) );
    putValue( HIL_s_adc_r3s, getProfileInt( "Settings", "HIL_s_adc_r3s", 0, profileFile ) );
    putValue( HIL_s_adc_r4s, getProfileInt( "Settings", "HIL_s_adc_r4s", 0, profileFile ) );
    putValue( HIL_s_adc_r21_gemessen, getProfileInt( "Settings", "HIL_s_adc_r21_gemessen", 0, profileFile ) );
    putValue( HIL_s_adc_r31_gemessen, getProfileInt( "Settings", "HIL_s_adc_r31_gemessen", 0, profileFile ) );
    putValue( HIL_s_adc_r11_gemessen, getProfileInt( "Settings", "HIL_s_adc_r11_gemessen", 0, profileFile ) );
    putValue( HIL_s_adc_r11_r1s, getProfileInt( "Settings", "HIL_s_adc_r11_r1s", 0, profileFile ) );
    putValue( HIL_s_adc_r21_r2s, getProfileInt( "Settings", "HIL_s_adc_r21_r2s", 0, profileFile ) );
    putValue( HIL_s_adc_r31_r3s, getProfileInt( "Settings", "HIL_s_adc_r31_r3s", 0, profileFile ) );
    putValue( HIL_s_adc_r41_gemessen, getProfileInt( "Settings", "HIL_s_adc_r41_gemessen", 0, profileFile ) );
    putValue( HIL_s_adc_r41_r4s, getProfileInt( "Settings", "HIL_s_adc_r41_r4s", 0, profileFile ) );
    putValue( HIL_s_adc_guete_g2, getProfileInt( "Settings", "HIL_s_adc_guete_g2", 0, profileFile ) );
    putValue( HIL_s_adc_ohmwert_skaliert_g1, getProfileInt( "Settings", "HIL_s_adc_ohmwert_skaliert_g1", 0, profileFile ) );
    putValue( HIL_s_adc_r22_gemessen, getProfileInt( "Settings", "HIL_s_adc_r22_gemessen", 0, profileFile ) );
    putValue( HIL_s_adc_r42_gemessen, getProfileInt( "Settings", "HIL_s_adc_r42_gemessen", 0, profileFile ) );
    putValue( HIL_s_tank_vol_geber_1_kalibriert, getProfileFloat( "Settings", "HIL_s_tank_vol_geber_1_kalibriert", 0, profileFile ) );
    putValue( HIL_s_tankwarnung_klassisch, getProfileInt( "Settings", "HIL_s_tankwarnung_klassisch", 0, profileFile ) );
    putValue( HIL_s_tankwarnung_klassisch_0km, getProfileInt( "Settings", "HIL_s_tankwarnung_klassisch_0km", 0, profileFile ) );
    putValue( HIL_s_tankwarnung_phev_batterie, getProfileInt( "Settings", "HIL_s_tankwarnung_phev_batterie", 0, profileFile ) );
    putValue( HIL_s_tankwarnung_phev_tank, getProfileInt( "Settings", "HIL_s_tankwarnung_phev_tank", 0, profileFile ) );
    putValue( HIL_s_tankwarnung_phev_tank_0km, getProfileInt( "Settings", "HIL_s_tankwarnung_phev_tank_0km", 0, profileFile ) );
    putValue( HIL_s_tankwarnung_phev_tank_0km_batterie, getProfileInt( "Settings", "HIL_s_tankwarnung_phev_tank_0km_batterie", 0, profileFile ) );
    putValue( HIL_s_tankwarnung_phev_tank_batterie, getProfileInt( "Settings", "HIL_s_tankwarnung_phev_tank_batterie", 0, profileFile ) );
    putValue( HIL_s_tankwarnung_phev_tank_leistung, getProfileInt( "Settings", "HIL_s_tankwarnung_phev_tank_leistung", 0, profileFile ) );
    putValue( HIL_s_tankwarnung_twin_cng, getProfileInt( "Settings", "HIL_s_tankwarnung_twin_cng", 0, profileFile ) );
    putValue( HIL_s_tankwarnung_twin_tank, getProfileInt( "Settings", "HIL_s_tankwarnung_twin_tank", 0, profileFile ) );
    putValue( HIL_s_tankwarnung_twin_tank_0km, getProfileInt( "Settings", "HIL_s_tankwarnung_twin_tank_0km", 0, profileFile ) );
    putValue( HIL_s_tankwarnung_twin_tank_0km_cng, getProfileInt( "Settings", "HIL_s_tankwarnung_twin_tank_0km_cng", 0, profileFile ) );
    putValue( HIL_s_tankwarnung_twin_tank_cng, getProfileInt( "Settings", "HIL_s_tankwarnung_twin_tank_cng", 0, profileFile ) );
    putValue( HIL_s_tank_geber_kopplung, getProfileFloat( "Settings", "HIL_s_tank_geber_kopplung", 0, profileFile ) );
    putValue( HIL_s_tank_geber_kopplung_beschl_y, getProfileFloat( "Settings", "HIL_s_tank_geber_kopplung_beschl_y", 0, profileFile ) );
    putValue( HIL_s_tank_geber_kopplung_v, getProfileFloat( "Settings", "HIL_s_tank_geber_kopplung_v", 0, profileFile ) );
    putValue( HIL_s_tank_geber_kopplung_vol, getProfileFloat( "Settings", "HIL_s_tank_geber_kopplung_vol", 0, profileFile ) );
    putValue( HIL_s_tank_zustand_avrg_gueltig, getProfileInt( "Settings", "HIL_s_tank_zustand_avrg_gueltig", 0, profileFile ) );
    putValue( HIL_s_tank_zustand_avrg_schnell_gueltig, getProfileInt( "Settings", "HIL_s_tank_zustand_avrg_schnell_gueltig", 0, profileFile ) );
    putValue( HIL_s_tank_zustand_nte, getProfileInt( "Settings", "HIL_s_tank_zustand_nte", 0, profileFile ) );
    putValue( HIL_s_tank_zustand_ref_gebildet, getProfileInt( "Settings", "HIL_s_tank_zustand_ref_gebildet", 0, profileFile ) );
    putValue( HIL_s_tank_kvs_gew, getProfileInt( "Settings", "HIL_s_tank_kvs_gew", 0, profileFile ) );
    putValue( HIL_s_tank_vol_geber_1_roh, getProfileFloat( "Settings", "HIL_s_tank_vol_geber_1_roh", 0, profileFile ) );
    putValue( HIL_s_tank_vol_geber_2_kalibriert, getProfileFloat( "Settings", "HIL_s_tank_vol_geber_2_kalibriert", 0, profileFile ) );
    putValue( HIL_s_tank_vol_geber_3_kalibriert, getProfileFloat( "Settings", "HIL_s_tank_vol_geber_3_kalibriert", 0, profileFile ) );
    putValue( HIL_s_tank_vol_geber_4_kalibriert, getProfileFloat( "Settings", "HIL_s_tank_vol_geber_4_kalibriert", 0, profileFile ) );
    putValue( HIL_b_DGN_Verlernzaehler, getProfileInt( "Settings", "HIL_b_DGN_Verlernzaehler", 0, profileFile ) );
    putValue( HIL_b_UH_Jahr, getProfileInt( "Settings", "HIL_b_UH_Jahr", 0, profileFile ) );
    putValue( HIL_b_UH_Minute, getProfileInt( "Settings", "HIL_b_UH_Minute", 0, profileFile ) );
    putValue( HIL_b_UH_Monat, getProfileInt( "Settings", "HIL_b_UH_Monat", 0, profileFile ) );
    putValue( HIL_b_UH_Sekunde, getProfileInt( "Settings", "HIL_b_UH_Sekunde", 0, profileFile ) );
    putValue( HIL_b_UH_Stunde, getProfileInt( "Settings", "HIL_b_UH_Stunde", 0, profileFile ) );
    putValue( HIL_b_UH_Tag, getProfileInt( "Settings", "HIL_b_UH_Tag", 0, profileFile ) );
    putValue( HIL_hmi_event_display_off, getProfileInt( "Settings", "HIL_hmi_event_display_off", 0, profileFile ) );
    putValue( HIL_hmi_event_display_on, getProfileInt( "Settings", "HIL_hmi_event_display_on", 0, profileFile ) );
    putValue( HIL_hmi_inszenierung_beendet, getProfileInt( "Settings", "HIL_hmi_inszenierung_beendet", 0, profileFile ) );
    putValue( HIL_s_externe_taste_fehler, getProfileInt( "Settings", "HIL_s_externe_taste_fehler", 0, profileFile ) );
    putValue( HIL_s_fsp_kombi_nicht_codiert, getProfileInt( "Settings", "HIL_s_fsp_kombi_nicht_codiert", 0, profileFile ) );
    putValue( HIL_s_inszenierung_beendet, getProfileInt( "Settings", "HIL_s_inszenierung_beendet", 0, profileFile ) );
    putValue( HIL_s_inszenierung_start, getProfileInt( "Settings", "HIL_s_inszenierung_start", 0, profileFile ) );
    putValue( HIL_s_meldungsfreigabe_ftuer, getProfileInt( "Settings", "HIL_s_meldungsfreigabe_ftuer", 0, profileFile ) );
    putValue( HIL_s_taste_check, getProfileInt( "Settings", "HIL_s_taste_check", 0, profileFile ) );
    putValue( HIL_s_taste_check_fehler, getProfileInt( "Settings", "HIL_s_taste_check_fehler", 0, profileFile ) );
    putValue( HIL_s_taste_check_hil, getProfileInt( "Settings", "HIL_s_taste_check_hil", 0, profileFile ) );
    putValue( HIL_s_taste_menue, getProfileInt( "Settings", "HIL_s_taste_menue", 0, profileFile ) );
    putValue( HIL_s_taste_menue_fehler, getProfileInt( "Settings", "HIL_s_taste_menue_fehler", 0, profileFile ) );
    putValue( HIL_s_taste_menue_hil, getProfileInt( "Settings", "HIL_s_taste_menue_hil", 0, profileFile ) );
    putValue( HIL_s_taste_twsa, getProfileInt( "Settings", "HIL_s_taste_twsa", 0, profileFile ) );
    putValue( HIL_s_taste_twsa_fehler, getProfileInt( "Settings", "HIL_s_taste_twsa_fehler", 0, profileFile ) );
    putValue( HIL_s_taste_twsa_hil, getProfileInt( "Settings", "HIL_s_taste_twsa_hil", 0, profileFile ) );
    putValue( HIL_s_ub_dauerhaft_hoch, getProfileInt( "Settings", "HIL_s_ub_dauerhaft_hoch", 0, profileFile ) );
    putValue( HIL_s_ub_dauerhaft_niedrig, getProfileInt( "Settings", "HIL_s_ub_dauerhaft_niedrig", 0, profileFile ) );
    putValue( HIL_s_ub_kurzzeitig_hoch, getProfileInt( "Settings", "HIL_s_ub_kurzzeitig_hoch", 0, profileFile ) );
    putValue( HIL_s_ub_nio, getProfileInt( "Settings", "HIL_s_ub_nio", 0, profileFile ) );
    putValue( HIL_b_Perso_Kontonummer, getProfileInt( "Settings", "HIL_b_Perso_Kontonummer", 0, profileFile ) );
    putValue( HIL_b_Perso_Status, getProfileInt( "Settings", "HIL_b_Perso_Status", 0, profileFile ) );
    putValue( HIL_b_Perso_Steuerung, getProfileInt( "Settings", "HIL_b_Perso_Steuerung", 0, profileFile ) );
    putValue( HIL_b_Perso_Steuerungsparameter, getProfileInt( "Settings", "HIL_b_Perso_Steuerungsparameter", 0, profileFile ) );
    putValue( HIL_b_SI_P_Mode, getProfileInt( "Settings", "HIL_b_SI_P_Mode", 0, profileFile ) );
    putValue( HIL_b_SI_P_Mode_gueltig, getProfileInt( "Settings", "HIL_b_SI_P_Mode_gueltig", 0, profileFile ) );
    putValue( HIL_hmi_ego_fahrzeug, getProfileInt( "Settings", "HIL_hmi_ego_fahrzeug", 0, profileFile ) );
    putValue( HIL_hmi_v_kunde_aktiv, getProfileInt( "Settings", "HIL_hmi_v_kunde_aktiv", 0, profileFile ) );
    putValue( HIL_hmi_v_kunde_einheit, getProfileInt( "Settings", "HIL_hmi_v_kunde_einheit", 0, profileFile ) );
    putValue( HIL_hmi_v_kunde_sollgeschwindigkeit, getProfileInt( "Settings", "HIL_hmi_v_kunde_sollgeschwindigkeit", 0, profileFile ) );
    putValue( HIL_s_blinktakt, getProfileInt( "Settings", "HIL_s_blinktakt", 0, profileFile ) );
    putValue( HIL_s_hmi_blinktakt_request, getProfileInt( "Settings", "HIL_s_hmi_blinktakt_request", 0, profileFile ) );
    putValue( HIL_s_hmi_blinktakt_reset_event, getProfileInt( "Settings", "HIL_s_hmi_blinktakt_reset_event", 0, profileFile ) );
    putValue( HIL_s_Kombi_RAM_defekt, getProfileInt( "Settings", "HIL_s_Kombi_RAM_defekt", 0, profileFile ) );
    putValue( HIL_s_Kombi_ROM_defekt, getProfileInt( "Settings", "HIL_s_Kombi_ROM_defekt", 0, profileFile ) );
    putValue( HIL_s_kontrolllampenmanager_blinktakt_request, getProfileInt( "Settings", "HIL_s_kontrolllampenmanager_blinktakt_request", 0, profileFile ) );
    putValue( HIL_s_kontrolllampenmanager_blinktakt_reset_event, getProfileInt( "Settings", "HIL_s_kontrolllampenmanager_blinktakt_reset_event", 0, profileFile ) );
    putValue( HIL_s_selektiertes_design, getProfileInt( "Settings", "HIL_s_selektiertes_design", 0, profileFile ) );
    putValue( HIL_s_v_kunde_aktiv, getProfileInt( "Settings", "HIL_s_v_kunde_aktiv", 0, profileFile ) );
    putValue( HIL_s_v_kunde_sollgeschwindigkeit, getProfileInt( "Settings", "HIL_s_v_kunde_sollgeschwindigkeit", 0, profileFile ) );
    putValue( HIL_s_v_warnung_gesetzlich, getProfileInt( "Settings", "HIL_s_v_warnung_gesetzlich", 0, profileFile ) );
    putValue( HIL_s_v_warnung_kunde, getProfileInt( "Settings", "HIL_s_v_warnung_kunde", 0, profileFile ) );
    putValue( HIL_s_v_Warnung_Stufe_1_Akustik, getProfileInt( "Settings", "HIL_s_v_Warnung_Stufe_1_Akustik", 0, profileFile ) );
    putValue( HIL_s_v_warnung_winterreifen, getProfileInt( "Settings", "HIL_s_v_warnung_winterreifen", 0, profileFile ) );
    putValue( HIL_s_zpm_blinktakt_request, getProfileInt( "Settings", "HIL_s_zpm_blinktakt_request", 0, profileFile ) );
    putValue( HIL_s_zpm_blinktakt_reset_event, getProfileInt( "Settings", "HIL_s_zpm_blinktakt_reset_event", 0, profileFile ) );
    putValue( HIL_b_KBI_Kilometerstand, getProfileInt( "Settings", "HIL_b_KBI_Kilometerstand", 0, profileFile ) );
    putValue( HIL_b_MO_Anzeige_StSt_gueltig, getProfileInt( "Settings", "HIL_b_MO_Anzeige_StSt_gueltig", 0, profileFile ) );
    putValue( HIL_b_MO_Kuppl_schalter, getProfileInt( "Settings", "HIL_b_MO_Kuppl_schalter", 0, profileFile ) );
    putValue( HIL_b_ZAS_Kl_15, getProfileInt( "Settings", "HIL_b_ZAS_Kl_15", 0, profileFile ) );
    putValue( HIL_b_ZAS_Kl_S, getProfileInt( "Settings", "HIL_b_ZAS_Kl_S", 0, profileFile ) );
    putValue( HIL_hmi_klemme15, getProfileInt( "Settings", "HIL_hmi_klemme15", 0, profileFile ) );
    putValue( HIL_hmi_klemmeS, getProfileInt( "Settings", "HIL_hmi_klemmeS", 0, profileFile ) );
    putValue( HIL_hmi_motorkennbuchstaben_anzeigen, getProfileInt( "Settings", "HIL_hmi_motorkennbuchstaben_anzeigen", 0, profileFile ) );
    putValue( HIL_hmi_t_FreezeKlemme15Aus_ms, getProfileFloat( "Settings", "HIL_hmi_t_FreezeKlemme15Aus_ms", 0, profileFile ) );
    putValue( HIL_hmi_t_FreezeKlemme15Ein_ms, getProfileFloat( "Settings", "HIL_hmi_t_FreezeKlemme15Ein_ms", 0, profileFile ) );
    putValue( HIL_hmi_transportmodus_anzeigen, getProfileInt( "Settings", "HIL_hmi_transportmodus_anzeigen", 0, profileFile ) );
    putValue( HIL_hmi_ZV_verriegelt, getProfileInt( "Settings", "HIL_hmi_ZV_verriegelt", 0, profileFile ) );
    putValue( HIL_s_hmi_display_status, getProfileInt( "Settings", "HIL_s_hmi_display_status", 0, profileFile ) );
    putValue( HIL_s_HMI_LastMode_hmi_MFA_store, getProfileInt( "Settings", "HIL_s_HMI_LastMode_hmi_MFA_store", 0, profileFile ) );
    putValue( HIL_s_HMI_LastMode_hmi_ShowTrackChangePopup, getProfileInt( "Settings", "HIL_s_HMI_LastMode_hmi_ShowTrackChangePopup", 0, profileFile ) );
    putValue( HIL_s_klemme_15, getProfileInt( "Settings", "HIL_s_klemme_15", 0, profileFile ) );
    putValue( HIL_s_klemme_15_timeout, getProfileInt( "Settings", "HIL_s_klemme_15_timeout", 0, profileFile ) );
    putValue( HIL_s_v_Warnung_Stufe_1, getProfileInt( "Settings", "HIL_s_v_Warnung_Stufe_1", 0, profileFile ) );
    putValue( HIL_s_v_Warnung_Stufe_2, getProfileInt( "Settings", "HIL_s_v_Warnung_Stufe_2", 0, profileFile ) );
    putValue( HIL_s_verstellmodus_aktiv, getProfileInt( "Settings", "HIL_s_verstellmodus_aktiv", 0, profileFile ) );
    putValue( HIL_s_zpm_zentrale_warnlampe, getProfileInt( "Settings", "HIL_s_zpm_zentrale_warnlampe", 0, profileFile ) );
    putValue( HIL_b_DI_Display_Nachtdesign, getProfileInt( "Settings", "HIL_b_DI_Display_Nachtdesign", 0, profileFile ) );
    putValue( HIL_b_DI_KL_58xd, getProfileInt( "Settings", "HIL_b_DI_KL_58xd", 0, profileFile ) );
    putValue( HIL_b_DI_KL_58xs, getProfileInt( "Settings", "HIL_b_DI_KL_58xs", 0, profileFile ) );
    putValue( HIL_b_DI_KL_58xt, getProfileInt( "Settings", "HIL_b_DI_KL_58xt", 0, profileFile ) );
    putValue( HIL_b_ESP_07_alt, getProfileInt( "Settings", "HIL_b_ESP_07_alt", 0, profileFile ) );
    putValue( HIL_b_ESP_Rollenmodus_Deaktivieren, getProfileInt( "Settings", "HIL_b_ESP_Rollenmodus_Deaktivieren", 0, profileFile ) );
    putValue( HIL_b_MO_Fahrzeugtyp, getProfileInt( "Settings", "HIL_b_MO_Fahrzeugtyp", 0, profileFile ) );
    putValue( HIL_b_MO_Hybridfahrzeug, getProfileInt( "Settings", "HIL_b_MO_Hybridfahrzeug", 0, profileFile ) );
    putValue( HIL_b_MO_Kraftstoffart, getProfileInt( "Settings", "HIL_b_MO_Kraftstoffart", 0, profileFile ) );
    putValue( HIL_b_MO_Verbau_StartSys_RSG_MV, getProfileInt( "Settings", "HIL_b_MO_Verbau_StartSys_RSG_MV", 0, profileFile ) );
    putValue( HIL_b_MO_Verbau_StartSys_RSG_NV, getProfileInt( "Settings", "HIL_b_MO_Verbau_StartSys_RSG_NV", 0, profileFile ) );
    putValue( HIL_s_fhrz_typ, getProfileInt( "Settings", "HIL_s_fhrz_typ", 0, profileFile ) );
    putValue( HIL_s_fhrz_typ_prim_antr, getProfileInt( "Settings", "HIL_s_fhrz_typ_prim_antr", 0, profileFile ) );
    putValue( HIL_s_fhrz_typ_sek_antr, getProfileInt( "Settings", "HIL_s_fhrz_typ_sek_antr", 0, profileFile ) );
    putValue( HIL_s_fusi_lampe_abs, getProfileInt( "Settings", "HIL_s_fusi_lampe_abs", 0, profileFile ) );
    putValue( HIL_s_fusi_lampe_airbag, getProfileInt( "Settings", "HIL_s_fusi_lampe_airbag", 0, profileFile ) );
    putValue( HIL_s_fusi_lampe_bkl, getProfileInt( "Settings", "HIL_s_fusi_lampe_bkl", 0, profileFile ) );
    putValue( HIL_s_fusi_lampe_epb_status, getProfileInt( "Settings", "HIL_s_fusi_lampe_epb_status", 0, profileFile ) );
    putValue( HIL_s_fusi_lampe_eps_rot, getProfileInt( "Settings", "HIL_s_fusi_lampe_eps_rot", 0, profileFile ) );
    putValue( HIL_s_fusi_lampe_esc, getProfileInt( "Settings", "HIL_s_fusi_lampe_esc", 0, profileFile ) );
    putValue( HIL_s_fusi_zwl_gelb, getProfileInt( "Settings", "HIL_s_fusi_zwl_gelb", 0, profileFile ) );
    putValue( HIL_s_fusi_zwl_rot, getProfileInt( "Settings", "HIL_s_fusi_zwl_rot", 0, profileFile ) );
    putValue( HIL_s_KBI_Display_Ausfall, getProfileInt( "Settings", "HIL_s_KBI_Display_Ausfall", 0, profileFile ) );
    putValue( HIL_s_KBI_FoD_PopUP_Quittiert, getProfileInt( "Settings", "HIL_s_KBI_FoD_PopUP_Quittiert", 0, profileFile ) );
    putValue( HIL_s_mfl_joker_hinweisfehler, getProfileInt( "Settings", "HIL_s_mfl_joker_hinweisfehler", 0, profileFile ) );
    putValue( HIL_b_AZK_Kessy_defekt, getProfileInt( "Settings", "HIL_b_AZK_Kessy_defekt", 0, profileFile ) );
    putValue( HIL_b_AZK_Kessy_nicht_gefunden, getProfileInt( "Settings", "HIL_b_AZK_Kessy_nicht_gefunden", 0, profileFile ) );
    putValue( HIL_b_AZK_MobileKey_defekt, getProfileInt( "Settings", "HIL_b_AZK_MobileKey_defekt", 0, profileFile ) );
    putValue( HIL_b_AZK_Mobilgeraet_nicht_gefunden, getProfileInt( "Settings", "HIL_b_AZK_Mobilgeraet_nicht_gefunden", 0, profileFile ) );
    putValue( HIL_b_AZK_Schluessel_im_Fzg, getProfileInt( "Settings", "HIL_b_AZK_Schluessel_im_Fzg", 0, profileFile ) );
    putValue( HIL_b_AZK_Weiterfahrt_mit_Mobilgeraet, getProfileInt( "Settings", "HIL_b_AZK_Weiterfahrt_mit_Mobilgeraet", 0, profileFile ) );
    putValue( HIL_b_AZK_Weiterfahrt_mit_Schluessel, getProfileInt( "Settings", "HIL_b_AZK_Weiterfahrt_mit_Schluessel", 0, profileFile ) );
    putValue( HIL_b_FoD_Anz_Funktionsabschaltung, getProfileInt( "Settings", "HIL_b_FoD_Anz_Funktionsabschaltung", 0, profileFile ) );
    putValue( HIL_b_WFS_Fahrerhinweise, getProfileInt( "Settings", "HIL_b_WFS_Fahrerhinweise", 0, profileFile ) );
    putValue( HIL_b_WFS_LZ, getProfileInt( "Settings", "HIL_b_WFS_LZ", 0, profileFile ) );
    putValue( HIL_b_WFS_Safe, getProfileInt( "Settings", "HIL_b_WFS_Safe", 0, profileFile ) );
    putValue( HIL_b_WFS_Schluessel_Fahrberecht, getProfileInt( "Settings", "HIL_b_WFS_Schluessel_Fahrberecht", 0, profileFile ) );
    putValue( HIL_b_WFS_Schluessel_Ist, getProfileInt( "Settings", "HIL_b_WFS_Schluessel_Ist", 0, profileFile ) );
    putValue( HIL_b_WFS_Schluessel_Soll, getProfileInt( "Settings", "HIL_b_WFS_Schluessel_Soll", 0, profileFile ) );
    putValue( HIL_hmi_global_active_layout, getProfileInt( "Settings", "HIL_hmi_global_active_layout", 0, profileFile ) );
    putValue( HIL_s_aktives_design, getProfileInt( "Settings", "HIL_s_aktives_design", 0, profileFile ) );
    putValue( HIL_s_Fahrbereitschaft, getProfileInt( "Settings", "HIL_s_Fahrbereitschaft", 0, profileFile ) );
    putValue( HIL_s_FoD_Kombi_Variante, getProfileInt( "Settings", "HIL_s_FoD_Kombi_Variante", 0, profileFile ) );
    putValue( HIL_s_fsp_D10000, getProfileInt( "Settings", "HIL_s_fsp_D10000", 0, profileFile ) );
    putValue( HIL_s_fsp_D30000, getProfileInt( "Settings", "HIL_s_fsp_D30000", 0, profileFile ) );
    putValue( HIL_s_fsp_EA6100, getProfileInt( "Settings", "HIL_s_fsp_EA6100", 0, profileFile ) );
    putValue( HIL_s_fsp_EA6200, getProfileInt( "Settings", "HIL_s_fsp_EA6200", 0, profileFile ) );
    putValue( HIL_s_fsp_EA6400, getProfileInt( "Settings", "HIL_s_fsp_EA6400", 0, profileFile ) );
    putValue( HIL_s_Kombi_KompSchutz, getProfileInt( "Settings", "HIL_s_Kombi_KompSchutz", 0, profileFile ) );
    putValue( HIL_s_ks_safe, getProfileInt( "Settings", "HIL_s_ks_safe", 0, profileFile ) );
    putValue( HIL_s_ks_safe_text, getProfileInt( "Settings", "HIL_s_ks_safe_text", 0, profileFile ) );
    putValue( HIL_s_LED_ZWL_gelb, getProfileInt( "Settings", "HIL_s_LED_ZWL_gelb", 0, profileFile ) );
    putValue( HIL_s_LED_ZWL_gelb_Blinken, getProfileInt( "Settings", "HIL_s_LED_ZWL_gelb_Blinken", 0, profileFile ) );
    putValue( HIL_s_LED_ZWL_rot, getProfileInt( "Settings", "HIL_s_LED_ZWL_rot", 0, profileFile ) );
    putValue( HIL_s_LED_ZWL_rot_Blinken, getProfileInt( "Settings", "HIL_s_LED_ZWL_rot_Blinken", 0, profileFile ) );
    putValue( HIL_s_mfl_joker_hinweis, getProfileInt( "Settings", "HIL_s_mfl_joker_hinweis", 0, profileFile ) );
    putValue( HIL_s_WFS_Diag_LF_Aktiv_02, getProfileInt( "Settings", "HIL_s_WFS_Diag_LF_Aktiv_02", 0, profileFile ) );
    putValue( HIL_s_WFS_LF_aktiv_02, getProfileInt( "Settings", "HIL_s_WFS_LF_aktiv_02", 0, profileFile ) );
    putValue( HIL_s_WFS_Transp_Mod_Unterbrechung_02, getProfileInt( "Settings", "HIL_s_WFS_Transp_Mod_Unterbrechung_02", 0, profileFile ) );
    putValue( HIL_b_HRE_Anzeigetexte, getProfileInt( "Settings", "HIL_b_HRE_Anzeigetexte", 0, profileFile ) );
    putValue( HIL_b_LDW_Gong, getProfileInt( "Settings", "HIL_b_LDW_Gong", 0, profileFile ) );
    putValue( HIL_b_MKE_Stufe, getProfileInt( "Settings", "HIL_b_MKE_Stufe", 0, profileFile ) );
    putValue( HIL_b_MKE_Texte, getProfileInt( "Settings", "HIL_b_MKE_Texte", 0, profileFile ) );
    putValue( HIL_b_PLA_Abstand_zur_Parkluecke, getProfileInt( "Settings", "HIL_b_PLA_Abstand_zur_Parkluecke", 0, profileFile ) );
    putValue( HIL_b_PLA_Anf_Akustik, getProfileInt( "Settings", "HIL_b_PLA_Anf_Akustik", 0, profileFile ) );
    putValue( HIL_b_PLA_Anf_Anzeige_Bremsfuss, getProfileInt( "Settings", "HIL_b_PLA_Anf_Anzeige_Bremsfuss", 0, profileFile ) );
    putValue( HIL_b_PLA_Anf_Anzeige_Mini, getProfileInt( "Settings", "HIL_b_PLA_Anf_Anzeige_Mini", 0, profileFile ) );
    putValue( HIL_b_PLA_Anf_Anzeige_Schwellpfeil, getProfileInt( "Settings", "HIL_b_PLA_Anf_Anzeige_Schwellpfeil", 0, profileFile ) );
    putValue( HIL_b_PLA_Anf_Anzeigemodus, getProfileInt( "Settings", "HIL_b_PLA_Anf_Anzeigemodus", 0, profileFile ) );
    putValue( HIL_b_PLA_Anf_Meldungen, getProfileInt( "Settings", "HIL_b_PLA_Anf_Meldungen", 0, profileFile ) );
    putValue( HIL_b_PLA_Anzahl_Segmente_Schwellpfeil, getProfileInt( "Settings", "HIL_b_PLA_Anzahl_Segmente_Schwellpfeil", 0, profileFile ) );
    putValue( HIL_b_PLA_Mini_Modus, getProfileInt( "Settings", "HIL_b_PLA_Mini_Modus", 0, profileFile ) );
    putValue( HIL_b_PLA_Status_Aktive_Seite, getProfileInt( "Settings", "HIL_b_PLA_Status_Aktive_Seite", 0, profileFile ) );
    putValue( HIL_b_PLA_Status_beenden_Mini, getProfileInt( "Settings", "HIL_b_PLA_Status_beenden_Mini", 0, profileFile ) );
    putValue( HIL_b_PLA_Status_Funktion, getProfileInt( "Settings", "HIL_b_PLA_Status_Funktion", 0, profileFile ) );
    putValue( HIL_b_SWA_Anzeigen, getProfileInt( "Settings", "HIL_b_SWA_Anzeigen", 0, profileFile ) );
    putValue( HIL_b_SWA_Sta_aktiv, getProfileInt( "Settings", "HIL_b_SWA_Sta_aktiv", 0, profileFile ) );
    putValue( HIL_b_SWA_Sta_passiv, getProfileInt( "Settings", "HIL_b_SWA_Sta_passiv", 0, profileFile ) );
    putValue( HIL_hmi_pla3_zpm, getProfileInt( "Settings", "HIL_hmi_pla3_zpm", 0, profileFile ) );
    putValue( HIL_hmi_swa_timeout, getProfileInt( "Settings", "HIL_hmi_swa_timeout", 0, profileFile ) );
    putValue( HIL_s_LED_Hands_Off_rot, getProfileInt( "Settings", "HIL_s_LED_Hands_Off_rot", 0, profileFile ) );
    putValue( HIL_s_LED_Hands_Off_weiss, getProfileInt( "Settings", "HIL_s_LED_Hands_Off_weiss", 0, profileFile ) );
    putValue( HIL_s_LED_SWA_gelb, getProfileInt( "Settings", "HIL_s_LED_SWA_gelb", 0, profileFile ) );
    putValue( HIL_s_LED_SWA_gruen, getProfileInt( "Settings", "HIL_s_LED_SWA_gruen", 0, profileFile ) );
    putValue( HIL_s_SWA_Sta_aktiv, getProfileInt( "Settings", "HIL_s_SWA_Sta_aktiv", 0, profileFile ) );
    putValue( HIL_s_SWA_Sta_passiv, getProfileInt( "Settings", "HIL_s_SWA_Sta_passiv", 0, profileFile ) );
    putValue( HIL_b_AWV_AW_Texte_Zusatzanzeige, getProfileInt( "Settings", "HIL_b_AWV_AW_Texte_Zusatzanzeige", 0, profileFile ) );
    putValue( HIL_b_DSSS_Warning, getProfileInt( "Settings", "HIL_b_DSSS_Warning", 0, profileFile ) );
    putValue( HIL_b_Heckradar_Kombitexte, getProfileInt( "Settings", "HIL_b_Heckradar_Kombitexte", 0, profileFile ) );
    putValue( HIL_b_ISA_Status, getProfileInt( "Settings", "HIL_b_ISA_Status", 0, profileFile ) );
    putValue( HIL_b_LDW_Lernmodus_seitenabhaengig, getProfileInt( "Settings", "HIL_b_LDW_Lernmodus_seitenabhaengig", 0, profileFile ) );
    putValue( HIL_b_LDW_Status_LED_gelb, getProfileInt( "Settings", "HIL_b_LDW_Status_LED_gelb", 0, profileFile ) );
    putValue( HIL_b_LDW_Status_LED_gruen, getProfileInt( "Settings", "HIL_b_LDW_Status_LED_gruen", 0, profileFile ) );
    putValue( HIL_b_LDW_Texte, getProfileInt( "Settings", "HIL_b_LDW_Texte", 0, profileFile ) );
    putValue( HIL_b_RCTA_Kombitexte, getProfileInt( "Settings", "HIL_b_RCTA_Kombitexte", 0, profileFile ) );
    putValue( HIL_b_TA_Spurwechsel, getProfileInt( "Settings", "HIL_b_TA_Spurwechsel", 0, profileFile ) );
    putValue( HIL_b_TA_Status, getProfileInt( "Settings", "HIL_b_TA_Status", 0, profileFile ) );
    putValue( HIL_b_TA_Texte, getProfileInt( "Settings", "HIL_b_TA_Texte", 0, profileFile ) );
    putValue( HIL_b_TSK_06_alt, getProfileInt( "Settings", "HIL_b_TSK_06_alt", 0, profileFile ) );
    putValue( HIL_b_TSK_Fahrzeugstatus_GRA, getProfileInt( "Settings", "HIL_b_TSK_Fahrzeugstatus_GRA", 0, profileFile ) );
    putValue( HIL_b_TSK_Fahrzeugstatus_Limiter, getProfileInt( "Settings", "HIL_b_TSK_Fahrzeugstatus_Limiter", 0, profileFile ) );
    putValue( HIL_b_TSK_Limiter_Anzeige, getProfileInt( "Settings", "HIL_b_TSK_Limiter_Anzeige", 0, profileFile ) );
    putValue( HIL_b_TSK_Limiter_Fahrerinfo, getProfileInt( "Settings", "HIL_b_TSK_Limiter_Fahrerinfo", 0, profileFile ) );
    putValue( HIL_b_TSK_Status_Anzeige, getProfileInt( "Settings", "HIL_b_TSK_Status_Anzeige", 0, profileFile ) );
    putValue( HIL_b_TSK_Texte_Primaeranz, getProfileInt( "Settings", "HIL_b_TSK_Texte_Primaeranz", 0, profileFile ) );
    putValue( HIL_b_TSK_Wunschgeschw, getProfileFloat( "Settings", "HIL_b_TSK_Wunschgeschw", 0, profileFile ) );
    putValue( HIL_s_GRA_Status, getProfileInt( "Settings", "HIL_s_GRA_Status", 0, profileFile ) );
    putValue( HIL_s_LED_LDW_gelb, getProfileInt( "Settings", "HIL_s_LED_LDW_gelb", 0, profileFile ) );
    putValue( HIL_s_LED_LDW_gruen, getProfileInt( "Settings", "HIL_s_LED_LDW_gruen", 0, profileFile ) );
    putValue( HIL_s_LIM_Status, getProfileInt( "Settings", "HIL_s_LIM_Status", 0, profileFile ) );
    putValue( HIL_b_ARA_Aktiver_Grafikmodus, getProfileInt( "Settings", "HIL_b_ARA_Aktiver_Grafikmodus", 0, profileFile ) );
    putValue( HIL_b_ARA_Bremsfuss, getProfileInt( "Settings", "HIL_b_ARA_Bremsfuss", 0, profileFile ) );
    putValue( HIL_b_ARA_Knickwinkel_Ist, getProfileInt( "Settings", "HIL_b_ARA_Knickwinkel_Ist", 0, profileFile ) );
    putValue( HIL_b_ARA_Knickwinkel_Max, getProfileInt( "Settings", "HIL_b_ARA_Knickwinkel_Max", 0, profileFile ) );
    putValue( HIL_b_ARA_Knickwinkel_Soll, getProfileInt( "Settings", "HIL_b_ARA_Knickwinkel_Soll", 0, profileFile ) );
    putValue( HIL_b_ARA_Modus, getProfileInt( "Settings", "HIL_b_ARA_Modus", 0, profileFile ) );
    putValue( HIL_b_ARA_Texte, getProfileInt( "Settings", "HIL_b_ARA_Texte", 0, profileFile ) );
    putValue( HIL_b_ESP_HDC_Regelgeschw, getProfileFloat( "Settings", "HIL_b_ESP_HDC_Regelgeschw", 0, profileFile ) );
    putValue( HIL_b_VZE_FoD_Status, getProfileInt( "Settings", "HIL_b_VZE_FoD_Status", 0, profileFile ) );
    putValue( HIL_hmi_ARA_Knickwinkel_Ist, getProfileInt( "Settings", "HIL_hmi_ARA_Knickwinkel_Ist", 0, profileFile ) );
    putValue( HIL_hmi_ARA_Knickwinkel_Soll, getProfileInt( "Settings", "HIL_hmi_ARA_Knickwinkel_Soll", 0, profileFile ) );
    putValue( HIL_s_ara_timeout_reakt, getProfileInt( "Settings", "HIL_s_ara_timeout_reakt", 0, profileFile ) );
    putValue( HIL_s_LED_Shiftlock_rot, getProfileInt( "Settings", "HIL_s_LED_Shiftlock_rot", 0, profileFile ) );
    putValue( HIL_b_ACC_Regelgeschw, getProfileFloat( "Settings", "HIL_b_ACC_Regelgeschw", 0, profileFile ) );
    putValue( HIL_b_ACC_Tempolimit, getProfileInt( "Settings", "HIL_b_ACC_Tempolimit", 0, profileFile ) );
    putValue( HIL_b_ACC_Texte_Sekundaeranz, getProfileInt( "Settings", "HIL_b_ACC_Texte_Sekundaeranz", 0, profileFile ) );
    putValue( HIL_b_ACC_Warnung_Verkehrszeichen_1, getProfileInt( "Settings", "HIL_b_ACC_Warnung_Verkehrszeichen_1", 0, profileFile ) );
    putValue( HIL_b_AWV_AW_Abstand, getProfileInt( "Settings", "HIL_b_AWV_AW_Abstand", 0, profileFile ) );
    putValue( HIL_b_AWV_Texte, getProfileInt( "Settings", "HIL_b_AWV_Texte", 0, profileFile ) );
    putValue( HIL_b_AWV_Warnlevel, getProfileInt( "Settings", "HIL_b_AWV_Warnlevel", 0, profileFile ) );
    putValue( HIL_b_AWV_Warnung, getProfileInt( "Settings", "HIL_b_AWV_Warnung", 0, profileFile ) );
    putValue( HIL_b_TA_HMI_Obj_02_dx, getProfileFloat( "Settings", "HIL_b_TA_HMI_Obj_02_dx", 0, profileFile ) );
    putValue( HIL_hmi_ACC_Regelgeschw, getProfileFloat( "Settings", "HIL_hmi_ACC_Regelgeschw", 0, profileFile ) );
    putValue( HIL_s_LED_ACC_Ego_rot, getProfileInt( "Settings", "HIL_s_LED_ACC_Ego_rot", 0, profileFile ) );
