/*@!Encoding:utf8*/
includes
{
    #include "BAPVariableBackup.can"
}

variables
{
  //timer timeout_delayoff;
  //timer timeout_delayon;
}

void loadSettings(byte loadState)
{
  char orgfile[1024];   // original filename/path
  char modfile[1024];   // modified name
  char modpath[1024];   // modified path
  dword handle;         // fileread result
  int orgidx;           // original file array index
  int nameidx;          // modified name index
  int pathidx;          // modified path index
  int bslctr;           // backslash counter     (to find how many)
  int bslctr2;          // backslash counter2    (to know when filename starts)
  int ctr;              // general purpose counter

  // init arrays
  for (ctr = 0; ctr < 1024; ctr++)
  {
    orgfile[ctr] = 0;   // init original filename/path
    modfile[ctr] = 0;   // init modified filename
    modpath[ctr] = 0;   // init modified path
  }

  getValue( ENV_LoadSettingsFile, orgfile );

  // count the number of "backslash"
  bslctr = 0;
  orgidx = 0;
  while (orgfile[orgidx] != 0)
  {
    if (orgfile[orgidx] == 0x5C)
    {
      bslctr++;   // backslash counter
    }
    orgidx++;
  }

  // store path and filename
  orgidx = 0;
  bslctr2 = 0;
  pathidx = 0;
  nameidx = 0;
  while (orgfile[orgidx] != 0)
  {
    if (bslctr2 != bslctr)    // store path until last backslash
    {
      if (orgfile[orgidx] == 0x5C)
      {
        bslctr2++;
      }
      // store path
      modpath[pathidx] = orgfile[orgidx];
      pathidx++;
    }
    else
    {
      // store filename
      modfile[nameidx] = orgfile[orgidx];
      nameidx++;
    }
    orgidx++;
  }

  setFilePath(modpath, 0);      //set path for *.ini file
  handle = openFileRead( modfile, 1 );

  if (handle > 0)
  {
    fileClose( handle );
    if (loadState == 1 || loadState == 3)
    {
      loadSettings( modfile );
    }
    if (loadState == 2 || loadState == 3)
    {
      loadBAPSettings( modfile );
    }
    strncat( modfile, " LOADED", elcount( modfile ) );
  }
  else
  {
    strncat( modfile, " NOT FOUND", elcount( modfile ) );
  }
  putValue( ENV_SettingsResult, modfile );
}

void saveSettings(byte saveState)
{
  char file[1024], filepath[1200], dirpath[1200], StrFileName[100];
  dword handle, i =0, j =0, index =0, StrLength =0;

  getValue( ENV_SaveSettingsFile, file );

  //write("\n Selected file path is %s", file);

  while(file[i] != '\0')
  {
     if (file[i] != '\\')
     {
         filepath[j] = file[i];
         j++;
         i++;
     }
     else
     {
         index = j;
         filepath[j] = file[i];
         filepath[j+1] = file[i];
         j+=2;
         i++;
     }
  }

  filepath[j] = '\0';
  StrLength = strlen(filepath);

  for(i=0; i<index; i++)
  {
      dirpath[i] = filepath[i];
  }
  dirpath[i] = '\0';

  j=0;
  for(i=index+2; i<StrLength; i++)
  {
      StrFileName[j] = filepath[i];
      j++;
  }

  StrFileName[j] = '\0';

  //write("\n Dir path is %s", dirpath);
  //write("\n File name is %s", StrFileName);

  setWritePath(dirpath);
  /*handle = openFileWrite (file, 1);
  if (handle > 0)
  {
      if (saveState == 1 || saveState == 3)
      {
        saveSettings(file);
      }
      if (saveState == 2 || saveState == 3)
      {
        saveBAPSettings(file);
      }
        
      fileClose( handle );
  }*/
  if (saveState == 1 || saveState == 3)
  {
    saveSettings(StrFileName);
  }
  if (saveState == 2 || saveState == 3)
  {
    saveBAPSettings(StrFileName);
  }

  if (writeProfileInt( "Settings", "Test", 1, StrFileName ) == 0)
  {
    strncat( StrFileName, " NOT", elcount( StrFileName ) );
  }
  strncat( StrFileName, " WRITTEN", elcount( StrFileName ) );
  putValue( ENV_SettingsResult, StrFileName );

  file[0] = '\0';
  filepath[0] = '\0';
  dirpath[0] = '\0';
  StrFileName[0] = '\0';
  i=j=index=StrLength=0;

  setWritePath("");
}

on EnvVar ENV_SaveAllSettings
{
  saveSettings(3);
}

on EnvVar ENV_BAPSaveSettings
{
  saveSettings(2);
}

on EnvVar ENV_SaveSettings
{
  saveSettings(1);
}

on EnvVar ENV_LoadAllSettings
{
  loadSettings(3);
}

on EnvVar ENV_BAPLoadSettings
{
  loadSettings(2);
}

on EnvVar ENV_LoadSettings
{
  loadSettings(1);
}

on start
{
    //putValue( eSaveSettings_To_ini, 1 ); /*Initialising the value for the Load seetings Button*/
    //IssueList #58
    //putValue( eSynchronizeDiagnose_01, 1 );
    //loadSettings( "RBS.ini" );

    //start1();
    //start1G();
    //start2();
    //start2G();

    //settimer(timeout_delayoff,2);
    //IssueList #200
    //if( getValue( ON_OFF_BAP_LoadSave_INI ) == 0x00 )
    //{
    //    EnableControl("Main", "EnvVar:eBAPLoadSettings",0);
    //    EnableControl("Main", "EnvVar:eBAPSaveSettings",0);
    //    EnableControl("Main", "EnvVar:eLoadAllSettings",0);
    //    EnableControl("Main", "EnvVar:eSaveAllSettings",0);
    //}
}

void start1()
{
}

void start1G()
{
}

void start2()
{
}

void start2G()
{
}

void stopMeasurement1()
{
    //writeProfileInt( "Settings", "eSaveSettings_To_ini", getValue( eSaveSettings_To_ini ), "RBS.ini" );/*Saving the settings for the Savings Enable Widget*/

    ///if(getValue(eSaveSettings_To_ini))
    //{
    //    saveSettings( "RBS.ini" );
    //}
}

void saveSettings( char profileFile[] )
{

    saveSettings_AAA_01( profileFile );
    saveSettings_ACC_19( profileFile );
    saveSettings_AGA_01( profileFile );
    saveSettings_Airbag_01( profileFile );
    saveSettings_Airbag_02( profileFile );
    saveSettings_Airbag_04( profileFile );
    saveSettings_Airbag_06( profileFile );
    saveSettings_Anhaenger_01( profileFile );
    saveSettings_ARA_Status_01( profileFile );
    saveSettings_ARC_HUD_Req_FD( profileFile );
    saveSettings_ARC_HUD_Resp_FD( profileFile );
    saveSettings_AWV_02( profileFile );
    saveSettings_AZK_01( profileFile );
    saveSettings_BCM_01( profileFile );
    saveSettings_BCM_03( profileFile );
    saveSettings_BCM_04( profileFile );
    saveSettings_BCM_Taster_02( profileFile );
    saveSettings_BCM_Taster_03( profileFile );
    saveSettings_BEM_02( profileFile );
    saveSettings_BEM_06( profileFile );
    saveSettings_Blinkmodi_02( profileFile );
    saveSettings_BMS_05( profileFile );
    saveSettings_BMS_07( profileFile );
    saveSettings_Bremse_EV_02( profileFile );
    saveSettings_Charisma_03( profileFile );
    saveSettings_Daempfer_01( profileFile );
    saveSettings_Daempfer_05( profileFile );
    saveSettings_DCDC_02( profileFile );
    saveSettings_DEV_SmaLi_Tx_01( profileFile );
    saveSettings_DEV_ZR_Produktion_1_Rx_1D( profileFile );
    saveSettings_DEV_ZR_Produktion_1_Tx_1C( profileFile );
    saveSettings_DEV_ZR_Req_0D( profileFile );
    saveSettings_DEV_ZR_Resp_00( profileFile );
    saveSettings_DEV_ZR_SmaLi_01_Tx( profileFile );
    saveSettings_DEV_ZR_Tx_14( profileFile );
    saveSettings_DEV_ZR_Tx_15( profileFile );
    saveSettings_DIA_ABT_1_Req( profileFile );
    saveSettings_DIA_ABT_1_Resp( profileFile );
    saveSettings_Diagnose_01( profileFile );
    saveSettings_DiETa_01( profileFile );
    saveSettings_Dimmung_01( profileFile );
    saveSettings_DispKBI_FS_01( profileFile );
    saveSettings_DispKBI_FS_DispPos_Req_FD( profileFile );
    saveSettings_DispKBI_FS_DispPos_Resp_FD( profileFile );
    saveSettings_Display_1_03( profileFile );
    saveSettings_DispPos_DispKBI_FS_Req_FD( profileFile );
    saveSettings_DispPos_DispKBI_FS_Resp_FD( profileFile );
    saveSettings_EA_02( profileFile );
    saveSettings_ELV_01( profileFile );
    saveSettings_EML_06( profileFile );
    saveSettings_EML_07( profileFile );
    saveSettings_Entfernungen_01( profileFile );
    saveSettings_EPB_03( profileFile );
    saveSettings_ESC_50( profileFile );
    saveSettings_ESC_51( profileFile );
    saveSettings_ESP_10( profileFile );
    saveSettings_ESP_20( profileFile );
    saveSettings_ESP_21( profileFile );
    saveSettings_ESP_24( profileFile );
    saveSettings_ESP_30( profileFile );
    saveSettings_FAS_Anzeigen_01( profileFile );
    saveSettings_FoD_01( profileFile );
    saveSettings_FoD_Kombi_Req( profileFile );
    saveSettings_FoD_Kombi_Resp( profileFile );
    saveSettings_FoD_ZR_Req( profileFile );
    saveSettings_FoD_ZR_Resp( profileFile );
    saveSettings_Gateway_71( profileFile );
    saveSettings_Gateway_73( profileFile );
    saveSettings_Getriebe_16( profileFile );
    saveSettings_Heckradar_01( profileFile );
    saveSettings_HID_DispKBI_FS_ZR_Req_FD( profileFile );
    saveSettings_HID_DispKBI_FS_ZR_Resp_FD( profileFile );
    saveSettings_HID_HUD_ZR_Req_FD( profileFile );
    saveSettings_HID_HUD_ZR_Resp_FD( profileFile );
    saveSettings_HID_ZR_DispKBI_FS_Req_FD( profileFile );
    saveSettings_HID_ZR_DispKBI_FS_Resp_FD( profileFile );
    saveSettings_HID_ZR_HUD_Req_FD( profileFile );
    saveSettings_HID_ZR_HUD_Resp_FD( profileFile );
    saveSettings_HUD_ARC_Req_FD( profileFile );
    saveSettings_HUD_ARC_Resp_FD( profileFile );
    saveSettings_HVK_01( profileFile );
    saveSettings_IPA_02( profileFile );
    saveSettings_ISO_Funktionaler_Req_All( profileFile );
    saveSettings_ISO_HUD_Req( profileFile );
    saveSettings_ISO_HUD_Resp( profileFile );
    saveSettings_ISO_Kombi_Req( profileFile );
    saveSettings_ISO_Kombi_Resp( profileFile );
    saveSettings_ISO_NFCIApp_NFCIServ_Req( profileFile );
    saveSettings_ISO_NFCIApp_NFCIServ_Resp( profileFile );
    saveSettings_ISO_NFCIServ_NFCIApp_Req( profileFile );
    saveSettings_ISO_NFCIServ_NFCIApp_Resp( profileFile );
    saveSettings_ISOx_DispKBI_FS_Req( profileFile );
    saveSettings_ISOx_DispKBI_FS_Req_FD( profileFile );
    saveSettings_ISOx_DispKBI_FS_Resp( profileFile );
    saveSettings_ISOx_DispKBI_FS_Resp_FD( profileFile );
    saveSettings_ISOx_Funkt_Req_All_FD( profileFile );
    saveSettings_ISOx_HUD_Req_FD( profileFile );
    saveSettings_ISOx_HUD_Resp_FD( profileFile );
    saveSettings_ISOx_Kombi_Req_FD( profileFile );
    saveSettings_ISOx_Kombi_Resp_FD( profileFile );
    saveSettings_ISOx_SmLi_01_Req( profileFile );
    saveSettings_ISOx_SmLi_01_Req_FD( profileFile );
    saveSettings_ISOx_SmLi_01_Resp( profileFile );
    saveSettings_ISOx_SmLi_01_Resp_FD( profileFile );
    saveSettings_ISOx_WLC1_Req( profileFile );
    saveSettings_ISOx_WLC1_Resp( profileFile );
    saveSettings_Kessy_04( profileFile );
    saveSettings_Klemmen_Status_01( profileFile );
    saveSettings_Klemmen_Status_02( profileFile );
    saveSettings_Klemmen_Steuerung_01( profileFile );
    saveSettings_Klima_03( profileFile );
    saveSettings_Klima_06( profileFile );
    saveSettings_Klima_12( profileFile );
    saveSettings_Klima_16( profileFile );
    saveSettings_Klima_Sensor_02( profileFile );
    saveSettings_KN_DispKBI_FS( profileFile );
    saveSettings_KN_Gateway( profileFile );
    saveSettings_KN_HUD( profileFile );
    saveSettings_KN_Info_El( profileFile );
    saveSettings_KN_Kombi( profileFile );
    saveSettings_KN_SmLi_1( profileFile );
    saveSettings_Kombi_01( profileFile );
    saveSettings_Kombi_02( profileFile );
    saveSettings_Kombi_03( profileFile );
    saveSettings_Kombi_08( profileFile );
    saveSettings_Kombi_21( profileFile );
    saveSettings_Kombi_HUD_01( profileFile );
    saveSettings_KonzernrollenModus_01( profileFile );
    saveSettings_KS_ICAS3Sys01_Req_FD( profileFile );
    saveSettings_KS_ICAS3Sys01_Resp_FD( profileFile );
    saveSettings_KS_Info_El_Req_FD( profileFile );
    saveSettings_KS_Info_El_Resp_FD( profileFile );
    saveSettings_KS_Kombi_Req_FD( profileFile );
    saveSettings_KS_Kombi_Resp_FD( profileFile );
    saveSettings_KS_SSN_ABT_1_Req( profileFile );
    saveSettings_KS_SSN_ABT_1_Resp( profileFile );
    saveSettings_LDW_02( profileFile );
    saveSettings_LH_EPS_01( profileFile );
    saveSettings_Licht_Anf_01( profileFile );
    saveSettings_Licht_hinten_01( profileFile );
    saveSettings_Licht_vorne_01( profileFile );
    saveSettings_LiSi_01( profileFile );
    saveSettings_LWI_01( profileFile );
    saveSettings_MainUnit_01( profileFile );
    saveSettings_Mem_BFS_01( profileFile );
    saveSettings_Mem_FS_01( profileFile );
    saveSettings_MFG_01( profileFile );
    saveSettings_MFL_01( profileFile );
    saveSettings_MFL_02( profileFile );
    saveSettings_MFL_Anf_01( profileFile );
    saveSettings_MFL_Tasten_Kon_01( profileFile );
    saveSettings_Motor_14( profileFile );
    saveSettings_Motor_18( profileFile );
    saveSettings_Motor_26( profileFile );
    saveSettings_Motor_41( profileFile );
    saveSettings_Motor_51( profileFile );
    saveSettings_Motor_52( profileFile );
    saveSettings_Motor_53( profileFile );
    saveSettings_Motor_54( profileFile );
    saveSettings_Motor_57( profileFile );
    saveSettings_Motor_Hybrid_06( profileFile );
    saveSettings_NavData_01( profileFile );
    saveSettings_NavData_02( profileFile );
    saveSettings_NavData_03( profileFile );
    saveSettings_NavData_04( profileFile );
    saveSettings_NavPos_01( profileFile );
    saveSettings_NavPos_02_Map_Matched( profileFile );
    saveSettings_NFC_01( profileFile );
    saveSettings_NFC_MiKo_01( profileFile );
    saveSettings_NMH_DispKBI_FS( profileFile );
    saveSettings_NMH_Gateway( profileFile );
    saveSettings_NMH_HUD( profileFile );
    saveSettings_NMH_Info_El( profileFile );
    saveSettings_NMH_Kombi( profileFile );
    saveSettings_NMH_SmLi_01( profileFile );
    saveSettings_OBDC_DispKBI_FS_Req_FD( profileFile );
    saveSettings_OBDC_DispKBI_FS_Resp_FD( profileFile );
    saveSettings_OBDC_Funktionaler_Req_All( profileFile );
    saveSettings_OBDC_Funktionaler_Req_All_FD( profileFile );
    saveSettings_OBDC_HUD_Req_FD( profileFile );
    saveSettings_OBDC_HUD_Resp_FD( profileFile );
    saveSettings_OBDC_Kombi_Req_FD( profileFile );
    saveSettings_OBDC_Kombi_Resp_FD( profileFile );
    saveSettings_OBDC_SmLi_01_Req_FD( profileFile );
    saveSettings_OBDC_SmLi_01_Resp_FD( profileFile );
    saveSettings_OBDC_SSN_ABT_1_Req( profileFile );
    saveSettings_OBDC_SSN_ABT_1_Resp( profileFile );
    saveSettings_OBDC_WLC1_Req( profileFile );
    saveSettings_OBDC_WLC1_Resp( profileFile );
    saveSettings_OBDx_allOBD_Req( profileFile );
    saveSettings_ORU_01( profileFile );
    saveSettings_Parkhilfe_01( profileFile );
    saveSettings_Parkhilfe_04( profileFile );
    saveSettings_Personalisierung_01( profileFile );
    saveSettings_PreCrash_02( profileFile );
    saveSettings_PSD_04( profileFile );
    saveSettings_PSD_05( profileFile );
    saveSettings_PSD_06( profileFile );
    saveSettings_PSD_LR_01( profileFile );
    saveSettings_Radio_01( profileFile );
    saveSettings_Rear_View_04( profileFile );
    saveSettings_Rear_View_06( profileFile );
    saveSettings_Reichweite_01( profileFile );
    saveSettings_Reichweite_02( profileFile );
    saveSettings_Reichweite_03( profileFile );
    saveSettings_RKA_01( profileFile );
    saveSettings_RLS_01( profileFile );
    saveSettings_RLS_02( profileFile );
    saveSettings_SAL_01( profileFile );
    saveSettings_SAM_01( profileFile );
    saveSettings_Sensorik_Dimmung_01( profileFile );
    saveSettings_SmaLi_Control_Frame_01( profileFile );
    saveSettings_SmaLi_Daten_Frame_01( profileFile );
    saveSettings_SmaLi_Daten_Frame_02( profileFile );
    saveSettings_SmaLi_Daten_Frame_03( profileFile );
    saveSettings_SmaLi_Daten_Frame_04( profileFile );
    saveSettings_SmaLi_Response_Frame_01( profileFile );
    saveSettings_SMLS_01( profileFile );
    saveSettings_Systeminfo_01( profileFile );
    saveSettings_TA_01( profileFile );
    saveSettings_Temperaturen_01( profileFile );
    saveSettings_Thermo_Verbrauch_01( profileFile );
    saveSettings_TM_01( profileFile );
    saveSettings_TSG_BT_01( profileFile );
    saveSettings_TSG_FT_01( profileFile );
    saveSettings_TSG_FT_02( profileFile );
    saveSettings_TSG_HBFS_01( profileFile );
    saveSettings_TSG_HFS_01( profileFile );
    saveSettings_UserStateServer_01( profileFile );
    saveSettings_VIN_01( profileFile );
    saveSettings_VLK_01( profileFile );
    saveSettings_VZE_04( profileFile );
    saveSettings_WBA_03( profileFile );
    saveSettings_WFS_01( profileFile );
    saveSettings_WFS_Transponder_Req_02( profileFile );
    saveSettings_WFS_Transponder_Resp_02( profileFile );
    saveSettings_WFS_Transponder_Status_02( profileFile );
    saveSettings_Wischer_01( profileFile );
    saveSettings_WLC1_01( profileFile );
    saveSettings_XCP_SmaLi_CRO_01( profileFile );
    saveSettings_XCP_SmaLi_DTO_01( profileFile );
    saveSettings_Zeitmaster_02( profileFile );
    saveSettings_Zentralrechner_01( profileFile );
    saveSettings_ZV_02( profileFile );
    saveSettings_ZV_04( profileFile );

    saveENVars( profileFile );
}

void saveSettings_AAA_01( char profileFile[] )
{
    writeProfileInt( "AAA_01", "AAA_01_BZ", getValue( KCAN_AAA_01_BZ ), profileFile );
    writeProfileInt( "AAA_01", "AAA_01_CRC", getValue( KCAN_AAA_01_CRC ), profileFile );
    writeProfileInt( "AAA_01", "AAA_Abbruchgrund", getValue( KCAN_AAA_Abbruchgrund ), profileFile );
    writeProfileInt( "AAA_01", "AAA_Anf_Meldungen", getValue( KCAN_AAA_Anf_Meldungen ), profileFile );
    writeProfileInt( "AAA_01", "AAA_Anf_Sonder_Funktion_Status", getValue( KCAN_AAA_Anf_Sonder_Funktion_Status ), profileFile );
    writeProfileInt( "AAA_01", "AAA_Anf_Sonder_Klemme_15", getValue( KCAN_AAA_Anf_Sonder_Klemme_15 ), profileFile );
    writeProfileInt( "AAA_01", "AAA_Anf_WFS_Freigabe", getValue( KCAN_AAA_Anf_WFS_Freigabe ), profileFile );
    writeProfileInt( "AAA_01", "AAA_Klauenerkennung_aktivieren", getValue( KCAN_AAA_Klauenerkennung_aktivieren ), profileFile );
    writeProfileInt( "AAA_01", "AAA_Klauenerkennung_Reset", getValue( KCAN_AAA_Klauenerkennung_Reset ), profileFile );
    writeProfileInt( "AAA_01", "AAA_PaCo_FunctionState", getValue( KCAN_AAA_PaCo_FunctionState ), profileFile );
    writeProfileInt( "AAA_01", "AAA_PaCo_MainState", getValue( KCAN_AAA_PaCo_MainState ), profileFile );
    writeProfileInt( "AAA_01", "AAA_PaCo_RemoteState", getValue( KCAN_AAA_PaCo_RemoteState ), profileFile );

}


void saveSettings_ACC_19( char profileFile[] )
{
    writeProfileInt( "ACC_19", "AbstWarn_LRR_FAS_Fkt_Status", getValue( KCAN_AbstWarn_LRR_FAS_Fkt_Status ), profileFile );
    writeProfileInt( "ACC_19", "ACA_Hinweistexte", getValue( KCAN_ACA_Hinweistexte ), profileFile );
    writeProfileInt( "ACC_19", "ACA_Querfuehrung", getValue( KCAN_ACA_Querfuehrung ), profileFile );
    writeProfileInt( "ACC_19", "ACA_Querfuehrung_Texte", getValue( KCAN_ACA_Querfuehrung_Texte ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Abstand_Abstandswarner", getValue( KCAN_ACC_Abstand_Abstandswarner ), profileFile );
    writeProfileFloat( "ACC_19", "ACC_Abstand_LNS", getValue( KCAN_ACC_Abstand_LNS ), profileFile );
    writeProfileFloat( "ACC_19", "ACC_Abstand_RNS", getValue( KCAN_ACC_Abstand_RNS ), profileFile );
    writeProfileFloat( "ACC_19", "ACC_Abstand_WZO", getValue( KCAN_ACC_Abstand_WZO ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Abstandsindex_02", getValue( KCAN_ACC_Abstandsindex_02 ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Akustik_03", getValue( KCAN_ACC_Akustik_03 ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Anzeige_Maximalabstand", getValue( KCAN_ACC_Anzeige_Maximalabstand ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Anzeige_Objektregelung", getValue( KCAN_ACC_Anzeige_Objektregelung ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Anzeige_Zeitluecke", getValue( KCAN_ACC_Anzeige_Zeitluecke ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Display_Prio", getValue( KCAN_ACC_Display_Prio ), profileFile );
    writeProfileInt( "ACC_19", "ACC_EGO_Fahrzeug", getValue( KCAN_ACC_EGO_Fahrzeug ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Einheit_Abstandswarner", getValue( KCAN_ACC_Einheit_Abstandswarner ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Einheit_maxSetzgeschw", getValue( KCAN_ACC_Einheit_maxSetzgeschw ), profileFile );
    writeProfileInt( "ACC_19", "ACC_ENG_Texte", getValue( KCAN_ACC_ENG_Texte ), profileFile );
    writeProfileInt( "ACC_19", "ACC_FoD_Status", getValue( KCAN_ACC_FoD_Status ), profileFile );
    writeProfileFloat( "ACC_19", "ACC_Geschw_Zielfahrzeug", getValue( KCAN_ACC_Geschw_Zielfahrzeug ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Gesetzte_Zeitluecke", getValue( KCAN_ACC_Gesetzte_Zeitluecke ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Kurvenassistent", getValue( KCAN_ACC_Kurvenassistent ), profileFile );
    writeProfileFloat( "ACC_19", "ACC_maxRegelgeschw", getValue( KCAN_ACC_maxRegelgeschw ), profileFile );
    writeProfileInt( "ACC_19", "ACC_maxSetzgeschw", getValue( KCAN_ACC_maxSetzgeschw ), profileFile );
    writeProfileFloat( "ACC_19", "ACC_minRegelgeschw", getValue( KCAN_ACC_minRegelgeschw ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Modus_Pop_Up", getValue( KCAN_ACC_Modus_Pop_Up ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Optischer_Fahrerhinweis", getValue( KCAN_ACC_Optischer_Fahrerhinweis ), profileFile );
    writeProfileFloat( "ACC_19", "ACC_Regelgeschw", getValue( KCAN_ACC_Regelgeschw ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Regelung_AIO", getValue( KCAN_ACC_Regelung_AIO ), profileFile );
    writeProfileInt( "ACC_19", "ACC_rel_Objekt_Zusatzanz", getValue( KCAN_ACC_rel_Objekt_Zusatzanz ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Relevantes_Objekt_02", getValue( KCAN_ACC_Relevantes_Objekt_02 ), profileFile );
    writeProfileInt( "ACC_19", "ACC_RUV", getValue( KCAN_ACC_RUV ), profileFile );
    writeProfileFloat( "ACC_19", "ACC_Sollabstand_1", getValue( KCAN_ACC_Sollabstand_1 ), profileFile );
    writeProfileFloat( "ACC_19", "ACC_Sollabstand_2", getValue( KCAN_ACC_Sollabstand_2 ), profileFile );
    writeProfileFloat( "ACC_19", "ACC_Sollabstand_3", getValue( KCAN_ACC_Sollabstand_3 ), profileFile );
    writeProfileFloat( "ACC_19", "ACC_Sollabstand_4", getValue( KCAN_ACC_Sollabstand_4 ), profileFile );
    writeProfileFloat( "ACC_19", "ACC_Sollabstand_5", getValue( KCAN_ACC_Sollabstand_5 ), profileFile );
    writeProfileInt( "ACC_19", "ACC_STA_Text", getValue( KCAN_ACC_STA_Text ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Status_Anzeige", getValue( KCAN_ACC_Status_Anzeige ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Status_GRA_Modus", getValue( KCAN_ACC_Status_GRA_Modus ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Status_Stauende", getValue( KCAN_ACC_Status_Stauende ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Statusicon", getValue( KCAN_ACC_Statusicon ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Tachokranz", getValue( KCAN_ACC_Tachokranz ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Tempolimit", getValue( KCAN_ACC_Tempolimit ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Tempolimit_Einheit", getValue( KCAN_ACC_Tempolimit_Einheit ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Tempolimitassistent_02", getValue( KCAN_ACC_Tempolimitassistent_02 ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Texte_02", getValue( KCAN_ACC_Texte_02 ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Texte_Abstandswarner", getValue( KCAN_ACC_Texte_Abstandswarner ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Texte_Primaeranz_03", getValue( KCAN_ACC_Texte_Primaeranz_03 ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Texte_Sekundaeranz", getValue( KCAN_ACC_Texte_Sekundaeranz ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Texte_Sekundaeranz_02", getValue( KCAN_ACC_Texte_Sekundaeranz_02 ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Texte_Zusatzanz_03", getValue( KCAN_ACC_Texte_Zusatzanz_03 ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Typ_LNS", getValue( KCAN_ACC_Typ_LNS ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Typ_RNS", getValue( KCAN_ACC_Typ_RNS ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Typ_Tachokranz", getValue( KCAN_ACC_Typ_Tachokranz ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Typ_Tachokranz_unten", getValue( KCAN_ACC_Typ_Tachokranz_unten ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Typ_WZO", getValue( KCAN_ACC_Typ_WZO ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Vorz_Abstandswarner", getValue( KCAN_ACC_Vorz_Abstandswarner ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Warnhinweis", getValue( KCAN_ACC_Warnhinweis ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Warnung_Verkehrszeichen_1", getValue( KCAN_ACC_Warnung_Verkehrszeichen_1 ), profileFile );
    writeProfileFloat( "ACC_19", "ACC_Wunschgeschw_02", getValue( KCAN_ACC_Wunschgeschw_02 ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Wunschgeschw_erreicht", getValue( KCAN_ACC_Wunschgeschw_erreicht ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Wunschgeschw_Farbe", getValue( KCAN_ACC_Wunschgeschw_Farbe ), profileFile );
    writeProfileInt( "ACC_19", "ACC_Wunschgeschw_Farbe_02", getValue( KCAN_ACC_Wunschgeschw_Farbe_02 ), profileFile );
    writeProfileFloat( "ACC_19", "ACC_Zeitluecke_Abstandswarner", getValue( KCAN_ACC_Zeitluecke_Abstandswarner ), profileFile );
    writeProfileInt( "ACC_19", "FAS_Licht_Anf", getValue( KCAN_FAS_Licht_Anf ), profileFile );
    writeProfileInt( "ACC_19", "STA_Primaeranz", getValue( KCAN_STA_Primaeranz ), profileFile );
    writeProfileInt( "ACC_19", "STA_Texte", getValue( KCAN_STA_Texte ), profileFile );
    writeProfileInt( "ACC_19", "STA_Zusatzanz", getValue( KCAN_STA_Zusatzanz ), profileFile );

}


void saveSettings_AGA_01( char profileFile[] )
{
    writeProfileInt( "AGA_01", "AGA_Charisma_FahrPr", getValue( KCAN_AGA_Charisma_FahrPr ), profileFile );
    writeProfileInt( "AGA_01", "AGA_Charisma_Status", getValue( KCAN_AGA_Charisma_Status ), profileFile );
    writeProfileInt( "AGA_01", "AGA_ohne_Funktion", getValue( KCAN_AGA_ohne_Funktion ), profileFile );
    writeProfileInt( "AGA_01", "AGA_Texte", getValue( KCAN_AGA_Texte ), profileFile );
    writeProfileInt( "AGA_01", "AGA_Verstaerker_Mute", getValue( KCAN_AGA_Verstaerker_Mute ), profileFile );
    writeProfileInt( "AGA_01", "E_Sound_verbaut", getValue( KCAN_E_Sound_verbaut ), profileFile );

}


void saveSettings_Airbag_01( char profileFile[] )
{
    writeProfileInt( "Airbag_01", "AB_Anzeige_Fussg", getValue( KCAN_AB_Anzeige_Fussg ), profileFile );
    writeProfileInt( "Airbag_01", "AB_Belegung_VF", getValue( KCAN_AB_Belegung_VF ), profileFile );
    writeProfileInt( "Airbag_01", "AB_Crash_Int", getValue( KCAN_AB_Crash_Int ), profileFile );
    writeProfileInt( "Airbag_01", "AB_Deaktiviert", getValue( KCAN_AB_Deaktiviert ), profileFile );
    writeProfileInt( "Airbag_01", "AB_Deaktivierung_HV", getValue( KCAN_AB_Deaktivierung_HV ), profileFile );
    writeProfileInt( "Airbag_01", "AB_Diagnose", getValue( KCAN_AB_Diagnose ), profileFile );
    writeProfileInt( "Airbag_01", "AB_EDR_Trigger", getValue( KCAN_AB_EDR_Trigger ), profileFile );
    writeProfileInt( "Airbag_01", "AB_Erh_Auf_VB", getValue( KCAN_AB_Erh_Auf_VB ), profileFile );
    writeProfileInt( "Airbag_01", "AB_Front_Crash", getValue( KCAN_AB_Front_Crash ), profileFile );
    writeProfileInt( "Airbag_01", "AB_Gurtschloss_FA_ext", getValue( KCAN_AB_Gurtschloss_FA_ext ), profileFile );
    writeProfileInt( "Airbag_01", "AB_Gurtschloss_FA_ext_aktiv", getValue( KCAN_AB_Gurtschloss_FA_ext_aktiv ), profileFile );
    writeProfileInt( "Airbag_01", "AB_Gurtwarn_VB", getValue( KCAN_AB_Gurtwarn_VB ), profileFile );
    writeProfileInt( "Airbag_01", "AB_Gurtwarn_VF", getValue( KCAN_AB_Gurtwarn_VF ), profileFile );
    writeProfileInt( "Airbag_01", "AB_Heck_Crash", getValue( KCAN_AB_Heck_Crash ), profileFile );
    writeProfileInt( "Airbag_01", "AB_Lampe", getValue( KCAN_AB_Lampe ), profileFile );
    writeProfileInt( "Airbag_01", "AB_MKB_Anforderung", getValue( KCAN_AB_MKB_Anforderung ), profileFile );
    writeProfileInt( "Airbag_01", "AB_MKB_gueltig", getValue( KCAN_AB_MKB_gueltig ), profileFile );
    writeProfileInt( "Airbag_01", "AB_PAO_Leuchte_Anf", getValue( KCAN_AB_PAO_Leuchte_Anf ), profileFile );
    writeProfileInt( "Airbag_01", "AB_RGS_Anst", getValue( KCAN_AB_RGS_Anst ), profileFile );
    writeProfileInt( "Airbag_01", "AB_Rollover_Crash", getValue( KCAN_AB_Rollover_Crash ), profileFile );
    writeProfileInt( "Airbag_01", "AB_SB_Crash", getValue( KCAN_AB_SB_Crash ), profileFile );
    writeProfileInt( "Airbag_01", "AB_SF_Crash", getValue( KCAN_AB_SF_Crash ), profileFile );
    writeProfileInt( "Airbag_01", "AB_Stellgliedtest", getValue( KCAN_AB_Stellgliedtest ), profileFile );
    writeProfileInt( "Airbag_01", "AB_Systemfehler", getValue( KCAN_AB_Systemfehler ), profileFile );
    writeProfileInt( "Airbag_01", "AB_Texte_AKS", getValue( KCAN_AB_Texte_AKS ), profileFile );
    writeProfileInt( "Airbag_01", "AB_VB_deaktiviert", getValue( KCAN_AB_VB_deaktiviert ), profileFile );
    writeProfileInt( "Airbag_01", "AB_Versorgungsspannung", getValue( KCAN_AB_Versorgungsspannung ), profileFile );
    writeProfileInt( "Airbag_01", "Airbag_01_BZ", getValue( KCAN_Airbag_01_BZ ), profileFile );
    writeProfileInt( "Airbag_01", "Airbag_01_CRC", getValue( KCAN_Airbag_01_CRC ), profileFile );
    writeProfileFloat( "Airbag_01", "ASM_Masterzeit", getValue( KCAN_ASM_Masterzeit ), profileFile );

}


void saveSettings_Airbag_02( char profileFile[] )
{
    writeProfileInt( "Airbag_02", "AB_Abschaltanf_SIH_BF", getValue( KCAN_AB_Abschaltanf_SIH_BF ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Anforderung_eCall", getValue( KCAN_AB_Anforderung_eCall ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Anforderung_USM", getValue( KCAN_AB_Anforderung_USM ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Anprall_FGS", getValue( KCAN_AB_Anprall_FGS ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Anprall_Front_Beifahrer", getValue( KCAN_AB_Anprall_Front_Beifahrer ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Anprall_Front_Fahrer", getValue( KCAN_AB_Anprall_Front_Fahrer ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Anprall_Heck_Beifahrer", getValue( KCAN_AB_Anprall_Heck_Beifahrer ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Anprall_Heck_Fahrer", getValue( KCAN_AB_Anprall_Heck_Fahrer ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Anprall_Rollover", getValue( KCAN_AB_Anprall_Rollover ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Anprall_Seite_Beifahrer", getValue( KCAN_AB_Anprall_Seite_Beifahrer ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Anprall_Seite_Fahrer", getValue( KCAN_AB_Anprall_Seite_Fahrer ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Belegung_VB", getValue( KCAN_AB_Belegung_VB ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Crashschwere", getValue( KCAN_AB_Crashschwere ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Gurtschloss_BF", getValue( KCAN_AB_Gurtschloss_BF ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Gurtschloss_FA", getValue( KCAN_AB_Gurtschloss_FA ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Gurtschloss_Reihe2_BF", getValue( KCAN_AB_Gurtschloss_Reihe2_BF ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Gurtschloss_Reihe2_FA", getValue( KCAN_AB_Gurtschloss_Reihe2_FA ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Gurtschloss_Reihe2_MI", getValue( KCAN_AB_Gurtschloss_Reihe2_MI ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Gurtschloss_Reihe3_BF", getValue( KCAN_AB_Gurtschloss_Reihe3_BF ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Gurtschloss_Reihe3_FA", getValue( KCAN_AB_Gurtschloss_Reihe3_FA ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Gurtschloss_Reihe3_MI", getValue( KCAN_AB_Gurtschloss_Reihe3_MI ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Sitzpos_Sens_BF", getValue( KCAN_AB_Sitzpos_Sens_BF ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Sitzpos_Sens_FA", getValue( KCAN_AB_Sitzpos_Sens_FA ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Wickelklappung_Reihe2_BF", getValue( KCAN_AB_Wickelklappung_Reihe2_BF ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Wickelklappung_Reihe2_FA", getValue( KCAN_AB_Wickelklappung_Reihe2_FA ), profileFile );
    writeProfileInt( "Airbag_02", "AB_Wickelklappung_Reihe2_MI", getValue( KCAN_AB_Wickelklappung_Reihe2_MI ), profileFile );
    writeProfileInt( "Airbag_02", "Airbag_02_BZ", getValue( KCAN_Airbag_02_BZ ), profileFile );
    writeProfileInt( "Airbag_02", "Airbag_02_CRC", getValue( KCAN_Airbag_02_CRC ), profileFile );
    writeProfileInt( "Airbag_02", "LoGeWa_Event_Kombiwarnung", getValue( KCAN_LoGeWa_Event_Kombiwarnung ), profileFile );
    writeProfileInt( "Airbag_02", "SC_PAO_OFF_Anf", getValue( KCAN_SC_PAO_OFF_Anf ), profileFile );
    writeProfileInt( "Airbag_02", "SC_PAO_ON_Anf", getValue( KCAN_SC_PAO_ON_Anf ), profileFile );
    writeProfileInt( "Airbag_02", "SC_PAO_Schriftzug_Anf", getValue( KCAN_SC_PAO_Schriftzug_Anf ), profileFile );

}


void saveSettings_Airbag_04( char profileFile[] )
{
    writeProfileInt( "Airbag_04", "AB_Anprall_Front", getValue( KCAN_AB_Anprall_Front ), profileFile );
    writeProfileInt( "Airbag_04", "AB_Anprall_Heck", getValue( KCAN_AB_Anprall_Heck ), profileFile );
    writeProfileInt( "Airbag_04", "AB_Belegung_VF_ext", getValue( KCAN_AB_Belegung_VF_ext ), profileFile );
    writeProfileInt( "Airbag_04", "AB_Belegung_VF_ext_aktiv", getValue( KCAN_AB_Belegung_VF_ext_aktiv ), profileFile );
    writeProfileInt( "Airbag_04", "AB_Gurtwarn_Reihe2_BF", getValue( KCAN_AB_Gurtwarn_Reihe2_BF ), profileFile );
    writeProfileInt( "Airbag_04", "AB_Gurtwarn_Reihe2_FA", getValue( KCAN_AB_Gurtwarn_Reihe2_FA ), profileFile );
    writeProfileInt( "Airbag_04", "AB_Gurtwarn_Reihe2_MI", getValue( KCAN_AB_Gurtwarn_Reihe2_MI ), profileFile );
    writeProfileInt( "Airbag_04", "AB_Gurtwarn_Reihe3_BF", getValue( KCAN_AB_Gurtwarn_Reihe3_BF ), profileFile );
    writeProfileInt( "Airbag_04", "AB_Gurtwarn_Reihe3_FA", getValue( KCAN_AB_Gurtwarn_Reihe3_FA ), profileFile );
    writeProfileInt( "Airbag_04", "AB_Gurtwarn_Reihe3_MI", getValue( KCAN_AB_Gurtwarn_Reihe3_MI ), profileFile );
    writeProfileInt( "Airbag_04", "AB_Gurtwarn_Reihe4_BF", getValue( KCAN_AB_Gurtwarn_Reihe4_BF ), profileFile );
    writeProfileInt( "Airbag_04", "AB_Gurtwarn_Reihe4_FA", getValue( KCAN_AB_Gurtwarn_Reihe4_FA ), profileFile );
    writeProfileInt( "Airbag_04", "AB_Gurtwarn_Reihe4_MI", getValue( KCAN_AB_Gurtwarn_Reihe4_MI ), profileFile );
    writeProfileInt( "Airbag_04", "AB_SBR_hinten_verbau", getValue( KCAN_AB_SBR_hinten_verbau ), profileFile );
    writeProfileInt( "Airbag_04", "AbstWarn_MV_FAS_Fkt_Status", getValue( KCAN_AbstWarn_MV_FAS_Fkt_Status ), profileFile );
    writeProfileInt( "Airbag_04", "Airbag_04_BZ", getValue( KCAN_Airbag_04_BZ ), profileFile );
    writeProfileInt( "Airbag_04", "Airbag_04_CRC", getValue( KCAN_Airbag_04_CRC ), profileFile );
    writeProfileInt( "Airbag_04", "AWV_Einstellung_System_ASG", getValue( KCAN_AWV_Einstellung_System_ASG ), profileFile );
    writeProfileInt( "Airbag_04", "AWV_Einstellung_Warnung_ASG", getValue( KCAN_AWV_Einstellung_Warnung_ASG ), profileFile );
    writeProfileInt( "Airbag_04", "LGI_FAS_Fkt_Status", getValue( KCAN_LGI_FAS_Fkt_Status ), profileFile );
    writeProfileInt( "Airbag_04", "PreCrash_FAS_Fkt_Status", getValue( KCAN_PreCrash_FAS_Fkt_Status ), profileFile );
    writeProfileInt( "Airbag_04", "SC_PreSense_Modus_System_KAS", getValue( KCAN_SC_PreSense_Modus_System_KAS ), profileFile );
    writeProfileInt( "Airbag_04", "SC_PreSense_Modus_System_MV", getValue( KCAN_SC_PreSense_Modus_System_MV ), profileFile );
    writeProfileInt( "Airbag_04", "SC_PreSense_Modus_System_NV", getValue( KCAN_SC_PreSense_Modus_System_NV ), profileFile );
    writeProfileInt( "Airbag_04", "SC_PreSense_Modus_Warnung_MV", getValue( KCAN_SC_PreSense_Modus_Warnung_MV ), profileFile );
    writeProfileInt( "Airbag_04", "SC_PreSense_Modus_Warnung_NV", getValue( KCAN_SC_PreSense_Modus_Warnung_NV ), profileFile );
    writeProfileInt( "Airbag_04", "WarnBrems_Charisma_FahrPr", getValue( KCAN_WarnBrems_Charisma_FahrPr ), profileFile );
    writeProfileInt( "Airbag_04", "WarnBrems_Charisma_Status", getValue( KCAN_WarnBrems_Charisma_Status ), profileFile );

}


void saveSettings_Airbag_06( char profileFile[] )
{
    writeProfileInt( "Airbag_06", "AB_Gurtschloss_MI", getValue( KCAN_AB_Gurtschloss_MI ), profileFile );
    writeProfileInt( "Airbag_06", "AB_Gurtschloss_Reihe4_BF", getValue( KCAN_AB_Gurtschloss_Reihe4_BF ), profileFile );
    writeProfileInt( "Airbag_06", "AB_Gurtschloss_Reihe4_FA", getValue( KCAN_AB_Gurtschloss_Reihe4_FA ), profileFile );
    writeProfileInt( "Airbag_06", "AB_Gurtschloss_Reihe4_MI", getValue( KCAN_AB_Gurtschloss_Reihe4_MI ), profileFile );
    writeProfileInt( "Airbag_06", "AB_Gurtwarn_VM", getValue( KCAN_AB_Gurtwarn_VM ), profileFile );
    writeProfileInt( "Airbag_06", "AB_wSBR_Batteriestatus", getValue( KCAN_AB_wSBR_Batteriestatus ), profileFile );

}


void saveSettings_Anhaenger_01( char profileFile[] )
{
    writeProfileInt( "Anhaenger_01", "AAG_Anhaenger_abgesteckt", getValue( KCAN_AAG_Anhaenger_abgesteckt ), profileFile );
    writeProfileInt( "Anhaenger_01", "AAG_Anhaenger_erkannt", getValue( KCAN_AAG_Anhaenger_erkannt ), profileFile );
    writeProfileInt( "Anhaenger_01", "AAG_AVS_Fehler_02", getValue( KCAN_AAG_AVS_Fehler_02 ), profileFile );
    writeProfileInt( "Anhaenger_01", "AAG_AVS_Fehler_02_inv", getValue( KCAN_AAG_AVS_Fehler_02_inv ), profileFile );
    writeProfileInt( "Anhaenger_01", "AAG_AVS_Stati", getValue( KCAN_AAG_AVS_Stati ), profileFile );
    writeProfileInt( "Anhaenger_01", "AAG_Blinker_H_aktiv", getValue( KCAN_AAG_Blinker_H_aktiv ), profileFile );
    writeProfileInt( "Anhaenger_01", "AAG_Blinker_HL_def", getValue( KCAN_AAG_Blinker_HL_def ), profileFile );
    writeProfileInt( "Anhaenger_01", "AAG_Blinker_HR_def", getValue( KCAN_AAG_Blinker_HR_def ), profileFile );
    writeProfileInt( "Anhaenger_01", "AAG_Bremsl_durch_ECD", getValue( KCAN_AAG_Bremsl_durch_ECD ), profileFile );
    writeProfileInt( "Anhaenger_01", "AAG_Bremslicht_H_def", getValue( KCAN_AAG_Bremslicht_H_def ), profileFile );
    writeProfileInt( "Anhaenger_01", "AAG_Bremslicht_Reku", getValue( KCAN_AAG_Bremslicht_Reku ), profileFile );
    writeProfileInt( "Anhaenger_01", "AAG_BZ", getValue( KCAN_AAG_BZ ), profileFile );
    writeProfileInt( "Anhaenger_01", "AAG_LED_aktiv", getValue( KCAN_AAG_LED_aktiv ), profileFile );
    writeProfileInt( "Anhaenger_01", "AAG_NSL_aktiv", getValue( KCAN_AAG_NSL_aktiv ), profileFile );
    writeProfileInt( "Anhaenger_01", "AAG_Schlusslicht_HL_def", getValue( KCAN_AAG_Schlusslicht_HL_def ), profileFile );
    writeProfileInt( "Anhaenger_01", "AAG_Schlusslicht_HR_def", getValue( KCAN_AAG_Schlusslicht_HR_def ), profileFile );

}


void saveSettings_ARA_Status_01( char profileFile[] )
{
    writeProfileInt( "ARA_Status_01", "ARA_Aktiver_Grafikmodus", getValue( KCAN_ARA_Aktiver_Grafikmodus ), profileFile );
    writeProfileInt( "ARA_Status_01", "ARA_Anf_Meldungen", getValue( KCAN_ARA_Anf_Meldungen ), profileFile );
    writeProfileInt( "ARA_Status_01", "ARA_Bremsfuss", getValue( KCAN_ARA_Bremsfuss ), profileFile );
    writeProfileInt( "ARA_Status_01", "ARA_Deaktivierung_sperren", getValue( KCAN_ARA_Deaktivierung_sperren ), profileFile );
    writeProfileInt( "ARA_Status_01", "ARA_Knickwinkel_Ist", getValue( KCAN_ARA_Knickwinkel_Ist ), profileFile );
    writeProfileInt( "ARA_Status_01", "ARA_Knickwinkel_Komfort", getValue( KCAN_ARA_Knickwinkel_Komfort ), profileFile );
    writeProfileInt( "ARA_Status_01", "ARA_Knickwinkel_konfidenz", getValue( KCAN_ARA_Knickwinkel_konfidenz ), profileFile );
    writeProfileInt( "ARA_Status_01", "ARA_Knickwinkel_Max", getValue( KCAN_ARA_Knickwinkel_Max ), profileFile );
    writeProfileInt( "ARA_Status_01", "ARA_Knickwinkel_Soll", getValue( KCAN_ARA_Knickwinkel_Soll ), profileFile );
    writeProfileInt( "ARA_Status_01", "ARA_Modus", getValue( KCAN_ARA_Modus ), profileFile );
    writeProfileInt( "ARA_Status_01", "ARA_Modus_Anf", getValue( KCAN_ARA_Modus_Anf ), profileFile );
    writeProfileInt( "ARA_Status_01", "ARA_Sensor_Aktivierung", getValue( KCAN_ARA_Sensor_Aktivierung ), profileFile );
    writeProfileInt( "ARA_Status_01", "ARA_Status", getValue( KCAN_ARA_Status ), profileFile );
    writeProfileInt( "ARA_Status_01", "ARA_Texte", getValue( KCAN_ARA_Texte ), profileFile );

}


void saveSettings_ARC_HUD_Req_FD( char profileFile[] )
{

}


void saveSettings_ARC_HUD_Resp_FD( char profileFile[] )
{

}


void saveSettings_AWV_02( char profileFile[] )
{
    writeProfileInt( "AWV_02", "AWV_AW_Abstand", getValue( KCAN_AWV_AW_Abstand ), profileFile );
    writeProfileInt( "AWV_02", "AWV_AW_Texte", getValue( KCAN_AWV_AW_Texte ), profileFile );
    writeProfileInt( "AWV_02", "AWV_AW_Texte_Zusatzanzeige", getValue( KCAN_AWV_AW_Texte_Zusatzanzeige ), profileFile );
    writeProfileInt( "AWV_02", "AWV_AW_Zeitluecke", getValue( KCAN_AWV_AW_Zeitluecke ), profileFile );
    writeProfileInt( "AWV_02", "AWV_Einstellung_System_FSG", getValue( KCAN_AWV_Einstellung_System_FSG ), profileFile );
    writeProfileInt( "AWV_02", "AWV_Einstellung_Warnung_FSG", getValue( KCAN_AWV_Einstellung_Warnung_FSG ), profileFile );
    writeProfileInt( "AWV_02", "AWV_KA_ObjektFront", getValue( KCAN_AWV_KA_ObjektFront ), profileFile );
    writeProfileInt( "AWV_02", "AWV_Kamera_Objekt_ID", getValue( KCAN_AWV_Kamera_Objekt_ID ), profileFile );
    writeProfileInt( "AWV_02", "AWV_LED_Leiste", getValue( KCAN_AWV_LED_Leiste ), profileFile );
    writeProfileInt( "AWV_02", "AWV_Priowarnung", getValue( KCAN_AWV_Priowarnung ), profileFile );
    writeProfileInt( "AWV_02", "AWV_Status_Anzeige", getValue( KCAN_AWV_Status_Anzeige ), profileFile );
    writeProfileInt( "AWV_02", "AWV_Texte", getValue( KCAN_AWV_Texte ), profileFile );
    writeProfileInt( "AWV_02", "AWV_Warnlevel", getValue( KCAN_AWV_Warnlevel ), profileFile );
    writeProfileInt( "AWV_02", "AWV_Warnung", getValue( KCAN_AWV_Warnung ), profileFile );
    writeProfileInt( "AWV_02", "AWV_Warnung_Richtung", getValue( KCAN_AWV_Warnung_Richtung ), profileFile );

}


void saveSettings_AZK_01( char profileFile[] )
{
    writeProfileInt( "AZK_01", "AZK_Kessy_defekt", getValue( KCAN_AZK_Kessy_defekt ), profileFile );
    writeProfileInt( "AZK_01", "AZK_Kessy_nicht_gefunden", getValue( KCAN_AZK_Kessy_nicht_gefunden ), profileFile );
    writeProfileInt( "AZK_01", "AZK_MobileKey_defekt", getValue( KCAN_AZK_MobileKey_defekt ), profileFile );
    writeProfileInt( "AZK_01", "AZK_Mobilgeraet_nicht_gefunden", getValue( KCAN_AZK_Mobilgeraet_nicht_gefunden ), profileFile );
    writeProfileInt( "AZK_01", "AZK_Schluessel_im_Fzg", getValue( KCAN_AZK_Schluessel_im_Fzg ), profileFile );
    writeProfileInt( "AZK_01", "AZK_Weiterfahrt_mit_Mobilgeraet", getValue( KCAN_AZK_Weiterfahrt_mit_Mobilgeraet ), profileFile );
    writeProfileInt( "AZK_01", "AZK_Weiterfahrt_mit_Schluessel", getValue( KCAN_AZK_Weiterfahrt_mit_Schluessel ), profileFile );

}


void saveSettings_BCM_01( char profileFile[] )
{
    writeProfileInt( "BCM_01", "APS_Tongeber_defekt", getValue( KCAN_APS_Tongeber_defekt ), profileFile );
    writeProfileInt( "BCM_01", "BCM1_AFS_Lampe", getValue( KCAN_BCM1_AFS_Lampe ), profileFile );
    writeProfileInt( "BCM_01", "BCM1_EasyEntry_Status", getValue( KCAN_BCM1_EasyEntry_Status ), profileFile );
    writeProfileInt( "BCM_01", "BCM1_Kl_15_HW_erkannt", getValue( KCAN_BCM1_Kl_15_HW_erkannt ), profileFile );
    writeProfileInt( "BCM_01", "BCM1_Kl_15_Sig_HW_erkannt", getValue( KCAN_BCM1_Kl_15_Sig_HW_erkannt ), profileFile );
    writeProfileInt( "BCM_01", "BCM1_Lenksaeule_aktiv", getValue( KCAN_BCM1_Lenksaeule_aktiv ), profileFile );
    writeProfileInt( "BCM_01", "BCM1_MH_Schalter", getValue( KCAN_BCM1_MH_Schalter ), profileFile );
    writeProfileInt( "BCM_01", "BCM1_MH_WIV_Schalter", getValue( KCAN_BCM1_MH_WIV_Schalter ), profileFile );
    writeProfileInt( "BCM_01", "BCM1_NV_Taster", getValue( KCAN_BCM1_NV_Taster ), profileFile );
    writeProfileInt( "BCM_01", "BCM1_Reisemodus_Texte", getValue( KCAN_BCM1_Reisemodus_Texte ), profileFile );
    writeProfileInt( "BCM_01", "BCM1_Rueckfahrlicht_Schalter", getValue( KCAN_BCM1_Rueckfahrlicht_Schalter ), profileFile );
    writeProfileInt( "BCM_01", "BCM1_Spannungs_Anf", getValue( KCAN_BCM1_Spannungs_Anf ), profileFile );
    writeProfileInt( "BCM_01", "BCM1_Valet_Parking_Taster", getValue( KCAN_BCM1_Valet_Parking_Taster ), profileFile );
    writeProfileInt( "BCM_01", "BCM1_Warnblink_Taster", getValue( KCAN_BCM1_Warnblink_Taster ), profileFile );
    writeProfileInt( "BCM_01", "BCM_Anf_AAW_MoLaWa", getValue( KCAN_BCM_Anf_AAW_MoLaWa ), profileFile );
    writeProfileInt( "BCM_01", "BCM_Bremsbelag_Sensor", getValue( KCAN_BCM_Bremsbelag_Sensor ), profileFile );
    writeProfileInt( "BCM_01", "BCM_Bremsfluessigkeit_Sensor", getValue( KCAN_BCM_Bremsfluessigkeit_Sensor ), profileFile );
    writeProfileInt( "BCM_01", "BCM_Charisma_Taste2", getValue( KCAN_BCM_Charisma_Taste2 ), profileFile );
    writeProfileInt( "BCM_01", "BCM_Eco_Charisma_Taste", getValue( KCAN_BCM_Eco_Charisma_Taste ), profileFile );
    writeProfileInt( "BCM_01", "BCM_Handbremse_Hinweis", getValue( KCAN_BCM_Handbremse_Hinweis ), profileFile );
    writeProfileInt( "BCM_01", "BCM_HDF_betaetigt", getValue( KCAN_BCM_HDF_betaetigt ), profileFile );
    writeProfileInt( "BCM_01", "BCM_Hybrid_StartStopp_Taste", getValue( KCAN_BCM_Hybrid_StartStopp_Taste ), profileFile );
    writeProfileInt( "BCM_01", "BCM_Hybrid_StSt_Taste_Fehler", getValue( KCAN_BCM_Hybrid_StSt_Taste_Fehler ), profileFile );
    writeProfileInt( "BCM_01", "BCM_Kuehlmittel_Sensor", getValue( KCAN_BCM_Kuehlmittel_Sensor ), profileFile );
    writeProfileInt( "BCM_01", "BCM_Kuehlmittel_Sensor_02", getValue( KCAN_BCM_Kuehlmittel_Sensor_02 ), profileFile );
    writeProfileInt( "BCM_01", "BCM_Offroad_Taste", getValue( KCAN_BCM_Offroad_Taste ), profileFile );
    writeProfileInt( "BCM_01", "BCM_ValetTaster_Fkts_LED", getValue( KCAN_BCM_ValetTaster_Fkts_LED ), profileFile );
    writeProfileInt( "BCM_01", "BCM_Waschwasser_Sensor", getValue( KCAN_BCM_Waschwasser_Sensor ), profileFile );
    writeProfileInt( "BCM_01", "Gong_TFL_Umschaltung", getValue( KCAN_Gong_TFL_Umschaltung ), profileFile );
    writeProfileInt( "BCM_01", "LRH_Taster", getValue( KCAN_LRH_Taster ), profileFile );

}


void saveSettings_BCM_03( char profileFile[] )
{
    writeProfileInt( "BCM_03", "BCM_anf_VLW", getValue( KCAN_BCM_anf_VLW ), profileFile );
    writeProfileInt( "BCM_03", "BCM_LTM_Allwetterl_Status", getValue( KCAN_BCM_LTM_Allwetterl_Status ), profileFile );
    writeProfileInt( "BCM_03", "BCM_LTM_Nebell_Status", getValue( KCAN_BCM_LTM_Nebell_Status ), profileFile );
    writeProfileInt( "BCM_03", "BCM_LTM_Nebelschluss_Status", getValue( KCAN_BCM_LTM_Nebelschluss_Status ), profileFile );
    writeProfileInt( "BCM_03", "BCM_LTM_PopUp_Anf", getValue( KCAN_BCM_LTM_PopUp_Anf ), profileFile );
    writeProfileInt( "BCM_03", "BCM_LTM_PopUp_Inhalt", getValue( KCAN_BCM_LTM_PopUp_Inhalt ), profileFile );
    writeProfileInt( "BCM_03", "BCM_LTM_PopUp_Status", getValue( KCAN_BCM_LTM_PopUp_Status ), profileFile );
    writeProfileInt( "BCM_03", "BCM_LTM_PopUp_Texte", getValue( KCAN_BCM_LTM_PopUp_Texte ), profileFile );

}


void saveSettings_BCM_04( char profileFile[] )
{
    writeProfileInt( "BCM_04", "BCM_RGB_Blau", getValue( KCAN_BCM_RGB_Blau ), profileFile );
    writeProfileInt( "BCM_04", "BCM_RGB_Gruen", getValue( KCAN_BCM_RGB_Gruen ), profileFile );
    writeProfileInt( "BCM_04", "BCM_RGB_Rot", getValue( KCAN_BCM_RGB_Rot ), profileFile );

}


void saveSettings_BCM_Taster_02( char profileFile[] )
{
    writeProfileInt( "BCM_Taster_02", "FAS_Profile_Taster", getValue( KCAN_FAS_Profile_Taster ), profileFile );
    writeProfileInt( "BCM_Taster_02", "LIM_bCall_Taster", getValue( KCAN_LIM_bCall_Taster ), profileFile );
    writeProfileInt( "BCM_Taster_02", "LIM_iCall_Taster", getValue( KCAN_LIM_iCall_Taster ), profileFile );
    writeProfileInt( "BCM_Taster_02", "LIM_S_Rollo_hi", getValue( KCAN_LIM_S_Rollo_hi ), profileFile );
    writeProfileInt( "BCM_Taster_02", "LIM_S_Rollo_vo", getValue( KCAN_LIM_S_Rollo_vo ), profileFile );
    writeProfileInt( "BCM_Taster_02", "LIM_S_SAD_hi", getValue( KCAN_LIM_S_SAD_hi ), profileFile );
    writeProfileInt( "BCM_Taster_02", "LIM_S_SAD_Vo", getValue( KCAN_LIM_S_SAD_Vo ), profileFile );
    writeProfileInt( "BCM_Taster_02", "LINDa_Touch_Event", getValue( KCAN_LINDa_Touch_Event ), profileFile );
    writeProfileInt( "BCM_Taster_02", "Tuerkontakt_Innenlicht_Taste", getValue( KCAN_Tuerkontakt_Innenlicht_Taste ), profileFile );

}


void saveSettings_BCM_Taster_03( char profileFile[] )
{
    writeProfileInt( "BCM_Taster_03", "LINDa_HL_SR3_Touch_Event", getValue( KCAN_LINDa_HL_SR3_Touch_Event ), profileFile );
    writeProfileInt( "BCM_Taster_03", "LINDa_HL_Touch_Event", getValue( KCAN_LINDa_HL_Touch_Event ), profileFile );
    writeProfileInt( "BCM_Taster_03", "LINDa_HR_SR3_Touch_Event", getValue( KCAN_LINDa_HR_SR3_Touch_Event ), profileFile );
    writeProfileInt( "BCM_Taster_03", "LINDa_HR_Touch_Event", getValue( KCAN_LINDa_HR_Touch_Event ), profileFile );

}


void saveSettings_BEM_02( char profileFile[] )
{
    writeProfileInt( "BEM_02", "BEM_Anf_KL15_schalten", getValue( KCAN_BEM_Anf_KL15_schalten ), profileFile );
    writeProfileInt( "BEM_02", "BEM_Batt_Ab", getValue( KCAN_BEM_Batt_Ab ), profileFile );
    writeProfileInt( "BEM_02", "BEM_Batteriediagnose", getValue( KCAN_BEM_Batteriediagnose ), profileFile );
    writeProfileFloat( "BEM_02", "BEM_DFM", getValue( KCAN_BEM_DFM ), profileFile );
    writeProfileInt( "BEM_02", "BEM_EMLIN_ungueltig", getValue( KCAN_BEM_EMLIN_ungueltig ), profileFile );
    writeProfileInt( "BEM_02", "BEM_Generatordiagnose", getValue( KCAN_BEM_Generatordiagnose ), profileFile );
    writeProfileInt( "BEM_02", "BEM_HL_Kontingentierung", getValue( KCAN_BEM_HL_Kontingentierung ), profileFile );
    writeProfileInt( "BEM_02", "BEM_HL_Regelung_Status", getValue( KCAN_BEM_HL_Regelung_Status ), profileFile );
    writeProfileInt( "BEM_02", "BEM_Ladezustand", getValue( KCAN_BEM_Ladezustand ), profileFile );
    writeProfileInt( "BEM_02", "BEM_MMI_Vorwarnung", getValue( KCAN_BEM_MMI_Vorwarnung ), profileFile );
    writeProfileInt( "BEM_02", "BEM_Red_Innengeblaese", getValue( KCAN_BEM_Red_Innengeblaese ), profileFile );
    writeProfileInt( "BEM_02", "BEM_REK_aktiv", getValue( KCAN_BEM_REK_aktiv ), profileFile );
    writeProfileInt( "BEM_02", "BEM_STH_Einschaltverbot", getValue( KCAN_BEM_STH_Einschaltverbot ), profileFile );
    writeProfileInt( "BEM_02", "BEM_STH_Zielzeit", getValue( KCAN_BEM_STH_Zielzeit ), profileFile );
    writeProfileFloat( "BEM_02", "BEM_UBDM", getValue( KCAN_BEM_UBDM ), profileFile );
    writeProfileFloat( "BEM_02", "BEM_UGenSoll", getValue( KCAN_BEM_UGenSoll ), profileFile );
    writeProfileInt( "BEM_02", "MIB_Stromsparmodus", getValue( KCAN_MIB_Stromsparmodus ), profileFile );
    writeProfileInt( "BEM_02", "NVEM_Abschaltstufe", getValue( KCAN_NVEM_Abschaltstufe ), profileFile );
    writeProfileInt( "BEM_02", "NVEM_Anf_SD_schalten", getValue( KCAN_NVEM_Anf_SD_schalten ), profileFile );
    writeProfileInt( "BEM_02", "NVEM_Batterie_Service", getValue( KCAN_NVEM_Batterie_Service ), profileFile );
    writeProfileInt( "BEM_02", "NVEM_Freigabe_OnlineUpdate", getValue( KCAN_NVEM_Freigabe_OnlineUpdate ), profileFile );
    writeProfileInt( "BEM_02", "NVEM_Freigabe_ORU4", getValue( KCAN_NVEM_Freigabe_ORU4 ), profileFile );
    writeProfileInt( "BEM_02", "NVEM_Freigabe_ZusBatt_Laden", getValue( KCAN_NVEM_Freigabe_ZusBatt_Laden ), profileFile );
    writeProfileInt( "BEM_02", "NVEM_Verbraucherabsch_Anz", getValue( KCAN_NVEM_Verbraucherabsch_Anz ), profileFile );

}


void saveSettings_BEM_06( char profileFile[] )
{
    writeProfileInt( "BEM_06", "BEM_06_BZ", getValue( KCAN_BEM_06_BZ ), profileFile );
    writeProfileInt( "BEM_06", "BEM_06_CRC", getValue( KCAN_BEM_06_CRC ), profileFile );
    writeProfileInt( "BEM_06", "HLR_PTC_linear_Freigabe", getValue( KCAN_HLR_PTC_linear_Freigabe ), profileFile );
    writeProfileInt( "BEM_06", "NVEM_Bordnetzdiagnose", getValue( KCAN_NVEM_Bordnetzdiagnose ), profileFile );
    writeProfileInt( "BEM_06", "NVEM_Energie_Klima_Vorgabe", getValue( KCAN_NVEM_Energie_Klima_Vorgabe ), profileFile );
    writeProfileInt( "BEM_06", "NVEM_Last_Anf", getValue( KCAN_NVEM_Last_Anf ), profileFile );
    writeProfileInt( "BEM_06", "NVEM_PTC_Sollstufe", getValue( KCAN_NVEM_PTC_Sollstufe ), profileFile );
    writeProfileInt( "BEM_06", "NVEM_Red_KomfortVerbrauch", getValue( KCAN_NVEM_Red_KomfortVerbrauch ), profileFile );
    writeProfileInt( "BEM_06", "NVEM_STH_ZielzeitLang", getValue( KCAN_NVEM_STH_ZielzeitLang ), profileFile );

}


void saveSettings_Blinkmodi_02( char profileFile[] )
{
    writeProfileInt( "Blinkmodi_02", "Blinken_li_Fzg_Takt", getValue( KCAN_Blinken_li_Fzg_Takt ), profileFile );
    writeProfileInt( "Blinkmodi_02", "Blinken_li_Kombi_Takt", getValue( KCAN_Blinken_li_Kombi_Takt ), profileFile );
    writeProfileInt( "Blinkmodi_02", "Blinken_re_Fzg_Takt", getValue( KCAN_Blinken_re_Fzg_Takt ), profileFile );
    writeProfileInt( "Blinkmodi_02", "Blinken_re_Kombi_Takt", getValue( KCAN_Blinken_re_Kombi_Takt ), profileFile );
    writeProfileInt( "Blinkmodi_02", "Blinkmodi_02_BZ", getValue( KCAN_Blinkmodi_02_BZ ), profileFile );
    writeProfileInt( "Blinkmodi_02", "Blinkmodi_02_CRC", getValue( KCAN_Blinkmodi_02_CRC ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_Autobahn", getValue( KCAN_BM_Autobahn ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_Crash", getValue( KCAN_BM_Crash ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_DWA_Alarm", getValue( KCAN_BM_DWA_Alarm ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_DWA_ein", getValue( KCAN_BM_DWA_ein ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_GDO", getValue( KCAN_BM_GDO ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_HD_Oeffnung_angelernt", getValue( KCAN_BM_HD_Oeffnung_angelernt ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_links", getValue( KCAN_BM_links ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_NBA_n_codiert_n_aktiv", getValue( KCAN_BM_NBA_n_codiert_n_aktiv ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_NBA_Status", getValue( KCAN_BM_NBA_Status ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_Not_Bremsung", getValue( KCAN_BM_Not_Bremsung ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_Panik", getValue( KCAN_BM_Panik ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_PiloPa", getValue( KCAN_BM_PiloPa ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_Recas", getValue( KCAN_BM_Recas ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_rechts", getValue( KCAN_BM_rechts ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_Rollenmodus_Blinken", getValue( KCAN_BM_Rollenmodus_Blinken ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_Taxi_Notalarm", getValue( KCAN_BM_Taxi_Notalarm ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_Telematik", getValue( KCAN_BM_Telematik ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_Telematik_Abbruchgrund", getValue( KCAN_BM_Telematik_Abbruchgrund ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_Warnblinken", getValue( KCAN_BM_Warnblinken ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_WBT_Beleuchtung", getValue( KCAN_BM_WBT_Beleuchtung ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_Wischblinken", getValue( KCAN_BM_Wischblinken ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_ZV_auf", getValue( KCAN_BM_ZV_auf ), profileFile );
    writeProfileInt( "Blinkmodi_02", "BM_ZV_zu", getValue( KCAN_BM_ZV_zu ), profileFile );
    writeProfileInt( "Blinkmodi_02", "SAL_TA_Blinken_Status", getValue( KCAN_SAL_TA_Blinken_Status ), profileFile );

}


void saveSettings_BMS_05( char profileFile[] )
{
    writeProfileFloat( "BMS_05", "BMC_Spannung", getValue( KCAN_BMC_Spannung ), profileFile );
    writeProfileInt( "BMS_05", "BMS_As_Entladezaehler", getValue( KCAN_BMS_As_Entladezaehler ), profileFile );
    writeProfileInt( "BMS_05", "BMS_As_Entladezaehler_Ueberlauf", getValue( KCAN_BMS_As_Entladezaehler_Ueberlauf ), profileFile );
    writeProfileInt( "BMS_05", "BMS_Rekuperation", getValue( KCAN_BMS_Rekuperation ), profileFile );
    writeProfileInt( "BMS_05", "BMS_Rekuperation_Ueberlauf", getValue( KCAN_BMS_Rekuperation_Ueberlauf ), profileFile );
    writeProfileInt( "BMS_05", "BMS_Verbrauch", getValue( KCAN_BMS_Verbrauch ), profileFile );
    writeProfileInt( "BMS_05", "BMS_Verbrauch_Ueberlauf", getValue( KCAN_BMS_Verbrauch_Ueberlauf ), profileFile );

}


void saveSettings_BMS_07( char profileFile[] )
{
    writeProfileInt( "BMS_07", "BMS_07_BZ", getValue( KCAN_BMS_07_BZ ), profileFile );
    writeProfileInt( "BMS_07", "BMS_07_CRC", getValue( KCAN_BMS_07_CRC ), profileFile );
    writeProfileInt( "BMS_07", "BMS_Ausgleichsladung_Anf", getValue( KCAN_BMS_Ausgleichsladung_Anf ), profileFile );
    writeProfileInt( "BMS_07", "BMS_Batteriediagnose", getValue( KCAN_BMS_Batteriediagnose ), profileFile );
    writeProfileInt( "BMS_07", "BMS_Energieinhalt", getValue( KCAN_BMS_Energieinhalt ), profileFile );
    writeProfileInt( "BMS_07", "BMS_Gesamtst_Spgfreiheit", getValue( KCAN_BMS_Gesamtst_Spgfreiheit ), profileFile );
    writeProfileInt( "BMS_07", "BMS_KundenWarnung", getValue( KCAN_BMS_KundenWarnung ), profileFile );
    writeProfileInt( "BMS_07", "BMS_MaxEnergieinhalt", getValue( KCAN_BMS_MaxEnergieinhalt ), profileFile );

}


void saveSettings_Bremse_EV_02( char profileFile[] )
{
    writeProfileInt( "Bremse_EV_02", "Bremse_EV_02_BZ", getValue( KCAN_Bremse_EV_02_BZ ), profileFile );
    writeProfileInt( "Bremse_EV_02", "Bremse_EV_02_CRC", getValue( KCAN_Bremse_EV_02_CRC ), profileFile );
    writeProfileInt( "Bremse_EV_02", "EBKV_BKL_Warnungen", getValue( KCAN_EBKV_BKL_Warnungen ), profileFile );
    writeProfileInt( "Bremse_EV_02", "EBKV_Charisma_FahrPr", getValue( KCAN_EBKV_Charisma_FahrPr ), profileFile );
    writeProfileInt( "Bremse_EV_02", "EBKV_Charisma_Status", getValue( KCAN_EBKV_Charisma_Status ), profileFile );
    writeProfileInt( "Bremse_EV_02", "EBKV_Hinweise", getValue( KCAN_EBKV_Hinweise ), profileFile );
    writeProfileInt( "Bremse_EV_02", "EBKV_SpannungsAnf", getValue( KCAN_EBKV_SpannungsAnf ), profileFile );
    writeProfileInt( "Bremse_EV_02", "EBKV_Warnungen", getValue( KCAN_EBKV_Warnungen ), profileFile );
    writeProfileInt( "Bremse_EV_02", "EPB_Fehlermeldung_ext", getValue( KCAN_EPB_Fehlermeldung_ext ), profileFile );
    writeProfileInt( "Bremse_EV_02", "EPB_Funktionslampe_ext", getValue( KCAN_EPB_Funktionslampe_ext ), profileFile );

}


void saveSettings_Charisma_03( char profileFile[] )
{
    writeProfileInt( "Charisma_03", "CHA_Charge_LED", getValue( KCAN_CHA_Charge_LED ), profileFile );
    writeProfileInt( "Charisma_03", "CHA_Charisma_Taste2_LED", getValue( KCAN_CHA_Charisma_Taste2_LED ), profileFile );
    writeProfileInt( "Charisma_03", "CHA_Current_Mode", getValue( KCAN_CHA_Current_Mode ), profileFile );
    writeProfileInt( "Charisma_03", "CHA_Current_Mode_BMA", getValue( KCAN_CHA_Current_Mode_BMA ), profileFile );
    writeProfileInt( "Charisma_03", "CHA_Current_Mode_FPA", getValue( KCAN_CHA_Current_Mode_FPA ), profileFile );
    writeProfileInt( "Charisma_03", "CHA_Eco_Charisma_LED", getValue( KCAN_CHA_Eco_Charisma_LED ), profileFile );
    writeProfileInt( "Charisma_03", "CHA_EV_LED", getValue( KCAN_CHA_EV_LED ), profileFile );
    writeProfileInt( "Charisma_03", "CHA_Fahrer_Umschaltung", getValue( KCAN_CHA_Fahrer_Umschaltung ), profileFile );
    writeProfileInt( "Charisma_03", "CHA_Kombi_Texte", getValue( KCAN_CHA_Kombi_Texte ), profileFile );
    writeProfileInt( "Charisma_03", "CHA_Kombi_Texte_02", getValue( KCAN_CHA_Kombi_Texte_02 ), profileFile );
    writeProfileInt( "Charisma_03", "CHA_Offroad_LED", getValue( KCAN_CHA_Offroad_LED ), profileFile );
    writeProfileInt( "Charisma_03", "CHA_Ziel_FahrPr_03_01", getValue( KCAN_CHA_Ziel_FahrPr_03_01 ), profileFile );
    writeProfileInt( "Charisma_03", "CHA_Ziel_FahrPr_03_02", getValue( KCAN_CHA_Ziel_FahrPr_03_02 ), profileFile );
    writeProfileInt( "Charisma_03", "CHA_Ziel_FahrPr_AMB", getValue( KCAN_CHA_Ziel_FahrPr_AMB ), profileFile );
    writeProfileInt( "Charisma_03", "CHA_Ziel_FahrPr_HSP", getValue( KCAN_CHA_Ziel_FahrPr_HSP ), profileFile );
    writeProfileInt( "Charisma_03", "CHA_Ziel_FahrPr_IVB", getValue( KCAN_CHA_Ziel_FahrPr_IVB ), profileFile );
    writeProfileInt( "Charisma_03", "CHA_Ziel_FahrPr_KL", getValue( KCAN_CHA_Ziel_FahrPr_KL ), profileFile );
    writeProfileInt( "Charisma_03", "CHA_Ziel_FahrPr_RWB", getValue( KCAN_CHA_Ziel_FahrPr_RWB ), profileFile );

}


void saveSettings_Daempfer_01( char profileFile[] )
{
    writeProfileInt( "Daempfer_01", "DR_Gelbe_Warnlampe", getValue( KCAN_DR_Gelbe_Warnlampe ), profileFile );

}


void saveSettings_Daempfer_05( char profileFile[] )
{
    writeProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_Add", getValue( KCAN_DR_DCCMonitor_I_Add ), profileFile );
    writeProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_HL", getValue( KCAN_DR_DCCMonitor_I_HL ), profileFile );
    writeProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_HR", getValue( KCAN_DR_DCCMonitor_I_HR ), profileFile );
    writeProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_SZ_Add", getValue( KCAN_DR_DCCMonitor_I_SZ_Add ), profileFile );
    writeProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_SZ_HL", getValue( KCAN_DR_DCCMonitor_I_SZ_HL ), profileFile );
    writeProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_SZ_HR", getValue( KCAN_DR_DCCMonitor_I_SZ_HR ), profileFile );
    writeProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_SZ_VL", getValue( KCAN_DR_DCCMonitor_I_SZ_VL ), profileFile );
    writeProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_SZ_VR", getValue( KCAN_DR_DCCMonitor_I_SZ_VR ), profileFile );
    writeProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_VL", getValue( KCAN_DR_DCCMonitor_I_VL ), profileFile );
    writeProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_VR", getValue( KCAN_DR_DCCMonitor_I_VR ), profileFile );

}


void saveSettings_DCDC_02( char profileFile[] )
{
    writeProfileFloat( "DCDC_02", "DC_HYB_Auslastungsgrad", getValue( KCAN_DC_HYB_Auslastungsgrad ), profileFile );
    writeProfileInt( "DCDC_02", "DC_ReserveStrom_NV", getValue( KCAN_DC_ReserveStrom_NV ), profileFile );
    writeProfileInt( "DCDC_02", "DC_Verbrauch", getValue( KCAN_DC_Verbrauch ), profileFile );
    writeProfileInt( "DCDC_02", "DC_Verbrauch_Ueberlauf", getValue( KCAN_DC_Verbrauch_Ueberlauf ), profileFile );
    writeProfileInt( "DCDC_02", "DC_Verlustleistung", getValue( KCAN_DC_Verlustleistung ), profileFile );
    writeProfileInt( "DCDC_02", "DCDC_02_BZ", getValue( KCAN_DCDC_02_BZ ), profileFile );
    writeProfileInt( "DCDC_02", "DCDC_02_CRC", getValue( KCAN_DCDC_02_CRC ), profileFile );

}


void saveSettings_DEV_SmaLi_Tx_01( char profileFile[] )
{

}


void saveSettings_DEV_ZR_Produktion_1_Rx_1D( char profileFile[] )
{

}


void saveSettings_DEV_ZR_Produktion_1_Tx_1C( char profileFile[] )
{

}


void saveSettings_DEV_ZR_Req_0D( char profileFile[] )
{

}


void saveSettings_DEV_ZR_Resp_00( char profileFile[] )
{

}


void saveSettings_DEV_ZR_SmaLi_01_Tx( char profileFile[] )
{

}


void saveSettings_DEV_ZR_Tx_14( char profileFile[] )
{

}


void saveSettings_DEV_ZR_Tx_15( char profileFile[] )
{
    writeProfileInt( "DEV_ZR_Tx_15", "DEV_ZR_Tx_15_Data", getValue( KCAN_DEV_ZR_Tx_15_Data ), profileFile );
    writeProfileInt( "DEV_ZR_Tx_15", "MMI_State_DEV_ZR_Tx_15", getValue( KCAN_MMI_State_DEV_ZR_Tx_15 ), profileFile );
    writeProfileInt( "DEV_ZR_Tx_15", "Reset_Counter", getValue( KCAN_Reset_Counter ), profileFile );
    writeProfileInt( "DEV_ZR_Tx_15", "Routeg_aktiv", getValue( KCAN_Routeg_aktiv ), profileFile );
    writeProfileInt( "DEV_ZR_Tx_15", "SI_MOST_Status", getValue( KCAN_SI_MOST_Status ), profileFile );
    writeProfileInt( "DEV_ZR_Tx_15", "Tel_aktiv", getValue( KCAN_Tel_aktiv ), profileFile );
    writeProfileInt( "DEV_ZR_Tx_15", "Tel_SIM_aktiv", getValue( KCAN_Tel_SIM_aktiv ), profileFile );
    writeProfileFloat( "DEV_ZR_Tx_15", "ZR_KL_30F", getValue( KCAN_ZR_KL_30F ), profileFile );
    writeProfileInt( "DEV_ZR_Tx_15", "ZR_LastOn", getValue( KCAN_ZR_LastOn ), profileFile );
    writeProfileInt( "DEV_ZR_Tx_15", "ZR_State_DU_1_DEV_ZR_Tx_15", getValue( KCAN_ZR_State_DU_1_DEV_ZR_Tx_15 ), profileFile );
    writeProfileInt( "DEV_ZR_Tx_15", "ZR_TempSens", getValue( KCAN_ZR_TempSens ), profileFile );

}


void saveSettings_DIA_ABT_1_Req( char profileFile[] )
{

}


void saveSettings_DIA_ABT_1_Resp( char profileFile[] )
{

}


void saveSettings_Diagnose_01( char profileFile[] )
{
    writeProfileInt( "Diagnose_01", "DGN_Verlernzaehler", getValue( KCAN_DGN_Verlernzaehler ), profileFile );
    writeProfileInt( "Diagnose_01", "KBI_Kilometerstand", getValue( KCAN_KBI_Kilometerstand ), profileFile );
    writeProfileInt( "Diagnose_01", "Kombi_02_alt", getValue( KCAN_Kombi_02_alt ), profileFile );
    writeProfileInt( "Diagnose_01", "UH_Jahr", getValue( KCAN_UH_Jahr ), profileFile );
    writeProfileInt( "Diagnose_01", "UH_Minute", getValue( KCAN_UH_Minute ), profileFile );
    writeProfileInt( "Diagnose_01", "UH_Monat", getValue( KCAN_UH_Monat ), profileFile );
    writeProfileInt( "Diagnose_01", "UH_Sekunde", getValue( KCAN_UH_Sekunde ), profileFile );
    writeProfileInt( "Diagnose_01", "UH_Stunde", getValue( KCAN_UH_Stunde ), profileFile );
    writeProfileInt( "Diagnose_01", "UH_Tag", getValue( KCAN_UH_Tag ), profileFile );
    writeProfileInt( "Diagnose_01", "Uhrzeit_01_alt", getValue( KCAN_Uhrzeit_01_alt ), profileFile );
    writeProfileInt( "Diagnose_01", "Vehicle_Driving_Cycle", getValue( KCAN_Vehicle_Driving_Cycle ), profileFile );

}


void saveSettings_DiETa_01( char profileFile[] )
{
    writeProfileInt( "DiETa_01", "DiETa_Car", getValue( KCAN_DiETa_Car ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_Defrost_Taste", getValue( KCAN_DiETa_Defrost_Taste ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_FAS_Stufe", getValue( KCAN_DiETa_FAS_Stufe ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_FSH_Taste", getValue( KCAN_DiETa_FSH_Taste ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_HSH_Taste", getValue( KCAN_DiETa_HSH_Taste ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_Klima", getValue( KCAN_DiETa_Klima ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_Lock_Unlock_Taste", getValue( KCAN_DiETa_Lock_Unlock_Taste ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_Mode", getValue( KCAN_DiETa_Mode ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_Mode2", getValue( KCAN_DiETa_Mode2 ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_Mode_roh", getValue( KCAN_DiETa_Mode_roh ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_PAO_OFF_Status", getValue( KCAN_DiETa_PAO_OFF_Status ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_PAO_ON_Status", getValue( KCAN_DiETa_PAO_ON_Status ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_Parken", getValue( KCAN_DiETa_Parken ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_Reserve_Byte2_4", getValue( KCAN_DiETa_Reserve_Byte2_4 ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_Reserve_Byte6_6", getValue( KCAN_DiETa_Reserve_Byte6_6 ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_Reserve_Byte7_4", getValue( KCAN_DiETa_Reserve_Byte7_4 ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_Reserve_Byte8", getValue( KCAN_DiETa_Reserve_Byte8 ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_ResponseError", getValue( KCAN_DiETa_ResponseError ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_Status", getValue( KCAN_DiETa_Status ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_Touch_Event", getValue( KCAN_DiETa_Touch_Event ), profileFile );
    writeProfileInt( "DiETa_01", "DiETa_Warnblink_Taste", getValue( KCAN_DiETa_Warnblink_Taste ), profileFile );
    writeProfileInt( "DiETa_01", "DiETas_01_BZ", getValue( KCAN_DiETas_01_BZ ), profileFile );
    writeProfileInt( "DiETa_01", "DiETas_01_CRC", getValue( KCAN_DiETas_01_CRC ), profileFile );
    writeProfileInt( "DiETa_01", "ESP_Off_Taster", getValue( KCAN_ESP_Off_Taster ), profileFile );

}


void saveSettings_Dimmung_01( char profileFile[] )
{
    writeProfileInt( "Dimmung_01", "BCM1_Stellgroesse_Kl_58s", getValue( KCAN_BCM1_Stellgroesse_Kl_58s ), profileFile );
    writeProfileInt( "Dimmung_01", "DI_Display_Nachtdesign", getValue( KCAN_DI_Display_Nachtdesign ), profileFile );
    writeProfileInt( "Dimmung_01", "DI_Fotosensor", getValue( KCAN_DI_Fotosensor ), profileFile );
    writeProfileInt( "Dimmung_01", "DI_KL_58xd", getValue( KCAN_DI_KL_58xd ), profileFile );
    writeProfileInt( "Dimmung_01", "DI_KL_58xs", getValue( KCAN_DI_KL_58xs ), profileFile );
    writeProfileInt( "Dimmung_01", "DI_KL_58xt", getValue( KCAN_DI_KL_58xt ), profileFile );

}


void saveSettings_DispKBI_FS_01( char profileFile[] )
{
    writeProfileInt( "DispKBI_FS_01", "DispKBI_FS_Systemstatus", getValue( KCAN_DispKBI_FS_Systemstatus ), profileFile );

}


void saveSettings_DispKBI_FS_DispPos_Req_FD( char profileFile[] )
{

}


void saveSettings_DispKBI_FS_DispPos_Resp_FD( char profileFile[] )
{

}


void saveSettings_Display_1_03( char profileFile[] )
{
    writeProfileInt( "Display_1_03", "DU1_Fehlerstatus", getValue( KCAN_DU1_Fehlerstatus ), profileFile );
    writeProfileInt( "Display_1_03", "DU1_HWR_Fehlerstatus", getValue( KCAN_DU1_HWR_Fehlerstatus ), profileFile );
    writeProfileInt( "Display_1_03", "DU1_KS_aktiv_anderer_Grund", getValue( KCAN_DU1_KS_aktiv_anderer_Grund ), profileFile );
    writeProfileInt( "Display_1_03", "DU1_KS_aktiv_falsche_Auth", getValue( KCAN_DU1_KS_aktiv_falsche_Auth ), profileFile );
    writeProfileInt( "Display_1_03", "DU1_KS_aktiv_Manipulationsschutz", getValue( KCAN_DU1_KS_aktiv_Manipulationsschutz ), profileFile );
    writeProfileInt( "Display_1_03", "DU1_KS_FIS_unplausibel", getValue( KCAN_DU1_KS_FIS_unplausibel ), profileFile );
    writeProfileInt( "Display_1_03", "DU1_KS_keine_Grundeinstellung", getValue( KCAN_DU1_KS_keine_Grundeinstellung ), profileFile );
    writeProfileInt( "Display_1_03", "DU1_KS_SHE_keine_Grundeinst", getValue( KCAN_DU1_KS_SHE_keine_Grundeinst ), profileFile );
    writeProfileInt( "Display_1_03", "DU1_Slider_Locked", getValue( KCAN_DU1_Slider_Locked ), profileFile );
    writeProfileInt( "Display_1_03", "DU1_Touchstatus", getValue( KCAN_DU1_Touchstatus ), profileFile );

}


void saveSettings_DispPos_DispKBI_FS_Req_FD( char profileFile[] )
{

}


void saveSettings_DispPos_DispKBI_FS_Resp_FD( char profileFile[] )
{

}


void saveSettings_EA_02( char profileFile[] )
{
    writeProfileInt( "EA_02", "ACF_Lampe_Hands_Off", getValue( KCAN_ACF_Lampe_Hands_Off ), profileFile );
    writeProfileInt( "EA_02", "EA_02_BZ", getValue( KCAN_EA_02_BZ ), profileFile );
    writeProfileInt( "EA_02", "EA_02_CRC", getValue( KCAN_EA_02_CRC ), profileFile );
    writeProfileInt( "EA_02", "EA_Blinken", getValue( KCAN_EA_Blinken ), profileFile );
    writeProfileInt( "EA_02", "EA_Bremslichtblinken", getValue( KCAN_EA_Bremslichtblinken ), profileFile );
    writeProfileInt( "EA_02", "EA_eCall_Anf", getValue( KCAN_EA_eCall_Anf ), profileFile );
    writeProfileInt( "EA_02", "EA_Fahrzeughupe_Anf", getValue( KCAN_EA_Fahrzeughupe_Anf ), profileFile );
    writeProfileInt( "EA_02", "EA_Infotainment_Anf", getValue( KCAN_EA_Infotainment_Anf ), profileFile );
    writeProfileInt( "EA_02", "EA_Innenraumlicht_Anf", getValue( KCAN_EA_Innenraumlicht_Anf ), profileFile );
    writeProfileInt( "EA_02", "EA_Texte", getValue( KCAN_EA_Texte ), profileFile );
    writeProfileInt( "EA_02", "EA_Tueren_Anf", getValue( KCAN_EA_Tueren_Anf ), profileFile );
    writeProfileInt( "EA_02", "EA_Warnlevel", getValue( KCAN_EA_Warnlevel ), profileFile );
    writeProfileInt( "EA_02", "STP_Primaeranz", getValue( KCAN_STP_Primaeranz ), profileFile );
    writeProfileInt( "EA_02", "zFAS_Warnblinken", getValue( KCAN_zFAS_Warnblinken ), profileFile );

}


void saveSettings_ELV_01( char profileFile[] )
{
    writeProfileInt( "ELV_01", "ELV_01_BZ", getValue( KCAN_ELV_01_BZ ), profileFile );
    writeProfileInt( "ELV_01", "ELV_01_CRC", getValue( KCAN_ELV_01_CRC ), profileFile );
    writeProfileInt( "ELV_01", "ELV_01_Sendestatus", getValue( KCAN_ELV_01_Sendestatus ), profileFile );
    writeProfileInt( "ELV_01", "ELV_Abbruch_Anf_Klemmenfreigabe", getValue( KCAN_ELV_Abbruch_Anf_Klemmenfreigabe ), profileFile );
    writeProfileInt( "ELV_01", "ELV_Anf_Klemme_15", getValue( KCAN_ELV_Anf_Klemme_15 ), profileFile );
    writeProfileInt( "ELV_01", "ELV_Anf_Klemme_50", getValue( KCAN_ELV_Anf_Klemme_50 ), profileFile );
    writeProfileInt( "ELV_01", "ELV_Anf_Klemme_S", getValue( KCAN_ELV_Anf_Klemme_S ), profileFile );
    writeProfileInt( "ELV_01", "ELV_Anlernmodus", getValue( KCAN_ELV_Anlernmodus ), profileFile );
    writeProfileInt( "ELV_01", "ELV_Entriegelt", getValue( KCAN_ELV_Entriegelt ), profileFile );
    writeProfileInt( "ELV_01", "ELV_Klemmenfreigabe", getValue( KCAN_ELV_Klemmenfreigabe ), profileFile );
    writeProfileInt( "ELV_01", "ELV_Lebenszustand", getValue( KCAN_ELV_Lebenszustand ), profileFile );
    writeProfileInt( "ELV_01", "ELV_LED_Gelb", getValue( KCAN_ELV_LED_Gelb ), profileFile );
    writeProfileInt( "ELV_01", "ELV_LED_Rot", getValue( KCAN_ELV_LED_Rot ), profileFile );
    writeProfileInt( "ELV_01", "ELV_P_verriegelt", getValue( KCAN_ELV_P_verriegelt ), profileFile );
    writeProfileInt( "ELV_01", "ELV_Txt_Bremse", getValue( KCAN_ELV_Txt_Bremse ), profileFile );
    writeProfileInt( "ELV_01", "ELV_Txt_Defekt", getValue( KCAN_ELV_Txt_Defekt ), profileFile );
    writeProfileInt( "ELV_01", "ELV_Txt_Kupplung", getValue( KCAN_ELV_Txt_Kupplung ), profileFile );
    writeProfileInt( "ELV_01", "ELV_Txt_Lkg_Bewegen", getValue( KCAN_ELV_Txt_Lkg_Bewegen ), profileFile );
    writeProfileInt( "ELV_01", "ELV_Txt_P_Gang", getValue( KCAN_ELV_Txt_P_Gang ), profileFile );
    writeProfileInt( "ELV_01", "ELV_Txt_Panikabschaltung", getValue( KCAN_ELV_Txt_Panikabschaltung ), profileFile );
    writeProfileInt( "ELV_01", "ELV_Txt_PN_Gang", getValue( KCAN_ELV_Txt_PN_Gang ), profileFile );
    writeProfileInt( "ELV_01", "ELV_Txt_Werkstatt", getValue( KCAN_ELV_Txt_Werkstatt ), profileFile );
    writeProfileInt( "ELV_01", "ELV_Verriegelt", getValue( KCAN_ELV_Verriegelt ), profileFile );
    writeProfileInt( "ELV_01", "ELV_ZAT_betaetigt", getValue( KCAN_ELV_ZAT_betaetigt ), profileFile );
    writeProfileInt( "ELV_01", "KST_Anf_ZV_Verriegelung_ELV_01", getValue( KCAN_KST_Anf_ZV_Verriegelung_ELV_01 ), profileFile );
    writeProfileInt( "ELV_01", "KST_aut_Abschaltung_Zuendung_ELV_01", getValue( KCAN_KST_aut_Abschaltung_Zuendung_ELV_01 ), profileFile );
    writeProfileInt( "ELV_01", "KST_Txt_Komfortabschaltung_ELV_01", getValue( KCAN_KST_Txt_Komfortabschaltung_ELV_01 ), profileFile );
    writeProfileInt( "ELV_01", "KST_Unterdr_Zuendungsmeldung_ELV_01", getValue( KCAN_KST_Unterdr_Zuendungsmeldung_ELV_01 ), profileFile );

}


void saveSettings_EML_06( char profileFile[] )
{
    writeProfileInt( "EML_06", "EML_06_BZ", getValue( KCAN_EML_06_BZ ), profileFile );
    writeProfileInt( "EML_06", "EML_06_CRC", getValue( KCAN_EML_06_CRC ), profileFile );
    writeProfileFloat( "EML_06", "EML_AnzeigeGeschw_EML_06", getValue( KCAN_EML_AnzeigeGeschw_EML_06 ), profileFile );
    writeProfileFloat( "EML_06", "EML_BeschlX", getValue( KCAN_EML_BeschlX ), profileFile );
    writeProfileInt( "EML_06", "EML_BeschlXCF", getValue( KCAN_EML_BeschlXCF ), profileFile );
    writeProfileFloat( "EML_06", "EML_BeschlY", getValue( KCAN_EML_BeschlY ), profileFile );
    writeProfileInt( "EML_06", "EML_BeschlYCF", getValue( KCAN_EML_BeschlYCF ), profileFile );
    writeProfileInt( "EML_06", "EML_Fahrtrichtungswahrsch", getValue( KCAN_EML_Fahrtrichtungswahrsch ), profileFile );
    writeProfileInt( "EML_06", "EML_Fahrwerksregeleingriff", getValue( KCAN_EML_Fahrwerksregeleingriff ), profileFile );
    writeProfileFloat( "EML_06", "EML_GeschwX", getValue( KCAN_EML_GeschwX ), profileFile );
    writeProfileFloat( "EML_06", "EML_GeschwXStdA", getValue( KCAN_EML_GeschwXStdA ), profileFile );
    writeProfileFloat( "EML_06", "EML_GierRate", getValue( KCAN_EML_GierRate ), profileFile );
    writeProfileInt( "EML_06", "EML_GierRateCF", getValue( KCAN_EML_GierRateCF ), profileFile );
    writeProfileFloat( "EML_06", "EML_GierRateStdA", getValue( KCAN_EML_GierRateStdA ), profileFile );
    writeProfileFloat( "EML_06", "EML_Gierwinkel", getValue( KCAN_EML_Gierwinkel ), profileFile );
    writeProfileInt( "EML_06", "EML_GierwinkelCF", getValue( KCAN_EML_GierwinkelCF ), profileFile );
    writeProfileFloat( "EML_06", "EML_GierwinkelStdA", getValue( KCAN_EML_GierwinkelStdA ), profileFile );
    writeProfileFloat( "EML_06", "EML_Hoehe2USK", getValue( KCAN_EML_Hoehe2USK ), profileFile );
    writeProfileFloat( "EML_06", "EML_Hoehe2USKStdA", getValue( KCAN_EML_Hoehe2USKStdA ), profileFile );
    writeProfileInt( "EML_06", "EML_Hoehe_Nick_Wankwinkel2USKCF", getValue( KCAN_EML_Hoehe_Nick_Wankwinkel2USKCF ), profileFile );
    writeProfileFloat( "EML_06", "EML_Kurvenkruemmung", getValue( KCAN_EML_Kurvenkruemmung ), profileFile );
    writeProfileFloat( "EML_06", "EML_LenkWnklVL", getValue( KCAN_EML_LenkWnklVL ), profileFile );
    writeProfileFloat( "EML_06", "EML_LenkWnklVR", getValue( KCAN_EML_LenkWnklVR ), profileFile );
    writeProfileFloat( "EML_06", "EML_MessZeitpunkt", getValue( KCAN_EML_MessZeitpunkt ), profileFile );
    writeProfileFloat( "EML_06", "EML_Nickwinkel", getValue( KCAN_EML_Nickwinkel ), profileFile );
    writeProfileFloat( "EML_06", "EML_Nickwinkel2USK", getValue( KCAN_EML_Nickwinkel2USK ), profileFile );
    writeProfileFloat( "EML_06", "EML_Nickwinkel2USKStdA", getValue( KCAN_EML_Nickwinkel2USKStdA ), profileFile );
    writeProfileInt( "EML_06", "EML_Pose_Qualifier", getValue( KCAN_EML_Pose_Qualifier ), profileFile );
    writeProfileInt( "EML_06", "EML_PositionCF", getValue( KCAN_EML_PositionCF ), profileFile );
    writeProfileFloat( "EML_06", "EML_PositionX", getValue( KCAN_EML_PositionX ), profileFile );
    writeProfileFloat( "EML_06", "EML_PositionXStdA", getValue( KCAN_EML_PositionXStdA ), profileFile );
    writeProfileFloat( "EML_06", "EML_PositionY", getValue( KCAN_EML_PositionY ), profileFile );
    writeProfileFloat( "EML_06", "EML_PositionYStdA", getValue( KCAN_EML_PositionYStdA ), profileFile );
    writeProfileInt( "EML_06", "EML_QBit_Anzeigegeschw_EML_06", getValue( KCAN_EML_QBit_Anzeigegeschw_EML_06 ), profileFile );
    writeProfileInt( "EML_06", "EML_QBit_Fahrtrichtungswahrsch", getValue( KCAN_EML_QBit_Fahrtrichtungswahrsch ), profileFile );
    writeProfileInt( "EML_06", "EML_QBit_Kurvenkruemmung", getValue( KCAN_EML_QBit_Kurvenkruemmung ), profileFile );
    writeProfileInt( "EML_06", "EML_QBit_Nickwinkel", getValue( KCAN_EML_QBit_Nickwinkel ), profileFile );
    writeProfileInt( "EML_06", "EML_QBit_Stillstandswahrsch", getValue( KCAN_EML_QBit_Stillstandswahrsch ), profileFile );
    writeProfileInt( "EML_06", "EML_Stillstandswahrsch", getValue( KCAN_EML_Stillstandswahrsch ), profileFile );
    writeProfileFloat( "EML_06", "EML_Wankwinkel2USK", getValue( KCAN_EML_Wankwinkel2USK ), profileFile );
    writeProfileFloat( "EML_06", "EML_Wankwinkel2USKStdA", getValue( KCAN_EML_Wankwinkel2USKStdA ), profileFile );

}


void saveSettings_EML_07( char profileFile[] )
{
    writeProfileFloat( "EML_07", "EML_AnzeigeGeschw", getValue( KCAN_EML_AnzeigeGeschw ), profileFile );
    writeProfileInt( "EML_07", "EML_QBit_Anzeigegeschw_EML_07", getValue( KCAN_EML_QBit_Anzeigegeschw_EML_07 ), profileFile );

}


void saveSettings_Entfernungen_01( char profileFile[] )
{
    writeProfileInt( "Entfernungen_01", "KBI_Kilometerstand_Extended", getValue( KCAN_KBI_Kilometerstand_Extended ), profileFile );

}


void saveSettings_EPB_03( char profileFile[] )
{
    writeProfileInt( "EPB_03", "EPB_03_BZ", getValue( KCAN_EPB_03_BZ ), profileFile );
    writeProfileInt( "EPB_03", "EPB_03_CRC", getValue( KCAN_EPB_03_CRC ), profileFile );
    writeProfileInt( "EPB_03", "EPB_Autohold_Standbyanzeige", getValue( KCAN_EPB_Autohold_Standbyanzeige ), profileFile );
    writeProfileInt( "EPB_03", "EPB_Autoholdlampe_02", getValue( KCAN_EPB_Autoholdlampe_02 ), profileFile );
    writeProfileInt( "EPB_03", "EPB_Fehlermeldungen_02", getValue( KCAN_EPB_Fehlermeldungen_02 ), profileFile );
    writeProfileInt( "EPB_03", "EPB_Funktionslampe_02", getValue( KCAN_EPB_Funktionslampe_02 ), profileFile );
    writeProfileInt( "EPB_03", "EPB_Parkanzeige", getValue( KCAN_EPB_Parkanzeige ), profileFile );
    writeProfileInt( "EPB_03", "EPB_Texte_02", getValue( KCAN_EPB_Texte_02 ), profileFile );

}


void saveSettings_ESC_50( char profileFile[] )
{
    writeProfileInt( "ESC_50", "ECD_Bremslicht_ESC_50", getValue( KCAN_ECD_Bremslicht_ESC_50 ), profileFile );
    writeProfileInt( "ESC_50", "ECD_Fehler", getValue( KCAN_ECD_Fehler ), profileFile );
    writeProfileInt( "ESC_50", "ECD_nicht_verfuegbar", getValue( KCAN_ECD_nicht_verfuegbar ), profileFile );
    writeProfileInt( "ESC_50", "EPB_DAA_Randbed_erf", getValue( KCAN_EPB_DAA_Randbed_erf ), profileFile );
    writeProfileInt( "ESC_50", "EPB_Fehlerstatus_02", getValue( KCAN_EPB_Fehlerstatus_02 ), profileFile );
    writeProfileInt( "ESC_50", "EPB_Freig_Verzoeg_Anf", getValue( KCAN_EPB_Freig_Verzoeg_Anf ), profileFile );
    writeProfileFloat( "ESC_50", "EPB_Pedalweg_Kuppl_ESC_50", getValue( KCAN_EPB_Pedalweg_Kuppl_ESC_50 ), profileFile );
    writeProfileInt( "ESC_50", "EPB_QBit_Pedalweg_Kuppl_ESC_50", getValue( KCAN_EPB_QBit_Pedalweg_Kuppl_ESC_50 ), profileFile );
    writeProfileInt( "ESC_50", "EPB_QBit_Schalterpos", getValue( KCAN_EPB_QBit_Schalterpos ), profileFile );
    writeProfileInt( "ESC_50", "EPB_Schalterposition", getValue( KCAN_EPB_Schalterposition ), profileFile );
    writeProfileInt( "ESC_50", "EPB_Spannkraft", getValue( KCAN_EPB_Spannkraft ), profileFile );
    writeProfileInt( "ESC_50", "EPB_Status", getValue( KCAN_EPB_Status ), profileFile );
    writeProfileInt( "ESC_50", "EPB_Status_02_ESC_50", getValue( KCAN_EPB_Status_02_ESC_50 ), profileFile );
    writeProfileFloat( "ESC_50", "EPB_Verzoeg_Anf", getValue( KCAN_EPB_Verzoeg_Anf ), profileFile );
    writeProfileInt( "ESC_50", "ESC_50_BZ", getValue( KCAN_ESC_50_BZ ), profileFile );
    writeProfileInt( "ESC_50", "ESC_50_CRC", getValue( KCAN_ESC_50_CRC ), profileFile );
    writeProfileInt( "ESC_50", "ESC_Bremsdruckgradient", getValue( KCAN_ESC_Bremsdruckgradient ), profileFile );
    writeProfileFloat( "ESC_50", "ESC_Fahrerbremswunsch", getValue( KCAN_ESC_Fahrerbremswunsch ), profileFile );
    writeProfileInt( "ESC_50", "ESC_Hydr_Fkt_aktiv", getValue( KCAN_ESC_Hydr_Fkt_aktiv ), profileFile );
    writeProfileInt( "ESC_50", "ESC_Motorstartverzoegerung", getValue( KCAN_ESC_Motorstartverzoegerung ), profileFile );
    writeProfileInt( "ESC_50", "ESC_QBit_Fahrerbremswunsch", getValue( KCAN_ESC_QBit_Fahrerbremswunsch ), profileFile );
    writeProfileInt( "ESC_50", "ESC_Raddruck_max", getValue( KCAN_ESC_Raddruck_max ), profileFile );
    writeProfileInt( "ESC_50", "ESC_SeitenwindAssistent_Eingriff", getValue( KCAN_ESC_SeitenwindAssistent_Eingriff ), profileFile );
    writeProfileInt( "ESC_50", "ESC_Unterdruckmangel_erkannt", getValue( KCAN_ESC_Unterdruckmangel_erkannt ), profileFile );
    writeProfileInt( "ESC_50", "ESCGeneratorSollMoment", getValue( KCAN_ESCGeneratorSollMoment ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Abrutschen_Stillstand", getValue( KCAN_ESP_Abrutschen_Stillstand ), profileFile );
    writeProfileInt( "ESC_50", "ESP_ANB_CM_Rueckk_Umsetz", getValue( KCAN_ESP_ANB_CM_Rueckk_Umsetz ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Anforderung_EPB", getValue( KCAN_ESP_Anforderung_EPB ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Anschleppstart_Freigabe", getValue( KCAN_ESP_Anschleppstart_Freigabe ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Autohold_aktiv", getValue( KCAN_ESP_Autohold_aktiv ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Autohold_Standby", getValue( KCAN_ESP_Autohold_Standby ), profileFile );
    writeProfileInt( "ESC_50", "ESP_BKV_Unterdruck", getValue( KCAN_ESP_BKV_Unterdruck ), profileFile );
    writeProfileFloat( "ESC_50", "ESP_Bremsdruck", getValue( KCAN_ESP_Bremsdruck ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Bremsruck_AWV2", getValue( KCAN_ESP_Bremsruck_AWV2 ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Eingr_HL", getValue( KCAN_ESP_Eingr_HL ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Eingr_HR", getValue( KCAN_ESP_Eingr_HR ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Eingr_VL", getValue( KCAN_ESP_Eingr_VL ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Eingr_VR", getValue( KCAN_ESP_Eingr_VR ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Fahrer_bremst", getValue( KCAN_ESP_Fahrer_bremst ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Fahrer_tritt_ZBR_Schw", getValue( KCAN_ESP_Fahrer_tritt_ZBR_Schw ), profileFile );
    writeProfileInt( "ESC_50", "ESP_FStatus_Anfahrhilfe", getValue( KCAN_ESP_FStatus_Anfahrhilfe ), profileFile );
    writeProfileFloat( "ESC_50", "ESP_Gierrate", getValue( KCAN_ESP_Gierrate ), profileFile );
    writeProfileInt( "ESC_50", "ESP_HBA_aktiv", getValue( KCAN_ESP_HBA_aktiv ), profileFile );
    writeProfileInt( "ESC_50", "ESP_HDC_aktiv", getValue( KCAN_ESP_HDC_aktiv ), profileFile );
    writeProfileInt( "ESC_50", "ESP_HDC_Standby_ESC_50", getValue( KCAN_ESP_HDC_Standby_ESC_50 ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Konsistenz_ACC_Botschaft", getValue( KCAN_ESP_Konsistenz_ACC_Botschaft ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Konsistenz_AWV2", getValue( KCAN_ESP_Konsistenz_AWV2 ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Konsistenz_TSK", getValue( KCAN_ESP_Konsistenz_TSK ), profileFile );
    writeProfileFloat( "ESC_50", "ESP_Laengsbeschl", getValue( KCAN_ESP_Laengsbeschl ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Lenkeingriff_ADS", getValue( KCAN_ESP_Lenkeingriff_ADS ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Notbremsanzeige", getValue( KCAN_ESP_Notbremsanzeige ), profileFile );
    writeProfileInt( "ESC_50", "ESP_PLA_Abbruch", getValue( KCAN_ESP_PLA_Abbruch ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Prefill_ausgeloest", getValue( KCAN_ESP_Prefill_ausgeloest ), profileFile );
    writeProfileInt( "ESC_50", "ESP_QBit_Bremsdruck", getValue( KCAN_ESP_QBit_Bremsdruck ), profileFile );
    writeProfileInt( "ESC_50", "ESP_QBit_Fahrer_bremst", getValue( KCAN_ESP_QBit_Fahrer_bremst ), profileFile );
    writeProfileInt( "ESC_50", "ESP_QBit_Gierrate", getValue( KCAN_ESP_QBit_Gierrate ), profileFile );
    writeProfileInt( "ESC_50", "ESP_QBit_Laengsbeschl", getValue( KCAN_ESP_QBit_Laengsbeschl ), profileFile );
    writeProfileInt( "ESC_50", "ESP_QBit_Querb", getValue( KCAN_ESP_QBit_Querb ), profileFile );
    writeProfileInt( "ESC_50", "ESP_QBit_v_ref", getValue( KCAN_ESP_QBit_v_ref ), profileFile );
    writeProfileFloat( "ESC_50", "ESP_Querbeschleunigung", getValue( KCAN_ESP_Querbeschleunigung ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Rueckwaertsfahrt_erkannt", getValue( KCAN_ESP_Rueckwaertsfahrt_erkannt ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Schwelle_Unterdruck", getValue( KCAN_ESP_Schwelle_Unterdruck ), profileFile );
    writeProfileInt( "ESC_50", "ESP_SpannungsAnf", getValue( KCAN_ESP_SpannungsAnf ), profileFile );
    writeProfileInt( "ESC_50", "ESP_StartStopp_Info", getValue( KCAN_ESP_StartStopp_Info ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Status_Anfahrhilfe", getValue( KCAN_ESP_Status_Anfahrhilfe ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Status_Bremsdruck", getValue( KCAN_ESP_Status_Bremsdruck ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Status_Bremsentemp", getValue( KCAN_ESP_Status_Bremsentemp ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Status_Bremsentemp_02_ESC_50", getValue( KCAN_ESP_Status_Bremsentemp_02_ESC_50 ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Status_ESP_PLA", getValue( KCAN_ESP_Status_ESP_PLA ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Stillstandsphase_erschoepft", getValue( KCAN_ESP_Stillstandsphase_erschoepft ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Tuerkontakt_Fahrertuer", getValue( KCAN_ESP_Tuerkontakt_Fahrertuer ), profileFile );
    writeProfileFloat( "ESC_50", "ESP_v_ref", getValue( KCAN_ESP_v_ref ), profileFile );
    writeProfileInt( "ESC_50", "ESP_v_ref_Fahrtrichtung", getValue( KCAN_ESP_v_ref_Fahrtrichtung ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Verz_EPB_aktiv", getValue( KCAN_ESP_Verz_EPB_aktiv ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Verz_TSK_aktiv", getValue( KCAN_ESP_Verz_TSK_aktiv ), profileFile );
    writeProfileInt( "ESC_50", "ESP_Verzoeg_EPB_verf", getValue( KCAN_ESP_Verzoeg_EPB_verf ), profileFile );
    writeProfileInt( "ESC_50", "ESP_VZ_Gierrate", getValue( KCAN_ESP_VZ_Gierrate ), profileFile );
    writeProfileInt( "ESC_50", "ESP_ZT_Rueckk_Umsetz", getValue( KCAN_ESP_ZT_Rueckk_Umsetz ), profileFile );

}


void saveSettings_ESC_51( char profileFile[] )
{
    writeProfileInt( "ESC_51", "ESC_51_BZ", getValue( KCAN_ESC_51_BZ ), profileFile );
    writeProfileInt( "ESC_51", "ESC_51_CRC", getValue( KCAN_ESC_51_CRC ), profileFile );
    writeProfileFloat( "ESC_51", "ESC_Achsdrehzahl_Max", getValue( KCAN_ESC_Achsdrehzahl_Max ), profileFile );
    writeProfileFloat( "ESC_51", "ESC_Achsdrehzahl_Max_sek", getValue( KCAN_ESC_Achsdrehzahl_Max_sek ), profileFile );
    writeProfileFloat( "ESC_51", "ESC_Achsdrehzahl_Min", getValue( KCAN_ESC_Achsdrehzahl_Min ), profileFile );
    writeProfileFloat( "ESC_51", "ESC_Achsdrehzahl_Min_sek", getValue( KCAN_ESC_Achsdrehzahl_Min_sek ), profileFile );
    writeProfileInt( "ESC_51", "ESC_aktBr_Modus", getValue( KCAN_ESC_aktBr_Modus ), profileFile );
    writeProfileFloat( "ESC_51", "ESC_aktBr_Volumenstrom", getValue( KCAN_ESC_aktBr_Volumenstrom ), profileFile );
    writeProfileFloat( "ESC_51", "ESC_Allrad_Anteil_max_sek", getValue( KCAN_ESC_Allrad_Anteil_max_sek ), profileFile );
    writeProfileFloat( "ESC_51", "ESC_Allrad_Anteil_min_sek", getValue( KCAN_ESC_Allrad_Anteil_min_sek ), profileFile );
    writeProfileInt( "ESC_51", "ESC_Allradverteilung_aktiv", getValue( KCAN_ESC_Allradverteilung_aktiv ), profileFile );
    writeProfileInt( "ESC_51", "ESC_Anf_Mindestreku", getValue( KCAN_ESC_Anf_Mindestreku ), profileFile );
    writeProfileFloat( "ESC_51", "ESC_Blending_Solldruck", getValue( KCAN_ESC_Blending_Solldruck ), profileFile );
    writeProfileFloat( "ESC_51", "ESC_Bremsdruck_02", getValue( KCAN_ESC_Bremsdruck_02 ), profileFile );
    writeProfileFloat( "ESC_51", "ESC_Bremsdruck_Modell", getValue( KCAN_ESC_Bremsdruck_Modell ), profileFile );
    writeProfileInt( "ESC_51", "ESC_EBKV_Kraftblending_Modus", getValue( KCAN_ESC_EBKV_Kraftblending_Modus ), profileFile );
    writeProfileInt( "ESC_51", "ESC_GMV_aktiv", getValue( KCAN_ESC_GMV_aktiv ), profileFile );
    writeProfileInt( "ESC_51", "ESC_GMV_nicht_verfuegbar", getValue( KCAN_ESC_GMV_nicht_verfuegbar ), profileFile );
    writeProfileInt( "ESC_51", "ESC_MomRad_Eingriff", getValue( KCAN_ESC_MomRad_Eingriff ), profileFile );
    writeProfileInt( "ESC_51", "ESC_MomRad_Eingriff_sek", getValue( KCAN_ESC_MomRad_Eingriff_sek ), profileFile );
    writeProfileInt( "ESC_51", "ESC_QBit_Bremsdruck_02", getValue( KCAN_ESC_QBit_Bremsdruck_02 ), profileFile );
    writeProfileInt( "ESC_51", "ESC_Status_Eingriff", getValue( KCAN_ESC_Status_Eingriff ), profileFile );
    writeProfileInt( "ESC_51", "ESC_Status_Eingriff_sek", getValue( KCAN_ESC_Status_Eingriff_sek ), profileFile );
    writeProfileInt( "ESC_51", "ESC_Status_vRef_Stuetzeingriff", getValue( KCAN_ESC_Status_vRef_Stuetzeingriff ), profileFile );
    writeProfileFloat( "ESC_51", "ESP_FDR_uebersteuern", getValue( KCAN_ESP_FDR_uebersteuern ), profileFile );
    writeProfileFloat( "ESC_51", "ESP_FDR_untersteuern", getValue( KCAN_ESP_FDR_untersteuern ), profileFile );
    writeProfileFloat( "ESC_51", "ESP_FZR_uebersteuern", getValue( KCAN_ESP_FZR_uebersteuern ), profileFile );
    writeProfileFloat( "ESC_51", "ESP_FZR_untersteuern", getValue( KCAN_ESP_FZR_untersteuern ), profileFile );
    writeProfileInt( "ESC_51", "ESP_HL_Bremsmoment", getValue( KCAN_ESP_HL_Bremsmoment ), profileFile );
    writeProfileFloat( "ESC_51", "ESP_HL_Radgeschw_02", getValue( KCAN_ESP_HL_Radgeschw_02 ), profileFile );
    writeProfileInt( "ESC_51", "ESP_HR_Bremsmoment", getValue( KCAN_ESP_HR_Bremsmoment ), profileFile );
    writeProfileFloat( "ESC_51", "ESP_HR_Radgeschw_02", getValue( KCAN_ESP_HR_Radgeschw_02 ), profileFile );
    writeProfileInt( "ESC_51", "ESP_VL_Bremsmoment", getValue( KCAN_ESP_VL_Bremsmoment ), profileFile );
    writeProfileFloat( "ESC_51", "ESP_VL_Radgeschw_02", getValue( KCAN_ESP_VL_Radgeschw_02 ), profileFile );
    writeProfileInt( "ESC_51", "ESP_VR_Bremsmoment", getValue( KCAN_ESP_VR_Bremsmoment ), profileFile );
    writeProfileFloat( "ESC_51", "ESP_VR_Radgeschw_02", getValue( KCAN_ESP_VR_Radgeschw_02 ), profileFile );
    writeProfileInt( "ESC_51", "FDR_Allradverteilung_aktiv", getValue( KCAN_FDR_Allradverteilung_aktiv ), profileFile );
    writeProfileInt( "ESC_51", "FDR_Anf_Allradbetrieb", getValue( KCAN_FDR_Anf_Allradbetrieb ), profileFile );
    writeProfileInt( "ESC_51", "TSMomBegrenzung", getValue( KCAN_TSMomBegrenzung ), profileFile );

}


void saveSettings_ESP_10( char profileFile[] )
{
    writeProfileInt( "ESP_10", "ESP_10_BZ", getValue( KCAN_ESP_10_BZ ), profileFile );
    writeProfileInt( "ESP_10", "ESP_10_CRC", getValue( KCAN_ESP_10_CRC ), profileFile );
    writeProfileInt( "ESP_10", "ESP_HL_Fahrtrichtung", getValue( KCAN_ESP_HL_Fahrtrichtung ), profileFile );
    writeProfileInt( "ESP_10", "ESP_HR_Fahrtrichtung", getValue( KCAN_ESP_HR_Fahrtrichtung ), profileFile );
    writeProfileInt( "ESP_10", "ESP_QBit_Wegimpuls_HL", getValue( KCAN_ESP_QBit_Wegimpuls_HL ), profileFile );
    writeProfileInt( "ESP_10", "ESP_QBit_Wegimpuls_HR", getValue( KCAN_ESP_QBit_Wegimpuls_HR ), profileFile );
    writeProfileInt( "ESP_10", "ESP_QBit_Wegimpuls_VL", getValue( KCAN_ESP_QBit_Wegimpuls_VL ), profileFile );
    writeProfileInt( "ESP_10", "ESP_QBit_Wegimpuls_VR", getValue( KCAN_ESP_QBit_Wegimpuls_VR ), profileFile );
    writeProfileInt( "ESP_10", "ESP_VL_Fahrtrichtung", getValue( KCAN_ESP_VL_Fahrtrichtung ), profileFile );
    writeProfileInt( "ESP_10", "ESP_VR_Fahrtrichtung", getValue( KCAN_ESP_VR_Fahrtrichtung ), profileFile );
    writeProfileInt( "ESP_10", "ESP_Wegimpuls_HL", getValue( KCAN_ESP_Wegimpuls_HL ), profileFile );
    writeProfileInt( "ESP_10", "ESP_Wegimpuls_HR", getValue( KCAN_ESP_Wegimpuls_HR ), profileFile );
    writeProfileInt( "ESP_10", "ESP_Wegimpuls_VL", getValue( KCAN_ESP_Wegimpuls_VL ), profileFile );
    writeProfileInt( "ESP_10", "ESP_Wegimpuls_VR", getValue( KCAN_ESP_Wegimpuls_VR ), profileFile );

}


void saveSettings_ESP_20( char profileFile[] )
{
    writeProfileInt( "ESP_20", "BR_QBit_Reifenumfang", getValue( KCAN_BR_QBit_Reifenumfang ), profileFile );
    writeProfileInt( "ESP_20", "BR_Reifenumfang", getValue( KCAN_BR_Reifenumfang ), profileFile );
    writeProfileInt( "ESP_20", "BR_Systemart", getValue( KCAN_BR_Systemart ), profileFile );
    writeProfileInt( "ESP_20", "ESP_20_BZ", getValue( KCAN_ESP_20_BZ ), profileFile );
    writeProfileInt( "ESP_20", "ESP_20_CRC", getValue( KCAN_ESP_20_CRC ), profileFile );
    writeProfileInt( "ESP_20", "ESP_Charisma_FahrPr", getValue( KCAN_ESP_Charisma_FahrPr ), profileFile );
    writeProfileInt( "ESP_20", "ESP_Charisma_Status", getValue( KCAN_ESP_Charisma_Status ), profileFile );
    writeProfileInt( "ESP_20", "ESP_Dachrelingsensor", getValue( KCAN_ESP_Dachrelingsensor ), profileFile );
    writeProfileInt( "ESP_20", "ESP_SpannungsAnf_02", getValue( KCAN_ESP_SpannungsAnf_02 ), profileFile );
    writeProfileInt( "ESP_20", "ESP_Stoppverbot_Anz_01", getValue( KCAN_ESP_Stoppverbot_Anz_01 ), profileFile );
    writeProfileInt( "ESP_20", "ESP_Stoppverbot_Anz_02", getValue( KCAN_ESP_Stoppverbot_Anz_02 ), profileFile );
    writeProfileInt( "ESP_20", "ESP_Stoppverbot_Anz_03", getValue( KCAN_ESP_Stoppverbot_Anz_03 ), profileFile );
    writeProfileInt( "ESP_20", "ESP_Stoppverbot_Anz_04", getValue( KCAN_ESP_Stoppverbot_Anz_04 ), profileFile );
    writeProfileInt( "ESP_20", "ESP_Stoppverbot_Anz_05", getValue( KCAN_ESP_Stoppverbot_Anz_05 ), profileFile );
    writeProfileInt( "ESP_20", "ESP_Stoppverbot_Anz_06", getValue( KCAN_ESP_Stoppverbot_Anz_06 ), profileFile );
    writeProfileInt( "ESP_20", "ESP_Stoppverbot_Anz_07", getValue( KCAN_ESP_Stoppverbot_Anz_07 ), profileFile );
    writeProfileInt( "ESP_20", "ESP_Stoppverbot_Anz_08", getValue( KCAN_ESP_Stoppverbot_Anz_08 ), profileFile );
    writeProfileInt( "ESP_20", "ESP_Stoppverbot_Anz_Std", getValue( KCAN_ESP_Stoppverbot_Anz_Std ), profileFile );
    writeProfileInt( "ESP_20", "ESP_Wiederstart_Anz_01", getValue( KCAN_ESP_Wiederstart_Anz_01 ), profileFile );
    writeProfileInt( "ESP_20", "ESP_Wiederstart_Anz_02", getValue( KCAN_ESP_Wiederstart_Anz_02 ), profileFile );
    writeProfileInt( "ESP_20", "ESP_Wiederstart_Anz_03", getValue( KCAN_ESP_Wiederstart_Anz_03 ), profileFile );
    writeProfileInt( "ESP_20", "ESP_Wiederstart_Anz_04", getValue( KCAN_ESP_Wiederstart_Anz_04 ), profileFile );
    writeProfileInt( "ESP_20", "ESP_Zaehnezahl", getValue( KCAN_ESP_Zaehnezahl ), profileFile );
    writeProfileInt( "ESP_20", "HDC_Charisma_FahrPr", getValue( KCAN_HDC_Charisma_FahrPr ), profileFile );
    writeProfileInt( "ESP_20", "HDC_Charisma_Status", getValue( KCAN_HDC_Charisma_Status ), profileFile );

}


void saveSettings_ESP_21( char profileFile[] )
{
    writeProfileInt( "ESP_21", "ABS_Bremsung_ESP_21", getValue( KCAN_ABS_Bremsung_ESP_21 ), profileFile );
    writeProfileInt( "ESP_21", "ASR_Anf", getValue( KCAN_ASR_Anf ), profileFile );
    writeProfileInt( "ESP_21", "ASR_Schalteingriff", getValue( KCAN_ASR_Schalteingriff ), profileFile );
    writeProfileInt( "ESP_21", "ASR_Tastung_passiv", getValue( KCAN_ASR_Tastung_passiv ), profileFile );
    writeProfileInt( "ESP_21", "BR_Eingriffsmoment", getValue( KCAN_BR_Eingriffsmoment ), profileFile );
    writeProfileInt( "ESP_21", "EBV_Eingriff", getValue( KCAN_EBV_Eingriff ), profileFile );
    writeProfileInt( "ESP_21", "EDS_Eingriff", getValue( KCAN_EDS_Eingriff ), profileFile );
    writeProfileInt( "ESP_21", "ESC_Reku_Freigabe", getValue( KCAN_ESC_Reku_Freigabe ), profileFile );
    writeProfileInt( "ESP_21", "ESC_v_Signal_Qualifier_High_Low", getValue( KCAN_ESC_v_Signal_Qualifier_High_Low ), profileFile );
    writeProfileInt( "ESP_21", "ESP_21_BZ", getValue( KCAN_ESP_21_BZ ), profileFile );
    writeProfileInt( "ESP_21", "ESP_21_CRC", getValue( KCAN_ESP_21_CRC ), profileFile );
    writeProfileInt( "ESP_21", "ESP_Anhaltevorgang_ACC_aktiv", getValue( KCAN_ESP_Anhaltevorgang_ACC_aktiv ), profileFile );
    writeProfileInt( "ESP_21", "ESP_ASP", getValue( KCAN_ESP_ASP ), profileFile );
    writeProfileInt( "ESP_21", "ESP_AWV3_Brems_aktiv", getValue( KCAN_ESP_AWV3_Brems_aktiv ), profileFile );
    writeProfileInt( "ESP_21", "ESP_Diagnose", getValue( KCAN_ESP_Diagnose ), profileFile );
    writeProfileInt( "ESP_21", "ESP_Eingriff_ESP_21", getValue( KCAN_ESP_Eingriff_ESP_21 ), profileFile );
    writeProfileInt( "ESP_21", "ESP_Haltebestaetigung", getValue( KCAN_ESP_Haltebestaetigung ), profileFile );
    writeProfileInt( "ESP_21", "ESP_MKB_Abbruch_Geschw_ESP_21", getValue( KCAN_ESP_MKB_Abbruch_Geschw_ESP_21 ), profileFile );
    writeProfileInt( "ESP_21", "ESP_PLA_Bremseingriff", getValue( KCAN_ESP_PLA_Bremseingriff ), profileFile );
    writeProfileInt( "ESP_21", "ESP_QBit_v_Signal", getValue( KCAN_ESP_QBit_v_Signal ), profileFile );
    writeProfileInt( "ESP_21", "ESP_Systemstatus", getValue( KCAN_ESP_Systemstatus ), profileFile );
    writeProfileInt( "ESP_21", "ESP_Tastung_passiv", getValue( KCAN_ESP_Tastung_passiv ), profileFile );
    writeProfileFloat( "ESP_21", "ESP_v_Signal", getValue( KCAN_ESP_v_Signal ), profileFile );
    writeProfileInt( "ESP_21", "ESP_Vorsteuerung", getValue( KCAN_ESP_Vorsteuerung ), profileFile );
    writeProfileInt( "ESP_21", "MSR_Anf", getValue( KCAN_MSR_Anf ), profileFile );
    writeProfileInt( "ESP_21", "OBD_QBit_Schlechtweg", getValue( KCAN_OBD_QBit_Schlechtweg ), profileFile );
    writeProfileInt( "ESP_21", "OBD_Schlechtweg", getValue( KCAN_OBD_Schlechtweg ), profileFile );

}


void saveSettings_ESP_24( char profileFile[] )
{
    writeProfileInt( "ESP_24", "ABS_Lampe", getValue( KCAN_ABS_Lampe ), profileFile );
    writeProfileInt( "ESP_24", "BK_Lampe_02", getValue( KCAN_BK_Lampe_02 ), profileFile );
    writeProfileInt( "ESP_24", "ESP_24_BZ", getValue( KCAN_ESP_24_BZ ), profileFile );
    writeProfileInt( "ESP_24", "ESP_24_CRC", getValue( KCAN_ESP_24_CRC ), profileFile );
    writeProfileInt( "ESP_24", "ESP_BKV_Warnung", getValue( KCAN_ESP_BKV_Warnung ), profileFile );
    writeProfileInt( "ESP_24", "ESP_Fehlerstatus_Wegimp", getValue( KCAN_ESP_Fehlerstatus_Wegimp ), profileFile );
    writeProfileInt( "ESP_24", "ESP_HDC_FktLampe", getValue( KCAN_ESP_HDC_FktLampe ), profileFile );
    writeProfileFloat( "ESP_24", "ESP_HDC_Regelgeschw", getValue( KCAN_ESP_HDC_Regelgeschw ), profileFile );
    writeProfileInt( "ESP_24", "ESP_Lampe", getValue( KCAN_ESP_Lampe ), profileFile );
    writeProfileFloat( "ESP_24", "ESP_m_Raddrehz", getValue( KCAN_ESP_m_Raddrehz ), profileFile );
    writeProfileInt( "ESP_24", "ESP_Meldungen", getValue( KCAN_ESP_Meldungen ), profileFile );
    writeProfileInt( "ESP_24", "ESP_Off_Lampe", getValue( KCAN_ESP_Off_Lampe ), profileFile );
    writeProfileInt( "ESP_24", "ESP_QBit_Wegimp_VA", getValue( KCAN_ESP_QBit_Wegimp_VA ), profileFile );
    writeProfileInt( "ESP_24", "ESP_Textanzeigen_03", getValue( KCAN_ESP_Textanzeigen_03 ), profileFile );
    writeProfileInt( "ESP_24", "ESP_Wegimp_Ueberlauf", getValue( KCAN_ESP_Wegimp_Ueberlauf ), profileFile );
    writeProfileInt( "ESP_24", "ESP_Wegimp_VA", getValue( KCAN_ESP_Wegimp_VA ), profileFile );
    writeProfileInt( "ESP_24", "TC_Lampe", getValue( KCAN_TC_Lampe ), profileFile );

}


void saveSettings_ESP_30( char profileFile[] )
{
    writeProfileInt( "ESP_30", "DBK_Fahrerwarnung", getValue( KCAN_DBK_Fahrerwarnung ), profileFile );
    writeProfileInt( "ESP_30", "EDS_Charisma_FahrPr", getValue( KCAN_EDS_Charisma_FahrPr ), profileFile );
    writeProfileInt( "ESP_30", "EDS_Charisma_Status", getValue( KCAN_EDS_Charisma_Status ), profileFile );
    writeProfileFloat( "ESP_30", "ESC_Anf_KL", getValue( KCAN_ESC_Anf_KL ), profileFile );
    writeProfileInt( "ESP_30", "ESC_Anf_KV", getValue( KCAN_ESC_Anf_KV ), profileFile );
    writeProfileInt( "ESP_30", "ESC_FBA_Meldungen", getValue( KCAN_ESC_FBA_Meldungen ), profileFile );
    writeProfileInt( "ESP_30", "ESC_Lernfreigabe_Abrollumfang", getValue( KCAN_ESC_Lernfreigabe_Abrollumfang ), profileFile );
    writeProfileInt( "ESP_30", "ESC_MBK_Meldungen", getValue( KCAN_ESC_MBK_Meldungen ), profileFile );
    writeProfileInt( "ESP_30", "ESC_Texte_eBKV_Betaetigung", getValue( KCAN_ESC_Texte_eBKV_Betaetigung ), profileFile );
    writeProfileInt( "ESP_30", "ESP_30_BZ", getValue( KCAN_ESP_30_BZ ), profileFile );
    writeProfileInt( "ESP_30", "ESP_30_CRC", getValue( KCAN_ESP_30_CRC ), profileFile );
    writeProfileInt( "ESP_30", "HHC_Charisma_FahrPr", getValue( KCAN_HHC_Charisma_FahrPr ), profileFile );
    writeProfileInt( "ESP_30", "HHC_Charisma_Status", getValue( KCAN_HHC_Charisma_Status ), profileFile );
    writeProfileFloat( "ESP_30", "HMS_EML_Steig_Exkl", getValue( KCAN_HMS_EML_Steig_Exkl ), profileFile );
    writeProfileInt( "ESP_30", "RLE_Anzeigen", getValue( KCAN_RLE_Anzeigen ), profileFile );

}


void saveSettings_FAS_Anzeigen_01( char profileFile[] )
{
    writeProfileInt( "FAS_Anzeigen_01", "KBI_aktive_Laengsfunktion_02", getValue( KCAN_KBI_aktive_Laengsfunktion_02 ), profileFile );
    writeProfileInt( "FAS_Anzeigen_01", "KBI_Anzeigefehler_LDW", getValue( KCAN_KBI_Anzeigefehler_LDW ), profileFile );
    writeProfileInt( "FAS_Anzeigen_01", "KBI_Anzeigestatus_ACC", getValue( KCAN_KBI_Anzeigestatus_ACC ), profileFile );
    writeProfileInt( "FAS_Anzeigen_01", "KBI_Anzeigestatus_GRA", getValue( KCAN_KBI_Anzeigestatus_GRA ), profileFile );
    writeProfileInt( "FAS_Anzeigen_01", "KBI_Anzeigestatus_LIM", getValue( KCAN_KBI_Anzeigestatus_LIM ), profileFile );
    writeProfileInt( "FAS_Anzeigen_01", "KBI_Fehler_Anzeige_ACC", getValue( KCAN_KBI_Fehler_Anzeige_ACC ), profileFile );
    writeProfileInt( "FAS_Anzeigen_01", "KBI_Konsistenz_ACC", getValue( KCAN_KBI_Konsistenz_ACC ), profileFile );

}


void saveSettings_FoD_01( char profileFile[] )
{
    writeProfileInt( "FoD_01", "FoD_Anz_Funktionsabschaltung", getValue( KCAN_FoD_Anz_Funktionsabschaltung ), profileFile );
    writeProfileInt( "FoD_01", "FoD_Transmission_Info", getValue( KCAN_FoD_Transmission_Info ), profileFile );
    writeProfileInt( "FoD_01", "GRA_FoD_Status", getValue( KCAN_GRA_FoD_Status ), profileFile );

}


void saveSettings_FoD_Kombi_Req( char profileFile[] )
{

}


void saveSettings_FoD_Kombi_Resp( char profileFile[] )
{

}


void saveSettings_FoD_ZR_Req( char profileFile[] )
{

}


void saveSettings_FoD_ZR_Resp( char profileFile[] )
{

}


void saveSettings_Gateway_71( char profileFile[] )
{
    writeProfileInt( "Gateway_71", "ABS_Bremsung_Gateway_71", getValue( KCAN_ABS_Bremsung_Gateway_71 ), profileFile );
    writeProfileInt( "Gateway_71", "ECD_Bremslicht_Gateway_71", getValue( KCAN_ECD_Bremslicht_Gateway_71 ), profileFile );
    writeProfileInt( "Gateway_71", "EPB_01_alt", getValue( KCAN_EPB_01_alt ), profileFile );
    writeProfileFloat( "Gateway_71", "EPB_Pedalweg_Kuppl_Gateway_71", getValue( KCAN_EPB_Pedalweg_Kuppl_Gateway_71 ), profileFile );
    writeProfileInt( "Gateway_71", "EPB_QBit_Pedalweg_Kuppl_Gateway_71", getValue( KCAN_EPB_QBit_Pedalweg_Kuppl_Gateway_71 ), profileFile );
    writeProfileInt( "Gateway_71", "EPB_Status_Gateway_71", getValue( KCAN_EPB_Status_Gateway_71 ), profileFile );
    writeProfileInt( "Gateway_71", "ESP_05_alt", getValue( KCAN_ESP_05_alt ), profileFile );
    writeProfileInt( "Gateway_71", "ESP_21_alt", getValue( KCAN_ESP_21_alt ), profileFile );
    writeProfileInt( "Gateway_71", "ESP_Eingriff_Gateway_71", getValue( KCAN_ESP_Eingriff_Gateway_71 ), profileFile );
    writeProfileInt( "Gateway_71", "ESP_HDC_Standby_Gateway_71", getValue( KCAN_ESP_HDC_Standby_Gateway_71 ), profileFile );
    writeProfileInt( "Gateway_71", "ESP_MKB_Abbruch_Geschw_Gateway_71", getValue( KCAN_ESP_MKB_Abbruch_Geschw_Gateway_71 ), profileFile );
    writeProfileInt( "Gateway_71", "ESP_QBit_v_Signal_Gateway_71", getValue( KCAN_ESP_QBit_v_Signal_Gateway_71 ), profileFile );
    writeProfileFloat( "Gateway_71", "ESP_v_Signal_Gateway_71", getValue( KCAN_ESP_v_Signal_Gateway_71 ), profileFile );
    writeProfileInt( "Gateway_71", "Kamera_FSH_aktiv", getValue( KCAN_Kamera_FSH_aktiv ), profileFile );
    writeProfileInt( "Gateway_71", "Kamera_Status_alt", getValue( KCAN_Kamera_Status_alt ), profileFile );
    writeProfileInt( "Gateway_71", "LWI_01_alt", getValue( KCAN_LWI_01_alt ), profileFile );
    writeProfileFloat( "Gateway_71", "LWI_Lenkradwinkel_Gateway_71", getValue( KCAN_LWI_Lenkradwinkel_Gateway_71 ), profileFile );
    writeProfileInt( "Gateway_71", "LWI_QBit_Lenkradwinkel_Gateway_71", getValue( KCAN_LWI_QBit_Lenkradwinkel_Gateway_71 ), profileFile );
    writeProfileInt( "Gateway_71", "LWI_Sensorstatus_Gateway_71", getValue( KCAN_LWI_Sensorstatus_Gateway_71 ), profileFile );
    writeProfileInt( "Gateway_71", "LWI_VZ_Lenkradwinkel_Gateway_71", getValue( KCAN_LWI_VZ_Lenkradwinkel_Gateway_71 ), profileFile );
    writeProfileInt( "Gateway_71", "Parkhilfe_01_alt", getValue( KCAN_Parkhilfe_01_alt ), profileFile );
    writeProfileInt( "Gateway_71", "PH_Anf_Audioabsenkung_Gateway_71", getValue( KCAN_PH_Anf_Audioabsenkung_Gateway_71 ), profileFile );
    writeProfileInt( "Gateway_71", "PH_Systemzustand_Gateway_71", getValue( KCAN_PH_Systemzustand_Gateway_71 ), profileFile );
    writeProfileInt( "Gateway_71", "PH_Taster_Gateway_71", getValue( KCAN_PH_Taster_Gateway_71 ), profileFile );
    writeProfileInt( "Gateway_71", "PLA_Anf_Aufschaltung_RVC_Gateway_71", getValue( KCAN_PLA_Anf_Aufschaltung_RVC_Gateway_71 ), profileFile );

}


void saveSettings_Gateway_73( char profileFile[] )
{
    writeProfileInt( "Gateway_73", "ACC_18_alt", getValue( KCAN_ACC_18_alt ), profileFile );
    writeProfileInt( "Gateway_73", "ACC_Status_ACC", getValue( KCAN_ACC_Status_ACC ), profileFile );
    writeProfileInt( "Gateway_73", "EPB_Status_02_Gateway_73", getValue( KCAN_EPB_Status_02_Gateway_73 ), profileFile );
    writeProfileInt( "Gateway_73", "ESP_07_alt", getValue( KCAN_ESP_07_alt ), profileFile );
    writeProfileInt( "Gateway_73", "ESP_50_alt", getValue( KCAN_ESP_50_alt ), profileFile );
    writeProfileInt( "Gateway_73", "ESP_Rollenmodus_Deaktivieren", getValue( KCAN_ESP_Rollenmodus_Deaktivieren ), profileFile );
    writeProfileInt( "Gateway_73", "ESP_Status_Bremsentemp_02_Gateway_73", getValue( KCAN_ESP_Status_Bremsentemp_02_Gateway_73 ), profileFile );
    writeProfileInt( "Gateway_73", "GE_Fahrstufe", getValue( KCAN_GE_Fahrstufe ), profileFile );
    writeProfileInt( "Gateway_73", "GE_Freilauf_Status", getValue( KCAN_GE_Freilauf_Status ), profileFile );
    writeProfileInt( "Gateway_73", "GE_Notlauf", getValue( KCAN_GE_Notlauf ), profileFile );
    writeProfileInt( "Gateway_73", "GE_Sperr_Info_WFS", getValue( KCAN_GE_Sperr_Info_WFS ), profileFile );
    writeProfileInt( "Gateway_73", "GE_Ursache_Fahrstufe_N", getValue( KCAN_GE_Ursache_Fahrstufe_N ), profileFile );
    writeProfileInt( "Gateway_73", "Getriebe_11_alt", getValue( KCAN_Getriebe_11_alt ), profileFile );
    writeProfileInt( "Gateway_73", "Getriebe_13_alt", getValue( KCAN_Getriebe_13_alt ), profileFile );
    writeProfileInt( "Gateway_73", "Getriebe_14_alt", getValue( KCAN_Getriebe_14_alt ), profileFile );
    writeProfileInt( "Gateway_73", "Getriebe_17_alt", getValue( KCAN_Getriebe_17_alt ), profileFile );
    writeProfileInt( "Gateway_73", "MKE_Stufe", getValue( KCAN_MKE_Stufe ), profileFile );
    writeProfileInt( "Gateway_73", "MKE_Texte", getValue( KCAN_MKE_Texte ), profileFile );
    writeProfileFloat( "Gateway_73", "MO_Drehzahl_01", getValue( KCAN_MO_Drehzahl_01 ), profileFile );
    writeProfileInt( "Gateway_73", "MO_QBit_Drehzahl_01", getValue( KCAN_MO_QBit_Drehzahl_01 ), profileFile );
    writeProfileInt( "Gateway_73", "Motor_12_alt", getValue( KCAN_Motor_12_alt ), profileFile );
    writeProfileInt( "Gateway_73", "TSK_06_alt", getValue( KCAN_TSK_06_alt ), profileFile );
    writeProfileInt( "Gateway_73", "TSK_Hauptschalter_GRA_ACC_Gateway_73", getValue( KCAN_TSK_Hauptschalter_GRA_ACC_Gateway_73 ), profileFile );
    writeProfileInt( "Gateway_73", "TSK_Limiter_ausgewaehlt_Gateway_73", getValue( KCAN_TSK_Limiter_ausgewaehlt_Gateway_73 ), profileFile );

}


void saveSettings_Getriebe_16( char profileFile[] )
{
    writeProfileInt( "Getriebe_16", "GE_Ausleuchtung_blinkend", getValue( KCAN_GE_Ausleuchtung_blinkend ), profileFile );
    writeProfileInt( "Getriebe_16", "GE_Ausleuchtung_Fahrstufe", getValue( KCAN_GE_Ausleuchtung_Fahrstufe ), profileFile );
    writeProfileInt( "Getriebe_16", "GE_N_Haltephase", getValue( KCAN_GE_N_Haltephase ), profileFile );
    writeProfileInt( "Getriebe_16", "GE_Soll_Haltemagnet", getValue( KCAN_GE_Soll_Haltemagnet ), profileFile );
    writeProfileInt( "Getriebe_16", "GE_Test_Freigabe", getValue( KCAN_GE_Test_Freigabe ), profileFile );
    writeProfileInt( "Getriebe_16", "GE_Testparameter_1", getValue( KCAN_GE_Testparameter_1 ), profileFile );
    writeProfileInt( "Getriebe_16", "GE_Testparameter_2", getValue( KCAN_GE_Testparameter_2 ), profileFile );
    writeProfileInt( "Getriebe_16", "GE_WH_Abschalten", getValue( KCAN_GE_WH_Abschalten ), profileFile );
    writeProfileInt( "Getriebe_16", "GE_WH_Mute", getValue( KCAN_GE_WH_Mute ), profileFile );
    writeProfileInt( "Getriebe_16", "GE_WH_Shiftlock", getValue( KCAN_GE_WH_Shiftlock ), profileFile );
    writeProfileInt( "Getriebe_16", "Getriebe_16_BZ", getValue( KCAN_Getriebe_16_BZ ), profileFile );
    writeProfileInt( "Getriebe_16", "Getriebe_16_CRC", getValue( KCAN_Getriebe_16_CRC ), profileFile );

}


void saveSettings_Heckradar_01( char profileFile[] )
{
    writeProfileInt( "Heckradar_01", "ASW_Kombitexte", getValue( KCAN_ASW_Kombitexte ), profileFile );
    writeProfileInt( "Heckradar_01", "ASW_Modus", getValue( KCAN_ASW_Modus ), profileFile );
    writeProfileInt( "Heckradar_01", "ASW_Status", getValue( KCAN_ASW_Status ), profileFile );
    writeProfileInt( "Heckradar_01", "ASW_Ton_Richtung_HL", getValue( KCAN_ASW_Ton_Richtung_HL ), profileFile );
    writeProfileInt( "Heckradar_01", "ASW_Ton_Richtung_HR", getValue( KCAN_ASW_Ton_Richtung_HR ), profileFile );
    writeProfileInt( "Heckradar_01", "ASW_Ton_Richtung_VL", getValue( KCAN_ASW_Ton_Richtung_VL ), profileFile );
    writeProfileInt( "Heckradar_01", "ASW_Ton_Richtung_VR", getValue( KCAN_ASW_Ton_Richtung_VR ), profileFile );
    writeProfileInt( "Heckradar_01", "ASW_Warnung_BFS", getValue( KCAN_ASW_Warnung_BFS ), profileFile );
    writeProfileInt( "Heckradar_01", "ASW_Warnung_FS", getValue( KCAN_ASW_Warnung_FS ), profileFile );
    writeProfileInt( "Heckradar_01", "Heckradar_Kombitexte", getValue( KCAN_Heckradar_Kombitexte ), profileFile );
    writeProfileInt( "Heckradar_01", "HRE_Anzeigetexte", getValue( KCAN_HRE_Anzeigetexte ), profileFile );
    writeProfileInt( "Heckradar_01", "RCTA_Kombitexte", getValue( KCAN_RCTA_Kombitexte ), profileFile );
    writeProfileInt( "Heckradar_01", "SWA_Anzeigen", getValue( KCAN_SWA_Anzeigen ), profileFile );
    writeProfileInt( "Heckradar_01", "SWA_Blindheit_erkannt", getValue( KCAN_SWA_Blindheit_erkannt ), profileFile );
    writeProfileInt( "Heckradar_01", "SWA_Blindheitsverdacht", getValue( KCAN_SWA_Blindheitsverdacht ), profileFile );
    writeProfileInt( "Heckradar_01", "SWA_Brightness_Mode_FPM", getValue( KCAN_SWA_Brightness_Mode_FPM ), profileFile );
    writeProfileInt( "Heckradar_01", "SWA_FT_RueckLED", getValue( KCAN_SWA_FT_RueckLED ), profileFile );
    writeProfileInt( "Heckradar_01", "SWA_Gischtzaehler", getValue( KCAN_SWA_Gischtzaehler ), profileFile );
    writeProfileInt( "Heckradar_01", "SWA_LED_Hell_BFS", getValue( KCAN_SWA_LED_Hell_BFS ), profileFile );
    writeProfileInt( "Heckradar_01", "SWA_LED_Hell_FS", getValue( KCAN_SWA_LED_Hell_FS ), profileFile );
    writeProfileInt( "Heckradar_01", "SWA_LED_Modus_BFS", getValue( KCAN_SWA_LED_Modus_BFS ), profileFile );
    writeProfileInt( "Heckradar_01", "SWA_LED_Modus_FS", getValue( KCAN_SWA_LED_Modus_FS ), profileFile );
    writeProfileInt( "Heckradar_01", "SWA_Modus", getValue( KCAN_SWA_Modus ), profileFile );
    writeProfileInt( "Heckradar_01", "SWA_rel_Fehler", getValue( KCAN_SWA_rel_Fehler ), profileFile );
    writeProfileInt( "Heckradar_01", "SWA_rel_Nichtverf", getValue( KCAN_SWA_rel_Nichtverf ), profileFile );
    writeProfileInt( "Heckradar_01", "SWA_Sta_aktiv", getValue( KCAN_SWA_Sta_aktiv ), profileFile );
    writeProfileInt( "Heckradar_01", "SWA_Sta_passiv", getValue( KCAN_SWA_Sta_passiv ), profileFile );
    writeProfileInt( "Heckradar_01", "SWA_Standziele_li", getValue( KCAN_SWA_Standziele_li ), profileFile );
    writeProfileInt( "Heckradar_01", "SWA_Standziele_re", getValue( KCAN_SWA_Standziele_re ), profileFile );
    writeProfileInt( "Heckradar_01", "SWA_Status", getValue( KCAN_SWA_Status ), profileFile );

}


void saveSettings_HID_DispKBI_FS_ZR_Req_FD( char profileFile[] )
{

}


void saveSettings_HID_DispKBI_FS_ZR_Resp_FD( char profileFile[] )
{

}


void saveSettings_HID_HUD_ZR_Req_FD( char profileFile[] )
{

}


void saveSettings_HID_HUD_ZR_Resp_FD( char profileFile[] )
{

}


void saveSettings_HID_ZR_DispKBI_FS_Req_FD( char profileFile[] )
{

}


void saveSettings_HID_ZR_DispKBI_FS_Resp_FD( char profileFile[] )
{

}


void saveSettings_HID_ZR_HUD_Req_FD( char profileFile[] )
{

}


void saveSettings_HID_ZR_HUD_Resp_FD( char profileFile[] )
{

}


void saveSettings_HUD_ARC_Req_FD( char profileFile[] )
{

}


void saveSettings_HUD_ARC_Resp_FD( char profileFile[] )
{

}


void saveSettings_HVK_01( char profileFile[] )
{
    writeProfileInt( "HVK_01", "HV_Bordnetz_aktiv", getValue( KCAN_HV_Bordnetz_aktiv ), profileFile );
    writeProfileInt( "HVK_01", "HV_Bordnetz_Fehler", getValue( KCAN_HV_Bordnetz_Fehler ), profileFile );
    writeProfileInt( "HVK_01", "HVK_01_BZ", getValue( KCAN_HVK_01_BZ ), profileFile );
    writeProfileInt( "HVK_01", "HVK_01_CRC", getValue( KCAN_HVK_01_CRC ), profileFile );
    writeProfileInt( "HVK_01", "HVK_AktiveEntladung_Anf", getValue( KCAN_HVK_AktiveEntladung_Anf ), profileFile );
    writeProfileInt( "HVK_01", "HVK_BMS_Sollmodus", getValue( KCAN_HVK_BMS_Sollmodus ), profileFile );
    writeProfileInt( "HVK_01", "HVK_DCDC_Sollmodus", getValue( KCAN_HVK_DCDC_Sollmodus ), profileFile );
    writeProfileInt( "HVK_01", "HVK_EKK_Sollmodus", getValue( KCAN_HVK_EKK_Sollmodus ), profileFile );
    writeProfileInt( "HVK_01", "HVK_Gesamtst_Spgfreiheit", getValue( KCAN_HVK_Gesamtst_Spgfreiheit ), profileFile );
    writeProfileInt( "HVK_01", "HVK_HV_Netz_Warnungen", getValue( KCAN_HVK_HV_Netz_Warnungen ), profileFile );
    writeProfileInt( "HVK_01", "HVK_HVEM_Freigabe", getValue( KCAN_HVK_HVEM_Freigabe ), profileFile );
    writeProfileInt( "HVK_01", "HVK_HVLM_Sollmodus", getValue( KCAN_HVK_HVLM_Sollmodus ), profileFile );
    writeProfileInt( "HVK_01", "HVK_HVPTC_Sollmodus", getValue( KCAN_HVK_HVPTC_Sollmodus ), profileFile );
    writeProfileInt( "HVK_01", "HVK_Iso_Messung_Start", getValue( KCAN_HVK_Iso_Messung_Start ), profileFile );
    writeProfileInt( "HVK_01", "HVK_Istmodus_Anf", getValue( KCAN_HVK_Istmodus_Anf ), profileFile );
    writeProfileInt( "HVK_01", "HVK_Ladebereit", getValue( KCAN_HVK_Ladebereit ), profileFile );
    writeProfileInt( "HVK_01", "HVK_Notabschaltung_Anf", getValue( KCAN_HVK_Notabschaltung_Anf ), profileFile );
    writeProfileInt( "HVK_01", "HVK_PPulsFreigabe", getValue( KCAN_HVK_PPulsFreigabe ), profileFile );
    writeProfileInt( "HVK_01", "HVK_TN1_Sollmodus", getValue( KCAN_HVK_TN1_Sollmodus ), profileFile );
    writeProfileInt( "HVK_01", "HVK_Vorladung_aktiv", getValue( KCAN_HVK_Vorladung_aktiv ), profileFile );

}


void saveSettings_IPA_02( char profileFile[] )
{
    writeProfileInt( "IPA_02", "IPA_02_BZ", getValue( KCAN_IPA_02_BZ ), profileFile );
    writeProfileInt( "IPA_02", "IPA_02_CRC", getValue( KCAN_IPA_02_CRC ), profileFile );
    writeProfileInt( "IPA_02", "IPA_Anf_Meldungen", getValue( KCAN_IPA_Anf_Meldungen ), profileFile );
    writeProfileInt( "IPA_02", "Parken_aktives_System_02", getValue( KCAN_Parken_aktives_System_02 ), profileFile );
    writeProfileInt( "IPA_02", "Parken_Aktivierungslicht_Anf", getValue( KCAN_Parken_Aktivierungslicht_Anf ), profileFile );
    writeProfileInt( "IPA_02", "Parken_Bestaetigungsblinken_Anf", getValue( KCAN_Parken_Bestaetigungsblinken_Anf ), profileFile );
    writeProfileInt( "IPA_02", "Parken_Fahrbereitschaftlicht_Anf", getValue( KCAN_Parken_Fahrbereitschaftlicht_Anf ), profileFile );
    writeProfileInt( "IPA_02", "Parken_Fahrerhinweise_Anf", getValue( KCAN_Parken_Fahrerhinweise_Anf ), profileFile );
    writeProfileInt( "IPA_02", "Parken_Fahrtrichtungslicht_Anf", getValue( KCAN_Parken_Fahrtrichtungslicht_Anf ), profileFile );
    writeProfileInt( "IPA_02", "Parken_FFB_LED_Anf", getValue( KCAN_Parken_FFB_LED_Anf ), profileFile );
    writeProfileInt( "IPA_02", "Parken_Lichtnachlauf_Anf", getValue( KCAN_Parken_Lichtnachlauf_Anf ), profileFile );
    writeProfileInt( "IPA_02", "Parken_Lichtsteuerung_Anf", getValue( KCAN_Parken_Lichtsteuerung_Anf ), profileFile );
    writeProfileInt( "IPA_02", "Parken_Schluesselsuche_Anf", getValue( KCAN_Parken_Schluesselsuche_Anf ), profileFile );
    writeProfileInt( "IPA_02", "Parken_Seitenspiegel_Anf", getValue( KCAN_Parken_Seitenspiegel_Anf ), profileFile );
    writeProfileInt( "IPA_02", "Parken_Wegfahrsperren_Anf", getValue( KCAN_Parken_Wegfahrsperren_Anf ), profileFile );
    writeProfileInt( "IPA_02", "Parken_ZR_Sondermodus_Anf", getValue( KCAN_Parken_ZR_Sondermodus_Anf ), profileFile );
    writeProfileInt( "IPA_02", "Parken_ZV_Schliessen", getValue( KCAN_Parken_ZV_Schliessen ), profileFile );

}


void saveSettings_ISO_Funktionaler_Req_All( char profileFile[] )
{

}


void saveSettings_ISO_HUD_Req( char profileFile[] )
{

}


void saveSettings_ISO_HUD_Resp( char profileFile[] )
{

}


void saveSettings_ISO_Kombi_Req( char profileFile[] )
{

}


void saveSettings_ISO_Kombi_Resp( char profileFile[] )
{

}


void saveSettings_ISO_NFCIApp_NFCIServ_Req( char profileFile[] )
{

}


void saveSettings_ISO_NFCIApp_NFCIServ_Resp( char profileFile[] )
{

}


void saveSettings_ISO_NFCIServ_NFCIApp_Req( char profileFile[] )
{

}


void saveSettings_ISO_NFCIServ_NFCIApp_Resp( char profileFile[] )
{

}


void saveSettings_ISOx_DispKBI_FS_Req( char profileFile[] )
{

}


void saveSettings_ISOx_DispKBI_FS_Req_FD( char profileFile[] )
{

}


void saveSettings_ISOx_DispKBI_FS_Resp( char profileFile[] )
{

}


void saveSettings_ISOx_DispKBI_FS_Resp_FD( char profileFile[] )
{

}


void saveSettings_ISOx_Funkt_Req_All_FD( char profileFile[] )
{

}


void saveSettings_ISOx_HUD_Req_FD( char profileFile[] )
{

}


void saveSettings_ISOx_HUD_Resp_FD( char profileFile[] )
{

}


void saveSettings_ISOx_Kombi_Req_FD( char profileFile[] )
{

}


void saveSettings_ISOx_Kombi_Resp_FD( char profileFile[] )
{

}


void saveSettings_ISOx_SmLi_01_Req( char profileFile[] )
{

}


void saveSettings_ISOx_SmLi_01_Req_FD( char profileFile[] )
{

}


void saveSettings_ISOx_SmLi_01_Resp( char profileFile[] )
{

}


void saveSettings_ISOx_SmLi_01_Resp_FD( char profileFile[] )
{

}


void saveSettings_ISOx_WLC1_Req( char profileFile[] )
{

}


void saveSettings_ISOx_WLC1_Resp( char profileFile[] )
{

}


void saveSettings_Kessy_04( char profileFile[] )
{
    writeProfileInt( "Kessy_04", "KY_Aktive_LFScans", getValue( KCAN_KY_Aktive_LFScans ), profileFile );
    writeProfileInt( "Kessy_04", "KY_AnzKoord_Info", getValue( KCAN_KY_AnzKoord_Info ), profileFile );
    writeProfileInt( "Kessy_04", "KY_EasyClose_Abbruch", getValue( KCAN_KY_EasyClose_Abbruch ), profileFile );
    writeProfileInt( "Kessy_04", "KY_EasyClose_Status", getValue( KCAN_KY_EasyClose_Status ), profileFile );
    writeProfileInt( "Kessy_04", "KY_Fzg_Verlassen_erkannt", getValue( KCAN_KY_Fzg_Verlassen_erkannt ), profileFile );
    writeProfileInt( "Kessy_04", "KY_Fzg_Zugang_erkannt", getValue( KCAN_KY_Fzg_Zugang_erkannt ), profileFile );
    writeProfileInt( "Kessy_04", "KY_Gestik_HD", getValue( KCAN_KY_Gestik_HD ), profileFile );
    writeProfileInt( "Kessy_04", "KY_Gong_600", getValue( KCAN_KY_Gong_600 ), profileFile );
    writeProfileInt( "Kessy_04", "KY_HD_Auffahrt", getValue( KCAN_KY_HD_Auffahrt ), profileFile );
    writeProfileInt( "Kessy_04", "KY_HD_Zufahrt", getValue( KCAN_KY_HD_Zufahrt ), profileFile );
    writeProfileInt( "Kessy_04", "KY_ID_Geber1_im_Fzg", getValue( KCAN_KY_ID_Geber1_im_Fzg ), profileFile );
    writeProfileInt( "Kessy_04", "KY_ID_Geber2_im_Fzg", getValue( KCAN_KY_ID_Geber2_im_Fzg ), profileFile );
    writeProfileInt( "Kessy_04", "KY_ID_Geber3_im_Fzg", getValue( KCAN_KY_ID_Geber3_im_Fzg ), profileFile );
    writeProfileInt( "Kessy_04", "KY_ID_Geber4_im_Fzg", getValue( KCAN_KY_ID_Geber4_im_Fzg ), profileFile );
    writeProfileInt( "Kessy_04", "KY_ID_Geber_Suche", getValue( KCAN_KY_ID_Geber_Suche ), profileFile );
    writeProfileInt( "Kessy_04", "KY_LF_Aktiv", getValue( KCAN_KY_LF_Aktiv ), profileFile );
    writeProfileInt( "Kessy_04", "KY_Meldungen", getValue( KCAN_KY_Meldungen ), profileFile );
    writeProfileInt( "Kessy_04", "KY_Passiv_Autolock", getValue( KCAN_KY_Passiv_Autolock ), profileFile );
    writeProfileInt( "Kessy_04", "KY_Passiv_Autolock_Akt", getValue( KCAN_KY_Passiv_Autolock_Akt ), profileFile );
    writeProfileInt( "Kessy_04", "KY_Passiv_Autolock_Menue", getValue( KCAN_KY_Passiv_Autolock_Menue ), profileFile );
    writeProfileInt( "Kessy_04", "KY_Passiv_Autounlock", getValue( KCAN_KY_Passiv_Autounlock ), profileFile );
    writeProfileInt( "Kessy_04", "KY_Schluesselposition_1", getValue( KCAN_KY_Schluesselposition_1 ), profileFile );
    writeProfileInt( "Kessy_04", "KY_Schluesselposition_2", getValue( KCAN_KY_Schluesselposition_2 ), profileFile );
    writeProfileInt( "Kessy_04", "KY_Schluesselposition_3", getValue( KCAN_KY_Schluesselposition_3 ), profileFile );
    writeProfileInt( "Kessy_04", "KY_Schluesselposition_4", getValue( KCAN_KY_Schluesselposition_4 ), profileFile );
    writeProfileInt( "Kessy_04", "KY_Schluesselposition_5", getValue( KCAN_KY_Schluesselposition_5 ), profileFile );
    writeProfileInt( "Kessy_04", "KY_Schluesselposition_6", getValue( KCAN_KY_Schluesselposition_6 ), profileFile );
    writeProfileInt( "Kessy_04", "KY_Schluesselposition_7", getValue( KCAN_KY_Schluesselposition_7 ), profileFile );
    writeProfileInt( "Kessy_04", "KY_Schluesselposition_8", getValue( KCAN_KY_Schluesselposition_8 ), profileFile );
    writeProfileInt( "Kessy_04", "KY_Startknopf_Bel", getValue( KCAN_KY_Startknopf_Bel ), profileFile );
    writeProfileInt( "Kessy_04", "KY_StartStopp_Info", getValue( KCAN_KY_StartStopp_Info ), profileFile );

}


void saveSettings_Klemmen_Status_01( char profileFile[] )
{
    writeProfileInt( "Klemmen_Status_01", "BCM_Ausparken_Betrieb", getValue( KCAN_BCM_Ausparken_Betrieb ), profileFile );
    writeProfileInt( "Klemmen_Status_01", "Klemmen_Status_01_BZ", getValue( KCAN_Klemmen_Status_01_BZ ), profileFile );
    writeProfileInt( "Klemmen_Status_01", "Klemmen_Status_01_CRC", getValue( KCAN_Klemmen_Status_01_CRC ), profileFile );
    writeProfileInt( "Klemmen_Status_01", "KST_Fahrerhinweis_1", getValue( KCAN_KST_Fahrerhinweis_1 ), profileFile );
    writeProfileInt( "Klemmen_Status_01", "KST_Fahrerhinweis_2", getValue( KCAN_KST_Fahrerhinweis_2 ), profileFile );
    writeProfileInt( "Klemmen_Status_01", "KST_Fahrerhinweis_4", getValue( KCAN_KST_Fahrerhinweis_4 ), profileFile );
    writeProfileInt( "Klemmen_Status_01", "KST_Fahrerhinweis_5", getValue( KCAN_KST_Fahrerhinweis_5 ), profileFile );
    writeProfileInt( "Klemmen_Status_01", "KST_Fahrerhinweis_6", getValue( KCAN_KST_Fahrerhinweis_6 ), profileFile );
    writeProfileInt( "Klemmen_Status_01", "KST_Warn_P1_ZST_def", getValue( KCAN_KST_Warn_P1_ZST_def ), profileFile );
    writeProfileInt( "Klemmen_Status_01", "KST_Warn_P2_ZST_def", getValue( KCAN_KST_Warn_P2_ZST_def ), profileFile );
    writeProfileInt( "Klemmen_Status_01", "RSt_Fahrerhinweise", getValue( KCAN_RSt_Fahrerhinweise ), profileFile );
    writeProfileInt( "Klemmen_Status_01", "ZAS_Kl_15", getValue( KCAN_ZAS_Kl_15 ), profileFile );
    writeProfileInt( "Klemmen_Status_01", "ZAS_Kl_50_Startanforderung", getValue( KCAN_ZAS_Kl_50_Startanforderung ), profileFile );
    writeProfileInt( "Klemmen_Status_01", "ZAS_Kl_Infotainment", getValue( KCAN_ZAS_Kl_Infotainment ), profileFile );
    writeProfileInt( "Klemmen_Status_01", "ZAS_Kl_S", getValue( KCAN_ZAS_Kl_S ), profileFile );
    writeProfileInt( "Klemmen_Status_01", "ZAS_Kl_X", getValue( KCAN_ZAS_Kl_X ), profileFile );

}


void saveSettings_Klemmen_Status_02( char profileFile[] )
{
    writeProfileInt( "Klemmen_Status_02", "KST_ComfortReadyStatus", getValue( KCAN_KST_ComfortReadyStatus ), profileFile );
    writeProfileInt( "Klemmen_Status_02", "KST_Sonderzustand_Anforderung", getValue( KCAN_KST_Sonderzustand_Anforderung ), profileFile );
    writeProfileInt( "Klemmen_Status_02", "KST_Sonderzustand_Status", getValue( KCAN_KST_Sonderzustand_Status ), profileFile );
    writeProfileInt( "Klemmen_Status_02", "KST_WFS_Fahrfreigabe_Anforderung", getValue( KCAN_KST_WFS_Fahrfreigabe_Anforderung ), profileFile );

}


void saveSettings_Klemmen_Steuerung_01( char profileFile[] )
{
    writeProfileInt( "Klemmen_Steuerung_01", "Klemmen_Steuerung_01_BZ", getValue( KCAN_Klemmen_Steuerung_01_BZ ), profileFile );
    writeProfileInt( "Klemmen_Steuerung_01", "Klemmen_Steuerung_01_CRC", getValue( KCAN_Klemmen_Steuerung_01_CRC ), profileFile );
    writeProfileInt( "Klemmen_Steuerung_01", "KST_Anf_Klemme_15", getValue( KCAN_KST_Anf_Klemme_15 ), profileFile );
    writeProfileInt( "Klemmen_Steuerung_01", "KST_Anf_Klemme_50", getValue( KCAN_KST_Anf_Klemme_50 ), profileFile );
    writeProfileInt( "Klemmen_Steuerung_01", "KST_Anf_Klemme_S", getValue( KCAN_KST_Anf_Klemme_S ), profileFile );
    writeProfileInt( "Klemmen_Steuerung_01", "KST_Anf_Klemmenfreigabe_ELV", getValue( KCAN_KST_Anf_Klemmenfreigabe_ELV ), profileFile );
    writeProfileInt( "Klemmen_Steuerung_01", "KST_Anf_Klemmenfreigabe_WFS", getValue( KCAN_KST_Anf_Klemmenfreigabe_WFS ), profileFile );
    writeProfileInt( "Klemmen_Steuerung_01", "KST_Anf_ZV_Verriegelung_Klemmen_Steuerung_01", getValue( KCAN_KST_Anf_ZV_Verriegelung_Klemmen_Steuerung_01 ), profileFile );
    writeProfileInt( "Klemmen_Steuerung_01", "KST_aut_Abschaltung_Zuendung_Klemmen_Steuerung_01", getValue( KCAN_KST_aut_Abschaltung_Zuendung_Klemmen_Steuerung_01 ), profileFile );
    writeProfileInt( "Klemmen_Steuerung_01", "KST_Fahrer_Info_Text", getValue( KCAN_KST_Fahrer_Info_Text ), profileFile );
    writeProfileInt( "Klemmen_Steuerung_01", "KST_Txt_Komfortabschaltung_Klemmen_Steuerung_01", getValue( KCAN_KST_Txt_Komfortabschaltung_Klemmen_Steuerung_01 ), profileFile );
    writeProfileInt( "Klemmen_Steuerung_01", "KST_Txt_P_Gang", getValue( KCAN_KST_Txt_P_Gang ), profileFile );
    writeProfileInt( "Klemmen_Steuerung_01", "KST_Txt_Panikabschaltung", getValue( KCAN_KST_Txt_Panikabschaltung ), profileFile );
    writeProfileInt( "Klemmen_Steuerung_01", "KST_Txt_Werkstatt", getValue( KCAN_KST_Txt_Werkstatt ), profileFile );
    writeProfileInt( "Klemmen_Steuerung_01", "KST_Unterdr_Zuendungsmeldung_Klemmen_Steuerung_01", getValue( KCAN_KST_Unterdr_Zuendungsmeldung_Klemmen_Steuerung_01 ), profileFile );
    writeProfileInt( "Klemmen_Steuerung_01", "KST_ZAT_betaetigt", getValue( KCAN_KST_ZAT_betaetigt ), profileFile );
    writeProfileInt( "Klemmen_Steuerung_01", "KST_Zuendungswarnung", getValue( KCAN_KST_Zuendungswarnung ), profileFile );
    writeProfileInt( "Klemmen_Steuerung_01", "Relais_VoKo_angesteuert", getValue( KCAN_Relais_VoKo_angesteuert ), profileFile );
    writeProfileInt( "Klemmen_Steuerung_01", "RSt_Anforderung_HMS", getValue( KCAN_RSt_Anforderung_HMS ), profileFile );

}


void saveSettings_Klima_03( char profileFile[] )
{
    writeProfileInt( "Klima_03", "KL_Anf_AussenspiegelHzg", getValue( KCAN_KL_Anf_AussenspiegelHzg ), profileFile );
    writeProfileInt( "Klima_03", "KL_BCmE_Livetip_Freigabe", getValue( KCAN_KL_BCmE_Livetip_Freigabe ), profileFile );
    writeProfileInt( "Klima_03", "KL_ErwVK_Anf", getValue( KCAN_KL_ErwVK_Anf ), profileFile );
    writeProfileInt( "Klima_03", "KL_FSH_Automatikbetrieb", getValue( KCAN_KL_FSH_Automatikbetrieb ), profileFile );
    writeProfileInt( "Klima_03", "KL_Geblaese_Fond_Status", getValue( KCAN_KL_Geblaese_Fond_Status ), profileFile );
    writeProfileInt( "Klima_03", "KL_Geblaese_Status", getValue( KCAN_KL_Geblaese_Status ), profileFile );
    writeProfileInt( "Klima_03", "KL_Heizkreisventilstellung", getValue( KCAN_KL_Heizkreisventilstellung ), profileFile );
    writeProfileFloat( "Klima_03", "KL_I_Geblaese_Fond", getValue( KCAN_KL_I_Geblaese_Fond ), profileFile );
    writeProfileFloat( "Klima_03", "KL_Innen_Temp", getValue( KCAN_KL_Innen_Temp ), profileFile );
    writeProfileInt( "Klima_03", "KL_Kompressorkupplung", getValue( KCAN_KL_Kompressorkupplung ), profileFile );
    writeProfileInt( "Klima_03", "KL_Magnetventil", getValue( KCAN_KL_Magnetventil ), profileFile );
    writeProfileInt( "Klima_03", "KL_Restwaerme_aktiv", getValue( KCAN_KL_Restwaerme_aktiv ), profileFile );
    writeProfileInt( "Klima_03", "KL_SH_Soll_hl", getValue( KCAN_KL_SH_Soll_hl ), profileFile );
    writeProfileInt( "Klima_03", "KL_SH_Soll_hr", getValue( KCAN_KL_SH_Soll_hr ), profileFile );
    writeProfileInt( "Klima_03", "KL_SIH_LEH_Verteilung_VL", getValue( KCAN_KL_SIH_LEH_Verteilung_VL ), profileFile );
    writeProfileInt( "Klima_03", "KL_SIH_LEH_Verteilung_VR", getValue( KCAN_KL_SIH_LEH_Verteilung_VR ), profileFile );
    writeProfileInt( "Klima_03", "KL_SIH_LEL_Verteilung_VL", getValue( KCAN_KL_SIH_LEL_Verteilung_VL ), profileFile );
    writeProfileInt( "Klima_03", "KL_SIH_LEL_Verteilung_VR", getValue( KCAN_KL_SIH_LEL_Verteilung_VR ), profileFile );
    writeProfileInt( "Klima_03", "KL_Solarluefter_aktiv", getValue( KCAN_KL_Solarluefter_aktiv ), profileFile );
    writeProfileInt( "Klima_03", "KL_STH_aktiv", getValue( KCAN_KL_STH_aktiv ), profileFile );
    writeProfileInt( "Klima_03", "KL_STH_Ansteuerung", getValue( KCAN_KL_STH_Ansteuerung ), profileFile );
    writeProfileInt( "Klima_03", "KL_STH_Betriebsdauer", getValue( KCAN_KL_STH_Betriebsdauer ), profileFile );
    writeProfileInt( "Klima_03", "KL_STL_aktiv", getValue( KCAN_KL_STL_aktiv ), profileFile );
    writeProfileInt( "Klima_03", "KL_Umluft_Taste", getValue( KCAN_KL_Umluft_Taste ), profileFile );
    writeProfileInt( "Klima_03", "KL_WaPu", getValue( KCAN_KL_WaPu ), profileFile );

}


void saveSettings_Klima_06( char profileFile[] )
{
    writeProfileInt( "Klima_06", "KL_Betriebsmodus_FH", getValue( KCAN_KL_Betriebsmodus_FH ), profileFile );
    writeProfileInt( "Klima_06", "KL_ErwVK_Beifahrerzone", getValue( KCAN_KL_ErwVK_Beifahrerzone ), profileFile );
    writeProfileInt( "Klima_06", "KL_ErwVK_Fahrerzone", getValue( KCAN_KL_ErwVK_Fahrerzone ), profileFile );
    writeProfileInt( "Klima_06", "KL_ErwVK_Heckzone_links", getValue( KCAN_KL_ErwVK_Heckzone_links ), profileFile );
    writeProfileInt( "Klima_06", "Kl_ErwVK_Heckzone_rechts", getValue( KCAN_Kl_ErwVK_Heckzone_rechts ), profileFile );
    writeProfileInt( "Klima_06", "KL_ErwVK_Scheibenheizung", getValue( KCAN_KL_ErwVK_Scheibenheizung ), profileFile );
    writeProfileInt( "Klima_06", "KL_ErwVK_Status", getValue( KCAN_KL_ErwVK_Status ), profileFile );
    writeProfileInt( "Klima_06", "KL_Hinweis_Kuehlmodus", getValue( KCAN_KL_Hinweis_Kuehlmodus ), profileFile );
    writeProfileInt( "Klima_06", "KL_Meldung_Status", getValue( KCAN_KL_Meldung_Status ), profileFile );
    writeProfileInt( "Klima_06", "KL_STH_Betriebsdauer_lang", getValue( KCAN_KL_STH_Betriebsdauer_lang ), profileFile );
    writeProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_01", getValue( KCAN_KL_Stopp_Wiederstart_Anz_01 ), profileFile );
    writeProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_02", getValue( KCAN_KL_Stopp_Wiederstart_Anz_02 ), profileFile );
    writeProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_03", getValue( KCAN_KL_Stopp_Wiederstart_Anz_03 ), profileFile );
    writeProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_04", getValue( KCAN_KL_Stopp_Wiederstart_Anz_04 ), profileFile );
    writeProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_05", getValue( KCAN_KL_Stopp_Wiederstart_Anz_05 ), profileFile );
    writeProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_06", getValue( KCAN_KL_Stopp_Wiederstart_Anz_06 ), profileFile );
    writeProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_07", getValue( KCAN_KL_Stopp_Wiederstart_Anz_07 ), profileFile );
    writeProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_08", getValue( KCAN_KL_Stopp_Wiederstart_Anz_08 ), profileFile );
    writeProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_09", getValue( KCAN_KL_Stopp_Wiederstart_Anz_09 ), profileFile );
    writeProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_Std1", getValue( KCAN_KL_Stopp_Wiederstart_Anz_Std1 ), profileFile );
    writeProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_Std2", getValue( KCAN_KL_Stopp_Wiederstart_Anz_Std2 ), profileFile );
    writeProfileInt( "Klima_06", "KL_ZZ_Betriebsmodus", getValue( KCAN_KL_ZZ_Betriebsmodus ), profileFile );
    writeProfileInt( "Klima_06", "KL_ZZ_Minute", getValue( KCAN_KL_ZZ_Minute ), profileFile );
    writeProfileInt( "Klima_06", "KL_ZZ_Monat", getValue( KCAN_KL_ZZ_Monat ), profileFile );
    writeProfileInt( "Klima_06", "KL_ZZ_Status_Timer", getValue( KCAN_KL_ZZ_Status_Timer ), profileFile );
    writeProfileInt( "Klima_06", "KL_ZZ_Stunde", getValue( KCAN_KL_ZZ_Stunde ), profileFile );
    writeProfileInt( "Klima_06", "KL_ZZ_Tag", getValue( KCAN_KL_ZZ_Tag ), profileFile );

}


void saveSettings_Klima_12( char profileFile[] )
{
    writeProfileInt( "Klima_12", "FSH_Taster", getValue( KCAN_FSH_Taster ), profileFile );
    writeProfileInt( "Klima_12", "HSH_Taster", getValue( KCAN_HSH_Taster ), profileFile );
    writeProfileInt( "Klima_12", "KL_Beschlagsgefahr", getValue( KCAN_KL_Beschlagsgefahr ), profileFile );
    writeProfileFloat( "Klima_12", "KL_Geblspng_Fond_Soll", getValue( KCAN_KL_Geblspng_Fond_Soll ), profileFile );
    writeProfileFloat( "Klima_12", "KL_Geblspng_Soll", getValue( KCAN_KL_Geblspng_Soll ), profileFile );
    writeProfileFloat( "Klima_12", "KL_I_Geblaese", getValue( KCAN_KL_I_Geblaese ), profileFile );
    writeProfileInt( "Klima_12", "KL_Kompressorstrom_soll", getValue( KCAN_KL_Kompressorstrom_soll ), profileFile );
    writeProfileInt( "Klima_12", "KL_LRH_Stufe", getValue( KCAN_KL_LRH_Stufe ), profileFile );
    writeProfileInt( "Klima_12", "KL_LRH_Taster", getValue( KCAN_KL_LRH_Taster ), profileFile );
    writeProfileInt( "Klima_12", "KL_PTC_Verbauinfo", getValue( KCAN_KL_PTC_Verbauinfo ), profileFile );
    writeProfileInt( "Klima_12", "KL_SIH_Soll_li", getValue( KCAN_KL_SIH_Soll_li ), profileFile );
    writeProfileInt( "Klima_12", "KL_SIH_Soll_re", getValue( KCAN_KL_SIH_Soll_re ), profileFile );
    writeProfileInt( "Klima_12", "KL_SIL_Soll_li", getValue( KCAN_KL_SIL_Soll_li ), profileFile );
    writeProfileInt( "Klima_12", "KL_SIL_Soll_re", getValue( KCAN_KL_SIL_Soll_re ), profileFile );
    writeProfileInt( "Klima_12", "KL_Umluftklappe_Status", getValue( KCAN_KL_Umluftklappe_Status ), profileFile );
    writeProfileInt( "Klima_12", "KL_Zuheizer_Freigabe", getValue( KCAN_KL_Zuheizer_Freigabe ), profileFile );
    writeProfileInt( "Klima_12", "KRH_Soll_li", getValue( KCAN_KRH_Soll_li ), profileFile );
    writeProfileInt( "Klima_12", "KRH_Soll_re", getValue( KCAN_KRH_Soll_re ), profileFile );

}


void saveSettings_Klima_16( char profileFile[] )
{
    writeProfileInt( "Klima_16", "FSH_Status", getValue( KCAN_FSH_Status ), profileFile );
    writeProfileInt( "Klima_16", "HSH_Relais_Anf", getValue( KCAN_HSH_Relais_Anf ), profileFile );
    writeProfileInt( "Klima_16", "KL_AL_HL_Anf", getValue( KCAN_KL_AL_HL_Anf ), profileFile );
    writeProfileInt( "Klima_16", "KL_AL_HR_Anf", getValue( KCAN_KL_AL_HR_Anf ), profileFile );
    writeProfileInt( "Klima_16", "KL_AL_VL_Anf", getValue( KCAN_KL_AL_VL_Anf ), profileFile );
    writeProfileInt( "Klima_16", "KL_AL_VR_Anf", getValue( KCAN_KL_AL_VR_Anf ), profileFile );
    writeProfileInt( "Klima_16", "KL_Defrost_LED", getValue( KCAN_KL_Defrost_LED ), profileFile );
    writeProfileInt( "Klima_16", "KL_FSH_LED", getValue( KCAN_KL_FSH_LED ), profileFile );
    writeProfileInt( "Klima_16", "KL_FSH_Soll", getValue( KCAN_KL_FSH_Soll ), profileFile );
    writeProfileInt( "Klima_16", "KL_Heizstufe_LSH", getValue( KCAN_KL_Heizstufe_LSH ), profileFile );
    writeProfileInt( "Klima_16", "KL_HSH_LED", getValue( KCAN_KL_HSH_LED ), profileFile );
    writeProfileInt( "Klima_16", "KL_HSH_Soll", getValue( KCAN_KL_HSH_Soll ), profileFile );
    writeProfileInt( "Klima_16", "KL_HUP_aktiv", getValue( KCAN_KL_HUP_aktiv ), profileFile );
    writeProfileInt( "Klima_16", "KL_Klappe_Status", getValue( KCAN_KL_Klappe_Status ), profileFile );
    writeProfileInt( "Klima_16", "KL_LRH_PWM", getValue( KCAN_KL_LRH_PWM ), profileFile );
    writeProfileInt( "Klima_16", "KL_LRH_Soll", getValue( KCAN_KL_LRH_Soll ), profileFile );
    writeProfileInt( "Klima_16", "KL_LSH_Ansteuerung", getValue( KCAN_KL_LSH_Ansteuerung ), profileFile );
    writeProfileInt( "Klima_16", "KL_LSH_Betriebsdauer", getValue( KCAN_KL_LSH_Betriebsdauer ), profileFile );
    writeProfileInt( "Klima_16", "KL_LSH_DBetr_Bestaet", getValue( KCAN_KL_LSH_DBetr_Bestaet ), profileFile );
    writeProfileInt( "Klima_16", "KL_LSH_DBetr_Ein", getValue( KCAN_KL_LSH_DBetr_Ein ), profileFile );
    writeProfileFloat( "Klima_16", "KL_Temp_ZH_Soll", getValue( KCAN_KL_Temp_ZH_Soll ), profileFile );
    writeProfileInt( "Klima_16", "KL_VoKo_LED", getValue( KCAN_KL_VoKo_LED ), profileFile );
    writeProfileInt( "Klima_16", "KL_Voko_Status", getValue( KCAN_KL_Voko_Status ), profileFile );
    writeProfileInt( "Klima_16", "KL_ZR_Anforderung", getValue( KCAN_KL_ZR_Anforderung ), profileFile );
    writeProfileInt( "Klima_16", "SIH_Stufe_LED_li", getValue( KCAN_SIH_Stufe_LED_li ), profileFile );
    writeProfileInt( "Klima_16", "SIH_Stufe_LED_re", getValue( KCAN_SIH_Stufe_LED_re ), profileFile );

}


void saveSettings_Klima_Sensor_02( char profileFile[] )
{
    writeProfileFloat( "Klima_Sensor_02", "BCM1_Aussen_Temp_ungef", getValue( KCAN_BCM1_Aussen_Temp_ungef ), profileFile );
    writeProfileInt( "Klima_Sensor_02", "BCM1_FStatus_Aussentemp_ungef", getValue( KCAN_BCM1_FStatus_Aussentemp_ungef ), profileFile );
    writeProfileInt( "Klima_Sensor_02", "BCM1_Kompressorstrom_ist", getValue( KCAN_BCM1_Kompressorstrom_ist ), profileFile );
    writeProfileInt( "Klima_Sensor_02", "BCM1_OBD_FStatus_ATemp", getValue( KCAN_BCM1_OBD_FStatus_ATemp ), profileFile );
    writeProfileInt( "Klima_Sensor_02", "BCM1_PTC_stufig_Status", getValue( KCAN_BCM1_PTC_stufig_Status ), profileFile );
    writeProfileInt( "Klima_Sensor_02", "BCM_Heizungsabsperrventil_Status", getValue( KCAN_BCM_Heizungsabsperrventil_Status ), profileFile );
    writeProfileInt( "Klima_Sensor_02", "BCM_Heizungspumpe_Status", getValue( KCAN_BCM_Heizungspumpe_Status ), profileFile );
    writeProfileInt( "Klima_Sensor_02", "BCM_Kompressorkupplung_Status", getValue( KCAN_BCM_Kompressorkupplung_Status ), profileFile );

}


void saveSettings_KN_DispKBI_FS( char profileFile[] )
{
    writeProfileInt( "KN_DispKBI_FS", "DispKBI_FS_Abschaltstufe", getValue( KCAN_DispKBI_FS_Abschaltstufe ), profileFile );
    writeProfileInt( "KN_DispKBI_FS", "DispKBI_FS_KD_Fehler", getValue( KCAN_DispKBI_FS_KD_Fehler ), profileFile );
    writeProfileInt( "KN_DispKBI_FS", "DispKBI_FS_KompSchutz", getValue( KCAN_DispKBI_FS_KompSchutz ), profileFile );
    writeProfileInt( "KN_DispKBI_FS", "DispKBI_FS_Nachlauftyp", getValue( KCAN_DispKBI_FS_Nachlauftyp ), profileFile );
    writeProfileInt( "KN_DispKBI_FS", "DispKBI_FS_Transport_Mode", getValue( KCAN_DispKBI_FS_Transport_Mode ), profileFile );
    writeProfileInt( "KN_DispKBI_FS", "KN_DispKBI_FS_BusKnockOut", getValue( KCAN_KN_DispKBI_FS_BusKnockOut ), profileFile );
    writeProfileInt( "KN_DispKBI_FS", "KN_DispKBI_FS_BusKnockOutTimer", getValue( KCAN_KN_DispKBI_FS_BusKnockOutTimer ), profileFile );
    writeProfileInt( "KN_DispKBI_FS", "KN_DispKBI_FS_DiagPfad", getValue( KCAN_KN_DispKBI_FS_DiagPfad ), profileFile );
    writeProfileInt( "KN_DispKBI_FS", "KN_DispKBI_FS_ECUKnockOut", getValue( KCAN_KN_DispKBI_FS_ECUKnockOut ), profileFile );
    writeProfileInt( "KN_DispKBI_FS", "KN_DispKBI_FS_ECUKnockOutTimer", getValue( KCAN_KN_DispKBI_FS_ECUKnockOutTimer ), profileFile );
    writeProfileInt( "KN_DispKBI_FS", "NM_DispKBI_FS_Wakeup", getValue( KCAN_NM_DispKBI_FS_Wakeup ), profileFile );

}


void saveSettings_KN_Gateway( char profileFile[] )
{
    writeProfileInt( "KN_Gateway", "Gateway_Abschaltstufe", getValue( KCAN_Gateway_Abschaltstufe ), profileFile );
    writeProfileInt( "KN_Gateway", "Gateway_KompSchutz", getValue( KCAN_Gateway_KompSchutz ), profileFile );
    writeProfileInt( "KN_Gateway", "Gateway_Nachlauftyp", getValue( KCAN_Gateway_Nachlauftyp ), profileFile );
    writeProfileInt( "KN_Gateway", "Gateway_Transport_Mode", getValue( KCAN_Gateway_Transport_Mode ), profileFile );
    writeProfileInt( "KN_Gateway", "GW_KD_Fehler_KN_Gateway", getValue( KCAN_GW_KD_Fehler_KN_Gateway ), profileFile );
    writeProfileInt( "KN_Gateway", "KN_GW_DiagPfad", getValue( KCAN_KN_GW_DiagPfad ), profileFile );
    writeProfileInt( "KN_Gateway", "NM_Gateway_Wakeup", getValue( KCAN_NM_Gateway_Wakeup ), profileFile );

}


void saveSettings_KN_HUD( char profileFile[] )
{
    writeProfileInt( "KN_HUD", "HUD_Abschaltstufe", getValue( KCAN_HUD_Abschaltstufe ), profileFile );
    writeProfileInt( "KN_HUD", "HUD_KD_Fehler", getValue( KCAN_HUD_KD_Fehler ), profileFile );
    writeProfileInt( "KN_HUD", "HUD_KompSchutz", getValue( KCAN_HUD_KompSchutz ), profileFile );
    writeProfileInt( "KN_HUD", "HUD_Nachlauftyp", getValue( KCAN_HUD_Nachlauftyp ), profileFile );
    writeProfileInt( "KN_HUD", "HUD_Transport_Mode", getValue( KCAN_HUD_Transport_Mode ), profileFile );
    writeProfileInt( "KN_HUD", "KN_HUD_BusKnockOut", getValue( KCAN_KN_HUD_BusKnockOut ), profileFile );
    writeProfileInt( "KN_HUD", "KN_HUD_BusKnockOutTimer", getValue( KCAN_KN_HUD_BusKnockOutTimer ), profileFile );
    writeProfileInt( "KN_HUD", "KN_HUD_DiagPfad", getValue( KCAN_KN_HUD_DiagPfad ), profileFile );
    writeProfileInt( "KN_HUD", "KN_HUD_ECUKnockOut", getValue( KCAN_KN_HUD_ECUKnockOut ), profileFile );
    writeProfileInt( "KN_HUD", "KN_HUD_ECUKnockOutTimer", getValue( KCAN_KN_HUD_ECUKnockOutTimer ), profileFile );
    writeProfileInt( "KN_HUD", "NM_HUD_Wakeup", getValue( KCAN_NM_HUD_Wakeup ), profileFile );

}


void saveSettings_KN_Info_El( char profileFile[] )
{
    writeProfileInt( "KN_Info_El", "Info_El_Abschaltstufe", getValue( KCAN_Info_El_Abschaltstufe ), profileFile );
    writeProfileInt( "KN_Info_El", "Info_El_KD_Fehler", getValue( KCAN_Info_El_KD_Fehler ), profileFile );
    writeProfileInt( "KN_Info_El", "Info_El_KompSchutz", getValue( KCAN_Info_El_KompSchutz ), profileFile );
    writeProfileInt( "KN_Info_El", "Info_El_Nachlauftyp", getValue( KCAN_Info_El_Nachlauftyp ), profileFile );
    writeProfileInt( "KN_Info_El", "Info_El_Transport_Mode", getValue( KCAN_Info_El_Transport_Mode ), profileFile );
    writeProfileInt( "KN_Info_El", "KN_Info_El_BusKnockOutTimer", getValue( KCAN_KN_Info_El_BusKnockOutTimer ), profileFile );
    writeProfileInt( "KN_Info_El", "KN_Info_El_DiagPfad", getValue( KCAN_KN_Info_El_DiagPfad ), profileFile );
    writeProfileInt( "KN_Info_El", "NM_Info_El_Wakeup", getValue( KCAN_NM_Info_El_Wakeup ), profileFile );

}


void saveSettings_KN_Kombi( char profileFile[] )
{
    writeProfileInt( "KN_Kombi", "KBI_KD_Fehler", getValue( KCAN_KBI_KD_Fehler ), profileFile );
    writeProfileInt( "KN_Kombi", "KN_KBI_DiagPfad", getValue( KCAN_KN_KBI_DiagPfad ), profileFile );
    writeProfileInt( "KN_Kombi", "KN_Kombi_BusKnockOut", getValue( KCAN_KN_Kombi_BusKnockOut ), profileFile );
    writeProfileInt( "KN_Kombi", "KN_Kombi_BusKnockOutTimer", getValue( KCAN_KN_Kombi_BusKnockOutTimer ), profileFile );
    writeProfileInt( "KN_Kombi", "KN_Kombi_ECUKnockOut", getValue( KCAN_KN_Kombi_ECUKnockOut ), profileFile );
    writeProfileInt( "KN_Kombi", "KN_Kombi_ECUKnockOutTimer", getValue( KCAN_KN_Kombi_ECUKnockOutTimer ), profileFile );
    writeProfileInt( "KN_Kombi", "Kombi_Abschaltstufe", getValue( KCAN_Kombi_Abschaltstufe ), profileFile );
    writeProfileInt( "KN_Kombi", "Kombi_KompSchutz", getValue( KCAN_Kombi_KompSchutz ), profileFile );
    writeProfileInt( "KN_Kombi", "Kombi_Nachlauftyp", getValue( KCAN_Kombi_Nachlauftyp ), profileFile );
    writeProfileInt( "KN_Kombi", "Kombi_Transport_Mode", getValue( KCAN_Kombi_Transport_Mode ), profileFile );
    writeProfileInt( "KN_Kombi", "NM_Kombi_Lokalaktiv", getValue( KCAN_NM_Kombi_Lokalaktiv ), profileFile );
    writeProfileInt( "KN_Kombi", "NM_Kombi_Subsystemaktiv", getValue( KCAN_NM_Kombi_Subsystemaktiv ), profileFile );
    writeProfileInt( "KN_Kombi", "NM_Kombi_Wakeup", getValue( KCAN_NM_Kombi_Wakeup ), profileFile );

}


void saveSettings_KN_SmLi_1( char profileFile[] )
{
    writeProfileInt( "KN_SmLi_1", "KN_SmLi_01_DiagPfad", getValue( KCAN_KN_SmLi_01_DiagPfad ), profileFile );
    writeProfileInt( "KN_SmLi_1", "KN_SmLi_BusKnockOut", getValue( KCAN_KN_SmLi_BusKnockOut ), profileFile );
    writeProfileInt( "KN_SmLi_1", "KN_SmLi_BusKnockOutTimer", getValue( KCAN_KN_SmLi_BusKnockOutTimer ), profileFile );
    writeProfileInt( "KN_SmLi_1", "KN_SmLi_ECUKnockOut", getValue( KCAN_KN_SmLi_ECUKnockOut ), profileFile );
    writeProfileInt( "KN_SmLi_1", "KN_SmLi_ECUKnockOutTimer", getValue( KCAN_KN_SmLi_ECUKnockOutTimer ), profileFile );
    writeProfileInt( "KN_SmLi_1", "NM_SmLi_01_Wakeup", getValue( KCAN_NM_SmLi_01_Wakeup ), profileFile );
    writeProfileInt( "KN_SmLi_1", "SmLi_01_Abschaltstufe", getValue( KCAN_SmLi_01_Abschaltstufe ), profileFile );
    writeProfileInt( "KN_SmLi_1", "SmLi_01_KD_Fehler", getValue( KCAN_SmLi_01_KD_Fehler ), profileFile );
    writeProfileInt( "KN_SmLi_1", "SmLi_01_KompSchutz", getValue( KCAN_SmLi_01_KompSchutz ), profileFile );
    writeProfileInt( "KN_SmLi_1", "SmLi_01_Nachlauftyp", getValue( KCAN_SmLi_01_Nachlauftyp ), profileFile );
    writeProfileInt( "KN_SmLi_1", "SmLi_01_Transport_Mode", getValue( KCAN_SmLi_01_Transport_Mode ), profileFile );

}


void saveSettings_Kombi_01( char profileFile[] )
{
    writeProfileInt( "Kombi_01", "KBI_Anzeigefehler_LDW_Kombi_01", getValue( KCAN_KBI_Anzeigefehler_LDW_Kombi_01 ), profileFile );
    writeProfileInt( "Kombi_01", "KBI_Anzeigefehler_SWA", getValue( KCAN_KBI_Anzeigefehler_SWA ), profileFile );
    writeProfileInt( "Kombi_01", "KBI_ARA_in_Anzeige", getValue( KCAN_KBI_ARA_in_Anzeige ), profileFile );
    writeProfileInt( "Kombi_01", "KBI_Einheit_Tacho", getValue( KCAN_KBI_Einheit_Tacho ), profileFile );
    writeProfileInt( "Kombi_01", "KBI_Handbremse", getValue( KCAN_KBI_Handbremse ), profileFile );
    writeProfileInt( "Kombi_01", "KBI_MFA_v_Einheit_01", getValue( KCAN_KBI_MFA_v_Einheit_01 ), profileFile );
    writeProfileInt( "Kombi_01", "KBI_PLA_in_Anzeige", getValue( KCAN_KBI_PLA_in_Anzeige ), profileFile );
    writeProfileInt( "Kombi_01", "KBI_Systemstatus", getValue( KCAN_KBI_Systemstatus ), profileFile );
    writeProfileInt( "Kombi_01", "KBI_Tankwarnung", getValue( KCAN_KBI_Tankwarnung ), profileFile );
    writeProfileInt( "Kombi_01", "KBI_Tankwarnung_ungueltig", getValue( KCAN_KBI_Tankwarnung_ungueltig ), profileFile );
    writeProfileInt( "Kombi_01", "KBI_Taster_Fahrwerk", getValue( KCAN_KBI_Taster_Fahrwerk ), profileFile );
    writeProfileInt( "Kombi_01", "KBI_Taster_Lift", getValue( KCAN_KBI_Taster_Lift ), profileFile );
    writeProfileInt( "Kombi_01", "KBI_V_Digital", getValue( KCAN_KBI_V_Digital ), profileFile );
    writeProfileInt( "Kombi_01", "KBI_Vorglueh_System_Lampe", getValue( KCAN_KBI_Vorglueh_System_Lampe ), profileFile );

}


void saveSettings_Kombi_02( char profileFile[] )
{
    writeProfileInt( "Kombi_02", "KBI_FoD_PopUP_Quittiert", getValue( KCAN_KBI_FoD_PopUP_Quittiert ), profileFile );
    writeProfileInt( "Kombi_02", "KBI_FStatus_Tank", getValue( KCAN_KBI_FStatus_Tank ), profileFile );

}


void saveSettings_Kombi_03( char profileFile[] )
{
    writeProfileInt( "Kombi_03", "KBI_GAP_Warn_Zeit_abgelaufen", getValue( KCAN_KBI_GAP_Warn_Zeit_abgelaufen ), profileFile );
    writeProfileFloat( "Kombi_03", "KBI_Max_Tankinhalt", getValue( KCAN_KBI_Max_Tankinhalt ), profileFile );
    writeProfileInt( "Kombi_03", "KBI_Nachtanken_erkannt", getValue( KCAN_KBI_Nachtanken_erkannt ), profileFile );
    writeProfileInt( "Kombi_03", "KBI_Tankfuellstand_Prozent", getValue( KCAN_KBI_Tankfuellstand_Prozent ), profileFile );
    writeProfileFloat( "Kombi_03", "KBI_Tankinhalt_hochaufl", getValue( KCAN_KBI_Tankinhalt_hochaufl ), profileFile );

}


void saveSettings_Kombi_08( char profileFile[] )
{
    writeProfileInt( "Kombi_08", "AuthTime_Trigger_Distribution", getValue( KCAN_AuthTime_Trigger_Distribution ), profileFile );
    writeProfileFloat( "Kombi_08", "KBI_Min_Tankinhalt", getValue( KCAN_KBI_Min_Tankinhalt ), profileFile );
    writeProfileInt( "Kombi_08", "KBI_Weg_Zaehler", getValue( KCAN_KBI_Weg_Zaehler ), profileFile );

}


void saveSettings_Kombi_21( char profileFile[] )
{
    writeProfileInt( "Kombi_21", "KBI_BC_Reset_E1", getValue( KCAN_KBI_BC_Reset_E1 ), profileFile );
    writeProfileFloat( "Kombi_21", "KBI_Tankinhalt_roh", getValue( KCAN_KBI_Tankinhalt_roh ), profileFile );

}


void saveSettings_Kombi_HUD_01( char profileFile[] )
{
    writeProfileInt( "Kombi_HUD_01", "KBI_HUD_Data_01", getValue( KCAN_KBI_HUD_Data_01 ), profileFile );
    writeProfileInt( "Kombi_HUD_01", "KBI_HUD_Data_02", getValue( KCAN_KBI_HUD_Data_02 ), profileFile );
    writeProfileInt( "Kombi_HUD_01", "KBI_HUD_Data_03", getValue( KCAN_KBI_HUD_Data_03 ), profileFile );
    writeProfileInt( "Kombi_HUD_01", "KBI_HUD_Data_04", getValue( KCAN_KBI_HUD_Data_04 ), profileFile );
    writeProfileInt( "Kombi_HUD_01", "KBI_HUD_Data_05", getValue( KCAN_KBI_HUD_Data_05 ), profileFile );
    writeProfileInt( "Kombi_HUD_01", "KBI_HUD_Data_06", getValue( KCAN_KBI_HUD_Data_06 ), profileFile );
    writeProfileInt( "Kombi_HUD_01", "KBI_HUD_Data_07", getValue( KCAN_KBI_HUD_Data_07 ), profileFile );
    writeProfileInt( "Kombi_HUD_01", "KBI_HUD_Data_08", getValue( KCAN_KBI_HUD_Data_08 ), profileFile );

}


void saveSettings_KonzernrollenModus_01( char profileFile[] )
{
    writeProfileInt( "KonzernrollenModus_01", "KRM_Fehler_im_Konzernrollenmodus", getValue( KCAN_KRM_Fehler_im_Konzernrollenmodus ), profileFile );
    writeProfileInt( "KonzernrollenModus_01", "KRM_Konzernrollenmodus_aktiv", getValue( KCAN_KRM_Konzernrollenmodus_aktiv ), profileFile );

}


void saveSettings_KS_ICAS3Sys01_Req_FD( char profileFile[] )
{

}


void saveSettings_KS_ICAS3Sys01_Resp_FD( char profileFile[] )
{

}


void saveSettings_KS_Info_El_Req_FD( char profileFile[] )
{

}


void saveSettings_KS_Info_El_Resp_FD( char profileFile[] )
{

}


void saveSettings_KS_Kombi_Req_FD( char profileFile[] )
{

}


void saveSettings_KS_Kombi_Resp_FD( char profileFile[] )
{

}


void saveSettings_KS_SSN_ABT_1_Req( char profileFile[] )
{

}


void saveSettings_KS_SSN_ABT_1_Resp( char profileFile[] )
{

}


void saveSettings_LDW_02( char profileFile[] )
{
    writeProfileInt( "LDW_02", "aLDW_FoD_Status", getValue( KCAN_aLDW_FoD_Status ), profileFile );
    writeProfileInt( "LDW_02", "HC_Uss_Anforderung", getValue( KCAN_HC_Uss_Anforderung ), profileFile );
    writeProfileFloat( "LDW_02", "LDW_DLC", getValue( KCAN_LDW_DLC ), profileFile );
    writeProfileInt( "LDW_02", "LDW_Frueh_Spaet", getValue( KCAN_LDW_Frueh_Spaet ), profileFile );
    writeProfileInt( "LDW_02", "LDW_Gong", getValue( KCAN_LDW_Gong ), profileFile );
    writeProfileInt( "LDW_02", "LDW_Lernmodus_seitenabhaengig", getValue( KCAN_LDW_Lernmodus_seitenabhaengig ), profileFile );
    writeProfileInt( "LDW_02", "LDW_Seite_DLCTLC", getValue( KCAN_LDW_Seite_DLCTLC ), profileFile );
    writeProfileInt( "LDW_02", "LDW_Status_Grid", getValue( KCAN_LDW_Status_Grid ), profileFile );
    writeProfileInt( "LDW_02", "LDW_Status_LED_gelb", getValue( KCAN_LDW_Status_LED_gelb ), profileFile );
    writeProfileInt( "LDW_02", "LDW_Status_LED_gruen", getValue( KCAN_LDW_Status_LED_gruen ), profileFile );
    writeProfileInt( "LDW_02", "LDW_Texte", getValue( KCAN_LDW_Texte ), profileFile );
    writeProfileFloat( "LDW_02", "LDW_TLC", getValue( KCAN_LDW_TLC ), profileFile );

}


void saveSettings_LH_EPS_01( char profileFile[] )
{
    writeProfileInt( "LH_EPS_01", "EPS_01_BZ", getValue( KCAN_EPS_01_BZ ), profileFile );
    writeProfileInt( "LH_EPS_01", "EPS_01_CRC", getValue( KCAN_EPS_01_CRC ), profileFile );
    writeProfileInt( "LH_EPS_01", "EPS_Akustiksignal", getValue( KCAN_EPS_Akustiksignal ), profileFile );
    writeProfileInt( "LH_EPS_01", "EPS_Anf_KL", getValue( KCAN_EPS_Anf_KL ), profileFile );
    writeProfileInt( "LH_EPS_01", "EPS_ARA_Status", getValue( KCAN_EPS_ARA_Status ), profileFile );
    writeProfileInt( "LH_EPS_01", "EPS_Charisma_FahrPr", getValue( KCAN_EPS_Charisma_FahrPr ), profileFile );
    writeProfileInt( "LH_EPS_01", "EPS_Charisma_Status", getValue( KCAN_EPS_Charisma_Status ), profileFile );
    writeProfileInt( "LH_EPS_01", "EPS_Endanschlag", getValue( KCAN_EPS_Endanschlag ), profileFile );
    writeProfileInt( "LH_EPS_01", "EPS_Fehlerlampe", getValue( KCAN_EPS_Fehlerlampe ), profileFile );
    writeProfileInt( "LH_EPS_01", "EPS_Lenkerposition", getValue( KCAN_EPS_Lenkerposition ), profileFile );
    writeProfileInt( "LH_EPS_01", "EPS_PLA_Abbruch", getValue( KCAN_EPS_PLA_Abbruch ), profileFile );
    writeProfileInt( "LH_EPS_01", "EPS_PLA_Fehler", getValue( KCAN_EPS_PLA_Fehler ), profileFile );
    writeProfileInt( "LH_EPS_01", "EPS_PLA_Status", getValue( KCAN_EPS_PLA_Status ), profileFile );
    writeProfileInt( "LH_EPS_01", "EPS_SpannungsAnf", getValue( KCAN_EPS_SpannungsAnf ), profileFile );
    writeProfileInt( "LH_EPS_01", "EPS_Warnungen", getValue( KCAN_EPS_Warnungen ), profileFile );

}


void saveSettings_Licht_Anf_01( char profileFile[] )
{
    writeProfileInt( "Licht_Anf_01", "BCM1_Abblendlicht_Anf", getValue( KCAN_BCM1_Abblendlicht_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Adaptive_Lichtvert_Anf", getValue( KCAN_BCM1_Adaptive_Lichtvert_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Allwetterlicht_Anf", getValue( KCAN_BCM1_Allwetterlicht_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Autobahnlicht_Anf", getValue( KCAN_BCM1_Autobahnlicht_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_CH_aktiv", getValue( KCAN_BCM1_CH_aktiv ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_CH_LH_aktiv", getValue( KCAN_BCM1_CH_LH_aktiv ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Fahrlicht_Hinweis", getValue( KCAN_BCM1_Fahrlicht_Hinweis ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Fernlicht_Anf", getValue( KCAN_BCM1_Fernlicht_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Gleitende_Leuchtw_Anf", getValue( KCAN_BCM1_Gleitende_Leuchtw_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_GLW_Fernlicht_Anf", getValue( KCAN_BCM1_GLW_Fernlicht_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Hinweis_Lichtnachlauf", getValue( KCAN_BCM1_Hinweis_Lichtnachlauf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Kurvenlicht_links_Anf", getValue( KCAN_BCM1_Kurvenlicht_links_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Kurvenlicht_rechts_Anf", getValue( KCAN_BCM1_Kurvenlicht_rechts_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_LH_aktiv", getValue( KCAN_BCM1_LH_aktiv ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Lichtwarn_Texte", getValue( KCAN_BCM1_Lichtwarn_Texte ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Nebellicht_Anf", getValue( KCAN_BCM1_Nebellicht_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Nebelschluss_Ahg_Anf", getValue( KCAN_BCM1_Nebelschluss_Ahg_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Nebelschluss_Fzg_Anf", getValue( KCAN_BCM1_Nebelschluss_Fzg_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Parklicht_li_Anf", getValue( KCAN_BCM1_Parklicht_li_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Parklicht_re_Anf", getValue( KCAN_BCM1_Parklicht_re_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Regenlicht_Anf", getValue( KCAN_BCM1_Regenlicht_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Schlusslicht_Anf", getValue( KCAN_BCM1_Schlusslicht_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Signaturlicht_Anf", getValue( KCAN_BCM1_Signaturlicht_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Standlicht_Anf", getValue( KCAN_BCM1_Standlicht_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Tagfahrlicht_Anf", getValue( KCAN_BCM1_Tagfahrlicht_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Touristen_Licht_Anf", getValue( KCAN_BCM1_Touristen_Licht_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM1_Umfeldleuchten_Anf", getValue( KCAN_BCM1_Umfeldleuchten_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "BCM_Rueckfahrlicht_Anf", getValue( KCAN_BCM_Rueckfahrlicht_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "Licht_Anf_01_BZ", getValue( KCAN_Licht_Anf_01_BZ ), profileFile );
    writeProfileInt( "Licht_Anf_01", "Licht_Anf_01_CRC", getValue( KCAN_Licht_Anf_01_CRC ), profileFile );
    writeProfileInt( "Licht_Anf_01", "TFL_Matrix_Variante01_Anf", getValue( KCAN_TFL_Matrix_Variante01_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "TFL_Matrix_Variante02_Anf", getValue( KCAN_TFL_Matrix_Variante02_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "TFL_Matrix_Variante03_Anf", getValue( KCAN_TFL_Matrix_Variante03_Anf ), profileFile );
    writeProfileInt( "Licht_Anf_01", "TFL_Matrix_Variante04_Anf", getValue( KCAN_TFL_Matrix_Variante04_Anf ), profileFile );

}


void saveSettings_Licht_hinten_01( char profileFile[] )
{
    writeProfileInt( "Licht_hinten_01", "BRL_als_SHL", getValue( KCAN_BRL_als_SHL ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_3_Bremsl_def", getValue( KCAN_LH_3_Bremsl_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Aussenlicht_def", getValue( KCAN_LH_Aussenlicht_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Blinker_HL_akt", getValue( KCAN_LH_Blinker_HL_akt ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Blinker_HR_akt", getValue( KCAN_LH_Blinker_HR_akt ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Blinker_li_def", getValue( KCAN_LH_Blinker_li_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Blinker_re_def", getValue( KCAN_LH_Blinker_re_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Brems_Blk_li_def", getValue( KCAN_LH_Brems_Blk_li_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Brems_Blk_re_def", getValue( KCAN_LH_Brems_Blk_re_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Bremsl_li_def", getValue( KCAN_LH_Bremsl_li_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Bremsl_li_ges_def", getValue( KCAN_LH_Bremsl_li_ges_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Bremsl_mi_def", getValue( KCAN_LH_Bremsl_mi_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Bremsl_re_def", getValue( KCAN_LH_Bremsl_re_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Bremsl_re_ges_def", getValue( KCAN_LH_Bremsl_re_ges_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Bremslicht_H_aktiv", getValue( KCAN_LH_Bremslicht_H_aktiv ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Diag_LED_li_def", getValue( KCAN_LH_Diag_LED_li_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Diag_LED_re_def", getValue( KCAN_LH_Diag_LED_re_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Diag_Status_li_def", getValue( KCAN_LH_Diag_Status_li_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Diag_Status_re_def", getValue( KCAN_LH_Diag_Status_re_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Kennzl_def", getValue( KCAN_LH_Kennzl_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Nebel_li_def", getValue( KCAN_LH_Nebel_li_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Nebel_mi_def", getValue( KCAN_LH_Nebel_mi_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Nebel_re_def", getValue( KCAN_LH_Nebel_re_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Nebelschluss_aktiv", getValue( KCAN_LH_Nebelschluss_aktiv ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Parklicht_HL_aktiv", getValue( KCAN_LH_Parklicht_HL_aktiv ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Parklicht_HR_aktiv", getValue( KCAN_LH_Parklicht_HR_aktiv ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Rueckf_li_def", getValue( KCAN_LH_Rueckf_li_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Rueckf_mi_def", getValue( KCAN_LH_Rueckf_mi_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Rueckf_re_def", getValue( KCAN_LH_Rueckf_re_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Rueckfahrlicht_aktiv", getValue( KCAN_LH_Rueckfahrlicht_aktiv ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Schluss_Brems_li_def", getValue( KCAN_LH_Schluss_Brems_li_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Schluss_Brems_mi_def", getValue( KCAN_LH_Schluss_Brems_mi_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Schluss_Brems_Nebel_li_def", getValue( KCAN_LH_Schluss_Brems_Nebel_li_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Schluss_Brems_Nebel_re_def", getValue( KCAN_LH_Schluss_Brems_Nebel_re_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Schluss_Brems_re_def", getValue( KCAN_LH_Schluss_Brems_re_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Schluss_Nebel_li_def", getValue( KCAN_LH_Schluss_Nebel_li_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Schluss_Nebel_re_def", getValue( KCAN_LH_Schluss_Nebel_re_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Schlusslicht_li_def", getValue( KCAN_LH_Schlusslicht_li_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Schlusslicht_mi_def", getValue( KCAN_LH_Schlusslicht_mi_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Schlusslicht_re_def", getValue( KCAN_LH_Schlusslicht_re_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_SL_BRL_BLK_li_def", getValue( KCAN_LH_SL_BRL_BLK_li_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_SL_BRL_BLK_re_def", getValue( KCAN_LH_SL_BRL_BLK_re_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Standlicht_H_aktiv", getValue( KCAN_LH_Standlicht_H_aktiv ), profileFile );
    writeProfileInt( "Licht_hinten_01", "LH_Zusatzschlussl_def", getValue( KCAN_LH_Zusatzschlussl_def ), profileFile );
    writeProfileInt( "Licht_hinten_01", "Licht_hinten_01_BZ", getValue( KCAN_Licht_hinten_01_BZ ), profileFile );

}


void saveSettings_Licht_vorne_01( char profileFile[] )
{
    writeProfileInt( "Licht_vorne_01", "BCM1_Licht_Dunkelheit_aktiv", getValue( KCAN_BCM1_Licht_Dunkelheit_aktiv ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Abbiegelicht_li_def", getValue( KCAN_LV_Abbiegelicht_li_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Abbiegelicht_re_def", getValue( KCAN_LV_Abbiegelicht_re_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Abblend_Fernlicht_li_def", getValue( KCAN_LV_Abblend_Fernlicht_li_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Abblend_Fernlicht_re_def", getValue( KCAN_LV_Abblend_Fernlicht_re_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Abblendlicht_Anzeige", getValue( KCAN_LV_Abblendlicht_Anzeige ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Abblendlicht_li_def", getValue( KCAN_LV_Abblendlicht_li_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Abblendlicht_re_def", getValue( KCAN_LV_Abblendlicht_re_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Abblendlicht_TFL_li_def", getValue( KCAN_LV_Abblendlicht_TFL_li_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Abblendlicht_TFL_re_def", getValue( KCAN_LV_Abblendlicht_TFL_re_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_AFL_aktiv_Anzeige", getValue( KCAN_LV_AFL_aktiv_Anzeige ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_AFL_defekt", getValue( KCAN_LV_AFL_defekt ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Aussenlicht_def", getValue( KCAN_LV_Aussenlicht_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Blinker_li_def", getValue( KCAN_LV_Blinker_li_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Blinker_re_def", getValue( KCAN_LV_Blinker_re_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Blinker_VL_aktiv", getValue( KCAN_LV_Blinker_VL_aktiv ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Blinker_VR_aktiv", getValue( KCAN_LV_Blinker_VR_aktiv ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Blk_li_Seite_def", getValue( KCAN_LV_Blk_li_Seite_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Blk_re_Seite_def", getValue( KCAN_LV_Blk_re_Seite_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Fernlicht_Anzeige", getValue( KCAN_LV_Fernlicht_Anzeige ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Fernlicht_li_def", getValue( KCAN_LV_Fernlicht_li_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Fernlicht_re_def", getValue( KCAN_LV_Fernlicht_re_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_FLA_aktiv_Anzeige", getValue( KCAN_LV_FLA_aktiv_Anzeige ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_FLA_defekt", getValue( KCAN_LV_FLA_defekt ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_FLA_Sensor_blockiert", getValue( KCAN_LV_FLA_Sensor_blockiert ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_LED_Scheinwerfer_li_def", getValue( KCAN_LV_LED_Scheinwerfer_li_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_LED_Scheinwerfer_re_def", getValue( KCAN_LV_LED_Scheinwerfer_re_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_MXB_Status_Anzeige", getValue( KCAN_LV_MXB_Status_Anzeige ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Nebellicht_Anzeige", getValue( KCAN_LV_Nebellicht_Anzeige ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Nebellicht_li_def", getValue( KCAN_LV_Nebellicht_li_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Nebellicht_re_def", getValue( KCAN_LV_Nebellicht_re_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Nebellicht_TFL_li_def", getValue( KCAN_LV_Nebellicht_TFL_li_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Nebellicht_TFL_re_def", getValue( KCAN_LV_Nebellicht_TFL_re_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Nebelschlusslicht_Anzeige", getValue( KCAN_LV_Nebelschlusslicht_Anzeige ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Standlicht_Anzeige", getValue( KCAN_LV_Standlicht_Anzeige ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Standlicht_li_def", getValue( KCAN_LV_Standlicht_li_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Standlicht_re_def", getValue( KCAN_LV_Standlicht_re_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Standlicht_TFL_li_def", getValue( KCAN_LV_Standlicht_TFL_li_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Standlicht_TFL_re_def", getValue( KCAN_LV_Standlicht_TFL_re_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Tagfahrlicht_Anzeige", getValue( KCAN_LV_Tagfahrlicht_Anzeige ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Tagfahrlicht_li_def", getValue( KCAN_LV_Tagfahrlicht_li_def ), profileFile );
    writeProfileInt( "Licht_vorne_01", "LV_Tagfahrlicht_re_def", getValue( KCAN_LV_Tagfahrlicht_re_def ), profileFile );

}


void saveSettings_LiSi_01( char profileFile[] )
{
    writeProfileInt( "LiSi_01", "LiSi_Defrost_Taste", getValue( KCAN_LiSi_Defrost_Taste ), profileFile );
    writeProfileInt( "LiSi_01", "LiSi_FSH_Taste", getValue( KCAN_LiSi_FSH_Taste ), profileFile );
    writeProfileInt( "LiSi_01", "LiSi_HSH_Taste", getValue( KCAN_LiSi_HSH_Taste ), profileFile );
    writeProfileInt( "LiSi_01", "LiSi_Touch_Event", getValue( KCAN_LiSi_Touch_Event ), profileFile );
    writeProfileInt( "LiSi_01", "LTM_01_BZ", getValue( KCAN_LTM_01_BZ ), profileFile );
    writeProfileInt( "LiSi_01", "LTM_01_CRC", getValue( KCAN_LTM_01_CRC ), profileFile );
    writeProfileInt( "LiSi_01", "LTM_Autolicht", getValue( KCAN_LTM_Autolicht ), profileFile );
    writeProfileInt( "LiSi_01", "LTM_Beruehrung", getValue( KCAN_LTM_Beruehrung ), profileFile );
    writeProfileInt( "LiSi_01", "LTM_Lokalaktiv", getValue( KCAN_LTM_Lokalaktiv ), profileFile );
    writeProfileInt( "LiSi_01", "LTM_Nebellicht", getValue( KCAN_LTM_Nebellicht ), profileFile );
    writeProfileInt( "LiSi_01", "LTM_Nebelschlusslicht", getValue( KCAN_LTM_Nebelschlusslicht ), profileFile );
    writeProfileInt( "LiSi_01", "LTM_ResponseError", getValue( KCAN_LTM_ResponseError ), profileFile );
    writeProfileInt( "LiSi_01", "LTM_StatusLichttastenmodul", getValue( KCAN_LTM_StatusLichttastenmodul ), profileFile );
    writeProfileInt( "LiSi_01", "LTM_Variante", getValue( KCAN_LTM_Variante ), profileFile );

}


void saveSettings_LWI_01( char profileFile[] )
{
    writeProfileInt( "LWI_01", "LWI_01_BZ", getValue( KCAN_LWI_01_BZ ), profileFile );
    writeProfileInt( "LWI_01", "LWI_01_CRC", getValue( KCAN_LWI_01_CRC ), profileFile );
    writeProfileInt( "LWI_01", "LWI_Lenkradw_Geschw", getValue( KCAN_LWI_Lenkradw_Geschw ), profileFile );
    writeProfileFloat( "LWI_01", "LWI_Lenkradwinkel", getValue( KCAN_LWI_Lenkradwinkel ), profileFile );
    writeProfileInt( "LWI_01", "LWI_QBit_Lenkradwinkel", getValue( KCAN_LWI_QBit_Lenkradwinkel ), profileFile );
    writeProfileInt( "LWI_01", "LWI_QBit_Sub_Daten", getValue( KCAN_LWI_QBit_Sub_Daten ), profileFile );
    writeProfileInt( "LWI_01", "LWI_Sensorstatus", getValue( KCAN_LWI_Sensorstatus ), profileFile );
    writeProfileInt( "LWI_01", "LWI_Sub_Daten", getValue( KCAN_LWI_Sub_Daten ), profileFile );
    writeProfileInt( "LWI_01", "LWI_VZ_Lenkradw_Geschw", getValue( KCAN_LWI_VZ_Lenkradw_Geschw ), profileFile );
    writeProfileInt( "LWI_01", "LWI_VZ_Lenkradwinkel", getValue( KCAN_LWI_VZ_Lenkradwinkel ), profileFile );

}


void saveSettings_MainUnit_01( char profileFile[] )
{
    writeProfileInt( "MainUnit_01", "DSSS_Warning", getValue( KCAN_DSSS_Warning ), profileFile );
    writeProfileInt( "MainUnit_01", "MIB_ASW_Diagnose", getValue( KCAN_MIB_ASW_Diagnose ), profileFile );
    writeProfileInt( "MainUnit_01", "MIB_Tongenerator_PH_verfuegbar", getValue( KCAN_MIB_Tongenerator_PH_verfuegbar ), profileFile );
    writeProfileInt( "MainUnit_01", "MMI_Counter_Bedienevent", getValue( KCAN_MMI_Counter_Bedienevent ), profileFile );
    writeProfileInt( "MainUnit_01", "MMI_Gurt_Mic_ref", getValue( KCAN_MMI_Gurt_Mic_ref ), profileFile );
    writeProfileInt( "MainUnit_01", "MMI_SDS_aktiv", getValue( KCAN_MMI_SDS_aktiv ), profileFile );
    writeProfileInt( "MainUnit_01", "MMI_Telefon_aktiv", getValue( KCAN_MMI_Telefon_aktiv ), profileFile );
    writeProfileInt( "MainUnit_01", "MU_SecondDisplay", getValue( KCAN_MU_SecondDisplay ), profileFile );
    writeProfileFloat( "MainUnit_01", "MU_Update_Time", getValue( KCAN_MU_Update_Time ), profileFile );
    writeProfileInt( "MainUnit_01", "Nav_FoD_Status", getValue( KCAN_Nav_FoD_Status ), profileFile );
    writeProfileInt( "MainUnit_01", "ZR_AppConnect_Zustand", getValue( KCAN_ZR_AppConnect_Zustand ), profileFile );
    writeProfileInt( "MainUnit_01", "ZR_Kindersicherung_RSE", getValue( KCAN_ZR_Kindersicherung_RSE ), profileFile );
    writeProfileInt( "MainUnit_01", "ZR_Lichter_Tag", getValue( KCAN_ZR_Lichter_Tag ), profileFile );
    writeProfileInt( "MainUnit_01", "ZR_LoGeWa_Event_Kombiwarnung", getValue( KCAN_ZR_LoGeWa_Event_Kombiwarnung ), profileFile );
    writeProfileInt( "MainUnit_01", "ZR_Parken_Sondermodus", getValue( KCAN_ZR_Parken_Sondermodus ), profileFile );
    writeProfileInt( "MainUnit_01", "ZR_RSE_aktivieren", getValue( KCAN_ZR_RSE_aktivieren ), profileFile );

}


void saveSettings_Mem_BFS_01( char profileFile[] )
{
    writeProfileInt( "Mem_BFS_01", "BFS_Fond_Bed_Ack", getValue( KCAN_BFS_Fond_Bed_Ack ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_FSV_ausgeklappt", getValue( KCAN_BFS_FSV_ausgeklappt ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_GHV_aktiv", getValue( KCAN_BFS_GHV_aktiv ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_Gurtbringer_Sperre", getValue( KCAN_BFS_Gurtbringer_Sperre ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_Klapptisch_offen", getValue( KCAN_BFS_Klapptisch_offen ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_KSS_Fahrt_aktiv", getValue( KCAN_BFS_KSS_Fahrt_aktiv ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_KSV_aktiv", getValue( KCAN_BFS_KSV_aktiv ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_Lehne_nicht_verriegelt", getValue( KCAN_BFS_Lehne_nicht_verriegelt ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_LHV_aktiv", getValue( KCAN_BFS_LHV_aktiv ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_LKV_aktiv", getValue( KCAN_BFS_LKV_aktiv ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_LNV_aktiv", getValue( KCAN_BFS_LNV_aktiv ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_LWV_aktiv", getValue( KCAN_BFS_LWV_aktiv ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_MMB_glob_stop", getValue( KCAN_BFS_MMB_glob_stop ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_MMB_lokal_Stop", getValue( KCAN_BFS_MMB_lokal_Stop ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_MMB_storage", getValue( KCAN_BFS_MMB_storage ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_MMB_storage_beep", getValue( KCAN_BFS_MMB_storage_beep ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_MMB_store", getValue( KCAN_BFS_MMB_store ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_MMB_store_LED_on", getValue( KCAN_BFS_MMB_store_LED_on ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_MMB_tast", getValue( KCAN_BFS_MMB_tast ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_MMB_tipp", getValue( KCAN_BFS_MMB_tipp ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_Ruhestellung_Status", getValue( KCAN_BFS_Ruhestellung_Status ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_Seat_Locked", getValue( KCAN_BFS_Seat_Locked ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_SHV_aktiv", getValue( KCAN_BFS_SHV_aktiv ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_Sitzfahrt_aktiv", getValue( KCAN_BFS_Sitzfahrt_aktiv ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_Sitzsym_Fahrt_aktiv", getValue( KCAN_BFS_Sitzsym_Fahrt_aktiv ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_SLV_aktiv", getValue( KCAN_BFS_SLV_aktiv ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_SNV_aktiv", getValue( KCAN_BFS_SNV_aktiv ), profileFile );
    writeProfileInt( "Mem_BFS_01", "BFS_STV_aktiv", getValue( KCAN_BFS_STV_aktiv ), profileFile );

}


void saveSettings_Mem_FS_01( char profileFile[] )
{
    writeProfileInt( "Mem_FS_01", "FS_BFS_Fond_Verst_enable", getValue( KCAN_FS_BFS_Fond_Verst_enable ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_BFS_KSS_Anfahrt", getValue( KCAN_FS_BFS_KSS_Anfahrt ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_BFS_Sitzsym_Anfahrt", getValue( KCAN_FS_BFS_Sitzsym_Anfahrt ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_EE_BFS_enable", getValue( KCAN_FS_EE_BFS_enable ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_EE_Fond_BFS_enable", getValue( KCAN_FS_EE_Fond_BFS_enable ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_EE_Fond_FS_enable", getValue( KCAN_FS_EE_Fond_FS_enable ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_Fond_Bed_enable", getValue( KCAN_FS_Fond_Bed_enable ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_GHV_aktiv", getValue( KCAN_FS_GHV_aktiv ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_Gurtbringer_Sperre", getValue( KCAN_FS_Gurtbringer_Sperre ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_KSV_aktiv", getValue( KCAN_FS_KSV_aktiv ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_Lehne_nicht_verriegelt", getValue( KCAN_FS_Lehne_nicht_verriegelt ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_LHV_aktiv", getValue( KCAN_FS_LHV_aktiv ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_LKV_aktiv", getValue( KCAN_FS_LKV_aktiv ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_LNV_aktiv", getValue( KCAN_FS_LNV_aktiv ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_LWV_aktiv", getValue( KCAN_FS_LWV_aktiv ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_MMB_glob_stop", getValue( KCAN_FS_MMB_glob_stop ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_MMB_lokal_Stop", getValue( KCAN_FS_MMB_lokal_Stop ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_MMB_storage", getValue( KCAN_FS_MMB_storage ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_MMB_storage_beep", getValue( KCAN_FS_MMB_storage_beep ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_MMB_store", getValue( KCAN_FS_MMB_store ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_MMB_store_LED_on", getValue( KCAN_FS_MMB_store_LED_on ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_MMB_tast", getValue( KCAN_FS_MMB_tast ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_MMB_tipp", getValue( KCAN_FS_MMB_tipp ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_SHV_aktiv", getValue( KCAN_FS_SHV_aktiv ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_Sitzfahrt_aktiv", getValue( KCAN_FS_Sitzfahrt_aktiv ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_SLV_aktiv", getValue( KCAN_FS_SLV_aktiv ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_SNV_aktiv", getValue( KCAN_FS_SNV_aktiv ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_Spezialposition_anfahren", getValue( KCAN_FS_Spezialposition_anfahren ), profileFile );
    writeProfileInt( "Mem_FS_01", "FS_STV_aktiv", getValue( KCAN_FS_STV_aktiv ), profileFile );

}


void saveSettings_MFG_01( char profileFile[] )
{
    writeProfileInt( "MFG_01", "MF_Abzugssperre", getValue( KCAN_MF_Abzugssperre ), profileFile );
    writeProfileInt( "MFG_01", "MF_Alarm_Blinker", getValue( KCAN_MF_Alarm_Blinker ), profileFile );
    writeProfileInt( "MFG_01", "MF_Alarm_Blinkertakt", getValue( KCAN_MF_Alarm_Blinkertakt ), profileFile );
    writeProfileInt( "MFG_01", "MF_Anlassersperre", getValue( KCAN_MF_Anlassersperre ), profileFile );
    writeProfileInt( "MFG_01", "MF_Blk_li", getValue( KCAN_MF_Blk_li ), profileFile );
    writeProfileInt( "MFG_01", "MF_Blk_re", getValue( KCAN_MF_Blk_re ), profileFile );
    writeProfileInt( "MFG_01", "MF_BT_entriegeln", getValue( KCAN_MF_BT_entriegeln ), profileFile );
    writeProfileInt( "MFG_01", "MF_BT_verriegeln", getValue( KCAN_MF_BT_verriegeln ), profileFile );
    writeProfileInt( "MFG_01", "MF_Fahrlicht", getValue( KCAN_MF_Fahrlicht ), profileFile );
    writeProfileInt( "MFG_01", "MF_Fernbed_ein", getValue( KCAN_MF_Fernbed_ein ), profileFile );
    writeProfileInt( "MFG_01", "MF_Fernlicht", getValue( KCAN_MF_Fernlicht ), profileFile );
    writeProfileInt( "MFG_01", "MF_FH_BT_hoch", getValue( KCAN_MF_FH_BT_hoch ), profileFile );
    writeProfileInt( "MFG_01", "MF_FH_BT_tief", getValue( KCAN_MF_FH_BT_tief ), profileFile );
    writeProfileInt( "MFG_01", "MF_FH_FT_hoch", getValue( KCAN_MF_FH_FT_hoch ), profileFile );
    writeProfileInt( "MFG_01", "MF_FH_FT_tief", getValue( KCAN_MF_FH_FT_tief ), profileFile );
    writeProfileInt( "MFG_01", "MF_Frontintervall", getValue( KCAN_MF_Frontintervall ), profileFile );
    writeProfileInt( "MFG_01", "MF_Frontwaschen", getValue( KCAN_MF_Frontwaschen ), profileFile );
    writeProfileInt( "MFG_01", "MF_FT_entriegeln", getValue( KCAN_MF_FT_entriegeln ), profileFile );
    writeProfileInt( "MFG_01", "MF_FT_verriegeln", getValue( KCAN_MF_FT_verriegeln ), profileFile );
    writeProfileInt( "MFG_01", "MF_Fussraumbel", getValue( KCAN_MF_Fussraumbel ), profileFile );
    writeProfileInt( "MFG_01", "MF_HBFS_entriegeln", getValue( KCAN_MF_HBFS_entriegeln ), profileFile );
    writeProfileInt( "MFG_01", "MF_HBFS_verriegeln", getValue( KCAN_MF_HBFS_verriegeln ), profileFile );
    writeProfileInt( "MFG_01", "MF_Heckintervall", getValue( KCAN_MF_Heckintervall ), profileFile );
    writeProfileInt( "MFG_01", "MF_Heckwaschen", getValue( KCAN_MF_Heckwaschen ), profileFile );
    writeProfileInt( "MFG_01", "MF_HFS_entriegeln", getValue( KCAN_MF_HFS_entriegeln ), profileFile );
    writeProfileInt( "MFG_01", "MF_HFS_verriegeln", getValue( KCAN_MF_HFS_verriegeln ), profileFile );
    writeProfileInt( "MFG_01", "MF_Innenraumbel", getValue( KCAN_MF_Innenraumbel ), profileFile );
    writeProfileInt( "MFG_01", "MF_Innenraumbel_Unterdrueck", getValue( KCAN_MF_Innenraumbel_Unterdrueck ), profileFile );
    writeProfileInt( "MFG_01", "MF_interm_Fahrlicht", getValue( KCAN_MF_interm_Fahrlicht ), profileFile );
    writeProfileInt( "MFG_01", "MF_interm_Fernlicht", getValue( KCAN_MF_interm_Fernlicht ), profileFile );
    writeProfileInt( "MFG_01", "MF_interm_Takt", getValue( KCAN_MF_interm_Takt ), profileFile );
    writeProfileInt( "MFG_01", "MF_Laderelais", getValue( KCAN_MF_Laderelais ), profileFile );
    writeProfileInt( "MFG_01", "MF_Lichthupe", getValue( KCAN_MF_Lichthupe ), profileFile );
    writeProfileInt( "MFG_01", "MF_Motorweiterlauf", getValue( KCAN_MF_Motorweiterlauf ), profileFile );
    writeProfileInt( "MFG_01", "MF_nachtr_Stopp_Anf", getValue( KCAN_MF_nachtr_Stopp_Anf ), profileFile );
    writeProfileInt( "MFG_01", "MF_Notstart", getValue( KCAN_MF_Notstart ), profileFile );
    writeProfileInt( "MFG_01", "MF_Schluessel_scan", getValue( KCAN_MF_Schluessel_scan ), profileFile );
    writeProfileInt( "MFG_01", "MF_Signalhorn", getValue( KCAN_MF_Signalhorn ), profileFile );
    writeProfileInt( "MFG_01", "MF_Standlicht", getValue( KCAN_MF_Standlicht ), profileFile );
    writeProfileInt( "MFG_01", "MF_StartStopp_Info", getValue( KCAN_MF_StartStopp_Info ), profileFile );
    writeProfileInt( "MFG_01", "MF_Summer", getValue( KCAN_MF_Summer ), profileFile );
    writeProfileInt( "MFG_01", "MF_TFL_Abschaltung", getValue( KCAN_MF_TFL_Abschaltung ), profileFile );
    writeProfileInt( "MFG_01", "MF_Tippwischen", getValue( KCAN_MF_Tippwischen ), profileFile );
    writeProfileInt( "MFG_01", "MF_Tuerentriegelung_hinten", getValue( KCAN_MF_Tuerentriegelung_hinten ), profileFile );
    writeProfileInt( "MFG_01", "MF_Variante", getValue( KCAN_MF_Variante ), profileFile );
    writeProfileInt( "MFG_01", "MF_Warnblinker", getValue( KCAN_MF_Warnblinker ), profileFile );
    writeProfileInt( "MFG_01", "MF_Wischerstufe_1", getValue( KCAN_MF_Wischerstufe_1 ), profileFile );
    writeProfileInt( "MFG_01", "MF_Wischerstufe_2", getValue( KCAN_MF_Wischerstufe_2 ), profileFile );
    writeProfileInt( "MFG_01", "MF_ZV_Lock", getValue( KCAN_MF_ZV_Lock ), profileFile );
    writeProfileInt( "MFG_01", "MFG_01_BZ", getValue( KCAN_MFG_01_BZ ), profileFile );
    writeProfileInt( "MFG_01", "MFG_01_CRC", getValue( KCAN_MFG_01_CRC ), profileFile );

}


void saveSettings_MFL_01( char profileFile[] )
{
    writeProfileInt( "MFL_01", "MFL_Dummy_0_Signal_1", getValue( KCAN_MFL_Dummy_0_Signal_1 ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Dummy_0_Signal_3", getValue( KCAN_MFL_Dummy_0_Signal_3 ), profileFile );
    writeProfileInt( "MFL_01", "MFL_ECU_Err", getValue( KCAN_MFL_ECU_Err ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Eventcode_1_MFL_01", getValue( KCAN_MFL_Eventcode_1_MFL_01 ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Eventcode_2_MFL_01", getValue( KCAN_MFL_Eventcode_2_MFL_01 ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Fehler_Codierung", getValue( KCAN_MFL_Fehler_Codierung ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Lokalaktiv", getValue( KCAN_MFL_Lokalaktiv ), profileFile );
    writeProfileInt( "MFL_01", "MFL_LR_HZG_Err", getValue( KCAN_MFL_LR_HZG_Err ), profileFile );
    writeProfileInt( "MFL_01", "MFL_LR_HZG_Status", getValue( KCAN_MFL_LR_HZG_Status ), profileFile );
    writeProfileInt( "MFL_01", "MFL_M_Taste", getValue( KCAN_MFL_M_Taste ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Marke_MFL_01", getValue( KCAN_MFL_Marke_MFL_01 ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Paddle_Verbau", getValue( KCAN_MFL_Paddle_Verbau ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Response_Err", getValue( KCAN_MFL_Response_Err ), profileFile );
    writeProfileInt( "MFL_01", "MFL_SatModul_links_Err", getValue( KCAN_MFL_SatModul_links_Err ), profileFile );
    writeProfileInt( "MFL_01", "MFL_SatModul_rechts_Err", getValue( KCAN_MFL_SatModul_rechts_Err ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Signalhorn", getValue( KCAN_MFL_Signalhorn ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Signalhorn_Err", getValue( KCAN_MFL_Signalhorn_Err ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Taste_links_Err", getValue( KCAN_MFL_Taste_links_Err ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Taste_rechts_Err", getValue( KCAN_MFL_Taste_rechts_Err ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Tastencode_1_MFL_01", getValue( KCAN_MFL_Tastencode_1_MFL_01 ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Tastencode_2_MFL_01", getValue( KCAN_MFL_Tastencode_2_MFL_01 ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Tip_Down", getValue( KCAN_MFL_Tip_Down ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Tip_links_Err", getValue( KCAN_MFL_Tip_links_Err ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Tip_rechts_Err", getValue( KCAN_MFL_Tip_rechts_Err ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Tip_Up", getValue( KCAN_MFL_Tip_Up ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Toggle", getValue( KCAN_MFL_Toggle ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Variante_MFL_01", getValue( KCAN_MFL_Variante_MFL_01 ), profileFile );
    writeProfileInt( "MFL_01", "MFL_Zaehler", getValue( KCAN_MFL_Zaehler ), profileFile );

}


void saveSettings_MFL_02( char profileFile[] )
{
    writeProfileInt( "MFL_02", "MFL_Beruehrungserkennung", getValue( KCAN_MFL_Beruehrungserkennung ), profileFile );
    writeProfileInt( "MFL_02", "MFL_Touch_Event", getValue( KCAN_MFL_Touch_Event ), profileFile );

}


void saveSettings_MFL_Anf_01( char profileFile[] )
{
    writeProfileInt( "MFL_Anf_01", "MFL_Taste_SDS_benoetigt", getValue( KCAN_MFL_Taste_SDS_benoetigt ), profileFile );
    writeProfileInt( "MFL_Anf_01", "MFL_Tasten_UpDownOK_benoetigt", getValue( KCAN_MFL_Tasten_UpDownOK_benoetigt ), profileFile );
    writeProfileInt( "MFL_Anf_01", "MFL_Tasten_Volume_benoetigt", getValue( KCAN_MFL_Tasten_Volume_benoetigt ), profileFile );
    writeProfileInt( "MFL_Anf_01", "MFL_Vibrationsimpuls_links", getValue( KCAN_MFL_Vibrationsimpuls_links ), profileFile );
    writeProfileInt( "MFL_Anf_01", "MFL_Vibrationsimpuls_rechts", getValue( KCAN_MFL_Vibrationsimpuls_rechts ), profileFile );

}


void saveSettings_MFL_Tasten_Kon_01( char profileFile[] )
{
    writeProfileInt( "MFL_Tasten_Kon_01", "MFL_Eventcode_1", getValue( KCAN_MFL_Eventcode_1 ), profileFile );
    writeProfileInt( "MFL_Tasten_Kon_01", "MFL_Eventcode_2", getValue( KCAN_MFL_Eventcode_2 ), profileFile );
    writeProfileInt( "MFL_Tasten_Kon_01", "MFL_Marke", getValue( KCAN_MFL_Marke ), profileFile );
    writeProfileInt( "MFL_Tasten_Kon_01", "MFL_Tastencode_1", getValue( KCAN_MFL_Tastencode_1 ), profileFile );
    writeProfileInt( "MFL_Tasten_Kon_01", "MFL_Tastencode_2", getValue( KCAN_MFL_Tastencode_2 ), profileFile );
    writeProfileInt( "MFL_Tasten_Kon_01", "MFL_Variante", getValue( KCAN_MFL_Variante ), profileFile );

}


void saveSettings_Motor_14( char profileFile[] )
{
    writeProfileInt( "Motor_14", "MO_Aussp_Anlass", getValue( KCAN_MO_Aussp_Anlass ), profileFile );
    writeProfileInt( "Motor_14", "MO_BKV_Unterdruckwarnung", getValue( KCAN_MO_BKV_Unterdruckwarnung ), profileFile );
    writeProfileInt( "Motor_14", "MO_BLS", getValue( KCAN_MO_BLS ), profileFile );
    writeProfileInt( "Motor_14", "MO_BMS_NV_Anf_stuetzen", getValue( KCAN_MO_BMS_NV_Anf_stuetzen ), profileFile );
    writeProfileInt( "Motor_14", "MO_EKlKomLeiRed", getValue( KCAN_MO_EKlKomLeiRed ), profileFile );
    writeProfileInt( "Motor_14", "MO_Ext_E_Fahrt_aktiv", getValue( KCAN_MO_Ext_E_Fahrt_aktiv ), profileFile );
    writeProfileInt( "Motor_14", "MO_Fahrer_bremst", getValue( KCAN_MO_Fahrer_bremst ), profileFile );
    writeProfileInt( "Motor_14", "MO_FMAus_aktiv", getValue( KCAN_MO_FMAus_aktiv ), profileFile );
    writeProfileInt( "Motor_14", "MO_FMAus_Startvariante", getValue( KCAN_MO_FMAus_Startvariante ), profileFile );
    writeProfileInt( "Motor_14", "MO_Freig_Anlass", getValue( KCAN_MO_Freig_Anlass ), profileFile );
    writeProfileInt( "Motor_14", "MO_Freig_Reku", getValue( KCAN_MO_Freig_Reku ), profileFile );
    writeProfileInt( "Motor_14", "MO_Freigabe_Segeln", getValue( KCAN_MO_Freigabe_Segeln ), profileFile );
    writeProfileInt( "Motor_14", "MO_Gangposition", getValue( KCAN_MO_Gangposition ), profileFile );
    writeProfileInt( "Motor_14", "MO_Handshake_STH", getValue( KCAN_MO_Handshake_STH ), profileFile );
    writeProfileInt( "Motor_14", "MO_HYB_Fahrbereitschaft", getValue( KCAN_MO_HYB_Fahrbereitschaft ), profileFile );
    writeProfileInt( "Motor_14", "MO_HYB_VM_aktiv", getValue( KCAN_MO_HYB_VM_aktiv ), profileFile );
    writeProfileInt( "Motor_14", "MO_Interlock", getValue( KCAN_MO_Interlock ), profileFile );
    writeProfileInt( "Motor_14", "MO_Kickdown", getValue( KCAN_MO_Kickdown ), profileFile );
    writeProfileInt( "Motor_14", "MO_Kl_50", getValue( KCAN_MO_Kl_50 ), profileFile );
    writeProfileInt( "Motor_14", "MO_Kl_75", getValue( KCAN_MO_Kl_75 ), profileFile );
    writeProfileInt( "Motor_14", "MO_Klima_Eingr", getValue( KCAN_MO_Klima_Eingr ), profileFile );
    writeProfileInt( "Motor_14", "MO_Konsistenz_Bremsped", getValue( KCAN_MO_Konsistenz_Bremsped ), profileFile );
    writeProfileInt( "Motor_14", "MO_Kuppl_schalter", getValue( KCAN_MO_Kuppl_schalter ), profileFile );
    writeProfileInt( "Motor_14", "MO_Motor_laeuft", getValue( KCAN_MO_Motor_laeuft ), profileFile );
    writeProfileInt( "Motor_14", "MO_PTC_Status", getValue( KCAN_MO_PTC_Status ), profileFile );
    writeProfileInt( "Motor_14", "MO_QBit_Fahrer_bremst", getValue( KCAN_MO_QBit_Fahrer_bremst ), profileFile );
    writeProfileInt( "Motor_14", "MO_QBit_Gangposition", getValue( KCAN_MO_QBit_Gangposition ), profileFile );
    writeProfileInt( "Motor_14", "MO_QBit_KL_75", getValue( KCAN_MO_QBit_KL_75 ), profileFile );
    writeProfileInt( "Motor_14", "MO_Remotestart_Betrieb", getValue( KCAN_MO_Remotestart_Betrieb ), profileFile );
    writeProfileInt( "Motor_14", "MO_Remotestart_moeglich", getValue( KCAN_MO_Remotestart_moeglich ), profileFile );
    writeProfileInt( "Motor_14", "MO_Signalquelle_Gangposition", getValue( KCAN_MO_Signalquelle_Gangposition ), profileFile );
    writeProfileInt( "Motor_14", "MO_StartStopp_Fahrerwunsch", getValue( KCAN_MO_StartStopp_Fahrerwunsch ), profileFile );
    writeProfileInt( "Motor_14", "MO_StartStopp_Motorstopp", getValue( KCAN_MO_StartStopp_Motorstopp ), profileFile );
    writeProfileInt( "Motor_14", "MO_StartStopp_Status", getValue( KCAN_MO_StartStopp_Status ), profileFile );
    writeProfileInt( "Motor_14", "MO_StartStopp_Wiederstart", getValue( KCAN_MO_StartStopp_Wiederstart ), profileFile );
    writeProfileInt( "Motor_14", "MO_StartVorauss_erfuellt", getValue( KCAN_MO_StartVorauss_erfuellt ), profileFile );
    writeProfileInt( "Motor_14", "MO_Timeout_ESP", getValue( KCAN_MO_Timeout_ESP ), profileFile );
    writeProfileInt( "Motor_14", "MO_Zylinderabschaltung", getValue( KCAN_MO_Zylinderabschaltung ), profileFile );
    writeProfileInt( "Motor_14", "Motor_14_BZ", getValue( KCAN_Motor_14_BZ ), profileFile );
    writeProfileInt( "Motor_14", "Motor_14_CRC", getValue( KCAN_Motor_14_CRC ), profileFile );

}


void saveSettings_Motor_18( char profileFile[] )
{
    writeProfileInt( "Motor_18", "MO1_Freigabe_Info_WFS", getValue( KCAN_MO1_Freigabe_Info_WFS ), profileFile );
    writeProfileInt( "Motor_18", "MO1_Freigabe_Verfallsinfo_WFS", getValue( KCAN_MO1_Freigabe_Verfallsinfo_WFS ), profileFile );
    writeProfileInt( "Motor_18", "MO1_Sperr_Info_WFS", getValue( KCAN_MO1_Sperr_Info_WFS ), profileFile );
    writeProfileInt( "Motor_18", "MO_Abstellzeit", getValue( KCAN_MO_Abstellzeit ), profileFile );
    writeProfileInt( "Motor_18", "MO_Abstellzeit_Status", getValue( KCAN_MO_Abstellzeit_Status ), profileFile );
    writeProfileInt( "Motor_18", "MO_ANC_Kennfeld_Anf", getValue( KCAN_MO_ANC_Kennfeld_Anf ), profileFile );
    writeProfileInt( "Motor_18", "MO_Anzahl_Abgesch_Zyl", getValue( KCAN_MO_Anzahl_Abgesch_Zyl ), profileFile );
    writeProfileInt( "Motor_18", "MO_Bremslicht_Reku", getValue( KCAN_MO_Bremslicht_Reku ), profileFile );
    writeProfileInt( "Motor_18", "MO_Drehzahl_Warnung", getValue( KCAN_MO_Drehzahl_Warnung ), profileFile );
    writeProfileInt( "Motor_18", "MO_EPCL", getValue( KCAN_MO_EPCL ), profileFile );
    writeProfileInt( "Motor_18", "MO_Ethanol_BS_Texte", getValue( KCAN_MO_Ethanol_BS_Texte ), profileFile );
    writeProfileInt( "Motor_18", "MO_Fahrzeugtyp", getValue( KCAN_MO_Fahrzeugtyp ), profileFile );
    writeProfileInt( "Motor_18", "MO_Fehler_Zylabsch", getValue( KCAN_MO_Fehler_Zylabsch ), profileFile );
    writeProfileInt( "Motor_18", "MO_Hybrid_StartStopp_LED", getValue( KCAN_MO_Hybrid_StartStopp_LED ), profileFile );
    writeProfileFloat( "Motor_18", "MO_max_Ladedruck", getValue( KCAN_MO_max_Ladedruck ), profileFile );
    writeProfileInt( "Motor_18", "MO_NMAX_Schaltanzeige", getValue( KCAN_MO_NMAX_Schaltanzeige ), profileFile );
    writeProfileInt( "Motor_18", "MO_obere_Drehzahlgrenze", getValue( KCAN_MO_obere_Drehzahlgrenze ), profileFile );
    writeProfileInt( "Motor_18", "MO_StartStopp_PopUp", getValue( KCAN_MO_StartStopp_PopUp ), profileFile );
    writeProfileInt( "Motor_18", "MO_Zylabsch_Texte", getValue( KCAN_MO_Zylabsch_Texte ), profileFile );
    writeProfileInt( "Motor_18", "MO_Zylabsch_Texte_02", getValue( KCAN_MO_Zylabsch_Texte_02 ), profileFile );

}


void saveSettings_Motor_26( char profileFile[] )
{
    writeProfileInt( "Motor_26", "MO_E_Mode", getValue( KCAN_MO_E_Mode ), profileFile );
    writeProfileInt( "Motor_26", "MO_E_Texte", getValue( KCAN_MO_E_Texte ), profileFile );
    writeProfileInt( "Motor_26", "MO_E_Warnungen", getValue( KCAN_MO_E_Warnungen ), profileFile );
    writeProfileInt( "Motor_26", "MO_EFLEX_Lampe", getValue( KCAN_MO_EFLEX_Lampe ), profileFile );
    writeProfileInt( "Motor_26", "MO_Heissleuchte", getValue( KCAN_MO_Heissleuchte ), profileFile );
    writeProfileInt( "Motor_26", "MO_ITM_Warnung_Pumpe", getValue( KCAN_MO_ITM_Warnung_Pumpe ), profileFile );
    writeProfileInt( "Motor_26", "MO_KJS_nicht_bereit", getValue( KCAN_MO_KJS_nicht_bereit ), profileFile );
    writeProfileInt( "Motor_26", "MO_Kuehlerluefter_1", getValue( KCAN_MO_Kuehlerluefter_1 ), profileFile );
    writeProfileInt( "Motor_26", "MO_Kuehlerluefter_2", getValue( KCAN_MO_Kuehlerluefter_2 ), profileFile );
    writeProfileInt( "Motor_26", "MO_Kuehlerluefter_MUX", getValue( KCAN_MO_Kuehlerluefter_MUX ), profileFile );
    writeProfileInt( "Motor_26", "MO_OBD2_Lampe", getValue( KCAN_MO_OBD2_Lampe ), profileFile );
    writeProfileInt( "Motor_26", "MO_Oelwarnung_max", getValue( KCAN_MO_Oelwarnung_max ), profileFile );
    writeProfileInt( "Motor_26", "MO_Partikel_Lampe", getValue( KCAN_MO_Partikel_Lampe ), profileFile );
    writeProfileInt( "Motor_26", "MO_RedFahrleistung_Lampe", getValue( KCAN_MO_RedFahrleistung_Lampe ), profileFile );
    writeProfileInt( "Motor_26", "MO_Systemlampe", getValue( KCAN_MO_Systemlampe ), profileFile );
    writeProfileInt( "Motor_26", "MO_Tankdeckel_Lampe", getValue( KCAN_MO_Tankdeckel_Lampe ), profileFile );
    writeProfileInt( "Motor_26", "MO_Text_Motorstart", getValue( KCAN_MO_Text_Motorstart ), profileFile );
    writeProfileInt( "Motor_26", "MO_Text_Partikelfil_Reg", getValue( KCAN_MO_Text_Partikelfil_Reg ), profileFile );
    writeProfileInt( "Motor_26", "MO_Text_Tankdeckelwarn", getValue( KCAN_MO_Text_Tankdeckelwarn ), profileFile );
    writeProfileInt( "Motor_26", "MO_Vorglueh_Lampe", getValue( KCAN_MO_Vorglueh_Lampe ), profileFile );
    writeProfileInt( "Motor_26", "MO_Zustand_HWP", getValue( KCAN_MO_Zustand_HWP ), profileFile );
    writeProfileInt( "Motor_26", "OLEV_Oelstand_nicht_vorhanden", getValue( KCAN_OLEV_Oelstand_nicht_vorhanden ), profileFile );
    writeProfileInt( "Motor_26", "OLEV_Systemstoerung", getValue( KCAN_OLEV_Systemstoerung ), profileFile );
    writeProfileInt( "Motor_26", "WIV_Anzeige_aktiv", getValue( KCAN_WIV_Anzeige_aktiv ), profileFile );
    writeProfileInt( "Motor_26", "WIV_laufender_Motor", getValue( KCAN_WIV_laufender_Motor ), profileFile );
    writeProfileInt( "Motor_26", "WIV_nachfuellanzeige_ein", getValue( KCAN_WIV_nachfuellanzeige_ein ), profileFile );
    writeProfileInt( "Motor_26", "WIV_nicht_betriebswarm", getValue( KCAN_WIV_nicht_betriebswarm ), profileFile );
    writeProfileInt( "Motor_26", "WIV_Oeldr_Warn_Motor", getValue( KCAN_WIV_Oeldr_Warn_Motor ), profileFile );
    writeProfileInt( "Motor_26", "WIV_Oeldyn_avl", getValue( KCAN_WIV_Oeldyn_avl ), profileFile );
    writeProfileInt( "Motor_26", "WIV_Oelmenge", getValue( KCAN_WIV_Oelmenge ), profileFile );
    writeProfileInt( "Motor_26", "WIV_Oelmin_Warn", getValue( KCAN_WIV_Oelmin_Warn ), profileFile );
    writeProfileFloat( "Motor_26", "WIV_Oelstand", getValue( KCAN_WIV_Oelstand ), profileFile );
    writeProfileInt( "Motor_26", "WIV_Oelstand_nicht_vorhanden", getValue( KCAN_WIV_Oelstand_nicht_vorhanden ), profileFile );
    writeProfileInt( "Motor_26", "WIV_Oelsystem_aktiv", getValue( KCAN_WIV_Oelsystem_aktiv ), profileFile );
    writeProfileInt( "Motor_26", "WIV_Schieflage", getValue( KCAN_WIV_Schieflage ), profileFile );
    writeProfileInt( "Motor_26", "WIV_Sensorfehler", getValue( KCAN_WIV_Sensorfehler ), profileFile );
    writeProfileInt( "Motor_26", "WIV_Ueberfuell_deaktiv", getValue( KCAN_WIV_Ueberfuell_deaktiv ), profileFile );
    writeProfileInt( "Motor_26", "WIV_Ueberfuell_Warn", getValue( KCAN_WIV_Ueberfuell_Warn ), profileFile );
    writeProfileInt( "Motor_26", "WIV_Unterfuell_Warn", getValue( KCAN_WIV_Unterfuell_Warn ), profileFile );

}


void saveSettings_Motor_41( char profileFile[] )
{
    writeProfileInt( "Motor_41", "FDR_Warnung_ALR", getValue( KCAN_FDR_Warnung_ALR ), profileFile );
    writeProfileInt( "Motor_41", "MO_ADR_Status", getValue( KCAN_MO_ADR_Status ), profileFile );
    writeProfileInt( "Motor_41", "MO_AGA_Sound_Texte", getValue( KCAN_MO_AGA_Sound_Texte ), profileFile );
    writeProfileInt( "Motor_41", "MO_Anz_Kuehlerluefter", getValue( KCAN_MO_Anz_Kuehlerluefter ), profileFile );
    writeProfileInt( "Motor_41", "MO_Anzeige_FMAus_Text", getValue( KCAN_MO_Anzeige_FMAus_Text ), profileFile );
    writeProfileInt( "Motor_41", "MO_Anzeige_StSt_Symbol", getValue( KCAN_MO_Anzeige_StSt_Symbol ), profileFile );
    writeProfileInt( "Motor_41", "MO_Anzeige_StSt_Text", getValue( KCAN_MO_Anzeige_StSt_Text ), profileFile );
    writeProfileInt( "Motor_41", "MO_ElAntrieb_Abschleppwarnung", getValue( KCAN_MO_ElAntrieb_Abschleppwarnung ), profileFile );
    writeProfileInt( "Motor_41", "MO_EM_Ueberhitzungswarnung", getValue( KCAN_MO_EM_Ueberhitzungswarnung ), profileFile );
    writeProfileInt( "Motor_41", "MO_Powermeter_Dauer_Grenze", getValue( KCAN_MO_Powermeter_Dauer_Grenze ), profileFile );
    writeProfileInt( "Motor_41", "MO_Rekuperationsstufe", getValue( KCAN_MO_Rekuperationsstufe ), profileFile );
    writeProfileInt( "Motor_41", "PEA_Texte", getValue( KCAN_PEA_Texte ), profileFile );
    writeProfileInt( "Motor_41", "TSK_Einheit_vMax_FahrerInfo", getValue( KCAN_TSK_Einheit_vMax_FahrerInfo ), profileFile );
    writeProfileInt( "Motor_41", "TSK_Status_vMax_FahrerInfo", getValue( KCAN_TSK_Status_vMax_FahrerInfo ), profileFile );
    writeProfileInt( "Motor_41", "TSK_Ueberstimmt_vMax_FahrerInfo", getValue( KCAN_TSK_Ueberstimmt_vMax_FahrerInfo ), profileFile );
    writeProfileInt( "Motor_41", "TSK_vMax_FahrerInfo", getValue( KCAN_TSK_vMax_FahrerInfo ), profileFile );

}


void saveSettings_Motor_51( char profileFile[] )
{
    writeProfileInt( "Motor_51", "GRA_KuFu_aktiv", getValue( KCAN_GRA_KuFu_aktiv ), profileFile );
    writeProfileInt( "Motor_51", "LIM_KuFu_aktiv", getValue( KCAN_LIM_KuFu_aktiv ), profileFile );
    writeProfileInt( "Motor_51", "MO_Entkopplung_Sollschlupf", getValue( KCAN_MO_Entkopplung_Sollschlupf ), profileFile );
    writeProfileInt( "Motor_51", "MO_Fahrpedalgradient", getValue( KCAN_MO_Fahrpedalgradient ), profileFile );
    writeProfileFloat( "Motor_51", "MO_Fahrpedalrohwert_01", getValue( KCAN_MO_Fahrpedalrohwert_01 ), profileFile );
    writeProfileInt( "Motor_51", "MO_Moment_im_Leerlauf", getValue( KCAN_MO_Moment_im_Leerlauf ), profileFile );
    writeProfileInt( "Motor_51", "MO_QBit_Fahrpedalwerte_01", getValue( KCAN_MO_QBit_Fahrpedalwerte_01 ), profileFile );
    writeProfileInt( "Motor_51", "MO_rel_Saugrohrdruck", getValue( KCAN_MO_rel_Saugrohrdruck ), profileFile );
    writeProfileInt( "Motor_51", "MO_rel_Saugrohrdruck_gem_err", getValue( KCAN_MO_rel_Saugrohrdruck_gem_err ), profileFile );
    writeProfileInt( "Motor_51", "MO_Schubabschaltung", getValue( KCAN_MO_Schubabschaltung ), profileFile );
    writeProfileInt( "Motor_51", "MO_Sig_Fahrpedalgradient", getValue( KCAN_MO_Sig_Fahrpedalgradient ), profileFile );
    writeProfileInt( "Motor_51", "MO_Solldrehz_Leerlauf", getValue( KCAN_MO_Solldrehz_Leerlauf ), profileFile );
    writeProfileInt( "Motor_51", "MO_StartStopp_StoppVorbereitung", getValue( KCAN_MO_StartStopp_StoppVorbereitung ), profileFile );
    writeProfileInt( "Motor_51", "MO_Status_MaxDrzEingriff", getValue( KCAN_MO_Status_MaxDrzEingriff ), profileFile );
    writeProfileInt( "Motor_51", "MO_Status_MaxDrzEingriff_sek", getValue( KCAN_MO_Status_MaxDrzEingriff_sek ), profileFile );
    writeProfileInt( "Motor_51", "MO_Status_MinDrzEingriff", getValue( KCAN_MO_Status_MinDrzEingriff ), profileFile );
    writeProfileInt( "Motor_51", "MO_Status_MinDrzEingriff_sek", getValue( KCAN_MO_Status_MinDrzEingriff_sek ), profileFile );
    writeProfileInt( "Motor_51", "MO_temporaere_Fahrerabwesenheit", getValue( KCAN_MO_temporaere_Fahrerabwesenheit ), profileFile );
    writeProfileInt( "Motor_51", "Motor_51_BZ", getValue( KCAN_Motor_51_BZ ), profileFile );
    writeProfileInt( "Motor_51", "Motor_51_CRC", getValue( KCAN_Motor_51_CRC ), profileFile );
    writeProfileFloat( "Motor_51", "TSK_a_Soll_gradientenbegrenzt", getValue( KCAN_TSK_a_Soll_gradientenbegrenzt ), profileFile );
    writeProfileFloat( "Motor_51", "TSK_ax_Getriebe_02", getValue( KCAN_TSK_ax_Getriebe_02 ), profileFile );
    writeProfileInt( "Motor_51", "TSK_Freig_Verzoeg_Anf", getValue( KCAN_TSK_Freig_Verzoeg_Anf ), profileFile );
    writeProfileInt( "Motor_51", "TSK_Freig_WU", getValue( KCAN_TSK_Freig_WU ), profileFile );
    writeProfileInt( "Motor_51", "TSK_Hauptschalter_GRA_ACC", getValue( KCAN_TSK_Hauptschalter_GRA_ACC ), profileFile );
    writeProfileInt( "Motor_51", "TSK_Limiter_ausgewaehlt_Motor_51", getValue( KCAN_TSK_Limiter_ausgewaehlt_Motor_51 ), profileFile );
    writeProfileInt( "Motor_51", "TSK_Notstopp_Anf", getValue( KCAN_TSK_Notstopp_Anf ), profileFile );
    writeProfileInt( "Motor_51", "TSK_Radbremsmom", getValue( KCAN_TSK_Radbremsmom ), profileFile );
    writeProfileFloat( "Motor_51", "TSK_Radsollmoment", getValue( KCAN_TSK_Radsollmoment ), profileFile );
    writeProfileInt( "Motor_51", "TSK_SRBM_Anf_ASIL", getValue( KCAN_TSK_SRBM_Anf_ASIL ), profileFile );
    writeProfileInt( "Motor_51", "TSK_SRBM_max_Gradient", getValue( KCAN_TSK_SRBM_max_Gradient ), profileFile );
    writeProfileInt( "Motor_51", "TSK_Standby_Anf_ESP", getValue( KCAN_TSK_Standby_Anf_ESP ), profileFile );
    writeProfileInt( "Motor_51", "TSK_Status", getValue( KCAN_TSK_Status ), profileFile );
    writeProfileInt( "Motor_51", "TSK_v_Begrenzung_aktiv", getValue( KCAN_TSK_v_Begrenzung_aktiv ), profileFile );
    writeProfileFloat( "Motor_51", "TSK_Wunsch_Uebersetz", getValue( KCAN_TSK_Wunsch_Uebersetz ), profileFile );
    writeProfileFloat( "Motor_51", "TSK_zul_Regelabw", getValue( KCAN_TSK_zul_Regelabw ), profileFile );
    writeProfileInt( "Motor_51", "TSK_Zwangszusch_ESP", getValue( KCAN_TSK_Zwangszusch_ESP ), profileFile );

}


void saveSettings_Motor_52( char profileFile[] )
{
    writeProfileFloat( "Motor_52", "Ladezustand_02", getValue( KCAN_Ladezustand_02 ), profileFile );
    writeProfileInt( "Motor_52", "Ladezustand_gering", getValue( KCAN_Ladezustand_gering ), profileFile );
    writeProfileInt( "Motor_52", "MO_Anzeige_Drehmoment", getValue( KCAN_MO_Anzeige_Drehmoment ), profileFile );
    writeProfileFloat( "Motor_52", "MO_Anzeige_Leistung", getValue( KCAN_MO_Anzeige_Leistung ), profileFile );
    writeProfileInt( "Motor_52", "MO_Anzeige_Verbr_Einheit", getValue( KCAN_MO_Anzeige_Verbr_Einheit ), profileFile );
    writeProfileInt( "Motor_52", "MO_Anzeigedrehz", getValue( KCAN_MO_Anzeigedrehz ), profileFile );
    writeProfileInt( "Motor_52", "MO_Effizienzmodus", getValue( KCAN_MO_Effizienzmodus ), profileFile );
    writeProfileFloat( "Motor_52", "MO_ePerformance", getValue( KCAN_MO_ePerformance ), profileFile );
    writeProfileFloat( "Motor_52", "MO_ePowermeter", getValue( KCAN_MO_ePowermeter ), profileFile );
    writeProfileInt( "Motor_52", "MO_Fehler_Oeldrucksensor", getValue( KCAN_MO_Fehler_Oeldrucksensor ), profileFile );
    writeProfileInt( "Motor_52", "MO_Hochschaltdrehz", getValue( KCAN_MO_Hochschaltdrehz ), profileFile );
    writeProfileInt( "Motor_52", "MO_Istgang", getValue( KCAN_MO_Istgang ), profileFile );
    writeProfileInt( "Motor_52", "MO_KVS", getValue( KCAN_MO_KVS ), profileFile );
    writeProfileInt( "Motor_52", "MO_KVS_Ueberlauf", getValue( KCAN_MO_KVS_Ueberlauf ), profileFile );
    writeProfileFloat( "Motor_52", "MO_Ladedruck", getValue( KCAN_MO_Ladedruck ), profileFile );
    writeProfileFloat( "Motor_52", "MO_Oeldruck", getValue( KCAN_MO_Oeldruck ), profileFile );
    writeProfileInt( "Motor_52", "MO_Powermeter", getValue( KCAN_MO_Powermeter ), profileFile );
    writeProfileFloat( "Motor_52", "MO_Powermeter_Elm_02", getValue( KCAN_MO_Powermeter_Elm_02 ), profileFile );
    writeProfileFloat( "Motor_52", "MO_rel_Ladedruck", getValue( KCAN_MO_rel_Ladedruck ), profileFile );
    writeProfileInt( "Motor_52", "MO_Schaltblitz_Anz", getValue( KCAN_MO_Schaltblitz_Anz ), profileFile );
    writeProfileInt( "Motor_52", "MO_Schaltempf_verfbar", getValue( KCAN_MO_Schaltempf_verfbar ), profileFile );
    writeProfileInt( "Motor_52", "MO_Sollgang", getValue( KCAN_MO_Sollgang ), profileFile );
    writeProfileInt( "Motor_52", "MO_Zust_Antrieb", getValue( KCAN_MO_Zust_Antrieb ), profileFile );
    writeProfileInt( "Motor_52", "MO_Zust_Betriebsstrategie", getValue( KCAN_MO_Zust_Betriebsstrategie ), profileFile );

}


void saveSettings_Motor_53( char profileFile[] )
{
    writeProfileInt( "Motor_53", "MO_Antriebsstrang_Warnung_HS", getValue( KCAN_MO_Antriebsstrang_Warnung_HS ), profileFile );
    writeProfileInt( "Motor_53", "MO_Anzeige_Betriebsmodus", getValue( KCAN_MO_Anzeige_Betriebsmodus ), profileFile );
    writeProfileInt( "Motor_53", "MO_Anzeige_Fahrbereitschaft", getValue( KCAN_MO_Anzeige_Fahrbereitschaft ), profileFile );
    writeProfileFloat( "Motor_53", "MO_Anzeige_Rekuperation", getValue( KCAN_MO_Anzeige_Rekuperation ), profileFile );
    writeProfileFloat( "Motor_53", "MO_Anzeige_Verbrauch_oE", getValue( KCAN_MO_Anzeige_Verbrauch_oE ), profileFile );
    writeProfileInt( "Motor_53", "MO_Boost_aktiv", getValue( KCAN_MO_Boost_aktiv ), profileFile );
    writeProfileFloat( "Motor_53", "MO_Boost_verfuegbar", getValue( KCAN_MO_Boost_verfuegbar ), profileFile );
    writeProfileInt( "Motor_53", "MO_BZS_Charisma_FahrPr", getValue( KCAN_MO_BZS_Charisma_FahrPr ), profileFile );
    writeProfileInt( "Motor_53", "MO_BZS_Charisma_Status", getValue( KCAN_MO_BZS_Charisma_Status ), profileFile );
    writeProfileInt( "Motor_53", "MO_Charisma_FahrPr", getValue( KCAN_MO_Charisma_FahrPr ), profileFile );
    writeProfileInt( "Motor_53", "MO_Charisma_Status", getValue( KCAN_MO_Charisma_Status ), profileFile );
    writeProfileFloat( "Motor_53", "MO_Drehzahlbeeinflussung", getValue( KCAN_MO_Drehzahlbeeinflussung ), profileFile );
    writeProfileInt( "Motor_53", "MO_Luftpfad_aktiv", getValue( KCAN_MO_Luftpfad_aktiv ), profileFile );
    writeProfileInt( "Motor_53", "MO_MAX_Wunschdrehzahl", getValue( KCAN_MO_MAX_Wunschdrehzahl ), profileFile );
    writeProfileInt( "Motor_53", "MO_MIN_Wunschdrehzahl", getValue( KCAN_MO_MIN_Wunschdrehzahl ), profileFile );
    writeProfileInt( "Motor_53", "MO_Motorlaufwarnung", getValue( KCAN_MO_Motorlaufwarnung ), profileFile );
    writeProfileInt( "Motor_53", "MO_NGS_Position", getValue( KCAN_MO_NGS_Position ), profileFile );
    writeProfileInt( "Motor_53", "MO_NGS_Status", getValue( KCAN_MO_NGS_Status ), profileFile );
    writeProfileInt( "Motor_53", "MO_Overboost", getValue( KCAN_MO_Overboost ), profileFile );
    writeProfileInt( "Motor_53", "MO_Prio_MAX_Wunschdrehzahl", getValue( KCAN_MO_Prio_MAX_Wunschdrehzahl ), profileFile );
    writeProfileInt( "Motor_53", "MO_Prio_MIN_Wunschdrehzahl", getValue( KCAN_MO_Prio_MIN_Wunschdrehzahl ), profileFile );
    writeProfileInt( "Motor_53", "MO_Rampenzeit_Generator_Anf", getValue( KCAN_MO_Rampenzeit_Generator_Anf ), profileFile );
    writeProfileInt( "Motor_53", "MO_Sperrung_FahrPr_BZS", getValue( KCAN_MO_Sperrung_FahrPr_BZS ), profileFile );
    writeProfileInt( "Motor_53", "MO_StSt_Charisma_FahrPr", getValue( KCAN_MO_StSt_Charisma_FahrPr ), profileFile );
    writeProfileInt( "Motor_53", "MO_StSt_Charisma_Status", getValue( KCAN_MO_StSt_Charisma_Status ), profileFile );
    writeProfileInt( "Motor_53", "MO_v_Begrenz_Aktivierbar", getValue( KCAN_MO_v_Begrenz_Aktivierbar ), profileFile );
    writeProfileInt( "Motor_53", "MO_v_Begrenzung_Niveau", getValue( KCAN_MO_v_Begrenzung_Niveau ), profileFile );
    writeProfileInt( "Motor_53", "PEA_Abschalttexte", getValue( KCAN_PEA_Abschalttexte ), profileFile );
    writeProfileInt( "Motor_53", "PEA_Ereignisanzeige", getValue( KCAN_PEA_Ereignisanzeige ), profileFile );
    writeProfileInt( "Motor_53", "PEA_Ereignisanzeige_temporaer", getValue( KCAN_PEA_Ereignisanzeige_temporaer ), profileFile );
    writeProfileInt( "Motor_53", "PEA_Fortschrittsanzeige", getValue( KCAN_PEA_Fortschrittsanzeige ), profileFile );
    writeProfileInt( "Motor_53", "PEA_Hinweis", getValue( KCAN_PEA_Hinweis ), profileFile );
    writeProfileInt( "Motor_53", "PEA_Zielgeschw", getValue( KCAN_PEA_Zielgeschw ), profileFile );
    writeProfileInt( "Motor_53", "PEA_Zielgeschw_Einheit", getValue( KCAN_PEA_Zielgeschw_Einheit ), profileFile );
    writeProfileInt( "Motor_53", "TSK_Akustik", getValue( KCAN_TSK_Akustik ), profileFile );
    writeProfileInt( "Motor_53", "TSK_Fahrzeugstatus_GRA", getValue( KCAN_TSK_Fahrzeugstatus_GRA ), profileFile );
    writeProfileInt( "Motor_53", "TSK_Fahrzeugstatus_Limiter", getValue( KCAN_TSK_Fahrzeugstatus_Limiter ), profileFile );
    writeProfileInt( "Motor_53", "TSK_Fahrzeugstatus_praed_Fkt", getValue( KCAN_TSK_Fahrzeugstatus_praed_Fkt ), profileFile );
    writeProfileInt( "Motor_53", "TSK_Limiter_Anzeige", getValue( KCAN_TSK_Limiter_Anzeige ), profileFile );
    writeProfileInt( "Motor_53", "TSK_Limiter_Fahrerinfo", getValue( KCAN_TSK_Limiter_Fahrerinfo ), profileFile );
    writeProfileInt( "Motor_53", "TSK_naechstes_Event", getValue( KCAN_TSK_naechstes_Event ), profileFile );
    writeProfileInt( "Motor_53", "TSK_naechstes_Event_Einheit", getValue( KCAN_TSK_naechstes_Event_Einheit ), profileFile );
    writeProfileFloat( "Motor_53", "TSK_praed_Wunschgeschw", getValue( KCAN_TSK_praed_Wunschgeschw ), profileFile );
    writeProfileInt( "Motor_53", "TSK_praediktiver_Automode", getValue( KCAN_TSK_praediktiver_Automode ), profileFile );
    writeProfileInt( "Motor_53", "TSK_praediktiver_Hinweis", getValue( KCAN_TSK_praediktiver_Hinweis ), profileFile );
    writeProfileInt( "Motor_53", "TSK_Status_Anzeige", getValue( KCAN_TSK_Status_Anzeige ), profileFile );
    writeProfileInt( "Motor_53", "TSK_Texte", getValue( KCAN_TSK_Texte ), profileFile );
    writeProfileInt( "Motor_53", "TSK_Texte_Primaeranz", getValue( KCAN_TSK_Texte_Primaeranz ), profileFile );
    writeProfileFloat( "Motor_53", "TSK_Wunschgeschw", getValue( KCAN_TSK_Wunschgeschw ), profileFile );

}


void saveSettings_Motor_54( char profileFile[] )
{
    writeProfileInt( "Motor_54", "FoD_DTC_TSK_ACC", getValue( KCAN_FoD_DTC_TSK_ACC ), profileFile );
    writeProfileInt( "Motor_54", "FoD_DTC_TSK_GRA", getValue( KCAN_FoD_DTC_TSK_GRA ), profileFile );
    writeProfileInt( "Motor_54", "ISA_Regelung_aktiv", getValue( KCAN_ISA_Regelung_aktiv ), profileFile );
    writeProfileInt( "Motor_54", "ISA_Status", getValue( KCAN_ISA_Status ), profileFile );
    writeProfileInt( "Motor_54", "ISA_Tempolimitwarnung", getValue( KCAN_ISA_Tempolimitwarnung ), profileFile );
    writeProfileInt( "Motor_54", "KVA_Ist_Pos", getValue( KCAN_KVA_Ist_Pos ), profileFile );
    writeProfileInt( "Motor_54", "MO_Anforderung_HMS", getValue( KCAN_MO_Anforderung_HMS ), profileFile );
    writeProfileInt( "Motor_54", "MO_EBoost_verf_praed", getValue( KCAN_MO_EBoost_verf_praed ), profileFile );
    writeProfileInt( "Motor_54", "MO_eLaunch_verf", getValue( KCAN_MO_eLaunch_verf ), profileFile );
    writeProfileInt( "Motor_54", "MO_Fahrbereitschaft", getValue( KCAN_MO_Fahrbereitschaft ), profileFile );
    writeProfileInt( "Motor_54", "MO_Freilauf_Info", getValue( KCAN_MO_Freilauf_Info ), profileFile );
    writeProfileInt( "Motor_54", "MO_Freilauf_Status", getValue( KCAN_MO_Freilauf_Status ), profileFile );
    writeProfileInt( "Motor_54", "MO_Heckspoiler_Anf", getValue( KCAN_MO_Heckspoiler_Anf ), profileFile );
    writeProfileInt( "Motor_54", "MO_Krit_Heckobjekt", getValue( KCAN_MO_Krit_Heckobjekt ), profileFile );
    writeProfileInt( "Motor_54", "MO_LaunchControl", getValue( KCAN_MO_LaunchControl ), profileFile );
    writeProfileInt( "Motor_54", "MO_NGS_Gangpos", getValue( KCAN_MO_NGS_Gangpos ), profileFile );
    writeProfileInt( "Motor_54", "MO_Positionierung_aktiv", getValue( KCAN_MO_Positionierung_aktiv ), profileFile );
    writeProfileInt( "Motor_54", "MO_QBit_Aussen_Temp", getValue( KCAN_MO_QBit_Aussen_Temp ), profileFile );
    writeProfileInt( "Motor_54", "MO_Red_El_Fahrleistung", getValue( KCAN_MO_Red_El_Fahrleistung ), profileFile );
    writeProfileInt( "Motor_54", "MO_Servicemodus", getValue( KCAN_MO_Servicemodus ), profileFile );
    writeProfileInt( "Motor_54", "MO_Startwunsch", getValue( KCAN_MO_Startwunsch ), profileFile );
    writeProfileInt( "Motor_54", "Motor_54_BZ", getValue( KCAN_Motor_54_BZ ), profileFile );
    writeProfileInt( "Motor_54", "Motor_54_CRC", getValue( KCAN_Motor_54_CRC ), profileFile );
    writeProfileFloat( "Motor_54", "OBD_Abs_Load_Val", getValue( KCAN_OBD_Abs_Load_Val ), profileFile );
    writeProfileFloat( "Motor_54", "OBD_Abs_Pedal_Pos", getValue( KCAN_OBD_Abs_Pedal_Pos ), profileFile );
    writeProfileFloat( "Motor_54", "OBD_Abs_Throttle_Pos", getValue( KCAN_OBD_Abs_Throttle_Pos ), profileFile );
    writeProfileInt( "Motor_54", "OBD_Aussen_Temp_gef", getValue( KCAN_OBD_Aussen_Temp_gef ), profileFile );
    writeProfileFloat( "Motor_54", "OBD_Calc_Load_Val", getValue( KCAN_OBD_Calc_Load_Val ), profileFile );
    writeProfileInt( "Motor_54", "OBD_ClearMem_Inhibit", getValue( KCAN_OBD_ClearMem_Inhibit ), profileFile );
    writeProfileInt( "Motor_54", "OBD_Driving_Cycle", getValue( KCAN_OBD_Driving_Cycle ), profileFile );
    writeProfileInt( "Motor_54", "OBD_Eng_Cool_Temp", getValue( KCAN_OBD_Eng_Cool_Temp ), profileFile );
    writeProfileInt( "Motor_54", "OBD_Kaltstart_Denominator", getValue( KCAN_OBD_Kaltstart_Denominator ), profileFile );
    writeProfileInt( "Motor_54", "OBD_Minimum_Trip", getValue( KCAN_OBD_Minimum_Trip ), profileFile );
    writeProfileInt( "Motor_54", "OBD_Normed_Trip", getValue( KCAN_OBD_Normed_Trip ), profileFile );
    writeProfileInt( "Motor_54", "OBD_Sperrung_IUMPR", getValue( KCAN_OBD_Sperrung_IUMPR ), profileFile );
    writeProfileInt( "Motor_54", "OBD_Sperrung_Kaltstart_Denom", getValue( KCAN_OBD_Sperrung_Kaltstart_Denom ), profileFile );
    writeProfileInt( "Motor_54", "OBD_Warm_Up_Cycle", getValue( KCAN_OBD_Warm_Up_Cycle ), profileFile );
    writeProfileInt( "Motor_54", "TSK_ACC_FoD_Status", getValue( KCAN_TSK_ACC_FoD_Status ), profileFile );
    writeProfileInt( "Motor_54", "TSK_aktives_System", getValue( KCAN_TSK_aktives_System ), profileFile );
    writeProfileInt( "Motor_54", "TSK_Anf_Antriebsmoment", getValue( KCAN_TSK_Anf_Antriebsmoment ), profileFile );
    writeProfileInt( "Motor_54", "TSK_Einheit_vMax_Fahrerassistenz", getValue( KCAN_TSK_Einheit_vMax_Fahrerassistenz ), profileFile );
    writeProfileInt( "Motor_54", "TSK_erhoehter_Fahrwiderstand", getValue( KCAN_TSK_erhoehter_Fahrwiderstand ), profileFile );
    writeProfileInt( "Motor_54", "TSK_GRA_FoD_Status", getValue( KCAN_TSK_GRA_FoD_Status ), profileFile );
    writeProfileInt( "Motor_54", "TSK_Status_ARA", getValue( KCAN_TSK_Status_ARA ), profileFile );
    writeProfileInt( "Motor_54", "TSK_Status_EA", getValue( KCAN_TSK_Status_EA ), profileFile );
    writeProfileInt( "Motor_54", "TSK_Status_IPA", getValue( KCAN_TSK_Status_IPA ), profileFile );
    writeProfileInt( "Motor_54", "TSK_Status_PLA", getValue( KCAN_TSK_Status_PLA ), profileFile );
    writeProfileInt( "Motor_54", "TSK_vMax_aktuell", getValue( KCAN_TSK_vMax_aktuell ), profileFile );
    writeProfileInt( "Motor_54", "TSK_vMax_Fahrerassistenz", getValue( KCAN_TSK_vMax_Fahrerassistenz ), profileFile );

}


void saveSettings_Motor_57( char profileFile[] )
{
    writeProfileInt( "Motor_57", "MO_Drehzahl_EM", getValue( KCAN_MO_Drehzahl_EM ), profileFile );
    writeProfileInt( "Motor_57", "MO_Drehzahl_EM_sek", getValue( KCAN_MO_Drehzahl_EM_sek ), profileFile );
    writeProfileInt( "Motor_57", "MO_EM1_Generator_Leistung", getValue( KCAN_MO_EM1_Generator_Leistung ), profileFile );
    writeProfileInt( "Motor_57", "MO_EM1_Max_Leistung_Gesamt", getValue( KCAN_MO_EM1_Max_Leistung_Gesamt ), profileFile );
    writeProfileInt( "Motor_57", "MO_EM1_Max_Spannung_Lim", getValue( KCAN_MO_EM1_Max_Spannung_Lim ), profileFile );
    writeProfileInt( "Motor_57", "MO_EM1_Min_Leistung_Gesamt", getValue( KCAN_MO_EM1_Min_Leistung_Gesamt ), profileFile );
    writeProfileInt( "Motor_57", "MO_EM1_Min_Spannung_Lim", getValue( KCAN_MO_EM1_Min_Spannung_Lim ), profileFile );
    writeProfileInt( "Motor_57", "MO_EM2_Generator_Leistung", getValue( KCAN_MO_EM2_Generator_Leistung ), profileFile );
    writeProfileInt( "Motor_57", "MO_EM2_Max_Leistung_Gesamt", getValue( KCAN_MO_EM2_Max_Leistung_Gesamt ), profileFile );
    writeProfileInt( "Motor_57", "MO_EM2_Max_Spannung_Lim", getValue( KCAN_MO_EM2_Max_Spannung_Lim ), profileFile );
    writeProfileInt( "Motor_57", "MO_EM2_Min_Leistung_Gesamt", getValue( KCAN_MO_EM2_Min_Leistung_Gesamt ), profileFile );
    writeProfileInt( "Motor_57", "MO_EM2_Min_Spannung_Lim", getValue( KCAN_MO_EM2_Min_Spannung_Lim ), profileFile );
    writeProfileInt( "Motor_57", "MO_Rekuperation_EM_Ges_Ueberlauf", getValue( KCAN_MO_Rekuperation_EM_Ges_Ueberlauf ), profileFile );
    writeProfileInt( "Motor_57", "MO_Rekuperation_Ges_EM", getValue( KCAN_MO_Rekuperation_Ges_EM ), profileFile );
    writeProfileFloat( "Motor_57", "MO_Uebersetzung_EM", getValue( KCAN_MO_Uebersetzung_EM ), profileFile );
    writeProfileFloat( "Motor_57", "MO_Uebersetzung_EM_sek", getValue( KCAN_MO_Uebersetzung_EM_sek ), profileFile );
    writeProfileInt( "Motor_57", "MO_Verbrauch_EM_Ges", getValue( KCAN_MO_Verbrauch_EM_Ges ), profileFile );
    writeProfileInt( "Motor_57", "MO_Verbrauch_EM_Ges_Ueberlauf", getValue( KCAN_MO_Verbrauch_EM_Ges_Ueberlauf ), profileFile );
    writeProfileInt( "Motor_57", "Motor_57_BZ", getValue( KCAN_Motor_57_BZ ), profileFile );
    writeProfileInt( "Motor_57", "Motor_57_CRC", getValue( KCAN_Motor_57_CRC ), profileFile );

}


void saveSettings_Motor_Hybrid_06( char profileFile[] )
{
    writeProfileInt( "Motor_Hybrid_06", "MO_Powermeter_Charge_Grenze", getValue( KCAN_MO_Powermeter_Charge_Grenze ), profileFile );
    writeProfileInt( "Motor_Hybrid_06", "Mo_Powermeter_Grenze", getValue( KCAN_Mo_Powermeter_Grenze ), profileFile );
    writeProfileInt( "Motor_Hybrid_06", "MO_Powermeter_Grenze_strategisch", getValue( KCAN_MO_Powermeter_Grenze_strategisch ), profileFile );
    writeProfileInt( "Motor_Hybrid_06", "MO_Powermeter_Inszenierung_aktiv", getValue( KCAN_MO_Powermeter_Inszenierung_aktiv ), profileFile );
    writeProfileInt( "Motor_Hybrid_06", "MO_Powermeter_obere_E_Grenze", getValue( KCAN_MO_Powermeter_obere_E_Grenze ), profileFile );
    writeProfileInt( "Motor_Hybrid_06", "MO_Powermeter_untere_E_Grenze", getValue( KCAN_MO_Powermeter_untere_E_Grenze ), profileFile );
    writeProfileInt( "Motor_Hybrid_06", "MO_Text_Aktivierung_Antrieb", getValue( KCAN_MO_Text_Aktivierung_Antrieb ), profileFile );

}


void saveSettings_NavData_01( char profileFile[] )
{
    writeProfileFloat( "NavData_01", "ND_GDOP", getValue( KCAN_ND_GDOP ), profileFile );
    writeProfileFloat( "NavData_01", "ND_HDOP", getValue( KCAN_ND_HDOP ), profileFile );
    writeProfileFloat( "NavData_01", "ND_Heading", getValue( KCAN_ND_Heading ), profileFile );
    writeProfileInt( "NavData_01", "ND_Init", getValue( KCAN_ND_Init ), profileFile );
    writeProfileFloat( "NavData_01", "ND_PDOP", getValue( KCAN_ND_PDOP ), profileFile );
    writeProfileFloat( "NavData_01", "ND_TDOP", getValue( KCAN_ND_TDOP ), profileFile );
    writeProfileFloat( "NavData_01", "ND_VDOP", getValue( KCAN_ND_VDOP ), profileFile );

}


void saveSettings_NavData_02( char profileFile[] )
{
    writeProfileInt( "NavData_02", "ND_SatInUse", getValue( KCAN_ND_SatInUse ), profileFile );
    writeProfileInt( "NavData_02", "ND_SatInView", getValue( KCAN_ND_SatInView ), profileFile );
    writeProfileInt( "NavData_02", "ND_UTC", getValue( KCAN_ND_UTC ), profileFile );
    writeProfileInt( "NavData_02", "NP_Altitude", getValue( KCAN_NP_Altitude ), profileFile );
    writeProfileInt( "NavData_02", "POS_Guete_horizontal", getValue( KCAN_POS_Guete_horizontal ), profileFile );
    writeProfileInt( "NavData_02", "POS_Guete_horizontal_verfuegbar", getValue( KCAN_POS_Guete_horizontal_verfuegbar ), profileFile );

}


void saveSettings_NavData_03( char profileFile[] )
{
    writeProfileInt( "NavData_03", "ND_Fuelstation_detected", getValue( KCAN_ND_Fuelstation_detected ), profileFile );
    writeProfileInt( "NavData_03", "ND_NrSameMeasure", getValue( KCAN_ND_NrSameMeasure ), profileFile );
    writeProfileInt( "NavData_03", "ND_RecDelay", getValue( KCAN_ND_RecDelay ), profileFile );
    writeProfileInt( "NavData_03", "ND_RouteType", getValue( KCAN_ND_RouteType ), profileFile );
    writeProfileInt( "NavData_03", "ND_SendDelay", getValue( KCAN_ND_SendDelay ), profileFile );
    writeProfileInt( "NavData_03", "ND_TimeOffset", getValue( KCAN_ND_TimeOffset ), profileFile );
    writeProfileInt( "NavData_03", "ND_TimeToDestination", getValue( KCAN_ND_TimeToDestination ), profileFile );
    writeProfileInt( "NavData_03", "ND_Timezone_DaylightSavingOffset", getValue( KCAN_ND_Timezone_DaylightSavingOffset ), profileFile );
    writeProfileInt( "NavData_03", "ND_Timezone_Offset", getValue( KCAN_ND_Timezone_Offset ), profileFile );
    writeProfileInt( "NavData_03", "ND_Timezone_SignBit", getValue( KCAN_ND_Timezone_SignBit ), profileFile );
    writeProfileInt( "NavData_03", "ND_Timezone_Validity", getValue( KCAN_ND_Timezone_Validity ), profileFile );
    writeProfileFloat( "NavData_03", "ND_Velocity", getValue( KCAN_ND_Velocity ), profileFile );

}


void saveSettings_NavData_04( char profileFile[] )
{
    writeProfileInt( "NavData_04", "ND_Avrg_Speed_RangeData", getValue( KCAN_ND_Avrg_Speed_RangeData ), profileFile );

}


void saveSettings_NavPos_01( char profileFile[] )
{
    writeProfileInt( "NavPos_01", "NP_Fix", getValue( KCAN_NP_Fix ), profileFile );
    writeProfileFloat( "NavPos_01", "NP_LatDegree", getValue( KCAN_NP_LatDegree ), profileFile );
    writeProfileInt( "NavPos_01", "NP_LatDirection", getValue( KCAN_NP_LatDirection ), profileFile );
    writeProfileFloat( "NavPos_01", "NP_LongDegree", getValue( KCAN_NP_LongDegree ), profileFile );
    writeProfileInt( "NavPos_01", "NP_LongDirection", getValue( KCAN_NP_LongDirection ), profileFile );
    writeProfileInt( "NavPos_01", "NP_Sat", getValue( KCAN_NP_Sat ), profileFile );

}


void saveSettings_NavPos_02_Map_Matched( char profileFile[] )
{
    writeProfileFloat( "NavPos_02_Map_Matched", "POS_Heading", getValue( KCAN_POS_Heading ), profileFile );
    writeProfileInt( "NavPos_02_Map_Matched", "POS_Heading_Trust", getValue( KCAN_POS_Heading_Trust ), profileFile );
    writeProfileInt( "NavPos_02_Map_Matched", "POS_Last_GPS_Sync", getValue( KCAN_POS_Last_GPS_Sync ), profileFile );
    writeProfileFloat( "NavPos_02_Map_Matched", "POS_LatDegree", getValue( KCAN_POS_LatDegree ), profileFile );
    writeProfileInt( "NavPos_02_Map_Matched", "POS_LatDirection", getValue( KCAN_POS_LatDirection ), profileFile );
    writeProfileFloat( "NavPos_02_Map_Matched", "POS_LongDegree", getValue( KCAN_POS_LongDegree ), profileFile );
    writeProfileInt( "NavPos_02_Map_Matched", "POS_LongDirection", getValue( KCAN_POS_LongDirection ), profileFile );
    writeProfileInt( "NavPos_02_Map_Matched", "POS_MUX", getValue( KCAN_POS_MUX ), profileFile );
    writeProfileInt( "NavPos_02_Map_Matched", "POS_ODD_EVEN", getValue( KCAN_POS_ODD_EVEN ), profileFile );
    writeProfileInt( "NavPos_02_Map_Matched", "POS_PosStati", getValue( KCAN_POS_PosStati ), profileFile );
    writeProfileInt( "NavPos_02_Map_Matched", "POS_UTC_REF", getValue( KCAN_POS_UTC_REF ), profileFile );

}


void saveSettings_NFC_01( char profileFile[] )
{
    writeProfileInt( "NFC_01", "MDK_Anf_Start_Auth", getValue( KCAN_MDK_Anf_Start_Auth ), profileFile );
    writeProfileInt( "NFC_01", "MDK_BTLE_Spielschutz_aktivieren", getValue( KCAN_MDK_BTLE_Spielschutz_aktivieren ), profileFile );
    writeProfileInt( "NFC_01", "MDK_NFC_Spielschutz_aktivieren", getValue( KCAN_MDK_NFC_Spielschutz_aktivieren ), profileFile );
    writeProfileInt( "NFC_01", "NFC_aktiv", getValue( KCAN_NFC_aktiv ), profileFile );
    writeProfileInt( "NFC_01", "NFC_ESM_aktivieren", getValue( KCAN_NFC_ESM_aktivieren ), profileFile );
    writeProfileInt( "NFC_01", "NFC_Front_Entr_Authorisiert", getValue( KCAN_NFC_Front_Entr_Authorisiert ), profileFile );
    writeProfileInt( "NFC_01", "NFC_Front_Verr_Authorisiert", getValue( KCAN_NFC_Front_Verr_Authorisiert ), profileFile );
    writeProfileInt( "NFC_01", "NFC_FT_Entriegelung_Authorisiert", getValue( KCAN_NFC_FT_Entriegelung_Authorisiert ), profileFile );
    writeProfileInt( "NFC_01", "NFC_FT_Verriegelung_Authorisiert", getValue( KCAN_NFC_FT_Verriegelung_Authorisiert ), profileFile );
    writeProfileInt( "NFC_01", "NFC_HD_Entriegelung_Authorisiert", getValue( KCAN_NFC_HD_Entriegelung_Authorisiert ), profileFile );
    writeProfileInt( "NFC_01", "NFC_HD_Verriegelung_Authorisiert", getValue( KCAN_NFC_HD_Verriegelung_Authorisiert ), profileFile );
    writeProfileInt( "NFC_01", "NFC_Laden_unterbrechen", getValue( KCAN_NFC_Laden_unterbrechen ), profileFile );
    writeProfileInt( "NFC_01", "Stellgliedtest_NFC", getValue( KCAN_Stellgliedtest_NFC ), profileFile );
    writeProfileInt( "NFC_01", "ZV_auf_NFC", getValue( KCAN_ZV_auf_NFC ), profileFile );
    writeProfileInt( "NFC_01", "ZV_zu_NFC", getValue( KCAN_ZV_zu_NFC ), profileFile );

}


void saveSettings_NFC_MiKo_01( char profileFile[] )
{
    writeProfileInt( "NFC_MiKo_01", "NFC_MiKo_ESM_aktiv", getValue( KCAN_NFC_MiKo_ESM_aktiv ), profileFile );
    writeProfileInt( "NFC_MiKo_01", "NFC_MiKo_Fehler", getValue( KCAN_NFC_MiKo_Fehler ), profileFile );
    writeProfileInt( "NFC_MiKo_01", "NFC_MiKo_Laden_unterbrechen", getValue( KCAN_NFC_MiKo_Laden_unterbrechen ), profileFile );
    writeProfileInt( "NFC_MiKo_01", "NFC_MiKo_NFC_Device_gekoppelt", getValue( KCAN_NFC_MiKo_NFC_Device_gekoppelt ), profileFile );

}


void saveSettings_NMH_DispKBI_FS( char profileFile[] )
{
    writeProfileInt( "NMH_DispKBI_FS", "NM_DispKBI_FS_CAB_V10", getValue( KCAN_NM_DispKBI_FS_CAB_V10 ), profileFile );
    writeProfileInt( "NMH_DispKBI_FS", "NM_DispKBI_FS_CarWakeup", getValue( KCAN_NM_DispKBI_FS_CarWakeup ), profileFile );
    writeProfileInt( "NMH_DispKBI_FS", "NM_DispKBI_FS_CBV_AWB", getValue( KCAN_NM_DispKBI_FS_CBV_AWB ), profileFile );
    writeProfileInt( "NMH_DispKBI_FS", "NM_DispKBI_FS_CBV_CRI", getValue( KCAN_NM_DispKBI_FS_CBV_CRI ), profileFile );
    writeProfileInt( "NMH_DispKBI_FS", "NM_DispKBI_FS_NM_aktiv_Diagnose", getValue( KCAN_NM_DispKBI_FS_NM_aktiv_Diagnose ), profileFile );
    writeProfileInt( "NMH_DispKBI_FS", "NM_DispKBI_FS_NM_aktiv_KL15", getValue( KCAN_NM_DispKBI_FS_NM_aktiv_KL15 ), profileFile );
    writeProfileInt( "NMH_DispKBI_FS", "NM_DispKBI_FS_NM_aktiv_Tmin", getValue( KCAN_NM_DispKBI_FS_NM_aktiv_Tmin ), profileFile );
    writeProfileInt( "NMH_DispKBI_FS", "NM_DispKBI_FS_NM_State", getValue( KCAN_NM_DispKBI_FS_NM_State ), profileFile );
    writeProfileInt( "NMH_DispKBI_FS", "NM_DispKBI_FS_UDS_CC", getValue( KCAN_NM_DispKBI_FS_UDS_CC ), profileFile );

}


void saveSettings_NMH_Gateway( char profileFile[] )
{
    writeProfileInt( "NMH_Gateway", "NM_Gateway_CAB_V10", getValue( KCAN_NM_Gateway_CAB_V10 ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_Car_Wakeup", getValue( KCAN_NM_Gateway_Car_Wakeup ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_CBV_AWB", getValue( KCAN_NM_Gateway_CBV_AWB ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_CBV_CRI", getValue( KCAN_NM_Gateway_CBV_CRI ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_CAB", getValue( KCAN_NM_Gateway_NM_aktiv_CAB ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_Diagnose", getValue( KCAN_NM_Gateway_NM_aktiv_Diagnose ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_Energie", getValue( KCAN_NM_Gateway_NM_aktiv_Energie ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_FoD", getValue( KCAN_NM_Gateway_NM_aktiv_FoD ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_IAA_PSO", getValue( KCAN_NM_Gateway_NM_aktiv_IAA_PSO ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_Kessy", getValue( KCAN_NM_Gateway_NM_aktiv_Kessy ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_KL15", getValue( KCAN_NM_Gateway_NM_aktiv_KL15 ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_KS", getValue( KCAN_NM_Gateway_NM_aktiv_KS ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_Licht", getValue( KCAN_NM_Gateway_NM_aktiv_Licht ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_PaCo", getValue( KCAN_NM_Gateway_NM_aktiv_PaCo ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_RTM", getValue( KCAN_NM_Gateway_NM_aktiv_RTM ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_Standklima", getValue( KCAN_NM_Gateway_NM_aktiv_Standklima ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_Tmin", getValue( KCAN_NM_Gateway_NM_aktiv_Tmin ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_USS", getValue( KCAN_NM_Gateway_NM_aktiv_USS ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_ZM", getValue( KCAN_NM_Gateway_NM_aktiv_ZM ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_ZV", getValue( KCAN_NM_Gateway_NM_aktiv_ZV ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_NM_State", getValue( KCAN_NM_Gateway_NM_State ), profileFile );
    writeProfileInt( "NMH_Gateway", "NM_Gateway_UDS_CC", getValue( KCAN_NM_Gateway_UDS_CC ), profileFile );

}


void saveSettings_NMH_HUD( char profileFile[] )
{
    writeProfileInt( "NMH_HUD", "NM_HUD_CAB_V10", getValue( KCAN_NM_HUD_CAB_V10 ), profileFile );
    writeProfileInt( "NMH_HUD", "NM_HUD_Car_WakeUp", getValue( KCAN_NM_HUD_Car_WakeUp ), profileFile );
    writeProfileInt( "NMH_HUD", "NM_HUD_CBV_AWB", getValue( KCAN_NM_HUD_CBV_AWB ), profileFile );
    writeProfileInt( "NMH_HUD", "NM_HUD_CBV_CRI", getValue( KCAN_NM_HUD_CBV_CRI ), profileFile );
    writeProfileInt( "NMH_HUD", "NM_HUD_NM_aktiv_Diagnose", getValue( KCAN_NM_HUD_NM_aktiv_Diagnose ), profileFile );
    writeProfileInt( "NMH_HUD", "NM_HUD_NM_aktiv_KL15", getValue( KCAN_NM_HUD_NM_aktiv_KL15 ), profileFile );
    writeProfileInt( "NMH_HUD", "NM_HUD_NM_aktiv_Tmin", getValue( KCAN_NM_HUD_NM_aktiv_Tmin ), profileFile );
    writeProfileInt( "NMH_HUD", "NM_HUD_NM_State", getValue( KCAN_NM_HUD_NM_State ), profileFile );
    writeProfileInt( "NMH_HUD", "NM_HUD_UDS_CC", getValue( KCAN_NM_HUD_UDS_CC ), profileFile );

}


void saveSettings_NMH_Info_El( char profileFile[] )
{
    writeProfileInt( "NMH_Info_El", "NM_Info_El_CAB_V10", getValue( KCAN_NM_Info_El_CAB_V10 ), profileFile );
    writeProfileInt( "NMH_Info_El", "NM_Info_El_Car_Wakeup", getValue( KCAN_NM_Info_El_Car_Wakeup ), profileFile );
    writeProfileInt( "NMH_Info_El", "NM_Info_El_CBV_AWB", getValue( KCAN_NM_Info_El_CBV_AWB ), profileFile );
    writeProfileInt( "NMH_Info_El", "NM_Info_El_CBV_CRI", getValue( KCAN_NM_Info_El_CBV_CRI ), profileFile );
    writeProfileInt( "NMH_Info_El", "NM_Info_El_NM_aktiv_BAP_Comm", getValue( KCAN_NM_Info_El_NM_aktiv_BAP_Comm ), profileFile );
    writeProfileInt( "NMH_Info_El", "NM_Info_El_NM_aktiv_Diagnose", getValue( KCAN_NM_Info_El_NM_aktiv_Diagnose ), profileFile );
    writeProfileInt( "NMH_Info_El", "NM_Info_El_NM_aktiv_IAA", getValue( KCAN_NM_Info_El_NM_aktiv_IAA ), profileFile );
    writeProfileInt( "NMH_Info_El", "NM_Info_El_NM_aktiv_KL15", getValue( KCAN_NM_Info_El_NM_aktiv_KL15 ), profileFile );
    writeProfileInt( "NMH_Info_El", "NM_Info_El_NM_aktiv_MIBCAN", getValue( KCAN_NM_Info_El_NM_aktiv_MIBCAN ), profileFile );
    writeProfileInt( "NMH_Info_El", "NM_Info_El_NM_aktiv_SmartLight", getValue( KCAN_NM_Info_El_NM_aktiv_SmartLight ), profileFile );
    writeProfileInt( "NMH_Info_El", "NM_Info_El_NM_aktiv_Tmin", getValue( KCAN_NM_Info_El_NM_aktiv_Tmin ), profileFile );
    writeProfileInt( "NMH_Info_El", "NM_Info_El_NM_State", getValue( KCAN_NM_Info_El_NM_State ), profileFile );
    writeProfileInt( "NMH_Info_El", "NM_Info_El_UDS_CC", getValue( KCAN_NM_Info_El_UDS_CC ), profileFile );

}


void saveSettings_NMH_Kombi( char profileFile[] )
{
    writeProfileInt( "NMH_Kombi", "NM_Kombi_CAB_V10", getValue( KCAN_NM_Kombi_CAB_V10 ), profileFile );
    writeProfileInt( "NMH_Kombi", "NM_Kombi_Car_Wakeup", getValue( KCAN_NM_Kombi_Car_Wakeup ), profileFile );
    writeProfileInt( "NMH_Kombi", "NM_Kombi_CBV_AWB", getValue( KCAN_NM_Kombi_CBV_AWB ), profileFile );
    writeProfileInt( "NMH_Kombi", "NM_Kombi_CBV_CRI", getValue( KCAN_NM_Kombi_CBV_CRI ), profileFile );
    writeProfileInt( "NMH_Kombi", "NM_Kombi_NM_aktiv_Buzzer", getValue( KCAN_NM_Kombi_NM_aktiv_Buzzer ), profileFile );
    writeProfileInt( "NMH_Kombi", "NM_Kombi_NM_aktiv_Diagnose", getValue( KCAN_NM_Kombi_NM_aktiv_Diagnose ), profileFile );
    writeProfileInt( "NMH_Kombi", "NM_Kombi_NM_aktiv_KL15", getValue( KCAN_NM_Kombi_NM_aktiv_KL15 ), profileFile );
    writeProfileInt( "NMH_Kombi", "NM_Kombi_NM_aktiv_Schluesselkomm", getValue( KCAN_NM_Kombi_NM_aktiv_Schluesselkomm ), profileFile );
    writeProfileInt( "NMH_Kombi", "NM_Kombi_NM_aktiv_Tmin", getValue( KCAN_NM_Kombi_NM_aktiv_Tmin ), profileFile );
    writeProfileInt( "NMH_Kombi", "NM_Kombi_NM_aktiv_VLW", getValue( KCAN_NM_Kombi_NM_aktiv_VLW ), profileFile );
    writeProfileInt( "NMH_Kombi", "NM_Kombi_NM_State", getValue( KCAN_NM_Kombi_NM_State ), profileFile );
    writeProfileInt( "NMH_Kombi", "NM_Kombi_UDS_CC", getValue( KCAN_NM_Kombi_UDS_CC ), profileFile );

}


void saveSettings_NMH_SmLi_01( char profileFile[] )
{
    writeProfileInt( "NMH_SmLi_01", "NM_SmLi_01_CAB_V10", getValue( KCAN_NM_SmLi_01_CAB_V10 ), profileFile );
    writeProfileInt( "NMH_SmLi_01", "NM_SmLi_01_CarWakeup", getValue( KCAN_NM_SmLi_01_CarWakeup ), profileFile );
    writeProfileInt( "NMH_SmLi_01", "NM_SmLi_01_CBV_AWB", getValue( KCAN_NM_SmLi_01_CBV_AWB ), profileFile );
    writeProfileInt( "NMH_SmLi_01", "NM_SmLi_01_CBV_CRI", getValue( KCAN_NM_SmLi_01_CBV_CRI ), profileFile );
    writeProfileInt( "NMH_SmLi_01", "NM_SmLi_01_NM_aktiv_Diagnose", getValue( KCAN_NM_SmLi_01_NM_aktiv_Diagnose ), profileFile );
    writeProfileInt( "NMH_SmLi_01", "NM_SmLi_01_NM_aktiv_KL15", getValue( KCAN_NM_SmLi_01_NM_aktiv_KL15 ), profileFile );
    writeProfileInt( "NMH_SmLi_01", "NM_SmLi_01_NM_aktiv_Tmin", getValue( KCAN_NM_SmLi_01_NM_aktiv_Tmin ), profileFile );
    writeProfileInt( "NMH_SmLi_01", "NM_SmLi_01_NM_State", getValue( KCAN_NM_SmLi_01_NM_State ), profileFile );
    writeProfileInt( "NMH_SmLi_01", "NM_SmLi_01_UDS_CC", getValue( KCAN_NM_SmLi_01_UDS_CC ), profileFile );

}


void saveSettings_OBDC_DispKBI_FS_Req_FD( char profileFile[] )
{

}


void saveSettings_OBDC_DispKBI_FS_Resp_FD( char profileFile[] )
{

}


void saveSettings_OBDC_Funktionaler_Req_All( char profileFile[] )
{

}


void saveSettings_OBDC_Funktionaler_Req_All_FD( char profileFile[] )
{

}


void saveSettings_OBDC_HUD_Req_FD( char profileFile[] )
{

}


void saveSettings_OBDC_HUD_Resp_FD( char profileFile[] )
{

}


void saveSettings_OBDC_Kombi_Req_FD( char profileFile[] )
{

}


void saveSettings_OBDC_Kombi_Resp_FD( char profileFile[] )
{

}


void saveSettings_OBDC_SmLi_01_Req_FD( char profileFile[] )
{

}


void saveSettings_OBDC_SmLi_01_Resp_FD( char profileFile[] )
{

}


void saveSettings_OBDC_SSN_ABT_1_Req( char profileFile[] )
{

}


void saveSettings_OBDC_SSN_ABT_1_Resp( char profileFile[] )
{

}


void saveSettings_OBDC_WLC1_Req( char profileFile[] )
{

}


void saveSettings_OBDC_WLC1_Resp( char profileFile[] )
{

}


void saveSettings_OBDx_allOBD_Req( char profileFile[] )
{

}


void saveSettings_ORU_01( char profileFile[] )
{
    writeProfileInt( "ORU_01", "ORU_EM_Anfrage_Flashdauer", getValue( KCAN_ORU_EM_Anfrage_Flashdauer ), profileFile );
    writeProfileInt( "ORU_01", "ORU_EM_Anfrage_freigegebeneNetze", getValue( KCAN_ORU_EM_Anfrage_freigegebeneNetze ), profileFile );
    writeProfileFloat( "ORU_01", "ORU_EM_Anfrage_Stromaufnahme", getValue( KCAN_ORU_EM_Anfrage_Stromaufnahme ), profileFile );
    writeProfileInt( "ORU_01", "ORU_Status", getValue( KCAN_ORU_Status ), profileFile );
    writeProfileInt( "ORU_01", "ORU_Warnung", getValue( KCAN_ORU_Warnung ), profileFile );

}


void saveSettings_Parkhilfe_01( char profileFile[] )
{
    writeProfileInt( "Parkhilfe_01", "PDC_Tonausgabe_Front", getValue( KCAN_PDC_Tonausgabe_Front ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PDC_Tonausgabe_Heck", getValue( KCAN_PDC_Tonausgabe_Heck ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Abschaltursache", getValue( KCAN_PH_Abschaltursache ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Anf_Audioabsenkung", getValue( KCAN_PH_Anf_Audioabsenkung ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Anf_Verdeck", getValue( KCAN_PH_Anf_Verdeck ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_defekt", getValue( KCAN_PH_defekt ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Display_Kundenwunsch", getValue( KCAN_PH_Display_Kundenwunsch ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Frequenz_hinten", getValue( KCAN_PH_Frequenz_hinten ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Frequenz_vorn", getValue( KCAN_PH_Frequenz_vorn ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_gestoert", getValue( KCAN_PH_gestoert ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Lautstaerke_hinten", getValue( KCAN_PH_Lautstaerke_hinten ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Lautstaerke_vorn", getValue( KCAN_PH_Lautstaerke_vorn ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_nachtr_Stopp_Anf", getValue( KCAN_PH_nachtr_Stopp_Anf ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Opt_Anz_H_Hindernis", getValue( KCAN_PH_Opt_Anz_H_Hindernis ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Opt_Anz_V_Hindernis", getValue( KCAN_PH_Opt_Anz_V_Hindernis ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Opt_Anzeige_H_ein", getValue( KCAN_PH_Opt_Anzeige_H_ein ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Opt_Anzeige_V_ein", getValue( KCAN_PH_Opt_Anzeige_V_ein ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_StartStopp_Info", getValue( KCAN_PH_StartStopp_Info ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Stoermeldung", getValue( KCAN_PH_Stoermeldung ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Systemzustand_Parkhilfe_01", getValue( KCAN_PH_Systemzustand_Parkhilfe_01 ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Taster_Parkhilfe_01", getValue( KCAN_PH_Taster_Parkhilfe_01 ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Tongeber_H_aktiv", getValue( KCAN_PH_Tongeber_H_aktiv ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Tongeber_H_verfuegbar", getValue( KCAN_PH_Tongeber_H_verfuegbar ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Tongeber_mute", getValue( KCAN_PH_Tongeber_mute ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Tongeber_V_aktiv", getValue( KCAN_PH_Tongeber_V_aktiv ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PH_Visualisierung", getValue( KCAN_PH_Visualisierung ), profileFile );
    writeProfileInt( "Parkhilfe_01", "PLA_Anf_Aufschaltung_RVC_Parkhilfe_01", getValue( KCAN_PLA_Anf_Aufschaltung_RVC_Parkhilfe_01 ), profileFile );

}


void saveSettings_Parkhilfe_04( char profileFile[] )
{
    writeProfileInt( "Parkhilfe_04", "APS_PaCo_WarningTones", getValue( KCAN_APS_PaCo_WarningTones ), profileFile );
    writeProfileInt( "Parkhilfe_04", "APSOPS_PaCo_ApproachingFront", getValue( KCAN_APSOPS_PaCo_ApproachingFront ), profileFile );
    writeProfileInt( "Parkhilfe_04", "APSOPS_PaCo_ApproachingRear", getValue( KCAN_APSOPS_PaCo_ApproachingRear ), profileFile );
    writeProfileInt( "Parkhilfe_04", "APSOPS_PaCo_Button", getValue( KCAN_APSOPS_PaCo_Button ), profileFile );
    writeProfileInt( "Parkhilfe_04", "APSOPS_PaCo_FunctionState", getValue( KCAN_APSOPS_PaCo_FunctionState ), profileFile );
    writeProfileInt( "Parkhilfe_04", "APSOPS_PaCo_MainState", getValue( KCAN_APSOPS_PaCo_MainState ), profileFile );
    writeProfileInt( "Parkhilfe_04", "APSOPS_PaCo_ObstacleDetectFront", getValue( KCAN_APSOPS_PaCo_ObstacleDetectFront ), profileFile );
    writeProfileInt( "Parkhilfe_04", "APSOPS_PaCo_ObstacleDetectRear", getValue( KCAN_APSOPS_PaCo_ObstacleDetectRear ), profileFile );
    writeProfileInt( "Parkhilfe_04", "PDC_Charisma_FahrPr", getValue( KCAN_PDC_Charisma_FahrPr ), profileFile );
    writeProfileInt( "Parkhilfe_04", "PDC_Charisma_Status", getValue( KCAN_PDC_Charisma_Status ), profileFile );
    writeProfileInt( "Parkhilfe_04", "PH_Aufschaltursache", getValue( KCAN_PH_Aufschaltursache ), profileFile );
    writeProfileInt( "Parkhilfe_04", "PH_Ton_Ausgabe", getValue( KCAN_PH_Ton_Ausgabe ), profileFile );
    writeProfileInt( "Parkhilfe_04", "PH_Ton_Lautstaerke", getValue( KCAN_PH_Ton_Lautstaerke ), profileFile );
    writeProfileInt( "Parkhilfe_04", "PH_Ton_Pausenlaenge", getValue( KCAN_PH_Ton_Pausenlaenge ), profileFile );
    writeProfileInt( "Parkhilfe_04", "PH_Ton_Richtung", getValue( KCAN_PH_Ton_Richtung ), profileFile );
    writeProfileInt( "Parkhilfe_04", "PH_Verschmutzungsmeldung", getValue( KCAN_PH_Verschmutzungsmeldung ), profileFile );
    writeProfileInt( "Parkhilfe_04", "PH_WAH_Meldung", getValue( KCAN_PH_WAH_Meldung ), profileFile );
    writeProfileInt( "Parkhilfe_04", "RBF_Anf_Meldungen", getValue( KCAN_RBF_Anf_Meldungen ), profileFile );
    writeProfileInt( "Parkhilfe_04", "RBFMA_PaCo_BrakeIntervention", getValue( KCAN_RBFMA_PaCo_BrakeIntervention ), profileFile );
    writeProfileInt( "Parkhilfe_04", "RBFMA_PaCo_MainState", getValue( KCAN_RBFMA_PaCo_MainState ), profileFile );

}


void saveSettings_Personalisierung_01( char profileFile[] )
{
    writeProfileInt( "Personalisierung_01", "IAA_Active_User_ID", getValue( KCAN_IAA_Active_User_ID ), profileFile );
    writeProfileInt( "Personalisierung_01", "IAA_Identified_User_ID", getValue( KCAN_IAA_Identified_User_ID ), profileFile );
    writeProfileInt( "Personalisierung_01", "IAA_PSO_wake_up", getValue( KCAN_IAA_PSO_wake_up ), profileFile );
    writeProfileInt( "Personalisierung_01", "Perso_Aktiv", getValue( KCAN_Perso_Aktiv ), profileFile );
    writeProfileInt( "Personalisierung_01", "Perso_Bedienstelle", getValue( KCAN_Perso_Bedienstelle ), profileFile );
    writeProfileInt( "Personalisierung_01", "Perso_Fahrernummer", getValue( KCAN_Perso_Fahrernummer ), profileFile );
    writeProfileInt( "Personalisierung_01", "Perso_Freigabe_Verstellung", getValue( KCAN_Perso_Freigabe_Verstellung ), profileFile );
    writeProfileInt( "Personalisierung_01", "Perso_Kontonummer", getValue( KCAN_Perso_Kontonummer ), profileFile );
    writeProfileInt( "Personalisierung_01", "Perso_Schreibschutz", getValue( KCAN_Perso_Schreibschutz ), profileFile );
    writeProfileInt( "Personalisierung_01", "Perso_Status", getValue( KCAN_Perso_Status ), profileFile );
    writeProfileInt( "Personalisierung_01", "Perso_Steuerung", getValue( KCAN_Perso_Steuerung ), profileFile );
    writeProfileInt( "Personalisierung_01", "Perso_Steuerungsparameter", getValue( KCAN_Perso_Steuerungsparameter ), profileFile );

}


void saveSettings_PreCrash_02( char profileFile[] )
{
    writeProfileInt( "PreCrash_02", "PreCrash_Anforderung_AFR", getValue( KCAN_PreCrash_Anforderung_AFR ), profileFile );
    writeProfileInt( "PreCrash_02", "PreCrash_BFS_KSV_verfahren", getValue( KCAN_PreCrash_BFS_KSV_verfahren ), profileFile );
    writeProfileInt( "PreCrash_02", "PreCrash_BFS_Laengsverstellung", getValue( KCAN_PreCrash_BFS_Laengsverstellung ), profileFile );
    writeProfileInt( "PreCrash_02", "PreCrash_BFS_Pneumatik_ansteuern", getValue( KCAN_PreCrash_BFS_Pneumatik_ansteuern ), profileFile );
    writeProfileInt( "PreCrash_02", "PreCrash_BFS_Sitzlehne_verfahren", getValue( KCAN_PreCrash_BFS_Sitzlehne_verfahren ), profileFile );
    writeProfileInt( "PreCrash_02", "PreCrash_Blinken", getValue( KCAN_PreCrash_Blinken ), profileFile );
    writeProfileInt( "PreCrash_02", "PreCrash_Charisma_FahrPr", getValue( KCAN_PreCrash_Charisma_FahrPr ), profileFile );
    writeProfileInt( "PreCrash_02", "PreCrash_Charisma_Status", getValue( KCAN_PreCrash_Charisma_Status ), profileFile );
    writeProfileInt( "PreCrash_02", "PreCrash_Fenster_schliessen", getValue( KCAN_PreCrash_Fenster_schliessen ), profileFile );
    writeProfileInt( "PreCrash_02", "PreCrash_Fo_KSV_verfahren", getValue( KCAN_PreCrash_Fo_KSV_verfahren ), profileFile );
    writeProfileInt( "PreCrash_02", "PreCrash_Fo_Pneumatik_ansteuern", getValue( KCAN_PreCrash_Fo_Pneumatik_ansteuern ), profileFile );
    writeProfileInt( "PreCrash_02", "PreCrash_Fo_Sitzlehne_verfahren", getValue( KCAN_PreCrash_Fo_Sitzlehne_verfahren ), profileFile );
    writeProfileInt( "PreCrash_02", "PreCrash_FS_KSV_verfahren", getValue( KCAN_PreCrash_FS_KSV_verfahren ), profileFile );
    writeProfileInt( "PreCrash_02", "PreCrash_FS_Laengsverstellung", getValue( KCAN_PreCrash_FS_Laengsverstellung ), profileFile );
    writeProfileInt( "PreCrash_02", "PreCrash_FS_Pneumatik_ansteuern", getValue( KCAN_PreCrash_FS_Pneumatik_ansteuern ), profileFile );
    writeProfileInt( "PreCrash_02", "PreCrash_FS_Sitzlehne_verfahren", getValue( KCAN_PreCrash_FS_Sitzlehne_verfahren ), profileFile );
    writeProfileInt( "PreCrash_02", "PreCrash_Schiebedach_schliessen", getValue( KCAN_PreCrash_Schiebedach_schliessen ), profileFile );
    writeProfileInt( "PreCrash_02", "PreCrash_Tueren_Verriegeln", getValue( KCAN_PreCrash_Tueren_Verriegeln ), profileFile );
    writeProfileInt( "PreCrash_02", "SC_PreCrash_LED", getValue( KCAN_SC_PreCrash_LED ), profileFile );
    writeProfileInt( "PreCrash_02", "SC_PreCrash_Texte", getValue( KCAN_SC_PreCrash_Texte ), profileFile );
    writeProfileInt( "PreCrash_02", "SC_PreCrash_Warnung", getValue( KCAN_SC_PreCrash_Warnung ), profileFile );
    writeProfileInt( "PreCrash_02", "SC_PreSense_FCWP", getValue( KCAN_SC_PreSense_FCWP ), profileFile );

}


void saveSettings_PSD_04( char profileFile[] )
{
    writeProfileInt( "PSD_04", "PSD_Abzweigerichtung", getValue( KCAN_PSD_Abzweigerichtung ), profileFile );
    writeProfileFloat( "PSD_04", "PSD_Abzweigewinkel", getValue( KCAN_PSD_Abzweigewinkel ), profileFile );
    writeProfileInt( "PSD_04", "PSD_ADAS_Qualitaet", getValue( KCAN_PSD_ADAS_Qualitaet ), profileFile );
    writeProfileInt( "PSD_04", "PSD_Anfangskruemmung", getValue( KCAN_PSD_Anfangskruemmung ), profileFile );
    writeProfileInt( "PSD_04", "PSD_Anfangskruemmung_Vorz", getValue( KCAN_PSD_Anfangskruemmung_Vorz ), profileFile );
    writeProfileInt( "PSD_04", "PSD_Bebauung", getValue( KCAN_PSD_Bebauung ), profileFile );
    writeProfileInt( "PSD_04", "PSD_Endkruemmung", getValue( KCAN_PSD_Endkruemmung ), profileFile );
    writeProfileInt( "PSD_04", "PSD_Endkruemmung_Vorz", getValue( KCAN_PSD_Endkruemmung_Vorz ), profileFile );
    writeProfileInt( "PSD_04", "PSD_Fahrspuren_Anzahl", getValue( KCAN_PSD_Fahrspuren_Anzahl ), profileFile );
    writeProfileInt( "PSD_04", "PSD_Geradester_Pfad", getValue( KCAN_PSD_Geradester_Pfad ), profileFile );
    writeProfileInt( "PSD_04", "PSD_Idenditaets_ID", getValue( KCAN_PSD_Idenditaets_ID ), profileFile );
    writeProfileInt( "PSD_04", "PSD_Rampe", getValue( KCAN_PSD_Rampe ), profileFile );
    writeProfileInt( "PSD_04", "PSD_Segment_ID", getValue( KCAN_PSD_Segment_ID ), profileFile );
    writeProfileInt( "PSD_04", "PSD_Segment_Komplett", getValue( KCAN_PSD_Segment_Komplett ), profileFile );
    writeProfileInt( "PSD_04", "PSD_Segmentlaenge", getValue( KCAN_PSD_Segmentlaenge ), profileFile );
    writeProfileInt( "PSD_04", "PSD_Strassenkategorie", getValue( KCAN_PSD_Strassenkategorie ), profileFile );
    writeProfileInt( "PSD_04", "PSD_Vorgaenger_Segment_ID", getValue( KCAN_PSD_Vorgaenger_Segment_ID ), profileFile );
    writeProfileInt( "PSD_04", "PSD_wahrscheinlichster_Pfad", getValue( KCAN_PSD_wahrscheinlichster_Pfad ), profileFile );

}


void saveSettings_PSD_05( char profileFile[] )
{
    writeProfileInt( "PSD_05", "PSD_Attribut_1_ID", getValue( KCAN_PSD_Attribut_1_ID ), profileFile );
    writeProfileInt( "PSD_05", "PSD_Attribut_1_Offset", getValue( KCAN_PSD_Attribut_1_Offset ), profileFile );
    writeProfileInt( "PSD_05", "PSD_Attribut_1_Wert", getValue( KCAN_PSD_Attribut_1_Wert ), profileFile );
    writeProfileInt( "PSD_05", "PSD_Attribut_2_ID", getValue( KCAN_PSD_Attribut_2_ID ), profileFile );
    writeProfileInt( "PSD_05", "PSD_Attribut_2_Offset", getValue( KCAN_PSD_Attribut_2_Offset ), profileFile );
    writeProfileInt( "PSD_05", "PSD_Attribut_2_Wert", getValue( KCAN_PSD_Attribut_2_Wert ), profileFile );
    writeProfileInt( "PSD_05", "PSD_Attribut_Segment_ID_05", getValue( KCAN_PSD_Attribut_Segment_ID_05 ), profileFile );
    writeProfileInt( "PSD_05", "PSD_Attribute_Komplett_05", getValue( KCAN_PSD_Attribute_Komplett_05 ), profileFile );
    writeProfileInt( "PSD_05", "PSD_Pos_Fahrspur", getValue( KCAN_PSD_Pos_Fahrspur ), profileFile );
    writeProfileInt( "PSD_05", "PSD_Pos_Fehler_Laengsrichtung", getValue( KCAN_PSD_Pos_Fehler_Laengsrichtung ), profileFile );
    writeProfileInt( "PSD_05", "PSD_Pos_Inhibitzeit", getValue( KCAN_PSD_Pos_Inhibitzeit ), profileFile );
    writeProfileInt( "PSD_05", "PSD_Pos_Segment_ID", getValue( KCAN_PSD_Pos_Segment_ID ), profileFile );
    writeProfileInt( "PSD_05", "PSD_Pos_Segmentlaenge", getValue( KCAN_PSD_Pos_Segmentlaenge ), profileFile );
    writeProfileInt( "PSD_05", "PSD_Pos_Standort_Eindeutig", getValue( KCAN_PSD_Pos_Standort_Eindeutig ), profileFile );

}


void saveSettings_PSD_06( char profileFile[] )
{
    writeProfileInt( "PSD_06", "PSD_06_Mux", getValue( KCAN_PSD_06_Mux ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Attribut_3_ID", getValue( KCAN_PSD_Attribut_3_ID ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Attribut_3_Offset", getValue( KCAN_PSD_Attribut_3_Offset ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Attribut_3_Wert", getValue( KCAN_PSD_Attribut_3_Wert ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Attribut_4_ID", getValue( KCAN_PSD_Attribut_4_ID ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Attribut_4_Offset", getValue( KCAN_PSD_Attribut_4_Offset ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Attribut_4_Wert", getValue( KCAN_PSD_Attribut_4_Wert ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Attribut_5_ID", getValue( KCAN_PSD_Attribut_5_ID ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Attribut_5_Offset", getValue( KCAN_PSD_Attribut_5_Offset ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Attribut_5_Wert", getValue( KCAN_PSD_Attribut_5_Wert ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Attribut_Segment_ID", getValue( KCAN_PSD_Attribut_Segment_ID ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Attribute_Komplett_06", getValue( KCAN_PSD_Attribute_Komplett_06 ), profileFile );
    writeProfileFloat( "PSD_06", "PSD_Baum_Ausrichtung", getValue( KCAN_PSD_Baum_Ausrichtung ), profileFile );
    writeProfileFloat( "PSD_06", "PSD_Baum_Breite", getValue( KCAN_PSD_Baum_Breite ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Baum_Breite_VZ", getValue( KCAN_PSD_Baum_Breite_VZ ), profileFile );
    writeProfileFloat( "PSD_06", "PSD_Baum_Laenge", getValue( KCAN_PSD_Baum_Laenge ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Baum_Laenge_VZ", getValue( KCAN_PSD_Baum_Laenge_VZ ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Ges_Attribute_Komplett", getValue( KCAN_PSD_Ges_Attribute_Komplett ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Ges_Geschwindigkeit", getValue( KCAN_PSD_Ges_Geschwindigkeit ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Ges_Geschwindigkeit_Gespann", getValue( KCAN_PSD_Ges_Geschwindigkeit_Gespann ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Ges_Geschwindigkeit_Std_Anf", getValue( KCAN_PSD_Ges_Geschwindigkeit_Std_Anf ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Ges_Geschwindigkeit_Std_Ende", getValue( KCAN_PSD_Ges_Geschwindigkeit_Std_Ende ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Ges_Geschwindigkeit_Tag_Anf", getValue( KCAN_PSD_Ges_Geschwindigkeit_Tag_Anf ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Ges_Geschwindigkeit_Tag_Ende", getValue( KCAN_PSD_Ges_Geschwindigkeit_Tag_Ende ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Ges_Geschwindigkeit_Witter", getValue( KCAN_PSD_Ges_Geschwindigkeit_Witter ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Ges_Gesetzlich_Kategorie", getValue( KCAN_PSD_Ges_Gesetzlich_Kategorie ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Ges_Gesetzlich_Zusatz", getValue( KCAN_PSD_Ges_Gesetzlich_Zusatz ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Ges_Offset", getValue( KCAN_PSD_Ges_Offset ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Ges_Segment_ID", getValue( KCAN_PSD_Ges_Segment_ID ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Ges_Spur_Geschw_Begrenzung", getValue( KCAN_PSD_Ges_Spur_Geschw_Begrenzung ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Ges_Typ", getValue( KCAN_PSD_Ges_Typ ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Ges_Ueberholverbot", getValue( KCAN_PSD_Ges_Ueberholverbot ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Ges_Verkehrszeichen_Quelle", getValue( KCAN_PSD_Ges_Verkehrszeichen_Quelle ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Ges_Wechselverkehrszeichen", getValue( KCAN_PSD_Ges_Wechselverkehrszeichen ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Steigung_1_A_Offset", getValue( KCAN_PSD_Steigung_1_A_Offset ), profileFile );
    writeProfileFloat( "PSD_06", "PSD_Steigung_1_A_Steigung", getValue( KCAN_PSD_Steigung_1_A_Steigung ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Steigung_1_A_Vorz", getValue( KCAN_PSD_Steigung_1_A_Vorz ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Steigung_1_Attribute_kompl", getValue( KCAN_PSD_Steigung_1_Attribute_kompl ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Steigung_1_B_Offset", getValue( KCAN_PSD_Steigung_1_B_Offset ), profileFile );
    writeProfileFloat( "PSD_06", "PSD_Steigung_1_B_Steigung", getValue( KCAN_PSD_Steigung_1_B_Steigung ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Steigung_1_B_Vorz", getValue( KCAN_PSD_Steigung_1_B_Vorz ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Steigung_1_Segment_ID", getValue( KCAN_PSD_Steigung_1_Segment_ID ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Steigung_2_Attribute_kompl", getValue( KCAN_PSD_Steigung_2_Attribute_kompl ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Steigung_2_Offset", getValue( KCAN_PSD_Steigung_2_Offset ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Steigung_2_Segment_ID", getValue( KCAN_PSD_Steigung_2_Segment_ID ), profileFile );
    writeProfileFloat( "PSD_06", "PSD_Steigung_2_Steigung", getValue( KCAN_PSD_Steigung_2_Steigung ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Steigung_2_Vorz", getValue( KCAN_PSD_Steigung_2_Vorz ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_Alter_Karte", getValue( KCAN_PSD_Sys_Alter_Karte ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_Geometrieguete", getValue( KCAN_PSD_Sys_Geometrieguete ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_Geometrieguete_erweitert", getValue( KCAN_PSD_Sys_Geometrieguete_erweitert ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_Geschwindigkeit_Einheit", getValue( KCAN_PSD_Sys_Geschwindigkeit_Einheit ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_Laendercode", getValue( KCAN_PSD_Sys_Laendercode ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_Mapmatchingguete", getValue( KCAN_PSD_Sys_Mapmatchingguete ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_Quali_Geometrien", getValue( KCAN_PSD_Sys_Quali_Geometrien ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_Quali_Ortsinfo", getValue( KCAN_PSD_Sys_Quali_Ortsinfo ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_Quali_sonstige_Attribute", getValue( KCAN_PSD_Sys_Quali_sonstige_Attribute ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_Quali_Steigungen", getValue( KCAN_PSD_Sys_Quali_Steigungen ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_Quali_Strassenkennz", getValue( KCAN_PSD_Sys_Quali_Strassenkennz ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_Quali_Tempolimits", getValue( KCAN_PSD_Sys_Quali_Tempolimits ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_Quali_verfuegbar", getValue( KCAN_PSD_Sys_Quali_verfuegbar ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_Quali_Vorfahrtsregelung", getValue( KCAN_PSD_Sys_Quali_Vorfahrtsregelung ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_Segment_ID", getValue( KCAN_PSD_Sys_Segment_ID ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_US_State", getValue( KCAN_PSD_Sys_US_State ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_Verkehrsrichtung", getValue( KCAN_PSD_Sys_Verkehrsrichtung ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_Zielfuehrung", getValue( KCAN_PSD_Sys_Zielfuehrung ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Sys_Zielfuehrung_geaendert", getValue( KCAN_PSD_Sys_Zielfuehrung_geaendert ), profileFile );
    writeProfileInt( "PSD_06", "PSD_Wechselverkehrszeichen_Typ", getValue( KCAN_PSD_Wechselverkehrszeichen_Typ ), profileFile );

}


void saveSettings_PSD_LR_01( char profileFile[] )
{
    writeProfileInt( "PSD_LR_01", "PSD_LR_01_MUX", getValue( KCAN_PSD_LR_01_MUX ), profileFile );
    writeProfileFloat( "PSD_LR_01", "PSD_LR_Attribut_1_Offset", getValue( KCAN_PSD_LR_Attribut_1_Offset ), profileFile );
    writeProfileInt( "PSD_LR_01", "PSD_LR_Attribut_1_Wert", getValue( KCAN_PSD_LR_Attribut_1_Wert ), profileFile );
    writeProfileFloat( "PSD_LR_01", "PSD_LR_Attribut_2_Offset", getValue( KCAN_PSD_LR_Attribut_2_Offset ), profileFile );
    writeProfileInt( "PSD_LR_01", "PSD_LR_Attribut_2_Wert", getValue( KCAN_PSD_LR_Attribut_2_Wert ), profileFile );
    writeProfileFloat( "PSD_LR_01", "PSD_LR_Attribut_3_Offset", getValue( KCAN_PSD_LR_Attribut_3_Offset ), profileFile );
    writeProfileInt( "PSD_LR_01", "PSD_LR_Attribut_3_Wert", getValue( KCAN_PSD_LR_Attribut_3_Wert ), profileFile );
    writeProfileFloat( "PSD_LR_01", "PSD_LR_Fahrzeug_Pos", getValue( KCAN_PSD_LR_Fahrzeug_Pos ), profileFile );
    writeProfileFloat( "PSD_LR_01", "PSD_LR_Globale_Steigung", getValue( KCAN_PSD_LR_Globale_Steigung ), profileFile );
    writeProfileInt( "PSD_LR_01", "PSD_LR_Globale_Steigung_Vorz", getValue( KCAN_PSD_LR_Globale_Steigung_Vorz ), profileFile );
    writeProfileFloat( "PSD_LR_01", "PSD_LR_Koeff_1_Amp", getValue( KCAN_PSD_LR_Koeff_1_Amp ), profileFile );
    writeProfileFloat( "PSD_LR_01", "PSD_LR_Koeff_1_Phase", getValue( KCAN_PSD_LR_Koeff_1_Phase ), profileFile );
    writeProfileFloat( "PSD_LR_01", "PSD_LR_Koeff_2_Amp", getValue( KCAN_PSD_LR_Koeff_2_Amp ), profileFile );
    writeProfileFloat( "PSD_LR_01", "PSD_LR_Koeff_2_Phase", getValue( KCAN_PSD_LR_Koeff_2_Phase ), profileFile );
    writeProfileFloat( "PSD_LR_01", "PSD_LR_Koeff_3_Amp", getValue( KCAN_PSD_LR_Koeff_3_Amp ), profileFile );
    writeProfileFloat( "PSD_LR_01", "PSD_LR_Koeff_3_Phase", getValue( KCAN_PSD_LR_Koeff_3_Phase ), profileFile );
    writeProfileInt( "PSD_LR_01", "PSD_LR_Koeffizientensatz_Nr", getValue( KCAN_PSD_LR_Koeffizientensatz_Nr ), profileFile );
    writeProfileInt( "PSD_LR_01", "PSD_LR_Max_Koeff_Amp", getValue( KCAN_PSD_LR_Max_Koeff_Amp ), profileFile );
    writeProfileFloat( "PSD_LR_01", "PSD_LR_Profil_Laenge", getValue( KCAN_PSD_LR_Profil_Laenge ), profileFile );
    writeProfileInt( "PSD_LR_01", "PSD_LR_Profil_Nummer", getValue( KCAN_PSD_LR_Profil_Nummer ), profileFile );
    writeProfileInt( "PSD_LR_01", "PSD_LR_Reset", getValue( KCAN_PSD_LR_Reset ), profileFile );
    writeProfileFloat( "PSD_LR_01", "PSD_LR_Steigung_1_Offset", getValue( KCAN_PSD_LR_Steigung_1_Offset ), profileFile );
    writeProfileInt( "PSD_LR_01", "PSD_LR_Steigung_1_Vorz", getValue( KCAN_PSD_LR_Steigung_1_Vorz ), profileFile );
    writeProfileFloat( "PSD_LR_01", "PSD_LR_Steigung_1_Wert", getValue( KCAN_PSD_LR_Steigung_1_Wert ), profileFile );
    writeProfileFloat( "PSD_LR_01", "PSD_LR_Steigung_2_Offset", getValue( KCAN_PSD_LR_Steigung_2_Offset ), profileFile );
    writeProfileInt( "PSD_LR_01", "PSD_LR_Steigung_2_Vorz", getValue( KCAN_PSD_LR_Steigung_2_Vorz ), profileFile );
    writeProfileFloat( "PSD_LR_01", "PSD_LR_Steigung_2_Wert", getValue( KCAN_PSD_LR_Steigung_2_Wert ), profileFile );
    writeProfileFloat( "PSD_LR_01", "PSD_LR_Steigung_3_Offset", getValue( KCAN_PSD_LR_Steigung_3_Offset ), profileFile );
    writeProfileInt( "PSD_LR_01", "PSD_LR_Steigung_3_Vorz", getValue( KCAN_PSD_LR_Steigung_3_Vorz ), profileFile );
    writeProfileFloat( "PSD_LR_01", "PSD_LR_Steigung_3_Wert", getValue( KCAN_PSD_LR_Steigung_3_Wert ), profileFile );

}


void saveSettings_Radio_01( char profileFile[] )
{
    writeProfileInt( "Radio_01", "RA_AM_Tuning", getValue( KCAN_RA_AM_Tuning ), profileFile );
    writeProfileInt( "Radio_01", "RA_Frequency", getValue( KCAN_RA_Frequency ), profileFile );
    writeProfileInt( "Radio_01", "RA_Frequency_unit", getValue( KCAN_RA_Frequency_unit ), profileFile );
    writeProfileInt( "Radio_01", "RA_PowerAmpOn", getValue( KCAN_RA_PowerAmpOn ), profileFile );
    writeProfileInt( "Radio_01", "RA_Radio_Error_Flag", getValue( KCAN_RA_Radio_Error_Flag ), profileFile );
    writeProfileInt( "Radio_01", "RA_Radio_mute", getValue( KCAN_RA_Radio_mute ), profileFile );
    writeProfileInt( "Radio_01", "RA_Radio_on", getValue( KCAN_RA_Radio_on ), profileFile );
    writeProfileInt( "Radio_01", "RA_Radio_Surround", getValue( KCAN_RA_Radio_Surround ), profileFile );
    writeProfileInt( "Radio_01", "RA_VNC_OFF", getValue( KCAN_RA_VNC_OFF ), profileFile );

}


void saveSettings_Rear_View_04( char profileFile[] )
{
    writeProfileInt( "Rear_View_04", "VPS_PaCo_Button", getValue( KCAN_VPS_PaCo_Button ), profileFile );
    writeProfileInt( "Rear_View_04", "VPS_PaCo_CurrentBirdview", getValue( KCAN_VPS_PaCo_CurrentBirdview ), profileFile );
    writeProfileInt( "Rear_View_04", "VPS_PaCo_CurrentMode", getValue( KCAN_VPS_PaCo_CurrentMode ), profileFile );
    writeProfileInt( "Rear_View_04", "VPS_PaCo_CurrentRVCscreen", getValue( KCAN_VPS_PaCo_CurrentRVCscreen ), profileFile );
    writeProfileInt( "Rear_View_04", "VPS_PaCo_CurrentVideoState", getValue( KCAN_VPS_PaCo_CurrentVideoState ), profileFile );
    writeProfileInt( "Rear_View_04", "VPS_PaCo_CurrentView", getValue( KCAN_VPS_PaCo_CurrentView ), profileFile );
    writeProfileInt( "Rear_View_04", "VPS_PaCo_MainState", getValue( KCAN_VPS_PaCo_MainState ), profileFile );

}


void saveSettings_Rear_View_06( char profileFile[] )
{
    writeProfileInt( "Rear_View_06", "Kam_Anf_Meldung", getValue( KCAN_Kam_Anf_Meldung ), profileFile );
    writeProfileInt( "Rear_View_06", "Kam_PaCo_MainState", getValue( KCAN_Kam_PaCo_MainState ), profileFile );

}


void saveSettings_Reichweite_01( char profileFile[] )
{
    writeProfileInt( "Reichweite_01", "RW_Gesamt_Reichweite", getValue( KCAN_RW_Gesamt_Reichweite ), profileFile );
    writeProfileInt( "Reichweite_01", "RW_Gesamt_Reichweite_Max_Anzeige", getValue( KCAN_RW_Gesamt_Reichweite_Max_Anzeige ), profileFile );
    writeProfileInt( "Reichweite_01", "RW_Prim_Reichweitenv_Einheit", getValue( KCAN_RW_Prim_Reichweitenv_Einheit ), profileFile );
    writeProfileFloat( "Reichweite_01", "RW_Prim_Reichweitenverbrauch", getValue( KCAN_RW_Prim_Reichweitenverbrauch ), profileFile );
    writeProfileInt( "Reichweite_01", "RW_Primaer_Reichweite", getValue( KCAN_RW_Primaer_Reichweite ), profileFile );
    writeProfileInt( "Reichweite_01", "RW_Reservewarnung_2_aktiv", getValue( KCAN_RW_Reservewarnung_2_aktiv ), profileFile );
    writeProfileInt( "Reichweite_01", "RW_RWDS_Lastprofil", getValue( KCAN_RW_RWDS_Lastprofil ), profileFile );

}


void saveSettings_Reichweite_02( char profileFile[] )
{
    writeProfileInt( "Reichweite_02", "RW_Gesamt_Reichweite_Anzeige", getValue( KCAN_RW_Gesamt_Reichweite_Anzeige ), profileFile );
    writeProfileInt( "Reichweite_02", "RW_Primaer_Reichweite_Anzeige", getValue( KCAN_RW_Primaer_Reichweite_Anzeige ), profileFile );
    writeProfileInt( "Reichweite_02", "RW_Reichweite_Einheit_Anzeige", getValue( KCAN_RW_Reichweite_Einheit_Anzeige ), profileFile );
    writeProfileInt( "Reichweite_02", "RW_Reservewarnung_aktiv", getValue( KCAN_RW_Reservewarnung_aktiv ), profileFile );
    writeProfileInt( "Reichweite_02", "RW_Sek_Reichweitenv_Einheit", getValue( KCAN_RW_Sek_Reichweitenv_Einheit ), profileFile );
    writeProfileFloat( "Reichweite_02", "RW_Sek_Reichweitenverbrauch", getValue( KCAN_RW_Sek_Reichweitenverbrauch ), profileFile );
    writeProfileInt( "Reichweite_02", "RW_Sekundaer_Reichweite", getValue( KCAN_RW_Sekundaer_Reichweite ), profileFile );
    writeProfileInt( "Reichweite_02", "RW_Sekundaer_Reichweite_Anzeige", getValue( KCAN_RW_Sekundaer_Reichweite_Anzeige ), profileFile );
    writeProfileInt( "Reichweite_02", "RW_Tendenz", getValue( KCAN_RW_Tendenz ), profileFile );
    writeProfileInt( "Reichweite_02", "RW_Texte", getValue( KCAN_RW_Texte ), profileFile );

}


void saveSettings_Reichweite_03( char profileFile[] )
{
    writeProfileInt( "Reichweite_03", "RW_Prim_rRWB_aktiv", getValue( KCAN_RW_Prim_rRWB_aktiv ), profileFile );
    writeProfileInt( "Reichweite_03", "RW_Prim_rRWB_Reichw_Anz", getValue( KCAN_RW_Prim_rRWB_Reichw_Anz ), profileFile );
    writeProfileInt( "Reichweite_03", "RW_Prim_rRWB_Reichw_Gesamt_Anz", getValue( KCAN_RW_Prim_rRWB_Reichw_Gesamt_Anz ), profileFile );
    writeProfileInt( "Reichweite_03", "RW_Prim_rRWB_Reichw_Max_Ges_Anz", getValue( KCAN_RW_Prim_rRWB_Reichw_Max_Ges_Anz ), profileFile );
    writeProfileInt( "Reichweite_03", "RW_Prim_rRWB_Reichw_Rest_E_Anz", getValue( KCAN_RW_Prim_rRWB_Reichw_Rest_E_Anz ), profileFile );
    writeProfileInt( "Reichweite_03", "RW_Prim_statische_Reichw_Anz", getValue( KCAN_RW_Prim_statische_Reichw_Anz ), profileFile );

}


void saveSettings_RKA_01( char profileFile[] )
{
    writeProfileInt( "RKA_01", "RKA_FMVSS138_Lampe", getValue( KCAN_RKA_FMVSS138_Lampe ), profileFile );
    writeProfileInt( "RKA_01", "RKA_FMVSS138_MIL", getValue( KCAN_RKA_FMVSS138_MIL ), profileFile );
    writeProfileInt( "RKA_01", "RKA_Reifentyp", getValue( KCAN_RKA_Reifentyp ), profileFile );
    writeProfileInt( "RKA_01", "RKA_Warnungen_02", getValue( KCAN_RKA_Warnungen_02 ), profileFile );

}


void saveSettings_RLS_01( char profileFile[] )
{
    writeProfileInt( "RLS_01", "LS_defekt", getValue( KCAN_LS_defekt ), profileFile );
    writeProfileInt( "RLS_01", "LS_Helligkeit_FW_RLS_01", getValue( KCAN_LS_Helligkeit_FW_RLS_01 ), profileFile );
    writeProfileInt( "RLS_01", "LS_Helligkeit_IR_RLS_01", getValue( KCAN_LS_Helligkeit_IR_RLS_01 ), profileFile );
    writeProfileInt( "RLS_01", "LS_Verbau", getValue( KCAN_LS_Verbau ), profileFile );
    writeProfileInt( "RLS_01", "RLS_Vorfeldhelligkeit_Boost_RLS_01", getValue( KCAN_RLS_Vorfeldhelligkeit_Boost_RLS_01 ), profileFile );
    writeProfileInt( "RLS_01", "RS_defekt", getValue( KCAN_RS_defekt ), profileFile );
    writeProfileInt( "RLS_01", "RS_Regenmenge_RLS_01", getValue( KCAN_RS_Regenmenge_RLS_01 ), profileFile );
    writeProfileInt( "RLS_01", "RS_Schwall_RLS_01", getValue( KCAN_RS_Schwall_RLS_01 ), profileFile );
    writeProfileInt( "RLS_01", "RS_Verbau", getValue( KCAN_RS_Verbau ), profileFile );
    writeProfileInt( "RLS_01", "RS_Verglasung_schliessen_RLS_01", getValue( KCAN_RS_Verglasung_schliessen_RLS_01 ), profileFile );
    writeProfileInt( "RLS_01", "RS_Wischergeschwindigkeit_RLS_01", getValue( KCAN_RS_Wischergeschwindigkeit_RLS_01 ), profileFile );
    writeProfileInt( "RLS_01", "SLS_Helligkeit_IR", getValue( KCAN_SLS_Helligkeit_IR ), profileFile );

}


void saveSettings_RLS_02( char profileFile[] )
{
    writeProfileInt( "RLS_02", "LS_Autobahnfahrlicht", getValue( KCAN_LS_Autobahnfahrlicht ), profileFile );
    writeProfileInt( "RLS_02", "LS_Dunkel", getValue( KCAN_LS_Dunkel ), profileFile );
    writeProfileInt( "RLS_02", "LS_Error", getValue( KCAN_LS_Error ), profileFile );
    writeProfileInt( "RLS_02", "LS_Helligkeit_FW_RLS_02", getValue( KCAN_LS_Helligkeit_FW_RLS_02 ), profileFile );
    writeProfileInt( "RLS_02", "LS_Helligkeit_IR_RLS_02", getValue( KCAN_LS_Helligkeit_IR_RLS_02 ), profileFile );
    writeProfileInt( "RLS_02", "LS_Licht_ein", getValue( KCAN_LS_Licht_ein ), profileFile );
    writeProfileInt( "RLS_02", "LS_Licht_ein_invers", getValue( KCAN_LS_Licht_ein_invers ), profileFile );
    writeProfileInt( "RLS_02", "RLS_02_BZ", getValue( KCAN_RLS_02_BZ ), profileFile );
    writeProfileInt( "RLS_02", "RLS_02_CRC", getValue( KCAN_RLS_02_CRC ), profileFile );
    writeProfileInt( "RLS_02", "RLS_Qualifizierungsbit", getValue( KCAN_RLS_Qualifizierungsbit ), profileFile );
    writeProfileInt( "RLS_02", "RLS_ResponseError", getValue( KCAN_RLS_ResponseError ), profileFile );
    writeProfileInt( "RLS_02", "RLS_Vorfeldhelligkeit_Boost_RLS_02", getValue( KCAN_RLS_Vorfeldhelligkeit_Boost_RLS_02 ), profileFile );
    writeProfileInt( "RLS_02", "RS_AdaptierungError", getValue( KCAN_RS_AdaptierungError ), profileFile );
    writeProfileInt( "RLS_02", "RS_Error", getValue( KCAN_RS_Error ), profileFile );
    writeProfileInt( "RLS_02", "RS_Regenfahrlicht", getValue( KCAN_RS_Regenfahrlicht ), profileFile );
    writeProfileInt( "RLS_02", "RS_Regenmenge_RLS_02", getValue( KCAN_RS_Regenmenge_RLS_02 ), profileFile );
    writeProfileInt( "RLS_02", "RS_Schwall_RLS_02", getValue( KCAN_RS_Schwall_RLS_02 ), profileFile );
    writeProfileInt( "RLS_02", "RS_Verglasung_schliessen_RLS_02", getValue( KCAN_RS_Verglasung_schliessen_RLS_02 ), profileFile );
    writeProfileInt( "RLS_02", "RS_versParklage_Wischer", getValue( KCAN_RS_versParklage_Wischer ), profileFile );
    writeProfileInt( "RLS_02", "RS_Wischergeschwindigkeit_RLS_02", getValue( KCAN_RS_Wischergeschwindigkeit_RLS_02 ), profileFile );

}


void saveSettings_SAL_01( char profileFile[] )
{
    writeProfileInt( "SAL_01", "AFS_Lampe", getValue( KCAN_AFS_Lampe ), profileFile );
    writeProfileInt( "SAL_01", "BCM2_Bremsl_durch_ECD", getValue( KCAN_BCM2_Bremsl_durch_ECD ), profileFile );
    writeProfileInt( "SAL_01", "DLI_Ambex_RefStatus", getValue( KCAN_DLI_Ambex_RefStatus ), profileFile );
    writeProfileInt( "SAL_01", "LWR_Lampe", getValue( KCAN_LWR_Lampe ), profileFile );
    writeProfileInt( "SAL_01", "LWR_Reisemodus_Texte", getValue( KCAN_LWR_Reisemodus_Texte ), profileFile );
    writeProfileFloat( "SAL_01", "LWR_SollDC", getValue( KCAN_LWR_SollDC ), profileFile );
    writeProfileInt( "SAL_01", "SAL_01_BZ", getValue( KCAN_SAL_01_BZ ), profileFile );
    writeProfileInt( "SAL_01", "SAL_01_CRC", getValue( KCAN_SAL_01_CRC ), profileFile );
    writeProfileInt( "SAL_01", "SAL_Aussenbeleuchtung_defekt", getValue( KCAN_SAL_Aussenbeleuchtung_defekt ), profileFile );
    writeProfileInt( "SAL_01", "SAL_Blinkerzyklus_L", getValue( KCAN_SAL_Blinkerzyklus_L ), profileFile );
    writeProfileInt( "SAL_01", "SAL_Blinkerzyklus_R", getValue( KCAN_SAL_Blinkerzyklus_R ), profileFile );
    writeProfileInt( "SAL_01", "SAL_BLK_L_Anf", getValue( KCAN_SAL_BLK_L_Anf ), profileFile );
    writeProfileInt( "SAL_01", "SAL_BLK_R_Anf", getValue( KCAN_SAL_BLK_R_Anf ), profileFile );
    writeProfileInt( "SAL_01", "SAL_Bremszyklus", getValue( KCAN_SAL_Bremszyklus ), profileFile );
    writeProfileInt( "SAL_01", "SAL_BRL_Anf", getValue( KCAN_SAL_BRL_Anf ), profileFile );
    writeProfileInt( "SAL_01", "SAL_CH_Anf", getValue( KCAN_SAL_CH_Anf ), profileFile );
    writeProfileInt( "SAL_01", "SAL_HGB_Anf", getValue( KCAN_SAL_HGB_Anf ), profileFile );
    writeProfileInt( "SAL_01", "SAL_Kl_15", getValue( KCAN_SAL_Kl_15 ), profileFile );
    writeProfileInt( "SAL_01", "SAL_Kl_15_vFzg", getValue( KCAN_SAL_Kl_15_vFzg ), profileFile );
    writeProfileInt( "SAL_01", "SAL_Kl_15_vFzg_S", getValue( KCAN_SAL_Kl_15_vFzg_S ), profileFile );
    writeProfileInt( "SAL_01", "SAL_KL_50", getValue( KCAN_SAL_KL_50 ), profileFile );
    writeProfileInt( "SAL_01", "SAL_KL_50_5s", getValue( KCAN_SAL_KL_50_5s ), profileFile );
    writeProfileInt( "SAL_01", "SAL_Kl_75", getValue( KCAN_SAL_Kl_75 ), profileFile );
    writeProfileInt( "SAL_01", "SAL_KL_75_vFzg", getValue( KCAN_SAL_KL_75_vFzg ), profileFile );
    writeProfileInt( "SAL_01", "SAL_KL_75a", getValue( KCAN_SAL_KL_75a ), profileFile );
    writeProfileInt( "SAL_01", "SAL_KL_75a_vFzg", getValue( KCAN_SAL_KL_75a_vFzg ), profileFile );
    writeProfileInt( "SAL_01", "SAL_KZL_Anf", getValue( KCAN_SAL_KZL_Anf ), profileFile );
    writeProfileInt( "SAL_01", "SAL_LDS_Abblendlicht_Anf", getValue( KCAN_SAL_LDS_Abblendlicht_Anf ), profileFile );
    writeProfileInt( "SAL_01", "SAL_LDS_Assistenzfahrlicht_Anf", getValue( KCAN_SAL_LDS_Assistenzfahrlicht_Anf ), profileFile );
    writeProfileInt( "SAL_01", "SAL_LDS_Nullstellung_Anf", getValue( KCAN_SAL_LDS_Nullstellung_Anf ), profileFile );
    writeProfileInt( "SAL_01", "SAL_LDS_Standlicht_Anf", getValue( KCAN_SAL_LDS_Standlicht_Anf ), profileFile );
    writeProfileInt( "SAL_01", "SAL_LH_Anf", getValue( KCAN_SAL_LH_Anf ), profileFile );
    writeProfileInt( "SAL_01", "SAL_NSL_Anf", getValue( KCAN_SAL_NSL_Anf ), profileFile );
    writeProfileInt( "SAL_01", "SAL_PL_L_Anf", getValue( KCAN_SAL_PL_L_Anf ), profileFile );
    writeProfileInt( "SAL_01", "SAL_PL_R_Anf", getValue( KCAN_SAL_PL_R_Anf ), profileFile );
    writeProfileInt( "SAL_01", "SAL_RFL_Anf", getValue( KCAN_SAL_RFL_Anf ), profileFile );
    writeProfileInt( "SAL_01", "SAL_SL_Anf", getValue( KCAN_SAL_SL_Anf ), profileFile );
    writeProfileInt( "SAL_01", "SAL_WBT_Bel", getValue( KCAN_SAL_WBT_Bel ), profileFile );
    writeProfileInt( "SAL_01", "SBBR_SL_AnimDimm_Freigabe", getValue( KCAN_SBBR_SL_AnimDimm_Freigabe ), profileFile );

}


void saveSettings_SAM_01( char profileFile[] )
{
    writeProfileInt( "SAM_01", "BCM_Bremsbelag_Sensor_CND", getValue( KCAN_BCM_Bremsbelag_Sensor_CND ), profileFile );
    writeProfileInt( "SAM_01", "BCM_Bremsbelag_Sensor_NAR", getValue( KCAN_BCM_Bremsbelag_Sensor_NAR ), profileFile );
    writeProfileInt( "SAM_01", "BCM_Bremsbelag_Sensor_Rdw", getValue( KCAN_BCM_Bremsbelag_Sensor_Rdw ), profileFile );
    writeProfileInt( "SAM_01", "BCM_Tankklappensteller_Fehler", getValue( KCAN_BCM_Tankklappensteller_Fehler ), profileFile );
    writeProfileInt( "SAM_01", "BRL_Bremslicht_Schalter", getValue( KCAN_BRL_Bremslicht_Schalter ), profileFile );
    writeProfileInt( "SAM_01", "HD_Hauptraste", getValue( KCAN_HD_Hauptraste ), profileFile );
    writeProfileInt( "SAM_01", "HD_Vorraste", getValue( KCAN_HD_Vorraste ), profileFile );
    writeProfileInt( "SAM_01", "HW_Drehfalle_Tuer_HL", getValue( KCAN_HW_Drehfalle_Tuer_HL ), profileFile );
    writeProfileInt( "SAM_01", "HW_Drehfalle_Tuer_HR", getValue( KCAN_HW_Drehfalle_Tuer_HR ), profileFile );
    writeProfileInt( "SAM_01", "HW_HD_Taste_Innenraum", getValue( KCAN_HW_HD_Taste_Innenraum ), profileFile );
    writeProfileInt( "SAM_01", "HW_HSB_erkannt", getValue( KCAN_HW_HSB_erkannt ), profileFile );
    writeProfileInt( "SAM_01", "HW_MH_Schalter1", getValue( KCAN_HW_MH_Schalter1 ), profileFile );
    writeProfileInt( "SAM_01", "HW_MH_Schalter2", getValue( KCAN_HW_MH_Schalter2 ), profileFile );
    writeProfileInt( "SAM_01", "HW_Softtouch_betaetigt", getValue( KCAN_HW_Softtouch_betaetigt ), profileFile );
    writeProfileInt( "SAM_01", "HW_Status_Schloss_gesafet_HL", getValue( KCAN_HW_Status_Schloss_gesafet_HL ), profileFile );
    writeProfileInt( "SAM_01", "HW_Status_Schloss_gesafet_HR", getValue( KCAN_HW_Status_Schloss_gesafet_HR ), profileFile );
    writeProfileInt( "SAM_01", "HW_Status_Schloss_verriegelt_HL", getValue( KCAN_HW_Status_Schloss_verriegelt_HL ), profileFile );
    writeProfileInt( "SAM_01", "HW_Status_Schloss_verriegelt_HR", getValue( KCAN_HW_Status_Schloss_verriegelt_HR ), profileFile );
    writeProfileInt( "SAM_01", "HW_Tankdeckel_offen", getValue( KCAN_HW_Tankdeckel_offen ), profileFile );
    writeProfileInt( "SAM_01", "HW_Toggle_Taster", getValue( KCAN_HW_Toggle_Taster ), profileFile );
    writeProfileInt( "SAM_01", "KST_BSW_Fehlermode2", getValue( KCAN_KST_BSW_Fehlermode2 ), profileFile );
    writeProfileInt( "SAM_01", "KST_BSW_Klemme_15_HW_Ist", getValue( KCAN_KST_BSW_Klemme_15_HW_Ist ), profileFile );
    writeProfileInt( "SAM_01", "KST_BSW_Klemmenhochschalten_Sper", getValue( KCAN_KST_BSW_Klemmenhochschalten_Sper ), profileFile );
    writeProfileInt( "SAM_01", "KST_BSW_Not_Taster_betaetigt", getValue( KCAN_KST_BSW_Not_Taster_betaetigt ), profileFile );
    writeProfileInt( "SAM_01", "KST_BSW_ZAT_betaetigt", getValue( KCAN_KST_BSW_ZAT_betaetigt ), profileFile );
    writeProfileInt( "SAM_01", "SAL_li1_Blinker_Status", getValue( KCAN_SAL_li1_Blinker_Status ), profileFile );
    writeProfileInt( "SAM_01", "SAL_re1_Blinker_Status", getValue( KCAN_SAL_re1_Blinker_Status ), profileFile );
    writeProfileInt( "SAM_01", "SAM_01_BZ", getValue( KCAN_SAM_01_BZ ), profileFile );
    writeProfileInt( "SAM_01", "SAM_01_CRC", getValue( KCAN_SAM_01_CRC ), profileFile );
    writeProfileInt( "SAM_01", "SAM_Fehler_DC_LWR", getValue( KCAN_SAM_Fehler_DC_LWR ), profileFile );

}


void saveSettings_Sensorik_Dimmung_01( char profileFile[] )
{
    writeProfileInt( "Sensorik_Dimmung_01", "KBI_Dimmpoti", getValue( KCAN_KBI_Dimmpoti ), profileFile );
    writeProfileInt( "Sensorik_Dimmung_01", "KBI_Phototransistor", getValue( KCAN_KBI_Phototransistor ), profileFile );

}


void saveSettings_SmaLi_Control_Frame_01( char profileFile[] )
{
    writeProfileInt( "SmaLi_Control_Frame_01", "SmaLi_brightness", getValue( KCAN_SmaLi_brightness ), profileFile );
    writeProfileInt( "SmaLi_Control_Frame_01", "SmaLi_Cnt_05", getValue( KCAN_SmaLi_Cnt_05 ), profileFile );
    writeProfileInt( "SmaLi_Control_Frame_01", "SmaLi_CtrlCmd_01", getValue( KCAN_SmaLi_CtrlCmd_01 ), profileFile );
    writeProfileInt( "SmaLi_Control_Frame_01", "SmaLi_Loops", getValue( KCAN_SmaLi_Loops ), profileFile );
    writeProfileInt( "SmaLi_Control_Frame_01", "SmaLi_MovieBundleVersion", getValue( KCAN_SmaLi_MovieBundleVersion ), profileFile );
    writeProfileInt( "SmaLi_Control_Frame_01", "SmaLi_MovieID", getValue( KCAN_SmaLi_MovieID ), profileFile );
    writeProfileInt( "SmaLi_Control_Frame_01", "SmaLi_SlotID_05", getValue( KCAN_SmaLi_SlotID_05 ), profileFile );

}


void saveSettings_SmaLi_Daten_Frame_01( char profileFile[] )
{
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_Cnt_01", getValue( KCAN_SmaLi_Cnt_01 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_01", getValue( KCAN_SmaLi_ColorValue_01 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_02", getValue( KCAN_SmaLi_ColorValue_02 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_03", getValue( KCAN_SmaLi_ColorValue_03 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_04", getValue( KCAN_SmaLi_ColorValue_04 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_05", getValue( KCAN_SmaLi_ColorValue_05 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_06", getValue( KCAN_SmaLi_ColorValue_06 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_07", getValue( KCAN_SmaLi_ColorValue_07 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_08", getValue( KCAN_SmaLi_ColorValue_08 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_09", getValue( KCAN_SmaLi_ColorValue_09 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_10", getValue( KCAN_SmaLi_ColorValue_10 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_11", getValue( KCAN_SmaLi_ColorValue_11 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_12", getValue( KCAN_SmaLi_ColorValue_12 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_13", getValue( KCAN_SmaLi_ColorValue_13 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_14", getValue( KCAN_SmaLi_ColorValue_14 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_FrameCmd_01", getValue( KCAN_SmaLi_FrameCmd_01 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_length", getValue( KCAN_SmaLi_length ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_SlotID_01", getValue( KCAN_SmaLi_SlotID_01 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_StartIndex", getValue( KCAN_SmaLi_StartIndex ), profileFile );

}


void saveSettings_SmaLi_Daten_Frame_02( char profileFile[] )
{
    writeProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_Cnt_02", getValue( KCAN_SmaLi_Cnt_02 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_15", getValue( KCAN_SmaLi_ColorValue_15 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_16", getValue( KCAN_SmaLi_ColorValue_16 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_17", getValue( KCAN_SmaLi_ColorValue_17 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_18", getValue( KCAN_SmaLi_ColorValue_18 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_19", getValue( KCAN_SmaLi_ColorValue_19 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_20", getValue( KCAN_SmaLi_ColorValue_20 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_21", getValue( KCAN_SmaLi_ColorValue_21 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_22", getValue( KCAN_SmaLi_ColorValue_22 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_23", getValue( KCAN_SmaLi_ColorValue_23 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_24", getValue( KCAN_SmaLi_ColorValue_24 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_25", getValue( KCAN_SmaLi_ColorValue_25 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_26", getValue( KCAN_SmaLi_ColorValue_26 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_27", getValue( KCAN_SmaLi_ColorValue_27 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_28", getValue( KCAN_SmaLi_ColorValue_28 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_29", getValue( KCAN_SmaLi_ColorValue_29 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_FrameCmd_02", getValue( KCAN_SmaLi_FrameCmd_02 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_SlotID_02", getValue( KCAN_SmaLi_SlotID_02 ), profileFile );

}


void saveSettings_SmaLi_Daten_Frame_03( char profileFile[] )
{
    writeProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_Cnt_03", getValue( KCAN_SmaLi_Cnt_03 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_30", getValue( KCAN_SmaLi_ColorValue_30 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_31", getValue( KCAN_SmaLi_ColorValue_31 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_32", getValue( KCAN_SmaLi_ColorValue_32 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_33", getValue( KCAN_SmaLi_ColorValue_33 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_34", getValue( KCAN_SmaLi_ColorValue_34 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_35", getValue( KCAN_SmaLi_ColorValue_35 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_36", getValue( KCAN_SmaLi_ColorValue_36 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_37", getValue( KCAN_SmaLi_ColorValue_37 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_38", getValue( KCAN_SmaLi_ColorValue_38 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_39", getValue( KCAN_SmaLi_ColorValue_39 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_40", getValue( KCAN_SmaLi_ColorValue_40 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_41", getValue( KCAN_SmaLi_ColorValue_41 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_42", getValue( KCAN_SmaLi_ColorValue_42 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_43", getValue( KCAN_SmaLi_ColorValue_43 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_44", getValue( KCAN_SmaLi_ColorValue_44 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_FrameCmd_03", getValue( KCAN_SmaLi_FrameCmd_03 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_SlotID_03", getValue( KCAN_SmaLi_SlotID_03 ), profileFile );

}


void saveSettings_SmaLi_Daten_Frame_04( char profileFile[] )
{
    writeProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_Cnt_04", getValue( KCAN_SmaLi_Cnt_04 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_45", getValue( KCAN_SmaLi_ColorValue_45 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_46", getValue( KCAN_SmaLi_ColorValue_46 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_47", getValue( KCAN_SmaLi_ColorValue_47 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_48", getValue( KCAN_SmaLi_ColorValue_48 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_49", getValue( KCAN_SmaLi_ColorValue_49 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_50", getValue( KCAN_SmaLi_ColorValue_50 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_51", getValue( KCAN_SmaLi_ColorValue_51 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_52", getValue( KCAN_SmaLi_ColorValue_52 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_53", getValue( KCAN_SmaLi_ColorValue_53 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_54", getValue( KCAN_SmaLi_ColorValue_54 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_55", getValue( KCAN_SmaLi_ColorValue_55 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_56", getValue( KCAN_SmaLi_ColorValue_56 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_57", getValue( KCAN_SmaLi_ColorValue_57 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_58", getValue( KCAN_SmaLi_ColorValue_58 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_59", getValue( KCAN_SmaLi_ColorValue_59 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_FrameCmd_04", getValue( KCAN_SmaLi_FrameCmd_04 ), profileFile );
    writeProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_SlotID_04", getValue( KCAN_SmaLi_SlotID_04 ), profileFile );

}


void saveSettings_SmaLi_Response_Frame_01( char profileFile[] )
{
    writeProfileInt( "SmaLi_Response_Frame_01", "SmaLi_AppSwVersion", getValue( KCAN_SmaLi_AppSwVersion ), profileFile );
    writeProfileInt( "SmaLi_Response_Frame_01", "SmaLi_availMemory", getValue( KCAN_SmaLi_availMemory ), profileFile );
    writeProfileInt( "SmaLi_Response_Frame_01", "SmaLi_Cnt_06", getValue( KCAN_SmaLi_Cnt_06 ), profileFile );
    writeProfileInt( "SmaLi_Response_Frame_01", "SmaLi_CtrlCmdRsp_01", getValue( KCAN_SmaLi_CtrlCmdRsp_01 ), profileFile );
    writeProfileInt( "SmaLi_Response_Frame_01", "SmaLi_error_cause", getValue( KCAN_SmaLi_error_cause ), profileFile );
    writeProfileInt( "SmaLi_Response_Frame_01", "SmaLi_InterfaceVersion", getValue( KCAN_SmaLi_InterfaceVersion ), profileFile );
    writeProfileInt( "SmaLi_Response_Frame_01", "SmaLi_MovieIDRsp", getValue( KCAN_SmaLi_MovieIDRsp ), profileFile );
    writeProfileInt( "SmaLi_Response_Frame_01", "SmaLi_numLEDs", getValue( KCAN_SmaLi_numLEDs ), profileFile );
    writeProfileInt( "SmaLi_Response_Frame_01", "SmaLi_numOfSlots", getValue( KCAN_SmaLi_numOfSlots ), profileFile );
    writeProfileInt( "SmaLi_Response_Frame_01", "SmaLi_SavedMovieBundleVersion", getValue( KCAN_SmaLi_SavedMovieBundleVersion ), profileFile );
    writeProfileInt( "SmaLi_Response_Frame_01", "SmaLi_SlotID_06", getValue( KCAN_SmaLi_SlotID_06 ), profileFile );
    writeProfileInt( "SmaLi_Response_Frame_01", "SmaLi_xPosCenter", getValue( KCAN_SmaLi_xPosCenter ), profileFile );
    writeProfileInt( "SmaLi_Response_Frame_01", "SmaLi_xPosPassengerLeft", getValue( KCAN_SmaLi_xPosPassengerLeft ), profileFile );
    writeProfileInt( "SmaLi_Response_Frame_01", "SmaLi_xPosPassengerRight", getValue( KCAN_SmaLi_xPosPassengerRight ), profileFile );

}


void saveSettings_SMLS_01( char profileFile[] )
{
    writeProfileInt( "SMLS_01", "BH_Blinker_Fehler", getValue( KCAN_BH_Blinker_Fehler ), profileFile );
    writeProfileInt( "SMLS_01", "BH_Blinker_li", getValue( KCAN_BH_Blinker_li ), profileFile );
    writeProfileInt( "SMLS_01", "BH_Blinker_re", getValue( KCAN_BH_Blinker_re ), profileFile );
    writeProfileInt( "SMLS_01", "BH_Fernlicht", getValue( KCAN_BH_Fernlicht ), profileFile );
    writeProfileInt( "SMLS_01", "BH_Lichthupe", getValue( KCAN_BH_Lichthupe ), profileFile );
    writeProfileInt( "SMLS_01", "FAS_Taster", getValue( KCAN_FAS_Taster ), profileFile );
    writeProfileInt( "SMLS_01", "FAS_Taster_Fehler", getValue( KCAN_FAS_Taster_Fehler ), profileFile );
    writeProfileInt( "SMLS_01", "LRH_aktiv", getValue( KCAN_LRH_aktiv ), profileFile );
    writeProfileInt( "SMLS_01", "LRH_on_off", getValue( KCAN_LRH_on_off ), profileFile );
    writeProfileInt( "SMLS_01", "LSS_Tastencode", getValue( KCAN_LSS_Tastencode ), profileFile );
    writeProfileInt( "SMLS_01", "SMLS_01_BZ", getValue( KCAN_SMLS_01_BZ ), profileFile );
    writeProfileInt( "SMLS_01", "SMLS_01_CRC", getValue( KCAN_SMLS_01_CRC ), profileFile );
    writeProfileInt( "SMLS_01", "SMLS_Hupe", getValue( KCAN_SMLS_Hupe ), profileFile );
    writeProfileInt( "SMLS_01", "SMLS_P_verriegelt", getValue( KCAN_SMLS_P_verriegelt ), profileFile );
    writeProfileInt( "SMLS_01", "SMLS_P_verriegelt_plausibel", getValue( KCAN_SMLS_P_verriegelt_plausibel ), profileFile );
    writeProfileInt( "SMLS_01", "SMLS_PTT", getValue( KCAN_SMLS_PTT ), profileFile );
    writeProfileInt( "SMLS_01", "WH_Frontwaschen", getValue( KCAN_WH_Frontwaschen ), profileFile );
    writeProfileInt( "SMLS_01", "WH_Heckintervall", getValue( KCAN_WH_Heckintervall ), profileFile );
    writeProfileInt( "SMLS_01", "WH_Heckwaschen", getValue( KCAN_WH_Heckwaschen ), profileFile );
    writeProfileInt( "SMLS_01", "WH_Intervall", getValue( KCAN_WH_Intervall ), profileFile );
    writeProfileInt( "SMLS_01", "WH_Intervallstufen", getValue( KCAN_WH_Intervallstufen ), profileFile );
    writeProfileInt( "SMLS_01", "WH_SRA", getValue( KCAN_WH_SRA ), profileFile );
    writeProfileInt( "SMLS_01", "WH_Tipwischen", getValue( KCAN_WH_Tipwischen ), profileFile );
    writeProfileInt( "SMLS_01", "WH_Tipwischen_lang", getValue( KCAN_WH_Tipwischen_lang ), profileFile );
    writeProfileInt( "SMLS_01", "WH_Wischer_Fehler", getValue( KCAN_WH_Wischer_Fehler ), profileFile );
    writeProfileInt( "SMLS_01", "WH_WischerStufe1", getValue( KCAN_WH_WischerStufe1 ), profileFile );
    writeProfileInt( "SMLS_01", "WH_WischerStufe2", getValue( KCAN_WH_WischerStufe2 ), profileFile );

}


void saveSettings_Systeminfo_01( char profileFile[] )
{
    writeProfileInt( "Systeminfo_01", "GW_KD_Fehler", getValue( KCAN_GW_KD_Fehler ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_BUS_01", getValue( KCAN_SI_BUS_01 ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_BUS_02", getValue( KCAN_SI_BUS_02 ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_BUS_03", getValue( KCAN_SI_BUS_03 ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_BUS_04", getValue( KCAN_SI_BUS_04 ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_BUS_05", getValue( KCAN_SI_BUS_05 ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_BUS_06", getValue( KCAN_SI_BUS_06 ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_BUS_07", getValue( KCAN_SI_BUS_07 ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_BUS_08", getValue( KCAN_SI_BUS_08 ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_BUS_09", getValue( KCAN_SI_BUS_09 ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_BUS_10", getValue( KCAN_SI_BUS_10 ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_BUS_11", getValue( KCAN_SI_BUS_11 ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_BUS_12", getValue( KCAN_SI_BUS_12 ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_BUS_13", getValue( KCAN_SI_BUS_13 ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_BUS_14", getValue( KCAN_SI_BUS_14 ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_BUS_15", getValue( KCAN_SI_BUS_15 ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_Bus_Identifikation", getValue( KCAN_SI_Bus_Identifikation ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_CAB_V10", getValue( KCAN_SI_CAB_V10 ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_Diagnose_Aktiv", getValue( KCAN_SI_Diagnose_Aktiv ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_NWDF", getValue( KCAN_SI_NWDF ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_NWDF_gueltig", getValue( KCAN_SI_NWDF_gueltig ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_P_Mode", getValue( KCAN_SI_P_Mode ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_P_Mode_gueltig", getValue( KCAN_SI_P_Mode_gueltig ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_QRS_Mode", getValue( KCAN_SI_QRS_Mode ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_Sammel_SG_Fehler", getValue( KCAN_SI_Sammel_SG_Fehler ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_Sammelfehler", getValue( KCAN_SI_Sammelfehler ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_T_Mode", getValue( KCAN_SI_T_Mode ), profileFile );
    writeProfileInt( "Systeminfo_01", "SI_T_Schutz", getValue( KCAN_SI_T_Schutz ), profileFile );

}


void saveSettings_TA_01( char profileFile[] )
{
    writeProfileInt( "TA_01", "TA_01_BZ", getValue( KCAN_TA_01_BZ ), profileFile );
    writeProfileInt( "TA_01", "TA_01_CRC", getValue( KCAN_TA_01_CRC ), profileFile );
    writeProfileInt( "TA_01", "TA_ACC_Sollstatus", getValue( KCAN_TA_ACC_Sollstatus ), profileFile );
    writeProfileInt( "TA_01", "TA_FoD_Status", getValue( KCAN_TA_FoD_Status ), profileFile );
    writeProfileInt( "TA_01", "TA_Spurwechsel", getValue( KCAN_TA_Spurwechsel ), profileFile );
    writeProfileInt( "TA_01", "TA_Spurwechsel_Ready", getValue( KCAN_TA_Spurwechsel_Ready ), profileFile );
    writeProfileInt( "TA_01", "TA_Status", getValue( KCAN_TA_Status ), profileFile );
    writeProfileInt( "TA_01", "TA_Texte", getValue( KCAN_TA_Texte ), profileFile );
    writeProfileInt( "TA_01", "TA_Texte_02", getValue( KCAN_TA_Texte_02 ), profileFile );

}


void saveSettings_Temperaturen_01( char profileFile[] )
{
    writeProfileFloat( "Temperaturen_01", "KBI_Aussen_Temp_gef", getValue( KCAN_KBI_Aussen_Temp_gef ), profileFile );
    writeProfileInt( "Temperaturen_01", "KBI_QBit_Aussen_Temp_gef", getValue( KCAN_KBI_QBit_Aussen_Temp_gef ), profileFile );

}


void saveSettings_Thermo_Verbrauch_01( char profileFile[] )
{
    writeProfileInt( "Thermo_Verbrauch_01", "Thermo_Pred_Innen_Kunde_Anf", getValue( KCAN_Thermo_Pred_Innen_Kunde_Anf ), profileFile );
    writeProfileInt( "Thermo_Verbrauch_01", "Thermo_Pred_Innen_System_Anf", getValue( KCAN_Thermo_Pred_Innen_System_Anf ), profileFile );
    writeProfileInt( "Thermo_Verbrauch_01", "Thermo_Pred_P_dyn_Innen", getValue( KCAN_Thermo_Pred_P_dyn_Innen ), profileFile );
    writeProfileInt( "Thermo_Verbrauch_01", "Thermo_Pred_P_stat_Innen", getValue( KCAN_Thermo_Pred_P_stat_Innen ), profileFile );
    writeProfileInt( "Thermo_Verbrauch_01", "Thermo_Pred_T_dyn_Innen", getValue( KCAN_Thermo_Pred_T_dyn_Innen ), profileFile );
    writeProfileInt( "Thermo_Verbrauch_01", "Thermo_Verbrauch_BTL", getValue( KCAN_Thermo_Verbrauch_BTL ), profileFile );
    writeProfileInt( "Thermo_Verbrauch_01", "Thermo_Verbrauch_BTL_Ueberlauf", getValue( KCAN_Thermo_Verbrauch_BTL_Ueberlauf ), profileFile );
    writeProfileInt( "Thermo_Verbrauch_01", "Thermo_Verbrauch_Innen", getValue( KCAN_Thermo_Verbrauch_Innen ), profileFile );
    writeProfileInt( "Thermo_Verbrauch_01", "Thermo_Verbrauch_Innen_Ueberlauf", getValue( KCAN_Thermo_Verbrauch_Innen_Ueberlauf ), profileFile );

}


void saveSettings_TM_01( char profileFile[] )
{
    writeProfileInt( "TM_01", "bCall_active", getValue( KCAN_bCall_active ), profileFile );
    writeProfileInt( "TM_01", "eCall_Funktionsstatus", getValue( KCAN_eCall_Funktionsstatus ), profileFile );
    writeProfileInt( "TM_01", "eCall_Funktionsstatus_02", getValue( KCAN_eCall_Funktionsstatus_02 ), profileFile );
    writeProfileInt( "TM_01", "iCall_active", getValue( KCAN_iCall_active ), profileFile );
    writeProfileInt( "TM_01", "TM_Door_Lock", getValue( KCAN_TM_Door_Lock ), profileFile );
    writeProfileInt( "TM_01", "TM_Door_Unlock", getValue( KCAN_TM_Door_Unlock ), profileFile );
    writeProfileInt( "TM_01", "TM_Nur_Hupen", getValue( KCAN_TM_Nur_Hupen ), profileFile );
    writeProfileInt( "TM_01", "TM_Panik_Alarm", getValue( KCAN_TM_Panik_Alarm ), profileFile );
    writeProfileInt( "TM_01", "TM_Spiegel_Anklappen", getValue( KCAN_TM_Spiegel_Anklappen ), profileFile );
    writeProfileInt( "TM_01", "TM_Warnblinken", getValue( KCAN_TM_Warnblinken ), profileFile );
    writeProfileInt( "TM_01", "TM_ZV_Signatur", getValue( KCAN_TM_ZV_Signatur ), profileFile );

}


void saveSettings_TSG_BT_01( char profileFile[] )
{
    writeProfileInt( "TSG_BT_01", "ASW_Warnung_aktiv_BFS", getValue( KCAN_ASW_Warnung_aktiv_BFS ), profileFile );
    writeProfileInt( "TSG_BT_01", "BFS_Status_eTAG", getValue( KCAN_BFS_Status_eTAG ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_ASW_HMI_defekt", getValue( KCAN_BT_ASW_HMI_defekt ), profileFile );
    writeProfileFloat( "TSG_BT_01", "BT_EC_Spiegel_Helligkeit", getValue( KCAN_BT_EC_Spiegel_Helligkeit ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_FH_Bew_hoch", getValue( KCAN_BT_FH_Bew_hoch ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_FH_Bew_tief", getValue( KCAN_BT_FH_Bew_tief ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_FH_Block", getValue( KCAN_BT_FH_Block ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_FH_Fang", getValue( KCAN_BT_FH_Fang ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_FH_normiert", getValue( KCAN_BT_FH_normiert ), profileFile );
    writeProfileFloat( "TSG_BT_01", "BT_FH_Oeffnung", getValue( KCAN_BT_FH_Oeffnung ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_FH_Pos_oben", getValue( KCAN_BT_FH_Pos_oben ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_FH_S_AutoHoch", getValue( KCAN_BT_FH_S_AutoHoch ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_FH_S_AutoTief", getValue( KCAN_BT_FH_S_AutoTief ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_FH_S_ManHoch", getValue( KCAN_BT_FH_S_ManHoch ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_FH_S_ManTief", getValue( KCAN_BT_FH_S_ManTief ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_FH_Thermo", getValue( KCAN_BT_FH_Thermo ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_gesafet", getValue( KCAN_BT_gesafet ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Kisi_Fehler", getValue( KCAN_BT_Kisi_Fehler ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Lock_Taster", getValue( KCAN_BT_Lock_Taster ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Lock_Taster_inv", getValue( KCAN_BT_Lock_Taster_inv ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Lock_Unlock_Taster", getValue( KCAN_BT_Lock_Unlock_Taster ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Oben_Block_erw", getValue( KCAN_BT_Oben_Block_erw ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Schliesstaster", getValue( KCAN_BT_Schliesstaster ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Schluesselschalter_auf", getValue( KCAN_BT_Schluesselschalter_auf ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Schluesselschalter_zu", getValue( KCAN_BT_Schluesselschalter_zu ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Schluesselschalter_zu_inv", getValue( KCAN_BT_Schluesselschalter_zu_inv ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_SP_ausgerastet", getValue( KCAN_BT_SP_ausgerastet ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Sp_Blk_def", getValue( KCAN_BT_Sp_Blk_def ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_SP_Heizung_aktiv", getValue( KCAN_BT_SP_Heizung_aktiv ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Sp_Heizung_Anf", getValue( KCAN_BT_Sp_Heizung_Anf ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_SP_Heizung_Status", getValue( KCAN_BT_SP_Heizung_Status ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_SP_ht_aktiv", getValue( KCAN_BT_SP_ht_aktiv ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_SP_lr_aktiv", getValue( KCAN_BT_SP_lr_aktiv ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Sperrklinke", getValue( KCAN_BT_Sperrklinke ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_SWA_HMI_defekt", getValue( KCAN_BT_SWA_HMI_defekt ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_TAG_betaetigt", getValue( KCAN_BT_TAG_betaetigt ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_TCR_Mode_aktiv", getValue( KCAN_BT_TCR_Mode_aktiv ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_TIG_betaetigt", getValue( KCAN_BT_TIG_betaetigt ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_TSG_hinten_verbaut", getValue( KCAN_BT_TSG_hinten_verbaut ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Tuer_geoeffnet", getValue( KCAN_BT_Tuer_geoeffnet ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Tuer_Status", getValue( KCAN_BT_Tuer_Status ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Tuer_Status_QBit", getValue( KCAN_BT_Tuer_Status_QBit ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Tueroeffnen_Warnung", getValue( KCAN_BT_Tueroeffnen_Warnung ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Tuerschloss_defekt", getValue( KCAN_BT_Tuerschloss_defekt ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_UEKB_aktiviert", getValue( KCAN_BT_UEKB_aktiviert ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Unlock_Taster", getValue( KCAN_BT_Unlock_Taster ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Unten_Block_erw", getValue( KCAN_BT_Unten_Block_erw ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_verriegelt", getValue( KCAN_BT_verriegelt ), profileFile );
    writeProfileInt( "TSG_BT_01", "BT_Zuziehhilfe_aktiv", getValue( KCAN_BT_Zuziehhilfe_aktiv ), profileFile );

}


void saveSettings_TSG_FT_01( char profileFile[] )
{
    writeProfileInt( "TSG_FT_01", "ASW_HMI_defekt", getValue( KCAN_ASW_HMI_defekt ), profileFile );
    writeProfileInt( "TSG_FT_01", "ASW_wakeup", getValue( KCAN_ASW_wakeup ), profileFile );
    writeProfileInt( "TSG_FT_01", "ASW_Warnung_aktiv_FS", getValue( KCAN_ASW_Warnung_aktiv_FS ), profileFile );
    writeProfileInt( "TSG_FT_01", "FS_Status_eTAG", getValue( KCAN_FS_Status_eTAG ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_BFS_Fond_Freigabe", getValue( KCAN_FT_BFS_Fond_Freigabe ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Daemmglas", getValue( KCAN_FT_Daemmglas ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_FH_Bew_hoch", getValue( KCAN_FT_FH_Bew_hoch ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_FH_Bew_tief", getValue( KCAN_FT_FH_Bew_tief ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_FH_Block", getValue( KCAN_FT_FH_Block ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_FH_Fang", getValue( KCAN_FT_FH_Fang ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_FH_normiert", getValue( KCAN_FT_FH_normiert ), profileFile );
    writeProfileFloat( "TSG_FT_01", "FT_FH_Oeffnung", getValue( KCAN_FT_FH_Oeffnung ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_FH_Pos_oben", getValue( KCAN_FT_FH_Pos_oben ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_FH_S_AutoHoch", getValue( KCAN_FT_FH_S_AutoHoch ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_FH_S_AutoTief", getValue( KCAN_FT_FH_S_AutoTief ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_FH_S_ManHoch", getValue( KCAN_FT_FH_S_ManHoch ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_FH_S_ManTief", getValue( KCAN_FT_FH_S_ManTief ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_FH_Thermo", getValue( KCAN_FT_FH_Thermo ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_gesafet", getValue( KCAN_FT_gesafet ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_HD_Taste", getValue( KCAN_FT_HD_Taste ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_HD_Taste_2", getValue( KCAN_FT_HD_Taste_2 ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_IRUE_Taste", getValue( KCAN_FT_IRUE_Taste ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Kisi_Fehler", getValue( KCAN_FT_Kisi_Fehler ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Kisi_li_aktiv", getValue( KCAN_FT_Kisi_li_aktiv ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Kisi_re_aktiv", getValue( KCAN_FT_Kisi_re_aktiv ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Kisi_Taster_li", getValue( KCAN_FT_Kisi_Taster_li ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Kisi_Taster_re", getValue( KCAN_FT_Kisi_Taster_re ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Lock_Taster", getValue( KCAN_FT_Lock_Taster ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Lock_Unlock_Taster", getValue( KCAN_FT_Lock_Unlock_Taster ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Oben_Block_erw", getValue( KCAN_FT_Oben_Block_erw ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Schliesstaster", getValue( KCAN_FT_Schliesstaster ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Schluesselschalter_auf", getValue( KCAN_FT_Schluesselschalter_auf ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Schluesselschalter_zu", getValue( KCAN_FT_Schluesselschalter_zu ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_SP_ausgerastet", getValue( KCAN_FT_SP_ausgerastet ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Sp_Blk_def", getValue( KCAN_FT_Sp_Blk_def ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Sp_Heizung_Anf", getValue( KCAN_FT_Sp_Heizung_Anf ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_SP_Heizung_Status", getValue( KCAN_FT_SP_Heizung_Status ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_SP_ht_aktiv", getValue( KCAN_FT_SP_ht_aktiv ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_SP_lr_aktiv", getValue( KCAN_FT_SP_lr_aktiv ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Sperrklinke", getValue( KCAN_FT_Sperrklinke ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_SWA_Taster", getValue( KCAN_FT_SWA_Taster ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_TAG_betaetigt", getValue( KCAN_FT_TAG_betaetigt ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_TD_Taste", getValue( KCAN_FT_TD_Taste ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_TD_Taste_Fehler", getValue( KCAN_FT_TD_Taste_Fehler ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_TIG_betaetigt", getValue( KCAN_FT_TIG_betaetigt ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_TSG_hinten_verbaut", getValue( KCAN_FT_TSG_hinten_verbaut ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Tuer_geoeffnet", getValue( KCAN_FT_Tuer_geoeffnet ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Tuerschloss_defekt", getValue( KCAN_FT_Tuerschloss_defekt ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_UEKB_aktiviert", getValue( KCAN_FT_UEKB_aktiviert ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Unlock_Taster", getValue( KCAN_FT_Unlock_Taster ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Unten_Block_erw", getValue( KCAN_FT_Unten_Block_erw ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_verriegelt", getValue( KCAN_FT_verriegelt ), profileFile );
    writeProfileInt( "TSG_FT_01", "FT_Zuziehhilfe_aktiv", getValue( KCAN_FT_Zuziehhilfe_aktiv ), profileFile );
    writeProfileInt( "TSG_FT_01", "SSR_Temp_Freigabe", getValue( KCAN_SSR_Temp_Freigabe ), profileFile );
    writeProfileInt( "TSG_FT_01", "SWA_HMI_Diagnose", getValue( KCAN_SWA_HMI_Diagnose ), profileFile );

}


void saveSettings_TSG_FT_02( char profileFile[] )
{
    writeProfileInt( "TSG_FT_02", "FT_BFS_Tuer_Status", getValue( KCAN_FT_BFS_Tuer_Status ), profileFile );
    writeProfileInt( "TSG_FT_02", "FT_HBFS_Tuer_Status", getValue( KCAN_FT_HBFS_Tuer_Status ), profileFile );
    writeProfileInt( "TSG_FT_02", "FT_HFS_Tuer_Status", getValue( KCAN_FT_HFS_Tuer_Status ), profileFile );
    writeProfileInt( "TSG_FT_02", "FT_KiSi_Status_Soll_HBFS", getValue( KCAN_FT_KiSi_Status_Soll_HBFS ), profileFile );
    writeProfileInt( "TSG_FT_02", "FT_KiSi_Status_Soll_HFS", getValue( KCAN_FT_KiSi_Status_Soll_HFS ), profileFile );
    writeProfileInt( "TSG_FT_02", "FT_Kisi_Taster_li_02", getValue( KCAN_FT_Kisi_Taster_li_02 ), profileFile );
    writeProfileInt( "TSG_FT_02", "FT_Kisi_Taster_re_02", getValue( KCAN_FT_Kisi_Taster_re_02 ), profileFile );
    writeProfileInt( "TSG_FT_02", "FT_Lock_Taster_02", getValue( KCAN_FT_Lock_Taster_02 ), profileFile );
    writeProfileInt( "TSG_FT_02", "FT_Schluesselschalter_zu_02", getValue( KCAN_FT_Schluesselschalter_zu_02 ), profileFile );
    writeProfileInt( "TSG_FT_02", "FT_SP_Heizung_ein", getValue( KCAN_FT_SP_Heizung_ein ), profileFile );
    writeProfileInt( "TSG_FT_02", "FT_TCR_Mode_aktiv", getValue( KCAN_FT_TCR_Mode_aktiv ), profileFile );
    writeProfileInt( "TSG_FT_02", "FT_TD_Taste_Status", getValue( KCAN_FT_TD_Taste_Status ), profileFile );
    writeProfileInt( "TSG_FT_02", "FT_Tuer_Status", getValue( KCAN_FT_Tuer_Status ), profileFile );
    writeProfileInt( "TSG_FT_02", "FT_Tuer_Status_QBit", getValue( KCAN_FT_Tuer_Status_QBit ), profileFile );
    writeProfileInt( "TSG_FT_02", "FT_Tueroeffnen_Warnung", getValue( KCAN_FT_Tueroeffnen_Warnung ), profileFile );
    writeProfileInt( "TSG_FT_02", "TBF_FS_Touch_Event", getValue( KCAN_TBF_FS_Touch_Event ), profileFile );
    writeProfileInt( "TSG_FT_02", "TSG_FT_02_BZ", getValue( KCAN_TSG_FT_02_BZ ), profileFile );
    writeProfileInt( "TSG_FT_02", "TSG_FT_02_CRC", getValue( KCAN_TSG_FT_02_CRC ), profileFile );

}


void saveSettings_TSG_HBFS_01( char profileFile[] )
{
    writeProfileInt( "TSG_HBFS_01", "ASW_Warnung_aktiv_HBFS", getValue( KCAN_ASW_Warnung_aktiv_HBFS ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_FH_Bew_hoch", getValue( KCAN_HBFS_FH_Bew_hoch ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_FH_Bew_tief", getValue( KCAN_HBFS_FH_Bew_tief ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_FH_Block", getValue( KCAN_HBFS_FH_Block ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_FH_Fang", getValue( KCAN_HBFS_FH_Fang ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_FH_normiert", getValue( KCAN_HBFS_FH_normiert ), profileFile );
    writeProfileFloat( "TSG_HBFS_01", "HBFS_FH_Oeffnung", getValue( KCAN_HBFS_FH_Oeffnung ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_FH_S_AutoHoch", getValue( KCAN_HBFS_FH_S_AutoHoch ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_FH_S_AutoTief", getValue( KCAN_HBFS_FH_S_AutoTief ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_FH_S_HFS_AutoHoch", getValue( KCAN_HBFS_FH_S_HFS_AutoHoch ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_FH_S_HFS_AutoTief", getValue( KCAN_HBFS_FH_S_HFS_AutoTief ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_FH_S_HFS_ManHoch", getValue( KCAN_HBFS_FH_S_HFS_ManHoch ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_FH_S_HFS_ManTief", getValue( KCAN_HBFS_FH_S_HFS_ManTief ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_FH_S_ManHoch", getValue( KCAN_HBFS_FH_S_ManHoch ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_FH_S_ManTief", getValue( KCAN_HBFS_FH_S_ManTief ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_FH_Thermo", getValue( KCAN_HBFS_FH_Thermo ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_gesafet", getValue( KCAN_HBFS_gesafet ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Heckrollotaster_betaetigt", getValue( KCAN_HBFS_Heckrollotaster_betaetigt ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Lock_Taster", getValue( KCAN_HBFS_Lock_Taster ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Lock_Taster_inv", getValue( KCAN_HBFS_Lock_Taster_inv ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_MRollo_Schalter", getValue( KCAN_HBFS_MRollo_Schalter ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Oben_Block_erw", getValue( KCAN_HBFS_Oben_Block_erw ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_SAD_Schalter", getValue( KCAN_HBFS_SAD_Schalter ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Seitenrollo_hoch", getValue( KCAN_HBFS_Seitenrollo_hoch ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Seitenrollo_tief", getValue( KCAN_HBFS_Seitenrollo_tief ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_SK_betaetigt", getValue( KCAN_HBFS_SK_betaetigt ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Sperrklinke", getValue( KCAN_HBFS_Sperrklinke ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Status_eTAG", getValue( KCAN_HBFS_Status_eTAG ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Status_KiSi", getValue( KCAN_HBFS_Status_KiSi ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Status_KiSi_inv", getValue( KCAN_HBFS_Status_KiSi_inv ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_TAG_betaetigt", getValue( KCAN_HBFS_TAG_betaetigt ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_TIG_betaetigt", getValue( KCAN_HBFS_TIG_betaetigt ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_TIG_betaetigt_oeffnen", getValue( KCAN_HBFS_TIG_betaetigt_oeffnen ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_TIG_betaetigt_schliessen", getValue( KCAN_HBFS_TIG_betaetigt_schliessen ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Tuer_geoeffnet", getValue( KCAN_HBFS_Tuer_geoeffnet ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Tuer_Status", getValue( KCAN_HBFS_Tuer_Status ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Tuer_Status_QBit", getValue( KCAN_HBFS_Tuer_Status_QBit ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Tueroeffnen_Warnung", getValue( KCAN_HBFS_Tueroeffnen_Warnung ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Tuerschloss_defekt", getValue( KCAN_HBFS_Tuerschloss_defekt ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_UEKB_aktiviert", getValue( KCAN_HBFS_UEKB_aktiviert ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Unlock_Taster", getValue( KCAN_HBFS_Unlock_Taster ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Unten_Block_erw", getValue( KCAN_HBFS_Unten_Block_erw ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_verriegelt", getValue( KCAN_HBFS_verriegelt ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Vorraste_betaetigt", getValue( KCAN_HBFS_Vorraste_betaetigt ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "HBFS_Zuziehhilfe_aktiv", getValue( KCAN_HBFS_Zuziehhilfe_aktiv ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "MTHBFS_M_Taste", getValue( KCAN_MTHBFS_M_Taste ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "MTHBFS_Pos1", getValue( KCAN_MTHBFS_Pos1 ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "MTHBFS_Pos2", getValue( KCAN_MTHBFS_Pos2 ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "MTHBFS_Pos3", getValue( KCAN_MTHBFS_Pos3 ), profileFile );
    writeProfileInt( "TSG_HBFS_01", "SSR_HBFS_Pos_Unten", getValue( KCAN_SSR_HBFS_Pos_Unten ), profileFile );

}


void saveSettings_TSG_HFS_01( char profileFile[] )
{
    writeProfileInt( "TSG_HFS_01", "ASW_Warnung_aktiv_HFS", getValue( KCAN_ASW_Warnung_aktiv_HFS ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_FH_Bew_hoch", getValue( KCAN_HFS_FH_Bew_hoch ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_FH_Bew_tief", getValue( KCAN_HFS_FH_Bew_tief ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_FH_Block", getValue( KCAN_HFS_FH_Block ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_FH_Fang", getValue( KCAN_HFS_FH_Fang ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_FH_normiert", getValue( KCAN_HFS_FH_normiert ), profileFile );
    writeProfileFloat( "TSG_HFS_01", "HFS_FH_Oeffnung", getValue( KCAN_HFS_FH_Oeffnung ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_FH_S_AutoHoch", getValue( KCAN_HFS_FH_S_AutoHoch ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_FH_S_AutoTief", getValue( KCAN_HFS_FH_S_AutoTief ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_FH_S_HBFS_AutoHoch", getValue( KCAN_HFS_FH_S_HBFS_AutoHoch ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_FH_S_HBFS_AutoTief", getValue( KCAN_HFS_FH_S_HBFS_AutoTief ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_FH_S_HBFS_ManHoch", getValue( KCAN_HFS_FH_S_HBFS_ManHoch ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_FH_S_HBFS_ManTief", getValue( KCAN_HFS_FH_S_HBFS_ManTief ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_FH_S_ManHoch", getValue( KCAN_HFS_FH_S_ManHoch ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_FH_S_ManTief", getValue( KCAN_HFS_FH_S_ManTief ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_FH_Thermo", getValue( KCAN_HFS_FH_Thermo ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_gesafet", getValue( KCAN_HFS_gesafet ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_Heckrollotaster_betaetigt", getValue( KCAN_HFS_Heckrollotaster_betaetigt ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_Lock_Taster", getValue( KCAN_HFS_Lock_Taster ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_Lock_Taster_inv", getValue( KCAN_HFS_Lock_Taster_inv ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_MRollo_Schalter", getValue( KCAN_HFS_MRollo_Schalter ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_Oben_Block_erw", getValue( KCAN_HFS_Oben_Block_erw ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_SAD_Schalter", getValue( KCAN_HFS_SAD_Schalter ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_Seitenrollo_hoch", getValue( KCAN_HFS_Seitenrollo_hoch ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_Seitenrollo_tief", getValue( KCAN_HFS_Seitenrollo_tief ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_SK_betaetigt", getValue( KCAN_HFS_SK_betaetigt ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_Sperrklinke", getValue( KCAN_HFS_Sperrklinke ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_Status_eTAG", getValue( KCAN_HFS_Status_eTAG ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_Status_KiSi", getValue( KCAN_HFS_Status_KiSi ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_TAG_betaetigt", getValue( KCAN_HFS_TAG_betaetigt ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_TCR_Mode_aktiv", getValue( KCAN_HFS_TCR_Mode_aktiv ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_TIG_betaetigt", getValue( KCAN_HFS_TIG_betaetigt ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_TIG_betaetigt_oeffnen", getValue( KCAN_HFS_TIG_betaetigt_oeffnen ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_TIG_betaetigt_schliessen", getValue( KCAN_HFS_TIG_betaetigt_schliessen ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_Tuer_geoeffnet", getValue( KCAN_HFS_Tuer_geoeffnet ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_Tuer_Status", getValue( KCAN_HFS_Tuer_Status ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_Tuer_Status_QBit", getValue( KCAN_HFS_Tuer_Status_QBit ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_Tueroeffnen_Warnung", getValue( KCAN_HFS_Tueroeffnen_Warnung ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_Tuerschloss_defekt", getValue( KCAN_HFS_Tuerschloss_defekt ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_UEKB_aktiviert", getValue( KCAN_HFS_UEKB_aktiviert ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_Unlock_Taster", getValue( KCAN_HFS_Unlock_Taster ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_Unten_Block_erw", getValue( KCAN_HFS_Unten_Block_erw ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_verriegelt", getValue( KCAN_HFS_verriegelt ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_Vorraste_betaetigt", getValue( KCAN_HFS_Vorraste_betaetigt ), profileFile );
    writeProfileInt( "TSG_HFS_01", "HFS_Zuziehhilfe_aktiv", getValue( KCAN_HFS_Zuziehhilfe_aktiv ), profileFile );
    writeProfileInt( "TSG_HFS_01", "MTHFS_M_Taste", getValue( KCAN_MTHFS_M_Taste ), profileFile );
    writeProfileInt( "TSG_HFS_01", "MTHFS_Pos1", getValue( KCAN_MTHFS_Pos1 ), profileFile );
    writeProfileInt( "TSG_HFS_01", "MTHFS_Pos2", getValue( KCAN_MTHFS_Pos2 ), profileFile );
    writeProfileInt( "TSG_HFS_01", "MTHFS_Pos3", getValue( KCAN_MTHFS_Pos3 ), profileFile );
    writeProfileInt( "TSG_HFS_01", "SSR_HFS_Pos_Unten", getValue( KCAN_SSR_HFS_Pos_Unten ), profileFile );

}


void saveSettings_UserStateServer_01( char profileFile[] )
{
    writeProfileInt( "UserStateServer_01", "OPS_ComfortReadyStatus", getValue( KCAN_OPS_ComfortReadyStatus ), profileFile );
    writeProfileInt( "UserStateServer_01", "OPS_DriverPresenceStatus", getValue( KCAN_OPS_DriverPresenceStatus ), profileFile );
    writeProfileInt( "UserStateServer_01", "OPS_OccupantPresenceStatus", getValue( KCAN_OPS_OccupantPresenceStatus ), profileFile );
    writeProfileInt( "UserStateServer_01", "OPS_QBit_DriverPresence", getValue( KCAN_OPS_QBit_DriverPresence ), profileFile );

}


void saveSettings_VIN_01( char profileFile[] )
{
    writeProfileInt( "VIN_01", "KS_Geheimnis_1", getValue( KCAN_KS_Geheimnis_1 ), profileFile );
    writeProfileInt( "VIN_01", "KS_Geheimnis_2", getValue( KCAN_KS_Geheimnis_2 ), profileFile );
    writeProfileInt( "VIN_01", "KS_Geheimnis_3", getValue( KCAN_KS_Geheimnis_3 ), profileFile );
    writeProfileInt( "VIN_01", "KS_Geheimnis_4", getValue( KCAN_KS_Geheimnis_4 ), profileFile );
    writeProfileInt( "VIN_01", "VIN_1", getValue( KCAN_VIN_1 ), profileFile );
    writeProfileInt( "VIN_01", "VIN_01_MUX", getValue( KCAN_VIN_01_MUX ), profileFile );
    writeProfileInt( "VIN_01", "VIN_2", getValue( KCAN_VIN_2 ), profileFile );
    writeProfileInt( "VIN_01", "VIN_3", getValue( KCAN_VIN_3 ), profileFile );
    writeProfileInt( "VIN_01", "VIN_4", getValue( KCAN_VIN_4 ), profileFile );
    writeProfileInt( "VIN_01", "VIN_5", getValue( KCAN_VIN_5 ), profileFile );
    writeProfileInt( "VIN_01", "VIN_6", getValue( KCAN_VIN_6 ), profileFile );
    writeProfileInt( "VIN_01", "VIN_7", getValue( KCAN_VIN_7 ), profileFile );
    writeProfileInt( "VIN_01", "VIN_8", getValue( KCAN_VIN_8 ), profileFile );
    writeProfileInt( "VIN_01", "VIN_9", getValue( KCAN_VIN_9 ), profileFile );
    writeProfileInt( "VIN_01", "VIN_10", getValue( KCAN_VIN_10 ), profileFile );
    writeProfileInt( "VIN_01", "VIN_11", getValue( KCAN_VIN_11 ), profileFile );
    writeProfileInt( "VIN_01", "VIN_12", getValue( KCAN_VIN_12 ), profileFile );
    writeProfileInt( "VIN_01", "VIN_13", getValue( KCAN_VIN_13 ), profileFile );
    writeProfileInt( "VIN_01", "VIN_14", getValue( KCAN_VIN_14 ), profileFile );
    writeProfileInt( "VIN_01", "VIN_15", getValue( KCAN_VIN_15 ), profileFile );
    writeProfileInt( "VIN_01", "VIN_16", getValue( KCAN_VIN_16 ), profileFile );
    writeProfileInt( "VIN_01", "VIN_17", getValue( KCAN_VIN_17 ), profileFile );

}


void saveSettings_VLK_01( char profileFile[] )
{
    writeProfileInt( "VLK_01", "VLK_Anf_Antrieb", getValue( KCAN_VLK_Anf_Antrieb ), profileFile );
    writeProfileInt( "VLK_01", "VLK_Anforderung_HMS", getValue( KCAN_VLK_Anforderung_HMS ), profileFile );
    writeProfileInt( "VLK_01", "VLK_Anforderung_Rollfaehigkeit", getValue( KCAN_VLK_Anforderung_Rollfaehigkeit ), profileFile );
    writeProfileInt( "VLK_01", "VLK_Antriebsdeaktivierung", getValue( KCAN_VLK_Antriebsdeaktivierung ), profileFile );
    writeProfileInt( "VLK_01", "VLK_autom_Absch_Signalisierung", getValue( KCAN_VLK_autom_Absch_Signalisierung ), profileFile );
    writeProfileInt( "VLK_01", "VLK_Hinweis_Rollfaehigkeit", getValue( KCAN_VLK_Hinweis_Rollfaehigkeit ), profileFile );
    writeProfileInt( "VLK_01", "VLK_Parken_beibehalten_HMS", getValue( KCAN_VLK_Parken_beibehalten_HMS ), profileFile );
    writeProfileInt( "VLK_01", "VLK_VLW_Anf", getValue( KCAN_VLK_VLW_Anf ), profileFile );

}


void saveSettings_VZE_04( char profileFile[] )
{
    writeProfileInt( "VZE_04", "VZE_Anhaenger_Vmax", getValue( KCAN_VZE_Anhaenger_Vmax ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Anzeige_VZ_1", getValue( KCAN_VZE_Anzeige_VZ_1 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Anzeige_VZ_2", getValue( KCAN_VZE_Anzeige_VZ_2 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Anzeige_VZ_3", getValue( KCAN_VZE_Anzeige_VZ_3 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Anzeige_ZS_1", getValue( KCAN_VZE_Anzeige_ZS_1 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Anzeige_ZS_2", getValue( KCAN_VZE_Anzeige_ZS_2 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Anzeige_ZS_3", getValue( KCAN_VZE_Anzeige_ZS_3 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Anzeigemodus", getValue( KCAN_VZE_Anzeigemodus ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Anzeigeunterdrueck_Zeichen_1", getValue( KCAN_VZE_Anzeigeunterdrueck_Zeichen_1 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Anzeigeunterdrueck_Zeichen_2", getValue( KCAN_VZE_Anzeigeunterdrueck_Zeichen_2 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Anzeigeunterdrueck_Zeichen_3", getValue( KCAN_VZE_Anzeigeunterdrueck_Zeichen_3 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Anzeigeunterdrueck_Zeichen_4", getValue( KCAN_VZE_Anzeigeunterdrueck_Zeichen_4 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Anzeigeunterdrueck_Zeichen_5", getValue( KCAN_VZE_Anzeigeunterdrueck_Zeichen_5 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Baustelle", getValue( KCAN_VZE_Baustelle ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Erweiterte_Information", getValue( KCAN_VZE_Erweiterte_Information ), profileFile );
    writeProfileInt( "VZE_04", "VZE_FoD_Status", getValue( KCAN_VZE_FoD_Status ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Gong", getValue( KCAN_VZE_Gong ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Hinweistext", getValue( KCAN_VZE_Hinweistext ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Hinweistext_03", getValue( KCAN_VZE_Hinweistext_03 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Land", getValue( KCAN_VZE_Land ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Tempowarnung_Einheit", getValue( KCAN_VZE_Tempowarnung_Einheit ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Tempowarnung_Offset", getValue( KCAN_VZE_Tempowarnung_Offset ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Tempowarnung_Status", getValue( KCAN_VZE_Tempowarnung_Status ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Umweltinfo_Anhaengerbetrieb", getValue( KCAN_VZE_Umweltinfo_Anhaengerbetrieb ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Umweltinfo_Naesse", getValue( KCAN_VZE_Umweltinfo_Naesse ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Umweltinfo_Nebel", getValue( KCAN_VZE_Umweltinfo_Nebel ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Verkehrszeichen_1", getValue( KCAN_VZE_Verkehrszeichen_1 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Verkehrszeichen_2", getValue( KCAN_VZE_Verkehrszeichen_2 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Verkehrszeichen_3", getValue( KCAN_VZE_Verkehrszeichen_3 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Verkehrszeichen_4", getValue( KCAN_VZE_Verkehrszeichen_4 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Verkehrszeichen_5", getValue( KCAN_VZE_Verkehrszeichen_5 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Verkehrszeichen_6", getValue( KCAN_VZE_Verkehrszeichen_6 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Verkehrszeichen_Einheit", getValue( KCAN_VZE_Verkehrszeichen_Einheit ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Warnung_Verkehrszeichen_1", getValue( KCAN_VZE_Warnung_Verkehrszeichen_1 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Warnung_Verkehrszeichen_2", getValue( KCAN_VZE_Warnung_Verkehrszeichen_2 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Warnung_Verkehrszeichen_3", getValue( KCAN_VZE_Warnung_Verkehrszeichen_3 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Warnung_Verkehrszeichen_4", getValue( KCAN_VZE_Warnung_Verkehrszeichen_4 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Warnung_Verkehrszeichen_5", getValue( KCAN_VZE_Warnung_Verkehrszeichen_5 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Warnung_VZ_1", getValue( KCAN_VZE_Warnung_VZ_1 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Warnung_VZ_2", getValue( KCAN_VZE_Warnung_VZ_2 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Warnung_VZ_3", getValue( KCAN_VZE_Warnung_VZ_3 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_01_Gesetz", getValue( KCAN_VZE_Zeichen_01_Gesetz ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_01_Kamera", getValue( KCAN_VZE_Zeichen_01_Kamera ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_01_KameraWied", getValue( KCAN_VZE_Zeichen_01_KameraWied ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_01_Karte", getValue( KCAN_VZE_Zeichen_01_Karte ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_02_Gesetz", getValue( KCAN_VZE_Zeichen_02_Gesetz ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_02_Kamera", getValue( KCAN_VZE_Zeichen_02_Kamera ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_02_KameraWied", getValue( KCAN_VZE_Zeichen_02_KameraWied ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_02_Karte", getValue( KCAN_VZE_Zeichen_02_Karte ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_03_Gesetz", getValue( KCAN_VZE_Zeichen_03_Gesetz ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_03_Kamera", getValue( KCAN_VZE_Zeichen_03_Kamera ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_03_KameraWied", getValue( KCAN_VZE_Zeichen_03_KameraWied ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_03_Karte", getValue( KCAN_VZE_Zeichen_03_Karte ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_04_Gesetz", getValue( KCAN_VZE_Zeichen_04_Gesetz ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_04_Kamera", getValue( KCAN_VZE_Zeichen_04_Kamera ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_04_KameraWied", getValue( KCAN_VZE_Zeichen_04_KameraWied ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_04_Karte", getValue( KCAN_VZE_Zeichen_04_Karte ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_05_Entfernung", getValue( KCAN_VZE_Zeichen_05_Entfernung ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_05_Entfernung_StdA", getValue( KCAN_VZE_Zeichen_05_Entfernung_StdA ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_05_Gesetz", getValue( KCAN_VZE_Zeichen_05_Gesetz ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_05_Kamera", getValue( KCAN_VZE_Zeichen_05_Kamera ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_05_KameraWied", getValue( KCAN_VZE_Zeichen_05_KameraWied ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_05_Karte", getValue( KCAN_VZE_Zeichen_05_Karte ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_06_Entfernung", getValue( KCAN_VZE_Zeichen_06_Entfernung ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zeichen_06_Entfernung_StdA", getValue( KCAN_VZE_Zeichen_06_Entfernung_StdA ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zusatzschild_1", getValue( KCAN_VZE_Zusatzschild_1 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zusatzschild_2", getValue( KCAN_VZE_Zusatzschild_2 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zusatzschild_3", getValue( KCAN_VZE_Zusatzschild_3 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zusatzschild_4", getValue( KCAN_VZE_Zusatzschild_4 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zusatzschild_5", getValue( KCAN_VZE_Zusatzschild_5 ), profileFile );
    writeProfileInt( "VZE_04", "VZE_Zusatzschild_6", getValue( KCAN_VZE_Zusatzschild_6 ), profileFile );

}


void saveSettings_WBA_03( char profileFile[] )
{
    writeProfileInt( "WBA_03", "GE_Sollgang", getValue( KCAN_GE_Sollgang ), profileFile );
    writeProfileInt( "WBA_03", "GE_Stoppverbot_Anz_01", getValue( KCAN_GE_Stoppverbot_Anz_01 ), profileFile );
    writeProfileInt( "WBA_03", "GE_Stoppverbot_Anz_02", getValue( KCAN_GE_Stoppverbot_Anz_02 ), profileFile );
    writeProfileInt( "WBA_03", "GE_Stoppverbot_Anz_03", getValue( KCAN_GE_Stoppverbot_Anz_03 ), profileFile );
    writeProfileInt( "WBA_03", "GE_Stoppverbot_Anz_04", getValue( KCAN_GE_Stoppverbot_Anz_04 ), profileFile );
    writeProfileInt( "WBA_03", "GE_Stoppverbot_Anz_05", getValue( KCAN_GE_Stoppverbot_Anz_05 ), profileFile );
    writeProfileInt( "WBA_03", "GE_Stoppverbot_Anz_06", getValue( KCAN_GE_Stoppverbot_Anz_06 ), profileFile );
    writeProfileInt( "WBA_03", "GE_Stoppverbot_Anz_07", getValue( KCAN_GE_Stoppverbot_Anz_07 ), profileFile );
    writeProfileInt( "WBA_03", "GE_Stoppverbot_Anz_Std", getValue( KCAN_GE_Stoppverbot_Anz_Std ), profileFile );
    writeProfileInt( "WBA_03", "GE_Tipschaltempf_verfuegbar", getValue( KCAN_GE_Tipschaltempf_verfuegbar ), profileFile );
    writeProfileInt( "WBA_03", "GE_Wiederstart_Anz_Std", getValue( KCAN_GE_Wiederstart_Anz_Std ), profileFile );
    writeProfileInt( "WBA_03", "WBA_03_BZ", getValue( KCAN_WBA_03_BZ ), profileFile );
    writeProfileInt( "WBA_03", "WBA_03_CRC", getValue( KCAN_WBA_03_CRC ), profileFile );
    writeProfileInt( "WBA_03", "WBA_Anforderung_Akustik", getValue( KCAN_WBA_Anforderung_Akustik ), profileFile );
    writeProfileInt( "WBA_03", "WBA_Blinken", getValue( KCAN_WBA_Blinken ), profileFile );
    writeProfileInt( "WBA_03", "WBA_eing_Gang_02", getValue( KCAN_WBA_eing_Gang_02 ), profileFile );
    writeProfileInt( "WBA_03", "WBA_Fahrstufe_02", getValue( KCAN_WBA_Fahrstufe_02 ), profileFile );
    writeProfileInt( "WBA_03", "WBA_GE_Texte", getValue( KCAN_WBA_GE_Texte ), profileFile );
    writeProfileInt( "WBA_03", "WBA_GE_Texte_02", getValue( KCAN_WBA_GE_Texte_02 ), profileFile );
    writeProfileInt( "WBA_03", "WBA_GE_Warnung_02", getValue( KCAN_WBA_GE_Warnung_02 ), profileFile );
    writeProfileInt( "WBA_03", "WBA_GE_Zusatzwarnungen", getValue( KCAN_WBA_GE_Zusatzwarnungen ), profileFile );
    writeProfileInt( "WBA_03", "WBA_Schaltschema_02", getValue( KCAN_WBA_Schaltschema_02 ), profileFile );
    writeProfileInt( "WBA_03", "WBA_Schaltschema_Fahreraktion", getValue( KCAN_WBA_Schaltschema_Fahreraktion ), profileFile );
    writeProfileInt( "WBA_03", "WBA_Schaltschema_FS_inaktiv", getValue( KCAN_WBA_Schaltschema_FS_inaktiv ), profileFile );
    writeProfileInt( "WBA_03", "WBA_Schaltschema_FS_vorwaerts", getValue( KCAN_WBA_Schaltschema_FS_vorwaerts ), profileFile );
    writeProfileInt( "WBA_03", "WBA_Schaltschema_Tippgasse", getValue( KCAN_WBA_Schaltschema_Tippgasse ), profileFile );
    writeProfileInt( "WBA_03", "WBA_Segeln_aktiv", getValue( KCAN_WBA_Segeln_aktiv ), profileFile );
    writeProfileInt( "WBA_03", "WBA_Shiftlock_Lampe", getValue( KCAN_WBA_Shiftlock_Lampe ), profileFile );
    writeProfileInt( "WBA_03", "WBA_ZielFahrstufe", getValue( KCAN_WBA_ZielFahrstufe ), profileFile );

}


void saveSettings_WFS_01( char profileFile[] )
{
    writeProfileInt( "WFS_01", "WFS_Betrieb_Lesespule", getValue( KCAN_WFS_Betrieb_Lesespule ), profileFile );
    writeProfileInt( "WFS_01", "WFS_ELV_authorisiert", getValue( KCAN_WFS_ELV_authorisiert ), profileFile );
    writeProfileInt( "WFS_01", "WFS_Fahrerhinweise", getValue( KCAN_WFS_Fahrerhinweise ), profileFile );
    writeProfileInt( "WFS_01", "WFS_ID_Geb_autorisiert", getValue( KCAN_WFS_ID_Geb_autorisiert ), profileFile );
    writeProfileInt( "WFS_01", "WFS_ID_Geb_autorisiert_in_Kl15", getValue( KCAN_WFS_ID_Geb_autorisiert_in_Kl15 ), profileFile );
    writeProfileInt( "WFS_01", "WFS_ID_Geb_steckt", getValue( KCAN_WFS_ID_Geb_steckt ), profileFile );
    writeProfileInt( "WFS_01", "WFS_Klemmenfreigabe", getValue( KCAN_WFS_Klemmenfreigabe ), profileFile );
    writeProfileInt( "WFS_01", "WFS_Klemmenfreigabe_Signatur", getValue( KCAN_WFS_Klemmenfreigabe_Signatur ), profileFile );
    writeProfileInt( "WFS_01", "WFS_LF_Aktiv", getValue( KCAN_WFS_LF_Aktiv ), profileFile );
    writeProfileInt( "WFS_01", "WFS_LZ", getValue( KCAN_WFS_LZ ), profileFile );
    writeProfileInt( "WFS_01", "WFS_LZ_02", getValue( KCAN_WFS_LZ_02 ), profileFile );
    writeProfileInt( "WFS_01", "WFS_Parken_Status", getValue( KCAN_WFS_Parken_Status ), profileFile );
    writeProfileInt( "WFS_01", "WFS_Safe", getValue( KCAN_WFS_Safe ), profileFile );
    writeProfileInt( "WFS_01", "WFS_Schluessel_Fahrberecht", getValue( KCAN_WFS_Schluessel_Fahrberecht ), profileFile );
    writeProfileInt( "WFS_01", "WFS_Schluessel_Ist", getValue( KCAN_WFS_Schluessel_Ist ), profileFile );
    writeProfileInt( "WFS_01", "WFS_Schluessel_Soll", getValue( KCAN_WFS_Schluessel_Soll ), profileFile );
    writeProfileInt( "WFS_01", "WFS_Verbauinfo_ELV", getValue( KCAN_WFS_Verbauinfo_ELV ), profileFile );

}


void saveSettings_WFS_Transponder_Req_02( char profileFile[] )
{

}


void saveSettings_WFS_Transponder_Resp_02( char profileFile[] )
{

}


void saveSettings_WFS_Transponder_Status_02( char profileFile[] )
{
    writeProfileInt( "WFS_Transponder_Status_02", "WFS_Diag_LF_Aktiv_02", getValue( KCAN_WFS_Diag_LF_Aktiv_02 ), profileFile );
    writeProfileInt( "WFS_Transponder_Status_02", "WFS_LF_aktiv_02", getValue( KCAN_WFS_LF_aktiv_02 ), profileFile );
    writeProfileInt( "WFS_Transponder_Status_02", "WFS_Transp_Mod_Unterbrechung_02", getValue( KCAN_WFS_Transp_Mod_Unterbrechung_02 ), profileFile );
    writeProfileInt( "WFS_Transponder_Status_02", "WFS_Verbau_Transp_Ant_02", getValue( KCAN_WFS_Verbau_Transp_Ant_02 ), profileFile );

}


void saveSettings_Wischer_01( char profileFile[] )
{
    writeProfileInt( "Wischer_01", "BCM1_SRA_aktiv", getValue( KCAN_BCM1_SRA_aktiv ), profileFile );
    writeProfileInt( "Wischer_01", "Waschen_vorne_aktiv", getValue( KCAN_Waschen_vorne_aktiv ), profileFile );
    writeProfileInt( "Wischer_01", "Wischer1_Wischgeschwindigkeit", getValue( KCAN_Wischer1_Wischgeschwindigkeit ), profileFile );
    writeProfileInt( "Wischer_01", "Wischer_Anzeigetext", getValue( KCAN_Wischer_Anzeigetext ), profileFile );
    writeProfileInt( "Wischer_01", "Wischer_vorne_aktiv", getValue( KCAN_Wischer_vorne_aktiv ), profileFile );
    writeProfileInt( "Wischer_01", "Wischer_vorne_blockiert", getValue( KCAN_Wischer_vorne_blockiert ), profileFile );
    writeProfileInt( "Wischer_01", "Wischer_vorne_defekt", getValue( KCAN_Wischer_vorne_defekt ), profileFile );
    writeProfileInt( "Wischer_01", "Wischer_vorne_Normal", getValue( KCAN_Wischer_vorne_Normal ), profileFile );
    writeProfileInt( "Wischer_01", "Wischer_vorne_Parklage", getValue( KCAN_Wischer_vorne_Parklage ), profileFile );
    writeProfileInt( "Wischer_01", "Wischer_vorne_Schnell", getValue( KCAN_Wischer_vorne_Schnell ), profileFile );
    writeProfileInt( "Wischer_01", "WWSs_01_alt", getValue( KCAN_WWSs_01_alt ), profileFile );

}


void saveSettings_WLC1_01( char profileFile[] )
{
    writeProfileInt( "WLC1_01", "WLC1_aktive_Spule", getValue( KCAN_WLC1_aktive_Spule ), profileFile );
    writeProfileInt( "WLC1_01", "WLC1_Charger_Effizienz", getValue( KCAN_WLC1_Charger_Effizienz ), profileFile );
    writeProfileFloat( "WLC1_01", "WLC1_Charger_laedt", getValue( KCAN_WLC1_Charger_laedt ), profileFile );
    writeProfileInt( "WLC1_01", "WLC1_Fehler", getValue( KCAN_WLC1_Fehler ), profileFile );
    writeProfileInt( "WLC1_01", "WLC1_Fremdobjekt_erkannt", getValue( KCAN_WLC1_Fremdobjekt_erkannt ), profileFile );
    writeProfileFloat( "WLC1_01", "WLC1_Leistungsklasse_Receiver", getValue( KCAN_WLC1_Leistungsklasse_Receiver ), profileFile );
    writeProfileInt( "WLC1_01", "WLC1_Objekt_erkannt", getValue( KCAN_WLC1_Objekt_erkannt ), profileFile );
    writeProfileInt( "WLC1_01", "WLC1_Receiver_erkannt", getValue( KCAN_WLC1_Receiver_erkannt ), profileFile );
    writeProfileInt( "WLC1_01", "WLC1_Receiver_voll_geladen", getValue( KCAN_WLC1_Receiver_voll_geladen ), profileFile );
    writeProfileInt( "WLC1_01", "WLC1_Temp_Leistungsteil_Charger", getValue( KCAN_WLC1_Temp_Leistungsteil_Charger ), profileFile );
    writeProfileInt( "WLC1_01", "WLC1_Temp_Oberfaeche_Charger", getValue( KCAN_WLC1_Temp_Oberfaeche_Charger ), profileFile );
    writeProfileInt( "WLC1_01", "WLC1_Temp_Receiver", getValue( KCAN_WLC1_Temp_Receiver ), profileFile );
    writeProfileInt( "WLC1_01", "WLC1_verwendeter_Ladestandard", getValue( KCAN_WLC1_verwendeter_Ladestandard ), profileFile );

}


void saveSettings_XCP_SmaLi_CRO_01( char profileFile[] )
{

}


void saveSettings_XCP_SmaLi_DTO_01( char profileFile[] )
{

}


void saveSettings_Zeitmaster_02( char profileFile[] )
{
    writeProfileInt( "Zeitmaster_02", "BasicUTC_Day", getValue( KCAN_BasicUTC_Day ), profileFile );
    writeProfileInt( "Zeitmaster_02", "BasicUTC_Hour", getValue( KCAN_BasicUTC_Hour ), profileFile );
    writeProfileInt( "Zeitmaster_02", "BasicUTC_Minute", getValue( KCAN_BasicUTC_Minute ), profileFile );
    writeProfileInt( "Zeitmaster_02", "BasicUTC_Month", getValue( KCAN_BasicUTC_Month ), profileFile );
    writeProfileInt( "Zeitmaster_02", "BasicUTC_Quality", getValue( KCAN_BasicUTC_Quality ), profileFile );
    writeProfileInt( "Zeitmaster_02", "BasicUTC_Second", getValue( KCAN_BasicUTC_Second ), profileFile );
    writeProfileInt( "Zeitmaster_02", "BasicUTC_Year", getValue( KCAN_BasicUTC_Year ), profileFile );

}


void saveSettings_Zentralrechner_01( char profileFile[] )
{
    writeProfileInt( "Zentralrechner_01", "DI_Screendesign", getValue( KCAN_DI_Screendesign ), profileFile );
    writeProfileInt( "Zentralrechner_01", "MMI_State_Zentralrechner_01", getValue( KCAN_MMI_State_Zentralrechner_01 ), profileFile );
    writeProfileInt( "Zentralrechner_01", "SI_ICAN", getValue( KCAN_SI_ICAN ), profileFile );
    writeProfileInt( "Zentralrechner_01", "WLC1_Systemzustand", getValue( KCAN_WLC1_Systemzustand ), profileFile );
    writeProfileInt( "Zentralrechner_01", "WLC2_Systemzustand", getValue( KCAN_WLC2_Systemzustand ), profileFile );
    writeProfileInt( "Zentralrechner_01", "ZR_DimOffs_DU_1", getValue( KCAN_ZR_DimOffs_DU_1 ), profileFile );
    writeProfileInt( "Zentralrechner_01", "ZR_DimOffs_DU_2", getValue( KCAN_ZR_DimOffs_DU_2 ), profileFile );
    writeProfileInt( "Zentralrechner_01", "ZR_DimOffs_DU_3", getValue( KCAN_ZR_DimOffs_DU_3 ), profileFile );
    writeProfileInt( "Zentralrechner_01", "ZR_Lenkerposition", getValue( KCAN_ZR_Lenkerposition ), profileFile );
    writeProfileInt( "Zentralrechner_01", "ZR_State_DU_1_Zentralrechner_01", getValue( KCAN_ZR_State_DU_1_Zentralrechner_01 ), profileFile );
    writeProfileInt( "Zentralrechner_01", "ZR_State_DU_2", getValue( KCAN_ZR_State_DU_2 ), profileFile );
    writeProfileInt( "Zentralrechner_01", "ZR_State_DU_3", getValue( KCAN_ZR_State_DU_3 ), profileFile );
    writeProfileInt( "Zentralrechner_01", "ZR_WecktGesp", getValue( KCAN_ZR_WecktGesp ), profileFile );

}


void saveSettings_ZV_02( char profileFile[] )
{
    writeProfileInt( "ZV_02", "BCM_FH_Freigabe", getValue( KCAN_BCM_FH_Freigabe ), profileFile );
    writeProfileInt( "ZV_02", "BCM_HSK_Freigabe", getValue( KCAN_BCM_HSK_Freigabe ), profileFile );
    writeProfileInt( "ZV_02", "BCM_Komfortfkt_Freigabe", getValue( KCAN_BCM_Komfortfkt_Freigabe ), profileFile );
    writeProfileInt( "ZV_02", "BCM_Verdeck_Freigabe", getValue( KCAN_BCM_Verdeck_Freigabe ), profileFile );
    writeProfileInt( "ZV_02", "DWA_aktiv", getValue( KCAN_DWA_aktiv ), profileFile );
    writeProfileInt( "ZV_02", "FBS_IDG_in_Reichweite", getValue( KCAN_FBS_IDG_in_Reichweite ), profileFile );
    writeProfileInt( "ZV_02", "FBS_Warn_Schluessel_Batt", getValue( KCAN_FBS_Warn_Schluessel_Batt ), profileFile );
    writeProfileInt( "ZV_02", "FFB_Auf_Taste", getValue( KCAN_FFB_Auf_Taste ), profileFile );
    writeProfileInt( "ZV_02", "FFB_CarFinder", getValue( KCAN_FFB_CarFinder ), profileFile );
    writeProfileInt( "ZV_02", "FFB_HDF_Taste", getValue( KCAN_FFB_HDF_Taste ), profileFile );
    writeProfileInt( "ZV_02", "FFB_Komfortoeffnen", getValue( KCAN_FFB_Komfortoeffnen ), profileFile );
    writeProfileInt( "ZV_02", "FFB_Komfortschliessen", getValue( KCAN_FFB_Komfortschliessen ), profileFile );
    writeProfileInt( "ZV_02", "FFB_Panik_Taste", getValue( KCAN_FFB_Panik_Taste ), profileFile );
    writeProfileInt( "ZV_02", "FFB_Zu_Taste", getValue( KCAN_FFB_Zu_Taste ), profileFile );
    writeProfileInt( "ZV_02", "IRUE_aktiv", getValue( KCAN_IRUE_aktiv ), profileFile );
    writeProfileInt( "ZV_02", "IRUE_Taster_Fkts_LED", getValue( KCAN_IRUE_Taster_Fkts_LED ), profileFile );
    writeProfileInt( "ZV_02", "ZV_Anf_Challenge_Auth", getValue( KCAN_ZV_Anf_Challenge_Auth ), profileFile );
    writeProfileInt( "ZV_02", "ZV_BT_offen", getValue( KCAN_ZV_BT_offen ), profileFile );
    writeProfileInt( "ZV_02", "ZV_Einzeltuerentriegelung", getValue( KCAN_ZV_Einzeltuerentriegelung ), profileFile );
    writeProfileInt( "ZV_02", "ZV_eRWK_Umfeld_Pruefung", getValue( KCAN_ZV_eRWK_Umfeld_Pruefung ), profileFile );
    writeProfileInt( "ZV_02", "ZV_FT_offen", getValue( KCAN_ZV_FT_offen ), profileFile );
    writeProfileInt( "ZV_02", "ZV_gesafet_extern_ist", getValue( KCAN_ZV_gesafet_extern_ist ), profileFile );
    writeProfileInt( "ZV_02", "ZV_gesafet_extern_soll", getValue( KCAN_ZV_gesafet_extern_soll ), profileFile );
    writeProfileInt( "ZV_02", "ZV_HBFS_offen", getValue( KCAN_ZV_HBFS_offen ), profileFile );
    writeProfileInt( "ZV_02", "ZV_HD_offen", getValue( KCAN_ZV_HD_offen ), profileFile );
    writeProfileInt( "ZV_02", "ZV_Heckeinzelentriegelung", getValue( KCAN_ZV_Heckeinzelentriegelung ), profileFile );
    writeProfileInt( "ZV_02", "ZV_HFS_offen", getValue( KCAN_ZV_HFS_offen ), profileFile );
    writeProfileInt( "ZV_02", "ZV_HS_offen", getValue( KCAN_ZV_HS_offen ), profileFile );
    writeProfileInt( "ZV_02", "ZV_ist_Zustand_verfuegbar", getValue( KCAN_ZV_ist_Zustand_verfuegbar ), profileFile );
    writeProfileInt( "ZV_02", "ZV_Oeffnungsmodus", getValue( KCAN_ZV_Oeffnungsmodus ), profileFile );
    writeProfileInt( "ZV_02", "ZV_Rollo_auf", getValue( KCAN_ZV_Rollo_auf ), profileFile );
    writeProfileInt( "ZV_02", "ZV_Rollo_zu", getValue( KCAN_ZV_Rollo_zu ), profileFile );
    writeProfileInt( "ZV_02", "ZV_SAD_auf", getValue( KCAN_ZV_SAD_auf ), profileFile );
    writeProfileInt( "ZV_02", "ZV_SAD_zu", getValue( KCAN_ZV_SAD_zu ), profileFile );
    writeProfileInt( "ZV_02", "ZV_SafeFunktion_aktiv", getValue( KCAN_ZV_SafeFunktion_aktiv ), profileFile );
    writeProfileInt( "ZV_02", "ZV_Schluessel_Zugang", getValue( KCAN_ZV_Schluessel_Zugang ), profileFile );
    writeProfileInt( "ZV_02", "ZV_STSG_HBFS_Anf", getValue( KCAN_ZV_STSG_HBFS_Anf ), profileFile );
    writeProfileInt( "ZV_02", "ZV_STSG_HFS_Anf", getValue( KCAN_ZV_STSG_HFS_Anf ), profileFile );
    writeProfileInt( "ZV_02", "ZV_Tankklappe_offen", getValue( KCAN_ZV_Tankklappe_offen ), profileFile );
    writeProfileInt( "ZV_02", "ZV_verriegeln_Anf", getValue( KCAN_ZV_verriegeln_Anf ), profileFile );
    writeProfileInt( "ZV_02", "ZV_verriegelt_extern_ist", getValue( KCAN_ZV_verriegelt_extern_ist ), profileFile );
    writeProfileInt( "ZV_02", "ZV_verriegelt_extern_soll", getValue( KCAN_ZV_verriegelt_extern_soll ), profileFile );
    writeProfileInt( "ZV_02", "ZV_verriegelt_intern_ist", getValue( KCAN_ZV_verriegelt_intern_ist ), profileFile );
    writeProfileInt( "ZV_02", "ZV_verriegelt_intern_soll", getValue( KCAN_ZV_verriegelt_intern_soll ), profileFile );
    writeProfileInt( "ZV_02", "ZV_verriegelt_soll", getValue( KCAN_ZV_verriegelt_soll ), profileFile );

}


void saveSettings_ZV_04( char profileFile[] )
{
    writeProfileInt( "ZV_04", "BCM_Waehlhebel_P_Hinweis", getValue( KCAN_BCM_Waehlhebel_P_Hinweis ), profileFile );
    writeProfileInt( "ZV_04", "UHF_FFB_Funkschluesseltyp", getValue( KCAN_UHF_FFB_Funkschluesseltyp ), profileFile );
    writeProfileInt( "ZV_04", "UHF_FFB_SKC_anlernen", getValue( KCAN_UHF_FFB_SKC_anlernen ), profileFile );
    writeProfileInt( "ZV_04", "ZV_04_BZ", getValue( KCAN_ZV_04_BZ ), profileFile );
    writeProfileInt( "ZV_04", "ZV_04_CRC", getValue( KCAN_ZV_04_CRC ), profileFile );
    writeProfileInt( "ZV_04", "ZV_DWA_Einfachhorn_Anf", getValue( KCAN_ZV_DWA_Einfachhorn_Anf ), profileFile );
    writeProfileInt( "ZV_04", "ZV_DWA_Einfachhorn_Takt", getValue( KCAN_ZV_DWA_Einfachhorn_Takt ), profileFile );
    writeProfileInt( "ZV_04", "ZV_Einfachhorn_Anf", getValue( KCAN_ZV_Einfachhorn_Anf ), profileFile );
    writeProfileInt( "ZV_04", "ZV_Einfachhorn_Takt", getValue( KCAN_ZV_Einfachhorn_Takt ), profileFile );
    writeProfileInt( "ZV_04", "ZV_HD_Parkbremse_Hinweis", getValue( KCAN_ZV_HD_Parkbremse_Hinweis ), profileFile );
    writeProfileInt( "ZV_04", "ZV_HW_Motor_Lock_HK", getValue( KCAN_ZV_HW_Motor_Lock_HK ), profileFile );
    writeProfileInt( "ZV_04", "ZV_HW_Motor_Safe_Hinten", getValue( KCAN_ZV_HW_Motor_Safe_Hinten ), profileFile );
    writeProfileInt( "ZV_04", "ZV_HW_TKL_mot_entr", getValue( KCAN_ZV_HW_TKL_mot_entr ), profileFile );
    writeProfileInt( "ZV_04", "ZV_HW_TKL_mot_verr", getValue( KCAN_ZV_HW_TKL_mot_verr ), profileFile );
    writeProfileInt( "ZV_04", "ZV_Laderaumabd_elektr_aktiviert", getValue( KCAN_ZV_Laderaumabd_elektr_aktiviert ), profileFile );

}


void saveENVars( char profileFile[] )
{
    writeProfileInt("Settings" ,"eSendEnabled" ,getValue(eSendEnabled), profileFile);
    writeProfileInt("Settings" ,"env_PIC_Status_StArtActive" ,getValue(env_PIC_Status_StArtActive), profileFile);
    writeProfileInt("Settings" ,"env_PIC_Status_SendBtn" ,getValue(env_PIC_Status_SendBtn), profileFile);
    writeProfileInt("Settings" ,"env_PIC_Status_GetIntAddrActive" ,getValue(env_PIC_Status_GetIntAddrActive), profileFile);
    writeProfileInt("Settings" ,"env_PIC_Status_CoArtActive" ,getValue(env_PIC_Status_CoArtActive), profileFile);
    writeProfileInt("Settings" ,"env_PIC_Status_AdContactActive" ,getValue(env_PIC_Status_AdContactActive), profileFile);
    writeProfileInt("Settings" ,"env_PIC_Status_AcCallActive" ,getValue(env_PIC_Status_AcCallActive), profileFile);
    writeProfileInt("Settings" ,"env_PIC_CoverArt_CovArtType" ,getValue(env_PIC_CoverArt_CovArtType), profileFile);
    writeProfileInt("Settings" ,"env_PIC_CoverArt_SourceType" ,getValue(env_PIC_CoverArt_SourceType), profileFile);
    writeProfileInt("Settings" ,"env_PIC_StationArt_StnArtType" ,getValue(env_PIC_StationArt_StnArtType), profileFile);
    writeProfileInt("Settings" ,"env_PIC_StationArt_SourceType" ,getValue(env_PIC_StationArt_SourceType), profileFile);
    writeProfileInt("Settings" ,"env_PIC_ActCallPic_PictureType" ,getValue(env_PIC_ActCallPic_PictureType), profileFile);
    writeProfileInt("Settings" ,"env_PIC_ActCallPic_CallId" ,getValue(env_PIC_ActCallPic_CallId), profileFile);
    writeProfileInt("Settings" ,"env_PIC_bapMOST_setImage_Cat" ,getValue(env_PIC_bapMOST_setImage_Cat), profileFile);
    writeProfileInt("Settings" ,"env_PIC_bapMOST_setImage_POS" ,getValue(env_PIC_bapMOST_setImage_POS), profileFile);
    writeProfileInt("Settings" ,"env_PIC_bapMOST_setImage_button" ,getValue(env_PIC_bapMOST_setImage_button), profileFile);
    writeProfileInt("Settings" ,"env_PIC_CoverArt_Tx_Event" ,getValue(env_PIC_CoverArt_Tx_Event), profileFile);
    writeProfileInt("Settings" ,"env_PIC_AdbCntctPic_Tx_Event" ,getValue(env_PIC_AdbCntctPic_Tx_Event), profileFile);
    writeProfileInt("Settings" ,"env_PIC_ActCallPic_Tx_Event" ,getValue(env_PIC_ActCallPic_Tx_Event), profileFile);
    writeProfileInt("Settings" ,"env_PIC_ActCallPic_Handle" ,getValue(env_PIC_ActCallPic_Handle), profileFile);
    writeProfileInt("Settings" ,"env_PIC_AdbCntctPic_Handle" ,getValue(env_PIC_AdbCntctPic_Handle), profileFile);
    writeProfileInt("Settings" ,"env_PIC_CoverArt_Handle" ,getValue(env_PIC_CoverArt_Handle), profileFile);
    writeProfileInt("Settings" ,"env_PIC_StationArt_Tx_Event" ,getValue(env_PIC_StationArt_Tx_Event), profileFile);
    writeProfileInt("Settings" ,"env_PIC_StationArt_Handle" ,getValue(env_PIC_StationArt_Handle), profileFile);
    writeProfileInt("Settings" ,"env_PIC_bapMOST_active_flag" ,getValue(env_PIC_bapMOST_active_flag), profileFile);
    writeProfileInt("Settings" ,"env_PIC_StressTest_Progress" ,getValue(env_PIC_StressTest_Progress), profileFile);
    writeProfileInt("Settings" ,"env_PIC_StressTest_StressType" ,getValue(env_PIC_StressTest_StressType), profileFile);
    writeProfileInt("Settings" ,"env_PIC_StressTest_AcCallActive" ,getValue(env_PIC_StressTest_AcCallActive), profileFile);
    writeProfileInt("Settings" ,"env_PIC_StressTest_StArtActive" ,getValue(env_PIC_StressTest_StArtActive), profileFile);
    writeProfileInt("Settings" ,"env_PIC_StressTest_AcCallDelay" ,getValue(env_PIC_StressTest_AcCallDelay), profileFile);
    writeProfileInt("Settings" ,"env_PIC_StressTest_AcCallCount" ,getValue(env_PIC_StressTest_AcCallCount), profileFile);
    writeProfileInt("Settings" ,"env_PIC_StressTest_StArtCount" ,getValue(env_PIC_StressTest_StArtCount), profileFile);
    writeProfileInt("Settings" ,"env_PIC_StressTest_CoArtCount" ,getValue(env_PIC_StressTest_CoArtCount), profileFile);
    writeProfileInt("Settings" ,"env_PIC_StressTest_StArtDelay" ,getValue(env_PIC_StressTest_StArtDelay), profileFile);
    writeProfileInt("Settings" ,"env_PIC_StressTest_CoArtDelay" ,getValue(env_PIC_StressTest_CoArtDelay), profileFile);
    writeProfileInt("Settings" ,"env_PIC_StressTest_Time" ,getValue(env_PIC_StressTest_Time), profileFile);
    writeProfileInt("Settings" ,"env_PIC_StressTest_TestBtn" ,getValue(env_PIC_StressTest_TestBtn), profileFile);
    writeProfileInt("Settings" ,"env_PIC_StressTest_CoArtActive" ,getValue(env_PIC_StressTest_CoArtActive), profileFile);
    writeProfileInt("Settings" ,"env_ECL_RBDTestEvent" ,getValue(env_ECL_RBDTestEvent), profileFile);
    writeProfileInt("Settings" ,"env_WakeupRequestInQueueFlag" ,getValue(env_WakeupRequestInQueueFlag), profileFile);
    writeProfileInt("Settings" ,"env_ShutdownExecuteSendFlag" ,getValue(env_ShutdownExecuteSendFlag), profileFile);
    writeProfileInt("Settings" ,"env_RadioButton_Shutdown_Wakeup" ,getValue(env_RadioButton_Shutdown_Wakeup), profileFile);
    writeProfileInt("Settings" ,"env_RadioButton_MOSTLight_On_Off" ,getValue(env_RadioButton_MOSTLight_On_Off), profileFile);
    writeProfileInt("Settings" ,"ENV_WRN_Time_DisplayTime" ,getValue(ENV_WRN_Time_DisplayTime), profileFile);
    writeProfileInt("Settings" ,"ENV_WRN_Time_OnOff" ,getValue(ENV_WRN_Time_OnOff), profileFile);
    writeProfileInt("Settings" ,"ENV_MO_Ges_calcConsumption_button" ,getValue(ENV_MO_Ges_calcConsumption_button), profileFile);
    writeProfileInt("Settings" ,"ENV_MO_Recu_calcConsumption_button" ,getValue(ENV_MO_Recu_calcConsumption_button), profileFile);
    writeProfileInt("Settings" ,"ENV_BMS_Verbrauch_calcConsumption_button" ,getValue(ENV_BMS_Verbrauch_calcConsumption_button), profileFile);
    writeProfileInt("Settings" ,"ENV_BMS_Rekuperation_calcConsumption_button" ,getValue(ENV_BMS_Rekuperation_calcConsumption_button), profileFile);
    writeProfileInt("Settings" ,"ENV_PlayReplayblock" ,getValue(ENV_PlayReplayblock), profileFile);
    writeProfileInt("Settings" ,"ENV_KombiMQB_TxCycle_Check" ,getValue(ENV_KombiMQB_TxCycle_Check), profileFile);
    writeProfileInt("Settings" ,"ENV_DEV_Kombi_54_TxC_stat" ,getValue(ENV_DEV_Kombi_54_TxC_stat), profileFile);
    writeProfileInt("Settings" ,"ENV_DEV_Kombi_54_TxC_min" ,getValue(ENV_DEV_Kombi_54_TxC_min), profileFile);
    writeProfileInt("Settings" ,"ENV_DEV_Kombi_54_TxC_max" ,getValue(ENV_DEV_Kombi_54_TxC_max), profileFile);
    writeProfileInt("Settings" ,"ENV_DEV_Kombi_54_RedCtr" ,getValue(ENV_DEV_Kombi_54_RedCtr), profileFile);
    writeProfileInt("Settings" ,"ENV_TxCycleCheck_ErrSummary" ,getValue(ENV_TxCycleCheck_ErrSummary), profileFile);
    writeProfileFloat("Settings" ,"ENV_DEV_Kombi_54_TxC_timeStamp" ,getValue(ENV_DEV_Kombi_54_TxC_timeStamp), profileFile);
    writeProfileInt("Settings" ,"ENV_SendMFL_Tasten_Kon_01" ,getValue(ENV_SendMFL_Tasten_Kon_01), profileFile);
    writeProfileInt("Settings" ,"ENV_TESP_24" ,getValue(ENV_TESP_24), profileFile);
    writeProfileInt("Settings" ,"ENV_KBI_PhototransistorD" ,getValue(ENV_KBI_PhototransistorD), profileFile);
    writeProfileInt("Settings" ,"ENV_Phone_CombNum_list_short" ,getValue(ENV_Phone_CombNum_list_short), profileFile);
    writeProfileInt("Settings" ,"ENV_FSG_CN_Flg" ,getValue(ENV_FSG_CN_Flg), profileFile);
    writeProfileInt("Settings" ,"ENV_PIC_bapMOST_active_flag" ,getValue(ENV_PIC_bapMOST_active_flag), profileFile);
    writeProfileInt("Settings" ,"ENV_SendEnabled" ,getValue(ENV_SendEnabled), profileFile);
    writeProfileInt("Settings" ,"ENV_INTEGR_TestCase_OFF" ,getValue(ENV_INTEGR_TestCase_OFF), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ14" ,getValue(ENV_INTEGR_TestCase_BZ14), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ15" ,getValue(ENV_INTEGR_TestCase_BZ15), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ16" ,getValue(ENV_INTEGR_TestCase_BZ16), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ17" ,getValue(ENV_INTEGR_TestCase_BZ17), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ18" ,getValue(ENV_INTEGR_TestCase_BZ18), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ19" ,getValue(ENV_INTEGR_TestCase_BZ19), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ20" ,getValue(ENV_INTEGR_TestCase_BZ20), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ21" ,getValue(ENV_INTEGR_TestCase_BZ21), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ22" ,getValue(ENV_INTEGR_TestCase_BZ22), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ23" ,getValue(ENV_INTEGR_TestCase_BZ23), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ24" ,getValue(ENV_INTEGR_TestCase_BZ24), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ25" ,getValue(ENV_INTEGR_TestCase_BZ25), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ26" ,getValue(ENV_INTEGR_TestCase_BZ26), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ27" ,getValue(ENV_INTEGR_TestCase_BZ27), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ28" ,getValue(ENV_INTEGR_TestCase_BZ28), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ29" ,getValue(ENV_INTEGR_TestCase_BZ29), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ30" ,getValue(ENV_INTEGR_TestCase_BZ30), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ31" ,getValue(ENV_INTEGR_TestCase_BZ31), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ32" ,getValue(ENV_INTEGR_TestCase_BZ32), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ33" ,getValue(ENV_INTEGR_TestCase_BZ33), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ34" ,getValue(ENV_INTEGR_TestCase_BZ34), profileFile);
    writeProfileFloat("Settings" ,"ENV_INTEGR_TestCase_BZ35" ,getValue(ENV_INTEGR_TestCase_BZ35), profileFile);
    writeProfileInt("Settings" ,"ENV_NaviSD_RG_Status" ,getValue(ENV_NaviSD_RG_Status), profileFile);
    writeProfileInt("Settings" ,"ENV_NaviSD_RG_Status_update" ,getValue(ENV_NaviSD_RG_Status_update), profileFile);
    writeProfileInt("Settings" ,"ENV_Navi_LaneGuidanceList_Long" ,getValue(ENV_Navi_LaneGuidanceList_Long), profileFile);
    writeProfileInt("Settings" ,"ENV_NaviSD_MD_update" ,getValue(ENV_NaviSD_MD_update), profileFile);
    writeProfileInt("Settings" ,"ENV_NaviSD_LG_LGOnOff" ,getValue(ENV_NaviSD_LG_LGOnOff), profileFile);
    writeProfileInt("Settings" ,"ENV_NaviSD_MD_MainElement1" ,getValue(ENV_NaviSD_MD_MainElement1), profileFile);
    writeProfileInt("Settings" ,"ENV_AudioSD_PowerOnOff" ,getValue(ENV_AudioSD_PowerOnOff), profileFile);
    writeProfileInt("Settings" ,"ENV_MO_CNG_LPG" ,getValue(ENV_MO_CNG_LPG), profileFile);
    writeProfileInt("Settings" ,"ENV_MO_akt_Betrieb" ,getValue(ENV_MO_akt_Betrieb), profileFile);
    writeProfileFloat("Settings" ,"ENV_MO_Fuellungsgrad_CNG" ,getValue(ENV_MO_Fuellungsgrad_CNG), profileFile);
    writeProfileInt("Settings" ,"ENV_MO_Verbrauch_LPG" ,getValue(ENV_MO_Verbrauch_LPG), profileFile);
    writeProfileFloat("Settings" ,"ENV_MO_Tankmasse_CNG" ,getValue(ENV_MO_Tankmasse_CNG), profileFile);
    writeProfileFloat("Settings" ,"ENV_MO_Fuellungsgrad_LPG_m1" ,getValue(ENV_MO_Fuellungsgrad_LPG_m1), profileFile);
    writeProfileFloat("Settings" ,"ENV_MO_Tankvolumen_LPG" ,getValue(ENV_MO_Tankvolumen_LPG), profileFile);
    writeProfileInt("Settings" ,"ENV_RadioButton_MOSTLight_On_Off" ,getValue(ENV_RadioButton_MOSTLight_On_Off), profileFile);
    writeProfileInt("Settings" ,"ENV_RadioButton_Shutdown_Wakeup" ,getValue(ENV_RadioButton_Shutdown_Wakeup), profileFile);
    writeProfileInt("Settings" ,"ENV_ShutdownExecuteSendFlag" ,getValue(ENV_ShutdownExecuteSendFlag), profileFile);
    writeProfileInt("Settings" ,"ENV_WakeupRequestInQueueFlag" ,getValue(ENV_WakeupRequestInQueueFlag), profileFile);
    writeProfileInt("Settings" ,"ENV_ECL_RBDTestEvent" ,getValue(ENV_ECL_RBDTestEvent), profileFile);
    writeProfileInt("Settings" ,"ENV_AudioSD_MBList_Long" ,getValue(ENV_AudioSD_MBList_Long), profileFile);
    writeProfileInt("Settings" ,"ENV_AudioSD_MBList_Short" ,getValue(ENV_AudioSD_MBList_Short), profileFile);
    writeProfileInt("Settings" ,"ENV_AudioSD_SourceList_Long" ,getValue(ENV_AudioSD_SourceList_Long), profileFile);
    writeProfileInt("Settings" ,"ENV_AudioSD_SourceList_Short" ,getValue(ENV_AudioSD_SourceList_Short), profileFile);
    writeProfileInt("Settings" ,"ENV_NaviSD_BAP_Longlist" ,getValue(ENV_NaviSD_BAP_Longlist), profileFile);
    writeProfileInt("Settings" ,"ENV_NaviSD_BAP_Shortlist" ,getValue(ENV_NaviSD_BAP_Shortlist), profileFile);
    writeProfileInt("Settings" ,"ENV_Navi_LaneGuidanceList_Short" ,getValue(ENV_Navi_LaneGuidanceList_Short), profileFile);
    writeProfileInt("Settings" ,"ENV_Phone_CombNum_list_long" ,getValue(ENV_Phone_CombNum_list_long), profileFile);
    writeProfileInt("Settings" ,"ENV_Phone_Phonebook_list_short" ,getValue(ENV_Phone_Phonebook_list_short), profileFile);
    writeProfileInt("Settings" ,"ENV_Phone_Phonebook_list_long" ,getValue(ENV_Phone_Phonebook_list_long), profileFile);
    writeProfileInt("Settings" ,"ENV_NaviSD_PrefDeLis_Type" ,getValue(ENV_NaviSD_PrefDeLis_Type), profileFile);
    writeProfileInt("Settings" ,"ENV_FSG_Schalter_OnOff" ,getValue(ENV_FSG_Schalter_OnOff), profileFile);
    writeProfileInt("Settings" ,"ENV_NaviSD_LG_FRU" ,getValue(ENV_NaviSD_LG_FRU), profileFile);
    writeProfileInt("Settings" ,"ENV_NaviSD_LDL_FRU" ,getValue(ENV_NaviSD_LDL_FRU), profileFile);
    writeProfileInt("Settings" ,"ENV_AudioSD_MB_FRU" ,getValue(ENV_AudioSD_MB_FRU), profileFile);
    writeProfileInt("Settings" ,"ENV_FSG_CN_FRU" ,getValue(ENV_FSG_CN_FRU), profileFile);
    writeProfileInt("Settings" ,"ENV_FSG_IncomingCall" ,getValue(ENV_FSG_IncomingCall), profileFile);
    writeProfileInt("Settings" ,"ENV_FSG_HangupCall" ,getValue(ENV_FSG_HangupCall), profileFile);
    writeProfileInt("Settings" ,"ENV_Audio_StartResult_IND" ,getValue(ENV_Audio_StartResult_IND), profileFile);
    writeProfileInt("Settings" ,"ENV_Telephone_DataGet_IND" ,getValue(ENV_Telephone_DataGet_IND), profileFile);
    writeProfileInt("Settings" ,"ENV_NaviSD_FDL_FRU" ,getValue(ENV_NaviSD_FDL_FRU), profileFile);
    writeProfileInt("Settings" ,"KCAN__STOP_All_MESSAGES_DEFAULT_STARTDELAY" ,getValue(KCAN__STOP_All_MESSAGES_DEFAULT_STARTDELAY), profileFile);
    writeProfileInt("Settings" ,"KCAN__STOP_All_MESSAGES_SET_STARTDELAY" ,getValue(KCAN__STOP_All_MESSAGES_SET_STARTDELAY), profileFile);
    writeProfileInt("Settings" ,"KCAN__SAVE_PANEL_CONFIG" ,getValue(KCAN__SAVE_PANEL_CONFIG), profileFile);
    writeProfileInt("Settings" ,"KCAN__STOP_All_MESSAGES_ON" ,getValue(KCAN__STOP_All_MESSAGES_ON), profileFile);
    writeProfileInt("Settings" ,"KCAN__STOP_All_MESSAGES_OFF" ,getValue(KCAN__STOP_All_MESSAGES_OFF), profileFile);
    writeProfileInt("Settings" ,"KCAN__NMH_Fahrerdisplay_Kombi_ActualState" ,getValue(KCAN__NMH_Fahrerdisplay_Kombi_ActualState), profileFile);
    writeProfileInt("Settings" ,"KCAN__HeavyBusload" ,getValue(KCAN__HeavyBusload), profileFile);
    writeProfileInt("Settings" ,"KCAN__NMH_SmartLight_01_ActualState" ,getValue(KCAN__NMH_SmartLight_01_ActualState), profileFile);
    writeProfileInt("Settings" ,"KCAN__NMH_ICAS3_Gateway_ActualState" ,getValue(KCAN__NMH_ICAS3_Gateway_ActualState), profileFile);
    writeProfileInt("Settings" ,"KCAN__NMH_ICAS1_Gateway_ActualState" ,getValue(KCAN__NMH_ICAS1_Gateway_ActualState), profileFile);
    writeProfileInt("Settings" ,"KCAN__NMH_HUD_ActualState" ,getValue(KCAN__NMH_HUD_ActualState), profileFile);
    writeProfileInt("Settings" ,"KCAN__NMH_Kombi_ActualState" ,getValue(KCAN__NMH_Kombi_ActualState), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGID_AAA_01" ,getValue(KCAN__MSGID_AAA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_AAA_01" ,getValue(KCAN__MSGDLC_AAA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_AAA_01_CTRL" ,getValue(KCAN__MSGDLC_AAA_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__ALLDEF_AAA_01" ,getValue(KCAN__ALLDEF_AAA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_AAA_01" ,getValue(KCAN__STMSG_AAA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_AAA_01" ,getValue(KCAN__STMSGT_AAA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_AAA_01_CTRL" ,getValue(KCAN__STMSGT_AAA_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGSD_AAA_01" ,getValue(KCAN__STMSGSD_AAA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_AAA_01" ,getValue(KCAN__STMSGCT_AAA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_AAA_01_CTRL" ,getValue(KCAN__STMSGCT_AAA_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_PO_AAA_01" ,getValue(KCAN__STMSG_PO_AAA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLoadDefault_AAA_01" ,getValue(KCAN__MSGDLoadDefault_AAA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSG_SendNow_AAA_01" ,getValue(KCAN__MSG_SendNow_AAA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGID_ACC_19" ,getValue(KCAN__MSGID_ACC_19), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_ACC_19" ,getValue(KCAN__MSGDLC_ACC_19), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_ACC_19_CTRL" ,getValue(KCAN__MSGDLC_ACC_19_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__ALLDEF_ACC_19" ,getValue(KCAN__ALLDEF_ACC_19), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_ACC_19" ,getValue(KCAN__STMSG_ACC_19), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_ACC_19" ,getValue(KCAN__STMSGT_ACC_19), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_ACC_19_CTRL" ,getValue(KCAN__STMSGT_ACC_19_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGSD_ACC_19" ,getValue(KCAN__STMSGSD_ACC_19), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_ACC_19" ,getValue(KCAN__STMSGCT_ACC_19), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_ACC_19_CTRL" ,getValue(KCAN__STMSGCT_ACC_19_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_PO_ACC_19" ,getValue(KCAN__STMSG_PO_ACC_19), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLoadDefault_ACC_19" ,getValue(KCAN__MSGDLoadDefault_ACC_19), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSG_SendNow_ACC_19" ,getValue(KCAN__MSG_SendNow_ACC_19), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGID_AGA_01" ,getValue(KCAN__MSGID_AGA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_AGA_01" ,getValue(KCAN__MSGDLC_AGA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_AGA_01_CTRL" ,getValue(KCAN__MSGDLC_AGA_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__ALLDEF_AGA_01" ,getValue(KCAN__ALLDEF_AGA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_AGA_01" ,getValue(KCAN__STMSG_AGA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_AGA_01" ,getValue(KCAN__STMSGT_AGA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_AGA_01_CTRL" ,getValue(KCAN__STMSGT_AGA_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGSD_AGA_01" ,getValue(KCAN__STMSGSD_AGA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_AGA_01" ,getValue(KCAN__STMSGCT_AGA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_AGA_01_CTRL" ,getValue(KCAN__STMSGCT_AGA_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_PO_AGA_01" ,getValue(KCAN__STMSG_PO_AGA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLoadDefault_AGA_01" ,getValue(KCAN__MSGDLoadDefault_AGA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSG_SendNow_AGA_01" ,getValue(KCAN__MSG_SendNow_AGA_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGID_Airbag_01" ,getValue(KCAN__MSGID_Airbag_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_Airbag_01" ,getValue(KCAN__MSGDLC_Airbag_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_Airbag_01_CTRL" ,getValue(KCAN__MSGDLC_Airbag_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__ALLDEF_Airbag_01" ,getValue(KCAN__ALLDEF_Airbag_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_Airbag_01" ,getValue(KCAN__STMSG_Airbag_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_Airbag_01" ,getValue(KCAN__STMSGT_Airbag_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_Airbag_01_CTRL" ,getValue(KCAN__STMSGT_Airbag_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGSD_Airbag_01" ,getValue(KCAN__STMSGSD_Airbag_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_Airbag_01" ,getValue(KCAN__STMSGCT_Airbag_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_Airbag_01_CTRL" ,getValue(KCAN__STMSGCT_Airbag_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_PO_Airbag_01" ,getValue(KCAN__STMSG_PO_Airbag_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLoadDefault_Airbag_01" ,getValue(KCAN__MSGDLoadDefault_Airbag_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSG_SendNow_Airbag_01" ,getValue(KCAN__MSG_SendNow_Airbag_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGID_Airbag_02" ,getValue(KCAN__MSGID_Airbag_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_Airbag_02" ,getValue(KCAN__MSGDLC_Airbag_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_Airbag_02_CTRL" ,getValue(KCAN__MSGDLC_Airbag_02_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__ALLDEF_Airbag_02" ,getValue(KCAN__ALLDEF_Airbag_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_Airbag_02" ,getValue(KCAN__STMSG_Airbag_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_Airbag_02" ,getValue(KCAN__STMSGT_Airbag_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_Airbag_02_CTRL" ,getValue(KCAN__STMSGT_Airbag_02_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGSD_Airbag_02" ,getValue(KCAN__STMSGSD_Airbag_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_Airbag_02" ,getValue(KCAN__STMSGCT_Airbag_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_Airbag_02_CTRL" ,getValue(KCAN__STMSGCT_Airbag_02_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_PO_Airbag_02" ,getValue(KCAN__STMSG_PO_Airbag_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLoadDefault_Airbag_02" ,getValue(KCAN__MSGDLoadDefault_Airbag_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSG_SendNow_Airbag_02" ,getValue(KCAN__MSG_SendNow_Airbag_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGID_Airbag_04" ,getValue(KCAN__MSGID_Airbag_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_Airbag_04" ,getValue(KCAN__MSGDLC_Airbag_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_Airbag_04_CTRL" ,getValue(KCAN__MSGDLC_Airbag_04_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__ALLDEF_Airbag_04" ,getValue(KCAN__ALLDEF_Airbag_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_Airbag_04" ,getValue(KCAN__STMSG_Airbag_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_Airbag_04" ,getValue(KCAN__STMSGT_Airbag_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_Airbag_04_CTRL" ,getValue(KCAN__STMSGT_Airbag_04_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGSD_Airbag_04" ,getValue(KCAN__STMSGSD_Airbag_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_Airbag_04" ,getValue(KCAN__STMSGCT_Airbag_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_Airbag_04_CTRL" ,getValue(KCAN__STMSGCT_Airbag_04_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_PO_Airbag_04" ,getValue(KCAN__STMSG_PO_Airbag_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLoadDefault_Airbag_04" ,getValue(KCAN__MSGDLoadDefault_Airbag_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSG_SendNow_Airbag_04" ,getValue(KCAN__MSG_SendNow_Airbag_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGID_Airbag_06" ,getValue(KCAN__MSGID_Airbag_06), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_Airbag_06" ,getValue(KCAN__MSGDLC_Airbag_06), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_Airbag_06_CTRL" ,getValue(KCAN__MSGDLC_Airbag_06_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__ALLDEF_Airbag_06" ,getValue(KCAN__ALLDEF_Airbag_06), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_Airbag_06" ,getValue(KCAN__STMSG_Airbag_06), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_Airbag_06" ,getValue(KCAN__STMSGT_Airbag_06), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_Airbag_06_CTRL" ,getValue(KCAN__STMSGT_Airbag_06_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGSD_Airbag_06" ,getValue(KCAN__STMSGSD_Airbag_06), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_Airbag_06" ,getValue(KCAN__STMSGCT_Airbag_06), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_Airbag_06_CTRL" ,getValue(KCAN__STMSGCT_Airbag_06_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_PO_Airbag_06" ,getValue(KCAN__STMSG_PO_Airbag_06), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLoadDefault_Airbag_06" ,getValue(KCAN__MSGDLoadDefault_Airbag_06), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSG_SendNow_Airbag_06" ,getValue(KCAN__MSG_SendNow_Airbag_06), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGID_Anhaenger_01" ,getValue(KCAN__MSGID_Anhaenger_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_Anhaenger_01" ,getValue(KCAN__MSGDLC_Anhaenger_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_Anhaenger_01_CTRL" ,getValue(KCAN__MSGDLC_Anhaenger_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__ALLDEF_Anhaenger_01" ,getValue(KCAN__ALLDEF_Anhaenger_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_Anhaenger_01" ,getValue(KCAN__STMSG_Anhaenger_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_Anhaenger_01" ,getValue(KCAN__STMSGT_Anhaenger_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_Anhaenger_01_CTRL" ,getValue(KCAN__STMSGT_Anhaenger_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGSD_Anhaenger_01" ,getValue(KCAN__STMSGSD_Anhaenger_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_Anhaenger_01" ,getValue(KCAN__STMSGCT_Anhaenger_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_Anhaenger_01_CTRL" ,getValue(KCAN__STMSGCT_Anhaenger_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_PO_Anhaenger_01" ,getValue(KCAN__STMSG_PO_Anhaenger_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLoadDefault_Anhaenger_01" ,getValue(KCAN__MSGDLoadDefault_Anhaenger_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSG_SendNow_Anhaenger_01" ,getValue(KCAN__MSG_SendNow_Anhaenger_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGID_ARA_Status_01" ,getValue(KCAN__MSGID_ARA_Status_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_ARA_Status_01" ,getValue(KCAN__MSGDLC_ARA_Status_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_ARA_Status_01_CTRL" ,getValue(KCAN__MSGDLC_ARA_Status_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__ALLDEF_ARA_Status_01" ,getValue(KCAN__ALLDEF_ARA_Status_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_ARA_Status_01" ,getValue(KCAN__STMSG_ARA_Status_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_ARA_Status_01" ,getValue(KCAN__STMSGT_ARA_Status_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_ARA_Status_01_CTRL" ,getValue(KCAN__STMSGT_ARA_Status_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGSD_ARA_Status_01" ,getValue(KCAN__STMSGSD_ARA_Status_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_ARA_Status_01" ,getValue(KCAN__STMSGCT_ARA_Status_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_ARA_Status_01_CTRL" ,getValue(KCAN__STMSGCT_ARA_Status_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_PO_ARA_Status_01" ,getValue(KCAN__STMSG_PO_ARA_Status_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLoadDefault_ARA_Status_01" ,getValue(KCAN__MSGDLoadDefault_ARA_Status_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSG_SendNow_ARA_Status_01" ,getValue(KCAN__MSG_SendNow_ARA_Status_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGID_ARC_HUD_Req_FD" ,getValue(KCAN__MSGID_ARC_HUD_Req_FD), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_ARC_HUD_Req_FD" ,getValue(KCAN__MSGDLC_ARC_HUD_Req_FD), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_ARC_HUD_Req_FD_CTRL" ,getValue(KCAN__MSGDLC_ARC_HUD_Req_FD_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__ALLDEF_ARC_HUD_Req_FD" ,getValue(KCAN__ALLDEF_ARC_HUD_Req_FD), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_ARC_HUD_Req_FD" ,getValue(KCAN__STMSG_ARC_HUD_Req_FD), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_ARC_HUD_Req_FD" ,getValue(KCAN__STMSGT_ARC_HUD_Req_FD), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_ARC_HUD_Req_FD_CTRL" ,getValue(KCAN__STMSGT_ARC_HUD_Req_FD_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGSD_ARC_HUD_Req_FD" ,getValue(KCAN__STMSGSD_ARC_HUD_Req_FD), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_ARC_HUD_Req_FD_CTRL" ,getValue(KCAN__STMSGCT_ARC_HUD_Req_FD_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_ARC_HUD_Req_FD_CTRL" ,getValue(KCAN__STMSGCT_ARC_HUD_Req_FD_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_PO_ARC_HUD_Req_FD" ,getValue(KCAN__STMSG_PO_ARC_HUD_Req_FD), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLoadDefault_ARC_HUD_Req_FD" ,getValue(KCAN__MSGDLoadDefault_ARC_HUD_Req_FD), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSG_SendNow_ARC_HUD_Req_FD" ,getValue(KCAN__MSG_SendNow_ARC_HUD_Req_FD), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGID_ARC_HUD_Resp_FD" ,getValue(KCAN__MSGID_ARC_HUD_Resp_FD), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_ARC_HUD_Resp_FD_CTRL" ,getValue(KCAN__MSGDLC_ARC_HUD_Resp_FD_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_ARC_HUD_Resp_FD_CTRL" ,getValue(KCAN__MSGDLC_ARC_HUD_Resp_FD_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__ALLDEF_ARC_HUD_Resp_FD" ,getValue(KCAN__ALLDEF_ARC_HUD_Resp_FD), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_ARC_HUD_Resp_FD" ,getValue(KCAN__STMSG_ARC_HUD_Resp_FD), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_ARC_HUD_Resp_FD_CTRL" ,getValue(KCAN__STMSGT_ARC_HUD_Resp_FD_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_ARC_HUD_Resp_FD_CTRL" ,getValue(KCAN__STMSGT_ARC_HUD_Resp_FD_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGSD_ARC_HUD_Resp_FD" ,getValue(KCAN__STMSGSD_ARC_HUD_Resp_FD), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_ARC_HUD_Resp_FD" ,getValue(KCAN__STMSGCT_ARC_HUD_Resp_FD), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_ARC_HUD_Resp_FD_CTRL" ,getValue(KCAN__STMSGCT_ARC_HUD_Resp_FD_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_PO_ARC_HUD_Resp_FD" ,getValue(KCAN__STMSG_PO_ARC_HUD_Resp_FD), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLoadDefault_ARC_HUD_Resp_FD" ,getValue(KCAN__MSGDLoadDefault_ARC_HUD_Resp_FD), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSG_SendNow_ARC_HUD_Resp_FD" ,getValue(KCAN__MSG_SendNow_ARC_HUD_Resp_FD), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGID_AWV_02" ,getValue(KCAN__MSGID_AWV_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_AWV_02" ,getValue(KCAN__MSGDLC_AWV_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_AWV_02_CTRL" ,getValue(KCAN__MSGDLC_AWV_02_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__ALLDEF_AWV_02" ,getValue(KCAN__ALLDEF_AWV_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_AWV_02" ,getValue(KCAN__STMSG_AWV_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_AWV_02" ,getValue(KCAN__STMSGT_AWV_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_AWV_02_CTRL" ,getValue(KCAN__STMSGT_AWV_02_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGSD_AWV_02" ,getValue(KCAN__STMSGSD_AWV_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_AWV_02" ,getValue(KCAN__STMSGCT_AWV_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_AWV_02_CTRL" ,getValue(KCAN__STMSGCT_AWV_02_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_PO_AWV_02" ,getValue(KCAN__STMSG_PO_AWV_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLoadDefault_AWV_02" ,getValue(KCAN__MSGDLoadDefault_AWV_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSG_SendNow_AWV_02" ,getValue(KCAN__MSG_SendNow_AWV_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGID_AZK_01" ,getValue(KCAN__MSGID_AZK_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_AZK_01" ,getValue(KCAN__MSGDLC_AZK_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_AZK_01_CTRL" ,getValue(KCAN__MSGDLC_AZK_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__ALLDEF_AZK_01" ,getValue(KCAN__ALLDEF_AZK_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_AZK_01" ,getValue(KCAN__STMSG_AZK_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_AZK_01" ,getValue(KCAN__STMSGT_AZK_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_AZK_01_CTRL" ,getValue(KCAN__STMSGT_AZK_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGSD_AZK_01" ,getValue(KCAN__STMSGSD_AZK_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_AZK_01" ,getValue(KCAN__STMSGCT_AZK_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_AZK_01_CTRL" ,getValue(KCAN__STMSGCT_AZK_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_PO_AZK_01" ,getValue(KCAN__STMSG_PO_AZK_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLoadDefault_AZK_01" ,getValue(KCAN__MSGDLoadDefault_AZK_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSG_SendNow_AZK_01" ,getValue(KCAN__MSG_SendNow_AZK_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGID_BCM_01" ,getValue(KCAN__MSGID_BCM_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_BCM_01" ,getValue(KCAN__MSGDLC_BCM_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_BCM_01_CTRL" ,getValue(KCAN__MSGDLC_BCM_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__ALLDEF_BCM_01" ,getValue(KCAN__ALLDEF_BCM_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_BCM_01" ,getValue(KCAN__STMSG_BCM_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_BCM_01" ,getValue(KCAN__STMSGT_BCM_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_BCM_01_CTRL" ,getValue(KCAN__STMSGT_BCM_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGSD_BCM_01" ,getValue(KCAN__STMSGSD_BCM_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_BCM_01" ,getValue(KCAN__STMSGCT_BCM_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_BCM_01_CTRL" ,getValue(KCAN__STMSGCT_BCM_01_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_PO_BCM_01" ,getValue(KCAN__STMSG_PO_BCM_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLoadDefault_BCM_01" ,getValue(KCAN__MSGDLoadDefault_BCM_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSG_SendNow_BCM_01" ,getValue(KCAN__MSG_SendNow_BCM_01), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGID_BCM_03" ,getValue(KCAN__MSGID_BCM_03), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_BCM_03" ,getValue(KCAN__MSGDLC_BCM_03), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_BCM_03_CTRL" ,getValue(KCAN__MSGDLC_BCM_03_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__ALLDEF_BCM_03" ,getValue(KCAN__ALLDEF_BCM_03), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_BCM_03" ,getValue(KCAN__STMSG_BCM_03), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_BCM_03" ,getValue(KCAN__STMSGT_BCM_03), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_BCM_03_CTRL" ,getValue(KCAN__STMSGT_BCM_03_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGSD_BCM_03" ,getValue(KCAN__STMSGSD_BCM_03), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_BCM_03" ,getValue(KCAN__STMSGCT_BCM_03), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_BCM_03_CTRL" ,getValue(KCAN__STMSGCT_BCM_03_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_PO_BCM_03" ,getValue(KCAN__STMSG_PO_BCM_03), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLoadDefault_BCM_03" ,getValue(KCAN__MSGDLoadDefault_BCM_03), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSG_SendNow_BCM_03" ,getValue(KCAN__MSG_SendNow_BCM_03), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGID_BCM_04" ,getValue(KCAN__MSGID_BCM_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_BCM_04" ,getValue(KCAN__MSGDLC_BCM_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_BCM_04_CTRL" ,getValue(KCAN__MSGDLC_BCM_04_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__ALLDEF_BCM_04" ,getValue(KCAN__ALLDEF_BCM_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_BCM_04" ,getValue(KCAN__STMSG_BCM_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_BCM_04" ,getValue(KCAN__STMSGT_BCM_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_BCM_04_CTRL" ,getValue(KCAN__STMSGT_BCM_04_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGSD_BCM_04" ,getValue(KCAN__STMSGSD_BCM_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_BCM_04" ,getValue(KCAN__STMSGCT_BCM_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_BCM_04_CTRL" ,getValue(KCAN__STMSGCT_BCM_04_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_PO_BCM_04" ,getValue(KCAN__STMSG_PO_BCM_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLoadDefault_BCM_04" ,getValue(KCAN__MSGDLoadDefault_BCM_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSG_SendNow_BCM_04" ,getValue(KCAN__MSG_SendNow_BCM_04), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGID_BCM_Taster_02" ,getValue(KCAN__MSGID_BCM_Taster_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_BCM_Taster_02" ,getValue(KCAN__MSGDLC_BCM_Taster_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_BCM_Taster_02_CTRL" ,getValue(KCAN__MSGDLC_BCM_Taster_02_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__ALLDEF_BCM_Taster_02" ,getValue(KCAN__ALLDEF_BCM_Taster_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_BCM_Taster_02" ,getValue(KCAN__STMSG_BCM_Taster_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_BCM_Taster_02" ,getValue(KCAN__STMSGT_BCM_Taster_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_BCM_Taster_02_CTRL" ,getValue(KCAN__STMSGT_BCM_Taster_02_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGSD_BCM_Taster_02" ,getValue(KCAN__STMSGSD_BCM_Taster_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_BCM_Taster_02" ,getValue(KCAN__STMSGCT_BCM_Taster_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGCT_BCM_Taster_02_CTRL" ,getValue(KCAN__STMSGCT_BCM_Taster_02_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_PO_BCM_Taster_02" ,getValue(KCAN__STMSG_PO_BCM_Taster_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLoadDefault_BCM_Taster_02" ,getValue(KCAN__MSGDLoadDefault_BCM_Taster_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSG_SendNow_BCM_Taster_02" ,getValue(KCAN__MSG_SendNow_BCM_Taster_02), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGID_BCM_Taster_03" ,getValue(KCAN__MSGID_BCM_Taster_03), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_BCM_Taster_03" ,getValue(KCAN__MSGDLC_BCM_Taster_03), profileFile);
    writeProfileInt("Settings" ,"KCAN__MSGDLC_BCM_Taster_03_CTRL" ,getValue(KCAN__MSGDLC_BCM_Taster_03_CTRL), profileFile);
    writeProfileInt("Settings" ,"KCAN__ALLDEF_BCM_Taster_03" ,getValue(KCAN__ALLDEF_BCM_Taster_03), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSG_BCM_Taster_03" ,getValue(KCAN__STMSG_BCM_Taster_03), profileFile);
    writeProfileInt("Settings" ,"KCAN__STMSGT_BCM_Taster_03" ,getValue(KCAN__STMSGT_BCM_Taster_03), profileFile);
