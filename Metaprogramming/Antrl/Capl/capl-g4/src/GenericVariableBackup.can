    writeProfileInt("Settings" ,"ENV_Write_SK1_Key_Data_1" ,getValue(ENV_Write_SK1_Key_Data_1), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_SK1_Key_Data_2" ,getValue(ENV_Write_SK1_Key_Data_2), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_SK1_Key_Data_3" ,getValue(ENV_Write_SK1_Key_Data_3), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_SK1_Key_Data_4" ,getValue(ENV_Write_SK1_Key_Data_4), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_SK1_Key_Data_5" ,getValue(ENV_Write_SK1_Key_Data_5), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_SK1_Key_Data_6" ,getValue(ENV_Write_SK1_Key_Data_6), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_SK1_Key_Data_7" ,getValue(ENV_Write_SK1_Key_Data_7), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_SK1_Key_Data_8" ,getValue(ENV_Write_SK1_Key_Data_8), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_SK1_Key_Data_9" ,getValue(ENV_Write_SK1_Key_Data_9), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_SK1_MUX" ,getValue(ENV_Write_SK1_MUX), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_UH_Jahr_0" ,getValue(ENV_Write_UH_Jahr_0), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_UH_Minute_0" ,getValue(ENV_Write_UH_Minute_0), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_UH_Monat_0" ,getValue(ENV_Write_UH_Monat_0), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_UH_Sekunde_0" ,getValue(ENV_Write_UH_Sekunde_0), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_UH_Stunde_0" ,getValue(ENV_Write_UH_Stunde_0), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_UH_Tag_0" ,getValue(ENV_Write_UH_Tag_0), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_VIN_01_MUX" ,getValue(ENV_Write_VIN_01_MUX), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_VIN_10" ,getValue(ENV_Write_VIN_10), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_VIN_11" ,getValue(ENV_Write_VIN_11), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_VIN_12" ,getValue(ENV_Write_VIN_12), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_VIN_13" ,getValue(ENV_Write_VIN_13), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_VIN_14" ,getValue(ENV_Write_VIN_14), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_VIN_15" ,getValue(ENV_Write_VIN_15), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_VIN_16" ,getValue(ENV_Write_VIN_16), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_VIN_17" ,getValue(ENV_Write_VIN_17), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_VIN_1" ,getValue(ENV_Write_VIN_1), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_VIN_2" ,getValue(ENV_Write_VIN_2), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_VIN_3" ,getValue(ENV_Write_VIN_3), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_VIN_4" ,getValue(ENV_Write_VIN_4), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_VIN_5" ,getValue(ENV_Write_VIN_5), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_VIN_6" ,getValue(ENV_Write_VIN_6), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_VIN_7" ,getValue(ENV_Write_VIN_7), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_VIN_8" ,getValue(ENV_Write_VIN_8), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_VIN_9" ,getValue(ENV_Write_VIN_9), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_Betrieb_Lesespule" ,getValue(ENV_Write_WFS_Betrieb_Lesespule), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_Challenge" ,getValue(ENV_Write_WFS_Challenge), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_ELV_authorisiert" ,getValue(ENV_Write_WFS_ELV_authorisiert), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_GoTrigger" ,getValue(ENV_Write_WFS_GoTrigger), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_ID_Geb_autorisiert_in_Kl15" ,getValue(ENV_Write_WFS_ID_Geb_autorisiert_in_Kl15), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_IMMO_ELV_CRC" ,getValue(ENV_Write_WFS_IMMO_ELV_CRC), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_IMMO_ELV_Status" ,getValue(ENV_Write_WFS_IMMO_ELV_Status), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_IMMO_GSG_CRC" ,getValue(ENV_Write_WFS_IMMO_GSG_CRC), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_IMMO_GSG_Status" ,getValue(ENV_Write_WFS_IMMO_GSG_Status), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_IMMO_MSG1_CRC" ,getValue(ENV_Write_WFS_IMMO_MSG1_CRC), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_IMMO_MSG1_Status" ,getValue(ENV_Write_WFS_IMMO_MSG1_Status), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_IMMO_MSG2_CRC" ,getValue(ENV_Write_WFS_IMMO_MSG2_CRC), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_IMMO_MSG2_Status" ,getValue(ENV_Write_WFS_IMMO_MSG2_Status), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_IMMO_MSG3_CRC" ,getValue(ENV_Write_WFS_IMMO_MSG3_CRC), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_IMMO_MSG3_Status" ,getValue(ENV_Write_WFS_IMMO_MSG3_Status), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_IMMO_MSG4_CRC" ,getValue(ENV_Write_WFS_IMMO_MSG4_CRC), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_IMMO_MSG4_Status" ,getValue(ENV_Write_WFS_IMMO_MSG4_Status), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_Kombi_Resp_Data" ,getValue(ENV_Write_WFS_Kombi_Resp_Data), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_Nr_ID_Geber" ,getValue(ENV_Write_WFS_Nr_ID_Geber), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_Schluessel_Fahrberecht" ,getValue(ENV_Write_WFS_Schluessel_Fahrberecht), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_Trigger_TranspID" ,getValue(ENV_Write_WFS_Trigger_TranspID), profileFile);
    writeProfileInt("Settings" ,"ENV_Write_WFS_Zufallszahl" ,getValue(ENV_Write_WFS_Zufallszahl), profileFile);
    writeProfileInt("Settings" ,"ON_OFF_BAP_LoadSave_INI" ,getValue(ON_OFF_BAP_LoadSave_INI), profileFile);
    writeProfileInt("Settings" ,"ON_OFF_BAP_Main" ,getValue(ON_OFF_BAP_Main), profileFile);
    writeProfileInt("Settings" ,"ENV_PERF_CarModel" ,getValue(ENV_PERF_CarModel), profileFile);
    writeProfileInt("Settings" ,"ENV_PERF_Logging" ,getValue(ENV_PERF_Logging), profileFile);
    writeProfileInt("Settings" ,"ENV_PERF_ScenarioTableBox" ,getValue(ENV_PERF_ScenarioTableBox), profileFile);
    writeProfileInt("Settings" ,"ENV_PERF_BasicLoadSwitch" ,getValue(ENV_PERF_BasicLoadSwitch), profileFile);
    writeProfileInt("Settings" ,"ENV_PERF_DimmingSweepSwitch" ,getValue(ENV_PERF_DimmingSweepSwitch), profileFile);
    writeProfileInt("Settings" ,"ENV_PERF_TankKmtSwitch" ,getValue(ENV_PERF_TankKmtSwitch), profileFile);
    writeProfileInt("Settings" ,"ENV_PERF_TurnLightsSwitch" ,getValue(ENV_PERF_TurnLightsSwitch), profileFile);
    writeProfileInt("Settings" ,"ENV_PERF_RadioListSwitch" ,getValue(ENV_PERF_RadioListSwitch), profileFile);
    writeProfileInt("Settings" ,"ENV_PERF_PointerSweepSwitch" ,getValue(ENV_PERF_PointerSweepSwitch), profileFile);
    writeProfileInt("Settings" ,"ENV_PERF_StartSwitch" ,getValue(ENV_PERF_StartSwitch), profileFile);
    writeProfileInt("Settings" ,"ENV_NGSM_Support" ,getValue(ENV_NGSM_Support), profileFile);
    writeProfileInt("Settings" ,"ENV_NGSM_OnStopEnable" ,getValue(ENV_NGSM_OnStopEnable), profileFile);
    writeProfileInt("Settings" ,"ENV_NGSM_OnStartEnable" ,getValue(ENV_NGSM_OnStartEnable), profileFile);
    writeProfileFloat("Settings" ,"ENV_NGSM_ActualVoltageDisplay" ,getValue(ENV_NGSM_ActualVoltageDisplay), profileFile);
    writeProfileInt("Settings" ,"ENV_NGSM_OutputState" ,getValue(ENV_NGSM_OutputState), profileFile);
    writeProfileInt("Settings" ,"ENV_NGSM_PowerSupplyState" ,getValue(ENV_NGSM_PowerSupplyState), profileFile);
    writeProfileFloat("Settings" ,"ENV_NGSM_VoltageDisplay" ,getValue(ENV_NGSM_VoltageDisplay), profileFile);
    writeProfileInt("Settings" ,"ENV_NGSM_MaxCurrent" ,getValue(ENV_NGSM_MaxCurrent), profileFile);
    writeProfileInt("Settings" ,"ENV_NGSM_SetCurveSelector" ,getValue(ENV_NGSM_SetCurveSelector), profileFile);
    writeProfileInt("Settings" ,"ENV_NGSM_OutputControl" ,getValue(ENV_NGSM_OutputControl), profileFile);
    writeProfileFloat("Settings" ,"ENV_NGSM_ActualCurrentDisplay" ,getValue(ENV_NGSM_ActualCurrentDisplay), profileFile);
    writeProfileFloat("Settings" ,"ENV_NGSM_VoltageSliderControl" ,getValue(ENV_NGSM_VoltageSliderControl), profileFile);
    writeProfileInt("Settings" ,"ENV_NGSM_PowerSwitch" ,getValue(ENV_NGSM_PowerSwitch), profileFile);
    writeProfileInt("Settings" ,"ENV_NGSM_CurveRetry" ,getValue(ENV_NGSM_CurveRetry), profileFile);
    writeProfileInt("Settings" ,"ENV_INTEGR_DisVoltageCurves" ,getValue(ENV_INTEGR_DisVoltageCurves), profileFile);
    writeProfileInt("Settings" ,"ENV_INTEGR_Logging" ,getValue(ENV_INTEGR_Logging), profileFile);
    writeProfileInt("Settings" ,"ENV_INTEGR_TimerResetControl" ,getValue(ENV_INTEGR_TimerResetControl), profileFile);
    writeProfileInt("Settings" ,"ENV_INTEGR_TestCase" ,getValue(ENV_INTEGR_TestCase), profileFile);
    writeProfileInt("Settings" ,"ENV_INTEGR_TestMode" ,getValue(ENV_INTEGR_TestMode), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SI_BUS_01" ,getValue(HIL_b_SI_BUS_01), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SI_BUS_02" ,getValue(HIL_b_SI_BUS_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SI_BUS_03" ,getValue(HIL_b_SI_BUS_03), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SI_BUS_04" ,getValue(HIL_b_SI_BUS_04), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SI_BUS_06" ,getValue(HIL_b_SI_BUS_06), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SI_BUS_10" ,getValue(HIL_b_SI_BUS_10), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SI_BUS_14" ,getValue(HIL_b_SI_BUS_14), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ara_DLC_fehler" ,getValue(HIL_s_ara_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ara_falsch_codiert" ,getValue(HIL_s_ara_falsch_codiert), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ara_timeout_fehler" ,getValue(HIL_s_ara_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bcm1_DLC_fehler" ,getValue(HIL_s_bcm1_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bcm1_timeout" ,getValue(HIL_s_bcm1_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bcm1_timeout_fehler" ,getValue(HIL_s_bcm1_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_daempfer_DLC_fehler" ,getValue(HIL_s_daempfer_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_daempfer_falsch_codiert" ,getValue(HIL_s_daempfer_falsch_codiert), profileFile);
    writeProfileInt("Settings" ,"HIL_s_daempfer_timeout" ,getValue(HIL_s_daempfer_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_daempfer_timeout_fehler" ,getValue(HIL_s_daempfer_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_DCDC_02_DLC_fehler" ,getValue(HIL_s_DCDC_02_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_DCDC_02_timeout" ,getValue(HIL_s_DCDC_02_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_DCDC_02_timeout_fehler" ,getValue(HIL_s_DCDC_02_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_eCall_timeout_fehler" ,getValue(HIL_s_eCall_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_elv_DLC_fehler" ,getValue(HIL_s_elv_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_elv_falsch_codiert" ,getValue(HIL_s_elv_falsch_codiert), profileFile);
    writeProfileInt("Settings" ,"HIL_s_elv_timeout" ,getValue(HIL_s_elv_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_elv_timeout_fehler" ,getValue(HIL_s_elv_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_epb_falsch_codiert" ,getValue(HIL_s_epb_falsch_codiert), profileFile);
    writeProfileInt("Settings" ,"HIL_s_EPS_01_fifo_safe_state" ,getValue(HIL_s_EPS_01_fifo_safe_state), profileFile);
    writeProfileInt("Settings" ,"HIL_s_eps_falsch_codiert" ,getValue(HIL_s_eps_falsch_codiert), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ESP_24_fifo_safe_state" ,getValue(HIL_s_ESP_24_fifo_safe_state), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gateway_DLC_fehler" ,getValue(HIL_s_gateway_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gateway_timeout" ,getValue(HIL_s_gateway_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gateway_timeout_fehler" ,getValue(HIL_s_gateway_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_HVLM_05_timeout" ,getValue(HIL_s_HVLM_05_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_kessy_timeout" ,getValue(HIL_s_kessy_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KFG_DLC_fehler" ,getValue(HIL_s_KFG_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KFG_timeout" ,getValue(HIL_s_KFG_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KFG_timeout_fehler" ,getValue(HIL_s_KFG_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Klima_12_timeout" ,getValue(HIL_s_Klima_12_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ldw_DLC_fehler" ,getValue(HIL_s_ldw_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ldw_timeout" ,getValue(HIL_s_ldw_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ldw_timeout_fehler" ,getValue(HIL_s_ldw_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_mainunit_DLC_fehler" ,getValue(HIL_s_mainunit_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_mainunit_timeout" ,getValue(HIL_s_mainunit_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_mainunit_timeout_fehler" ,getValue(HIL_s_mainunit_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_mem_bfs_timeout" ,getValue(HIL_s_mem_bfs_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_mem_fs_timeout" ,getValue(HIL_s_mem_fs_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_motor_DLC_fehler" ,getValue(HIL_s_motor_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_motor_timeout" ,getValue(HIL_s_motor_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_motor_timeout_fehler" ,getValue(HIL_s_motor_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_MVK_01_CRC_fehler2" ,getValue(HIL_s_MVK_01_CRC_fehler2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_MVK_01_fifo_bz_fehler" ,getValue(HIL_s_MVK_01_fifo_bz_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_MVK_01_fifo_safe_state" ,getValue(HIL_s_MVK_01_fifo_safe_state), profileFile);
    writeProfileInt("Settings" ,"HIL_s_MVK_01_fifo_to_fehler" ,getValue(HIL_s_MVK_01_fifo_to_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ocu_timeout" ,getValue(HIL_s_ocu_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_perso_DLC_fehler" ,getValue(HIL_s_perso_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_perso_timeout" ,getValue(HIL_s_perso_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_perso_timeout_fehler" ,getValue(HIL_s_perso_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_pla_DLC_fehler" ,getValue(HIL_s_pla_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_pla_timeout" ,getValue(HIL_s_pla_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_pla_timeout_fehler" ,getValue(HIL_s_pla_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_TSL_timeout" ,getValue(HIL_s_TSL_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_TSR_timeout" ,getValue(HIL_s_TSR_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_acc_DLC_fehler" ,getValue(HIL_s_acc_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_acc_timeout" ,getValue(HIL_s_acc_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_acc_timeout_fehler" ,getValue(HIL_s_acc_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_afs_DLC_fehler" ,getValue(HIL_s_afs_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_afs_timeout" ,getValue(HIL_s_afs_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_afs_timeout_fehler" ,getValue(HIL_s_afs_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_aga_DLC_fehler" ,getValue(HIL_s_aga_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_aga_timeout" ,getValue(HIL_s_aga_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_aga_timeout_fehler" ,getValue(HIL_s_aga_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Airbag_01_DLC_fehler" ,getValue(HIL_s_Airbag_01_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Airbag_01_fifo_safe_state" ,getValue(HIL_s_Airbag_01_fifo_safe_state), profileFile);
    writeProfileInt("Settings" ,"HIL_s_anhaenger_timeout" ,getValue(HIL_s_anhaenger_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ara_timeout" ,getValue(HIL_s_ara_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_awv_DLC_fehler" ,getValue(HIL_s_awv_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_awv_timeout" ,getValue(HIL_s_awv_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_awv_timeout_fehler" ,getValue(HIL_s_awv_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_BEM_06_CRC_fehler2" ,getValue(HIL_s_BEM_06_CRC_fehler2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_BEM_06_fifo_safe_state" ,getValue(HIL_s_BEM_06_fifo_safe_state), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bus_off_fehler" ,getValue(HIL_s_bus_off_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_can_ram_check_fehler" ,getValue(HIL_s_can_ram_check_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_feststellbremse_konv" ,getValue(HIL_s_feststellbremse_konv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_rdk_DLC_fehler" ,getValue(HIL_s_rdk_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_rdk_falsch_codiert" ,getValue(HIL_s_rdk_falsch_codiert), profileFile);
    writeProfileInt("Settings" ,"HIL_s_rdk_timeout" ,getValue(HIL_s_rdk_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_rdk_timeout_fehler" ,getValue(HIL_s_rdk_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_rka_DLC_fehler" ,getValue(HIL_s_rka_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_rka_falsch_codiert" ,getValue(HIL_s_rka_falsch_codiert), profileFile);
    writeProfileInt("Settings" ,"HIL_s_rka_timeout" ,getValue(HIL_s_rka_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_rka_timeout_fehler" ,getValue(HIL_s_rka_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_SCR_timeout" ,getValue(HIL_s_SCR_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_SMLS_01_timeout" ,getValue(HIL_s_SMLS_01_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_STH_01_timeout" ,getValue(HIL_s_STH_01_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_swa_DLC_fehler" ,getValue(HIL_s_swa_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_swa_falsch_codiert" ,getValue(HIL_s_swa_falsch_codiert), profileFile);
    writeProfileInt("Settings" ,"HIL_s_swa_timeout" ,getValue(HIL_s_swa_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_swa_timeout_fehler" ,getValue(HIL_s_swa_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_TCO_01_DLC_fehler" ,getValue(HIL_s_TCO_01_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_TCO_01_timeout" ,getValue(HIL_s_TCO_01_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_TCO_01_timeout_fehler" ,getValue(HIL_s_TCO_01_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_verdeck_01_timeout" ,getValue(HIL_s_verdeck_01_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Wischer_timeout" ,getValue(HIL_s_Wischer_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SI_CAB_V09" ,getValue(HIL_b_SI_CAB_V09), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Airbag_01_CRC_fehler2" ,getValue(HIL_s_Airbag_01_CRC_fehler2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Airbag_01_fifo_bz_fehler" ,getValue(HIL_s_Airbag_01_fifo_bz_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Airbag_01_fifo_to_fehler" ,getValue(HIL_s_Airbag_01_fifo_to_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_BEM_06_fifo_bz_fehler" ,getValue(HIL_s_BEM_06_fifo_bz_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_BEM_06_fifo_to_fehler" ,getValue(HIL_s_BEM_06_fifo_to_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_BMS_DLC_fehler" ,getValue(HIL_s_BMS_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_BMS_timeout" ,getValue(HIL_s_BMS_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_BMS_timeout_fehler" ,getValue(HIL_s_BMS_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_EPB_03_CRC_fehler2" ,getValue(HIL_s_EPB_03_CRC_fehler2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_EPB_03_fifo_bz_fehler" ,getValue(HIL_s_EPB_03_fifo_bz_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_EPB_03_fifo_to_fehler" ,getValue(HIL_s_EPB_03_fifo_to_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_EPS_01_CRC_fehler2" ,getValue(HIL_s_EPS_01_CRC_fehler2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_EPS_01_fifo_bz_fehler" ,getValue(HIL_s_EPS_01_fifo_bz_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_EPS_01_fifo_to_fehler" ,getValue(HIL_s_EPS_01_fifo_to_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ESP_24_CRC_fehler2" ,getValue(HIL_s_ESP_24_CRC_fehler2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ESP_24_fifo_bz_fehler" ,getValue(HIL_s_ESP_24_fifo_bz_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ESP_24_fifo_to_fehler" ,getValue(HIL_s_ESP_24_fifo_to_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ESP_30_CRC_fehler2" ,getValue(HIL_s_ESP_30_CRC_fehler2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ESP_30_fifo_bz_fehler" ,getValue(HIL_s_ESP_30_fifo_bz_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ESP_30_fifo_safe_state" ,getValue(HIL_s_ESP_30_fifo_safe_state), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ESP_30_fifo_to_fehler" ,getValue(HIL_s_ESP_30_fifo_to_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LSH_timeout" ,getValue(HIL_s_LSH_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_TSG_FT_DLC_fehler" ,getValue(HIL_s_TSG_FT_DLC_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_TSG_FT_timeout" ,getValue(HIL_s_TSG_FT_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_TSG_FT_timeout_fehler" ,getValue(HIL_s_TSG_FT_timeout_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_WBA_03_CRC_fehler2" ,getValue(HIL_s_WBA_03_CRC_fehler2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_WBA_03_fifo_bz_fehler" ,getValue(HIL_s_WBA_03_fifo_bz_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_WBA_03_fifo_safe_state" ,getValue(HIL_s_WBA_03_fifo_safe_state), profileFile);
    writeProfileInt("Settings" ,"HIL_s_WBA_03_fifo_to_fehler" ,getValue(HIL_s_WBA_03_fifo_to_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_Anf_AAW_MoLaWa" ,getValue(HIL_b_BCM_Anf_AAW_MoLaWa), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_anf_VLW" ,getValue(HIL_b_BCM_anf_VLW), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_Handbremse_Hinweis" ,getValue(HIL_b_BCM_Handbremse_Hinweis), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_Remotestart_KL15_Anf" ,getValue(HIL_b_BCM_Remotestart_KL15_Anf), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_Waehlhebel_P_Hinweis" ,getValue(HIL_b_BCM_Waehlhebel_P_Hinweis), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ELV_LED_Rot" ,getValue(HIL_b_ELV_LED_Rot), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ELV_Txt_Defekt" ,getValue(HIL_b_ELV_Txt_Defekt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ELV_Txt_Lkg_Bewegen" ,getValue(HIL_b_ELV_Txt_Lkg_Bewegen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ELV_Txt_Werkstatt" ,getValue(HIL_b_ELV_Txt_Werkstatt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_FBS_Warn_Schluessel_Batt" ,getValue(HIL_b_FBS_Warn_Schluessel_Batt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_GE_Tipschaltempfehlung_verfuegbar" ,getValue(HIL_b_GE_Tipschaltempfehlung_verfuegbar), profileFile);
    writeProfileInt("Settings" ,"HIL_b_KL_Geblaese_Status" ,getValue(HIL_b_KL_Geblaese_Status), profileFile);
    writeProfileInt("Settings" ,"HIL_b_KST_Fahrerhinweis_6" ,getValue(HIL_b_KST_Fahrerhinweis_6), profileFile);
    writeProfileInt("Settings" ,"HIL_b_KST_Txt_Komfortabschaltung" ,getValue(HIL_b_KST_Txt_Komfortabschaltung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_KST_Txt_P_Gang" ,getValue(HIL_b_KST_Txt_P_Gang), profileFile);
    writeProfileInt("Settings" ,"HIL_b_KST_Txt_Panikabschaltung" ,getValue(HIL_b_KST_Txt_Panikabschaltung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_KST_Txt_Werkstatt" ,getValue(HIL_b_KST_Txt_Werkstatt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_KST_Warn_P2_ZST_def" ,getValue(HIL_b_KST_Warn_P2_ZST_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_KST_Zuendungswarnung" ,getValue(HIL_b_KST_Zuendungswarnung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RSt_Fahrerhinweise" ,getValue(HIL_b_RSt_Fahrerhinweise), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ZV_SafeFunktion_aktiv" ,getValue(HIL_b_ZV_SafeFunktion_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_wba_fahrstufe_anzeigen" ,getValue(HIL_hmi_wba_fahrstufe_anzeigen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_kanal1_belegt" ,getValue(HIL_s_kanal1_belegt), profileFile);
    writeProfileInt("Settings" ,"HIL_s_kanal2_belegt" ,getValue(HIL_s_kanal2_belegt), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Audioabsenkung_MIB" ,getValue(HIL_s_KBI_Audioabsenkung_MIB), profileFile);
    writeProfileInt("Settings" ,"HIL_s_schluesselwarnung" ,getValue(HIL_s_schluesselwarnung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_zpm_akustik_grundlautstaerke" ,getValue(HIL_s_zpm_akustik_grundlautstaerke), profileFile);
    writeProfileInt("Settings" ,"HIL_s_zpm_akustik_ID" ,getValue(HIL_s_zpm_akustik_ID), profileFile);
    writeProfileInt("Settings" ,"HIL_s_zpm_akustik_kennfeld_ID" ,getValue(HIL_s_zpm_akustik_kennfeld_ID), profileFile);
    writeProfileInt("Settings" ,"HIL_s_zpm_akustik_sync" ,getValue(HIL_s_zpm_akustik_sync), profileFile);
    writeProfileInt("Settings" ,"HIL_b_GE_Sollgang" ,getValue(HIL_b_GE_Sollgang), profileFile);
    writeProfileInt("Settings" ,"HIL_b_GE_Sumpftemperatur" ,getValue(HIL_b_GE_Sumpftemperatur), profileFile);
    writeProfileInt("Settings" ,"HIL_b_Getriebe_14_alt" ,getValue(HIL_b_Getriebe_14_alt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Antriebsstrang_Warnung_HS" ,getValue(HIL_b_MO_Antriebsstrang_Warnung_HS), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_WH_Texte" ,getValue(HIL_b_MO_WH_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WBA_Anforderung_Akustik" ,getValue(HIL_b_WBA_Anforderung_Akustik), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WBA_eing_Gang_02" ,getValue(HIL_b_WBA_eing_Gang_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WBA_Fahrstufe_02" ,getValue(HIL_b_WBA_Fahrstufe_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WBA_GE_Texte" ,getValue(HIL_b_WBA_GE_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WBA_GE_Texte_02" ,getValue(HIL_b_WBA_GE_Texte_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WBA_GE_Warnung_02" ,getValue(HIL_b_WBA_GE_Warnung_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WBA_GE_Zusatzwarnungen" ,getValue(HIL_b_WBA_GE_Zusatzwarnungen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WBA_Schaltschema_02" ,getValue(HIL_b_WBA_Schaltschema_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WBA_Schaltschema_Fahreraktion" ,getValue(HIL_b_WBA_Schaltschema_Fahreraktion), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WBA_Schaltschema_FS_inaktiv" ,getValue(HIL_b_WBA_Schaltschema_FS_inaktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WBA_Schaltschema_FS_vorwaerts" ,getValue(HIL_b_WBA_Schaltschema_FS_vorwaerts), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WBA_Schaltschema_Tippgasse" ,getValue(HIL_b_WBA_Schaltschema_Tippgasse), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WBA_Segeln_aktiv" ,getValue(HIL_b_WBA_Segeln_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WBA_Shiftlock_Lampe" ,getValue(HIL_b_WBA_Shiftlock_Lampe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WH_Verbau_Entsperrtaste" ,getValue(HIL_b_WH_Verbau_Entsperrtaste), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WH_Warnung_02" ,getValue(HIL_b_WH_Warnung_02), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_getriebetemperatur_anzeigen" ,getValue(HIL_hmi_bc_getriebetemperatur_anzeigen), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_Tipschaltempfehlung_anzeigen" ,getValue(HIL_hmi_Tipschaltempfehlung_anzeigen), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_wba_eingelegter_gang_anzeigen" ,getValue(HIL_hmi_wba_eingelegter_gang_anzeigen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Shiftlock" ,getValue(HIL_s_LED_Shiftlock), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_Uhrzeit_Format" ,getValue(HIL_hmi_Uhrzeit_Format), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_laptimer_aktuelle_rundenzeit" ,getValue(HIL_s_laptimer_aktuelle_rundenzeit), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_laptimer_gesamtzeit" ,getValue(HIL_s_laptimer_gesamtzeit), profileFile);
    writeProfileInt("Settings" ,"HIL_s_manuell_zeit_uhrzeit_minute" ,getValue(HIL_s_manuell_zeit_uhrzeit_minute), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Zeit_Uhrzeit_Minute" ,getValue(HIL_s_Zeit_Uhrzeit_Minute), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Zeit_Uhrzeit_Sekunde" ,getValue(HIL_s_Zeit_Uhrzeit_Sekunde), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_Uhrzeit_Minute" ,getValue(HIL_hmi_Uhrzeit_Minute), profileFile);
    writeProfileInt("Settings" ,"HIL_s_laptimer_abbruch" ,getValue(HIL_s_laptimer_abbruch), profileFile);
    writeProfileInt("Settings" ,"HIL_s_laptimer_loeschen" ,getValue(HIL_s_laptimer_loeschen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_laptimer_pause" ,getValue(HIL_s_laptimer_pause), profileFile);
    writeProfileInt("Settings" ,"HIL_s_laptimer_rundenzahl" ,getValue(HIL_s_laptimer_rundenzahl), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_laptimer_schnellste_rundenzeit" ,getValue(HIL_s_laptimer_schnellste_rundenzeit), profileFile);
    writeProfileInt("Settings" ,"HIL_s_laptimer_start" ,getValue(HIL_s_laptimer_start), profileFile);
    writeProfileInt("Settings" ,"HIL_s_laptimer_stop" ,getValue(HIL_s_laptimer_stop), profileFile);
    writeProfileInt("Settings" ,"HIL_s_laptimer_zwischen" ,getValue(HIL_s_laptimer_zwischen), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_laptimer_zwischenzeit" ,getValue(HIL_s_laptimer_zwischenzeit), profileFile);
    writeProfileInt("Settings" ,"HIL_s_manuell_zeit_set" ,getValue(HIL_s_manuell_zeit_set), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_Datum_Wochentag" ,getValue(HIL_hmi_Datum_Wochentag), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_Uhrzeit_Stunde" ,getValue(HIL_hmi_Uhrzeit_Stunde), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_laptimer_durchschnitt_rundenzeit" ,getValue(HIL_s_laptimer_durchschnitt_rundenzeit), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_laptimer_langsamste_rundenzeit" ,getValue(HIL_s_laptimer_langsamste_rundenzeit), profileFile);
    writeProfileInt("Settings" ,"HIL_s_manuell_zeit_uhrzeit_stunde" ,getValue(HIL_s_manuell_zeit_uhrzeit_stunde), profileFile);
    writeProfileInt("Settings" ,"HIL_s_symbol_uhrzeitquelle" ,getValue(HIL_s_symbol_uhrzeitquelle), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Zeit_Uhrzeit_Stunde" ,getValue(HIL_s_Zeit_Uhrzeit_Stunde), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_symbol_uhrzeitquelle" ,getValue(HIL_hmi_symbol_uhrzeitquelle), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_uhrzeit_blinktakt" ,getValue(HIL_hmi_uhrzeit_blinktakt), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_uhrzeit_verstellmodus_minuten_anzeigen" ,getValue(HIL_hmi_uhrzeit_verstellmodus_minuten_anzeigen), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_uhrzeit_verstellmodus_stunden_anzeigen" ,getValue(HIL_hmi_uhrzeit_verstellmodus_stunden_anzeigen), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_betriebszeit" ,getValue(HIL_s_betriebszeit), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Gueltigkeit_Synchzeit" ,getValue(HIL_s_Gueltigkeit_Synchzeit), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Einheit_Uhrzeit" ,getValue(HIL_s_KBI_Einheit_Uhrzeit), profileFile);
    writeProfileInt("Settings" ,"HIL_s_laptimer_abStart_wartet" ,getValue(HIL_s_laptimer_abStart_wartet), profileFile);
    writeProfileInt("Settings" ,"HIL_s_manuell_datum_set" ,getValue(HIL_s_manuell_datum_set), profileFile);
    writeProfileInt("Settings" ,"HIL_s_UH_Jahr" ,getValue(HIL_s_UH_Jahr), profileFile);
    writeProfileInt("Settings" ,"HIL_s_UH_Monat" ,getValue(HIL_s_UH_Monat), profileFile);
    writeProfileInt("Settings" ,"HIL_s_UH_Sekunde" ,getValue(HIL_s_UH_Sekunde), profileFile);
    writeProfileInt("Settings" ,"HIL_s_UH_Tag" ,getValue(HIL_s_UH_Tag), profileFile);
    writeProfileInt("Settings" ,"HIL_s_AuthTime_Trigger_Distribution" ,getValue(HIL_s_AuthTime_Trigger_Distribution), profileFile);
    writeProfileInt("Settings" ,"HIL_s_laptimer_runde" ,getValue(HIL_s_laptimer_runde), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_laptimer_rundenzeiten_n_" ,getValue(HIL_s_laptimer_rundenzeiten_n_), profileFile);
    writeProfileInt("Settings" ,"HIL_s_laptimer_zustand" ,getValue(HIL_s_laptimer_zustand), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Motor_gelaufen" ,getValue(HIL_s_Motor_gelaufen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_UH_Minute" ,getValue(HIL_s_UH_Minute), profileFile);
    writeProfileInt("Settings" ,"HIL_s_UH_Stunde" ,getValue(HIL_s_UH_Stunde), profileFile);
    writeProfileInt("Settings" ,"HIL_s_UH_Typ" ,getValue(HIL_s_UH_Typ), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Zeit_Datum_Jahr" ,getValue(HIL_s_Zeit_Datum_Jahr), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Zeit_Datum_Monat" ,getValue(HIL_s_Zeit_Datum_Monat), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Zeit_Datum_Tag" ,getValue(HIL_s_Zeit_Datum_Tag), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AFS_Fehlertext" ,getValue(HIL_b_AFS_Fehlertext), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AFS_Lampe" ,getValue(HIL_b_AFS_Lampe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AFS_LED_Blinkmode" ,getValue(HIL_b_AFS_LED_Blinkmode), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM1_Fahrlicht_Hinweis" ,getValue(HIL_b_BCM1_Fahrlicht_Hinweis), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM1_Hinweis_Lichtnachlauf" ,getValue(HIL_b_BCM1_Hinweis_Lichtnachlauf), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM1_Lichtwarn_Texte" ,getValue(HIL_b_BCM1_Lichtwarn_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_LTM_Allwetterl_Status" ,getValue(HIL_b_BCM_LTM_Allwetterl_Status), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_LTM_Nebell_Status" ,getValue(HIL_b_BCM_LTM_Nebell_Status), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_LTM_Nebelschluss_Status" ,getValue(HIL_b_BCM_LTM_Nebelschluss_Status), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_LTM_PopUp_Anf" ,getValue(HIL_b_BCM_LTM_PopUp_Anf), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_LTM_PopUp_Inhalt" ,getValue(HIL_b_BCM_LTM_PopUp_Inhalt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_LTM_PopUp_Status" ,getValue(HIL_b_BCM_LTM_PopUp_Status), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_Rueckfahrlicht_Anf" ,getValue(HIL_b_BCM_Rueckfahrlicht_Anf), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BM_Warnblinken" ,getValue(HIL_b_BM_Warnblinken), profileFile);
    writeProfileInt("Settings" ,"HIL_b_Gong_TFL_Umschaltung" ,getValue(HIL_b_Gong_TFL_Umschaltung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Aussenlicht_def" ,getValue(HIL_b_LH_Aussenlicht_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Abblendlicht_Anzeige" ,getValue(HIL_b_LV_Abblendlicht_Anzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_AFL_defekt" ,getValue(HIL_b_LV_AFL_defekt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Aussenlicht_def" ,getValue(HIL_b_LV_Aussenlicht_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Fernlicht_Anzeige" ,getValue(HIL_b_LV_Fernlicht_Anzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_FLA_aktiv_Anzeige" ,getValue(HIL_b_LV_FLA_aktiv_Anzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_FLA_defekt" ,getValue(HIL_b_LV_FLA_defekt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_FLA_Sensor_blockiert" ,getValue(HIL_b_LV_FLA_Sensor_blockiert), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Nebellicht_Anzeige" ,getValue(HIL_b_LV_Nebellicht_Anzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Nebelschlusslicht_Anzeige" ,getValue(HIL_b_LV_Nebelschlusslicht_Anzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LWR_Lampe" ,getValue(HIL_b_LWR_Lampe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LWR_Reisemodus_Texte" ,getValue(HIL_b_LWR_Reisemodus_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Abblendlicht" ,getValue(HIL_s_LED_Abblendlicht), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Fernlicht" ,getValue(HIL_s_LED_Fernlicht), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_FLA" ,getValue(HIL_s_LED_FLA), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Nebellicht" ,getValue(HIL_s_LED_Nebellicht), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Nebelschlusslicht" ,getValue(HIL_s_LED_Nebelschlusslicht), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Standlicht" ,getValue(HIL_s_LED_Standlicht), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AAG_Blinker_H_aktiv" ,getValue(HIL_b_AAG_Blinker_H_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AAG_Blinker_HL_def" ,getValue(HIL_b_AAG_Blinker_HL_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AAG_Blinker_HR_def" ,getValue(HIL_b_AAG_Blinker_HR_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AAG_Bremslicht_H_def" ,getValue(HIL_b_AAG_Bremslicht_H_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AAG_Schlusslicht_HL_def" ,getValue(HIL_b_AAG_Schlusslicht_HL_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AAG_Schlusslicht_HR_def" ,getValue(HIL_b_AAG_Schlusslicht_HR_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_Blinken_li_Kombi_Takt" ,getValue(HIL_b_Blinken_li_Kombi_Takt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_Blinken_re_Kombi_Takt" ,getValue(HIL_b_Blinken_re_Kombi_Takt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_3_Bremsl_def" ,getValue(HIL_b_LH_3_Bremsl_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Blinker_li_def" ,getValue(HIL_b_LH_Blinker_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Blinker_re_def" ,getValue(HIL_b_LH_Blinker_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Brems_Blk_li_def" ,getValue(HIL_b_LH_Brems_Blk_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Brems_Blk_re_def" ,getValue(HIL_b_LH_Brems_Blk_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Bremsl_li_def" ,getValue(HIL_b_LH_Bremsl_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Bremsl_li_ges_def" ,getValue(HIL_b_LH_Bremsl_li_ges_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Bremsl_re_def" ,getValue(HIL_b_LH_Bremsl_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Bremsl_re_ges_def" ,getValue(HIL_b_LH_Bremsl_re_ges_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Kennzl_def" ,getValue(HIL_b_LH_Kennzl_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Nebel_li_def" ,getValue(HIL_b_LH_Nebel_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Nebel_mi_def" ,getValue(HIL_b_LH_Nebel_mi_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Nebel_re_def" ,getValue(HIL_b_LH_Nebel_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Rueckf_li_def" ,getValue(HIL_b_LH_Rueckf_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Rueckf_mi_def" ,getValue(HIL_b_LH_Rueckf_mi_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Rueckf_re_def" ,getValue(HIL_b_LH_Rueckf_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Schluss_Brems_li_def" ,getValue(HIL_b_LH_Schluss_Brems_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Schluss_Brems_Nebel_li_def" ,getValue(HIL_b_LH_Schluss_Brems_Nebel_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Schluss_Brems_Nebel_re_def" ,getValue(HIL_b_LH_Schluss_Brems_Nebel_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Schluss_Brems_re_def" ,getValue(HIL_b_LH_Schluss_Brems_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Schluss_Nebel_li_def" ,getValue(HIL_b_LH_Schluss_Nebel_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Schluss_Nebel_re_def" ,getValue(HIL_b_LH_Schluss_Nebel_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Schlusslicht_li_def" ,getValue(HIL_b_LH_Schlusslicht_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Schlusslicht_re_def" ,getValue(HIL_b_LH_Schlusslicht_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_SL_BRL_BLK_li_def" ,getValue(HIL_b_LH_SL_BRL_BLK_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_SL_BRL_BLK_re_def" ,getValue(HIL_b_LH_SL_BRL_BLK_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Abbiegelicht_li_def" ,getValue(HIL_b_LV_Abbiegelicht_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Abbiegelicht_re_def" ,getValue(HIL_b_LV_Abbiegelicht_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Abblend_Fernlicht_li_def" ,getValue(HIL_b_LV_Abblend_Fernlicht_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Abblend_Fernlicht_re_def" ,getValue(HIL_b_LV_Abblend_Fernlicht_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Abblendlicht_li_def" ,getValue(HIL_b_LV_Abblendlicht_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Abblendlicht_re_def" ,getValue(HIL_b_LV_Abblendlicht_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Abblendlicht_TFL_li_def" ,getValue(HIL_b_LV_Abblendlicht_TFL_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Abblendlicht_TFL_re_def" ,getValue(HIL_b_LV_Abblendlicht_TFL_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Blinker_li_def" ,getValue(HIL_b_LV_Blinker_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Blinker_re_def" ,getValue(HIL_b_LV_Blinker_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Blk_li_Seite_def" ,getValue(HIL_b_LV_Blk_li_Seite_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Blk_re_Seite_def" ,getValue(HIL_b_LV_Blk_re_Seite_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Fernlicht_li_def" ,getValue(HIL_b_LV_Fernlicht_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Fernlicht_re_def" ,getValue(HIL_b_LV_Fernlicht_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_LED_Scheinwerfer_li_def" ,getValue(HIL_b_LV_LED_Scheinwerfer_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_LED_Scheinwerfer_re_def" ,getValue(HIL_b_LV_LED_Scheinwerfer_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Nebellicht_li_def" ,getValue(HIL_b_LV_Nebellicht_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Nebellicht_re_def" ,getValue(HIL_b_LV_Nebellicht_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Nebellicht_TFL_li_def" ,getValue(HIL_b_LV_Nebellicht_TFL_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Nebellicht_TFL_re_def" ,getValue(HIL_b_LV_Nebellicht_TFL_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Standlicht_Anzeige" ,getValue(HIL_b_LV_Standlicht_Anzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Standlicht_li_def" ,getValue(HIL_b_LV_Standlicht_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Standlicht_re_def" ,getValue(HIL_b_LV_Standlicht_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Standlicht_TFL_li_def" ,getValue(HIL_b_LV_Standlicht_TFL_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Standlicht_TFL_re_def" ,getValue(HIL_b_LV_Standlicht_TFL_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Tagfahrlicht_li_def" ,getValue(HIL_b_LV_Tagfahrlicht_li_def), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LV_Tagfahrlicht_re_def" ,getValue(HIL_b_LV_Tagfahrlicht_re_def), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_AnhaengerBlinker" ,getValue(HIL_s_LED_AnhaengerBlinker), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Blinker_links" ,getValue(HIL_s_LED_Blinker_links), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Blinker_rechts" ,getValue(HIL_s_LED_Blinker_rechts), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_RGB_Blau" ,getValue(HIL_b_BCM_RGB_Blau), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_RGB_Gruen" ,getValue(HIL_b_BCM_RGB_Gruen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_RGB_Rot" ,getValue(HIL_b_BCM_RGB_Rot), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Ambientelicht_aktiv" ,getValue(HIL_s_Ambientelicht_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_BCM_RGB_Blau" ,getValue(HIL_s_BCM_RGB_Blau), profileFile);
    writeProfileInt("Settings" ,"HIL_s_BCM_RGB_Gruen" ,getValue(HIL_s_BCM_RGB_Gruen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_BCM_RGB_Rot" ,getValue(HIL_s_BCM_RGB_Rot), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_Ausparken_Betrieb" ,getValue(HIL_b_BCM_Ausparken_Betrieb), profileFile);
    writeProfileInt("Settings" ,"HIL_s_aufpruefung_aktiv" ,getValue(HIL_s_aufpruefung_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_aufpruefung_pilopa_aktiv" ,getValue(HIL_s_aufpruefung_pilopa_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Abstandswarnung" ,getValue(HIL_s_LED_Abstandswarnung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ACA_Quer_aktiv" ,getValue(HIL_s_LED_ACA_Quer_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ACA_Quer_passiv" ,getValue(HIL_s_LED_ACA_Quer_passiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ACA_Quer_Warnung" ,getValue(HIL_s_LED_ACA_Quer_Warnung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ACC_Ego_weiss" ,getValue(HIL_s_LED_ACC_Ego_weiss), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ACC_Radar_gruen" ,getValue(HIL_s_LED_ACC_Radar_gruen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ACC_Radar_rot_blinken" ,getValue(HIL_s_LED_ACC_Radar_rot_blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ACC_Radar_weiss" ,getValue(HIL_s_LED_ACC_Radar_weiss), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ACC_VorFzg_gruen" ,getValue(HIL_s_LED_ACC_VorFzg_gruen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ACC_VorFzg_rot_blinken1" ,getValue(HIL_s_LED_ACC_VorFzg_rot_blinken1), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ACC_VorFzg_weiss" ,getValue(HIL_s_LED_ACC_VorFzg_weiss), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_AEB" ,getValue(HIL_s_LED_AEB), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_aLDW_li_erkannt" ,getValue(HIL_s_LED_aLDW_li_erkannt), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_aLDW_li_nicht_erkannt" ,getValue(HIL_s_LED_aLDW_li_nicht_erkannt), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_aLDW_li_Warnung" ,getValue(HIL_s_LED_aLDW_li_Warnung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_aLDW_re_erkannt" ,getValue(HIL_s_LED_aLDW_re_erkannt), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_aLDW_re_nicht_erkannt" ,getValue(HIL_s_LED_aLDW_re_nicht_erkannt), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_aLDW_re_Warnung" ,getValue(HIL_s_LED_aLDW_re_Warnung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Antriebsart_weiss" ,getValue(HIL_s_LED_Antriebsart_weiss), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_CNG_Betrieb" ,getValue(HIL_s_LED_CNG_Betrieb), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_EPB_NAR_gruen" ,getValue(HIL_s_LED_EPB_NAR_gruen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_EPB_RDW_gruen" ,getValue(HIL_s_LED_EPB_RDW_gruen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_FLA_auto" ,getValue(HIL_s_LED_FLA_auto), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_GRA_weiss" ,getValue(HIL_s_LED_GRA_weiss), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Hands_Off" ,getValue(HIL_s_LED_Hands_Off), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_LIM_weiss" ,getValue(HIL_s_LED_LIM_weiss), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Querfuehrung_aktiv" ,getValue(HIL_s_LED_Querfuehrung_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Querfuehrung_passiv" ,getValue(HIL_s_LED_Querfuehrung_passiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Querfuehrung_Warnung" ,getValue(HIL_s_LED_Querfuehrung_Warnung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_FAS_Taster" ,getValue(HIL_b_FAS_Taster), profileFile);
    writeProfileInt("Settings" ,"HIL_b_FAS_Taster_Fehler" ,getValue(HIL_b_FAS_Taster_Fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LSS_Tastencode" ,getValue(HIL_b_LSS_Tastencode), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MFL_Eventcode_1" ,getValue(HIL_b_MFL_Eventcode_1), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MFL_Eventcode_2" ,getValue(HIL_b_MFL_Eventcode_2), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MFL_Marke" ,getValue(HIL_b_MFL_Marke), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MFL_Tastencode_1" ,getValue(HIL_b_MFL_Tastencode_1), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MFL_Tastencode_2" ,getValue(HIL_b_MFL_Tastencode_2), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MFL_Variante" ,getValue(HIL_b_MFL_Variante), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ZV_STSG_eKiSi_defekt" ,getValue(HIL_b_ZV_STSG_eKiSi_defekt), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_data_wheel_ticks" ,getValue(HIL_hmi_data_wheel_ticks), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_event_wheel_ticks" ,getValue(HIL_hmi_event_wheel_ticks), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_FAS_Taster_long_press" ,getValue(HIL_hmi_FAS_Taster_long_press), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_FAS_Taster_short_press" ,getValue(HIL_hmi_FAS_Taster_short_press), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_mfl_marke" ,getValue(HIL_hmi_mfl_marke), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_mfl_variante" ,getValue(HIL_hmi_mfl_variante), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_ok_long_press" ,getValue(HIL_hmi_ok_long_press), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_up_short_press" ,getValue(HIL_hmi_up_short_press), profileFile);
    writeProfileInt("Settings" ,"HIL_s_mfl_gueltig" ,getValue(HIL_s_mfl_gueltig), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AAG_ASTA_Status" ,getValue(HIL_b_AAG_ASTA_Status), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AAG_AVS_Fehler_02" ,getValue(HIL_b_AAG_AVS_Fehler_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ASTA_Anhaengerlast" ,getValue(HIL_b_ASTA_Anhaengerlast), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ASTA_Einheit" ,getValue(HIL_b_ASTA_Einheit), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ASTA_Stuetzlast" ,getValue(HIL_b_ASTA_Stuetzlast), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ASTAs_01_alt" ,getValue(HIL_b_ASTAs_01_alt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM1_MH_Schalter" ,getValue(HIL_b_BCM1_MH_Schalter), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MF_2BatSOCzugering" ,getValue(HIL_b_MF_2BatSOCzugering), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MF_NotStartAktiv" ,getValue(HIL_b_MF_NotStartAktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_b_VSG_Meldungen" ,getValue(HIL_b_VSG_Meldungen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ZV_BT_offen" ,getValue(HIL_b_ZV_BT_offen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ZV_FT_offen" ,getValue(HIL_b_ZV_FT_offen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ZV_HBFS_offen" ,getValue(HIL_b_ZV_HBFS_offen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ZV_HD_offen" ,getValue(HIL_b_ZV_HD_offen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ZV_HFS_offen" ,getValue(HIL_b_ZV_HFS_offen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ZV_HS_offen" ,getValue(HIL_b_ZV_HS_offen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ZV_Tankklappe_offen" ,getValue(HIL_b_ZV_Tankklappe_offen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ZV_verriegelt_extern_ist" ,getValue(HIL_b_ZV_verriegelt_extern_ist), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_anhaengerlast_anzeigen" ,getValue(HIL_hmi_anhaengerlast_anzeigen), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_anhaengerlast_fehler" ,getValue(HIL_hmi_anhaengerlast_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_caroutlineunterdrueckung" ,getValue(HIL_hmi_caroutlineunterdrueckung), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_stuetzlast_anzeigen" ,getValue(HIL_hmi_stuetzlast_anzeigen), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_stuetzlast_fehler" ,getValue(HIL_hmi_stuetzlast_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_variante" ,getValue(HIL_hmi_variante), profileFile);
    writeProfileInt("Settings" ,"HIL_s_car_outline_aktiv" ,getValue(HIL_s_car_outline_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_car_outline_hochprior" ,getValue(HIL_s_car_outline_hochprior), profileFile);
    writeProfileInt("Settings" ,"HIL_s_car_outline_trigger_v_hinweis" ,getValue(HIL_s_car_outline_trigger_v_hinweis), profileFile);
    writeProfileInt("Settings" ,"HIL_s_event_car_outline_trigger" ,getValue(HIL_s_event_car_outline_trigger), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Tankdeckel" ,getValue(HIL_s_LED_Tankdeckel), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Verdeck" ,getValue(HIL_s_LED_Verdeck), profileFile);
    writeProfileInt("Settings" ,"HIL_s_motorhaube_offen_hinweis" ,getValue(HIL_s_motorhaube_offen_hinweis), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tuerzustand_hinten_links" ,getValue(HIL_s_tuerzustand_hinten_links), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tuerzustand_hinten_rechts" ,getValue(HIL_s_tuerzustand_hinten_rechts), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tuerzustand_vorne_links" ,getValue(HIL_s_tuerzustand_vorne_links), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tuerzustand_vorne_rechts" ,getValue(HIL_s_tuerzustand_vorne_rechts), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_wSBR_Batteriestatus" ,getValue(HIL_b_AB_wSBR_Batteriestatus), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Tempolimit_Einheit" ,getValue(HIL_b_ACC_Tempolimit_Einheit), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_ValetTaster_Fkts_LED" ,getValue(HIL_b_BCM_ValetTaster_Fkts_LED), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_Waschwasser_Sensor" ,getValue(HIL_b_BCM_Waschwasser_Sensor), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BFS_MMB_storage_beep" ,getValue(HIL_b_BFS_MMB_storage_beep), profileFile);
    writeProfileInt("Settings" ,"HIL_b_eCall_Mute_Anf" ,getValue(HIL_b_eCall_Mute_Anf), profileFile);
    writeProfileInt("Settings" ,"HIL_b_FS_MMB_storage_beep" ,getValue(HIL_b_FS_MMB_storage_beep), profileFile);
    writeProfileInt("Settings" ,"HIL_b_FT_Kisi_Fehler" ,getValue(HIL_b_FT_Kisi_Fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_b_KL_LRH_Stufe" ,getValue(HIL_b_KL_LRH_Stufe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_KL_VoKo_LED" ,getValue(HIL_b_KL_VoKo_LED), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LRH_on_off" ,getValue(HIL_b_LRH_on_off), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MF_2BattAb" ,getValue(HIL_b_MF_2BattAb), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MF_2BattLadWarn" ,getValue(HIL_b_MF_2BattLadWarn), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MF_ExterneLadungWarn" ,getValue(HIL_b_MF_ExterneLadungWarn), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MF_Fahrerhinweis" ,getValue(HIL_b_MF_Fahrerhinweis), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MF_Motorweiterlauf" ,getValue(HIL_b_MF_Motorweiterlauf), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MF_Summer" ,getValue(HIL_b_MF_Summer), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_MO_Kuehlmittel_Temp" ,getValue(HIL_b_MO_Kuehlmittel_Temp), profileFile);
    writeProfileInt("Settings" ,"HIL_b_PEA_Ereignisanzeige_temporaer" ,getValue(HIL_b_PEA_Ereignisanzeige_temporaer), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RS_defekt" ,getValue(HIL_b_RS_defekt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_STH_Texte" ,getValue(HIL_b_STH_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_Wischer_vorne_defekt" ,getValue(HIL_b_Wischer_vorne_defekt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ZV_STSG_Crashzustand" ,getValue(HIL_b_ZV_STSG_Crashzustand), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_down_short_press" ,getValue(HIL_hmi_down_short_press), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_FAS_Taster_long_release" ,getValue(HIL_hmi_FAS_Taster_long_release), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_FAS_Taster_short_release" ,getValue(HIL_hmi_FAS_Taster_short_release), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Anzahl_belegte_Fondsitze" ,getValue(HIL_s_Anzahl_belegte_Fondsitze), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Anzahl_gesteckte_Fondgurte" ,getValue(HIL_s_Anzahl_gesteckte_Fondgurte), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Anzeige_Anzahl_Fondsitze" ,getValue(HIL_s_Anzeige_Anzahl_Fondsitze), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KL_VoKo_LED" ,getValue(HIL_s_KL_VoKo_LED), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Lenkradheizung_0" ,getValue(HIL_s_LED_Lenkradheizung_0), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Lenkradheizung_1" ,getValue(HIL_s_LED_Lenkradheizung_1), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Lenkradheizung_2" ,getValue(HIL_s_LED_Lenkradheizung_2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Standheizung" ,getValue(HIL_s_LED_Standheizung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_warnfall_fond_ohne_SBR" ,getValue(HIL_s_warnfall_fond_ohne_SBR), profileFile);
    writeProfileInt("Settings" ,"HIL_s_warnsequenz_ende" ,getValue(HIL_s_warnsequenz_ende), profileFile);
    writeProfileInt("Settings" ,"HIL_s_waschwassermangel_warn" ,getValue(HIL_s_waschwassermangel_warn), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtwarn_Reihe2_BF" ,getValue(HIL_b_AB_Gurtwarn_Reihe2_BF), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtwarn_Reihe2_FA" ,getValue(HIL_b_AB_Gurtwarn_Reihe2_FA), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtwarn_Reihe2_MI" ,getValue(HIL_b_AB_Gurtwarn_Reihe2_MI), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtwarn_Reihe3_BF" ,getValue(HIL_b_AB_Gurtwarn_Reihe3_BF), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtwarn_Reihe3_FA" ,getValue(HIL_b_AB_Gurtwarn_Reihe3_FA), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtwarn_Reihe3_MI" ,getValue(HIL_b_AB_Gurtwarn_Reihe3_MI), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtwarn_VB" ,getValue(HIL_b_AB_Gurtwarn_VB), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtwarn_VF" ,getValue(HIL_b_AB_Gurtwarn_VF), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_SBR_hinten_verbau" ,getValue(HIL_b_AB_SBR_hinten_verbau), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe2_links_blinken" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe2_links_blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe2_links_gesteckt" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe2_links_gesteckt), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe2_links_verbaut" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe2_links_verbaut), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe2_mitte_blinken" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe2_mitte_blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe2_mitte_gesteckt" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe2_mitte_gesteckt), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe2_mitte_verbaut" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe2_mitte_verbaut), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe2_rechts_blinken" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe2_rechts_blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe2_rechts_gesteckt" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe2_rechts_gesteckt), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe2_rechts_verbaut" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe2_rechts_verbaut), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe3_links_blinken" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe3_links_blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe3_links_gesteckt" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe3_links_gesteckt), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe3_links_verbaut" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe3_links_verbaut), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe3_mitte_blinken" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe3_mitte_blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe3_mitte_gesteckt" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe3_mitte_gesteckt), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe3_mitte_verbaut" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe3_mitte_verbaut), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe3_rechts_blinken" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe3_rechts_blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe3_rechts_gesteckt" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe3_rechts_gesteckt), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe3_rechts_verbaut" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe3_rechts_verbaut), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_Gurtschloss_anzeigen" ,getValue(HIL_hmi_Gurtschloss_anzeigen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Anzahl_Fondsitze" ,getValue(HIL_s_Anzahl_Fondsitze), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gurt_fond_gong" ,getValue(HIL_s_gurt_fond_gong), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gurtschloss_optisch_2_links" ,getValue(HIL_s_gurtschloss_optisch_2_links), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gurtschloss_optisch_2_mitte" ,getValue(HIL_s_gurtschloss_optisch_2_mitte), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gurtschloss_optisch_2_rechts" ,getValue(HIL_s_gurtschloss_optisch_2_rechts), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gurtschloss_optisch_3_links" ,getValue(HIL_s_gurtschloss_optisch_3_links), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gurtschloss_optisch_3_mitte" ,getValue(HIL_s_gurtschloss_optisch_3_mitte), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gurtschloss_optisch_3_rechts" ,getValue(HIL_s_gurtschloss_optisch_3_rechts), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gurtwarnung_akustisch_1" ,getValue(HIL_s_gurtwarnung_akustisch_1), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gurtwarnung_akustisch_2" ,getValue(HIL_s_gurtwarnung_akustisch_2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gurtwarnung_akustisch_3" ,getValue(HIL_s_gurtwarnung_akustisch_3), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gurtwarnung_akustisch_US" ,getValue(HIL_s_gurtwarnung_akustisch_US), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gurtwarnung_optisch" ,getValue(HIL_s_gurtwarnung_optisch), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Gurtwarnung" ,getValue(HIL_s_LED_Gurtwarnung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Anzeige_Fussg" ,getValue(HIL_b_AB_Anzeige_Fussg), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Deaktiviert" ,getValue(HIL_b_AB_Deaktiviert), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Erh_Auf_VB" ,getValue(HIL_b_AB_Erh_Auf_VB), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtschloss_Reihe2_BF" ,getValue(HIL_b_AB_Gurtschloss_Reihe2_BF), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtschloss_Reihe2_FA" ,getValue(HIL_b_AB_Gurtschloss_Reihe2_FA), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtschloss_Reihe2_MI" ,getValue(HIL_b_AB_Gurtschloss_Reihe2_MI), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtschloss_Reihe3_BF" ,getValue(HIL_b_AB_Gurtschloss_Reihe3_BF), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtschloss_Reihe3_FA" ,getValue(HIL_b_AB_Gurtschloss_Reihe3_FA), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtschloss_Reihe3_MI" ,getValue(HIL_b_AB_Gurtschloss_Reihe3_MI), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtschloss_Reihe4_BF" ,getValue(HIL_b_AB_Gurtschloss_Reihe4_BF), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtschloss_Reihe4_FA" ,getValue(HIL_b_AB_Gurtschloss_Reihe4_FA), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtschloss_Reihe4_MI" ,getValue(HIL_b_AB_Gurtschloss_Reihe4_MI), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtwarn_Reihe4_BF" ,getValue(HIL_b_AB_Gurtwarn_Reihe4_BF), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtwarn_Reihe4_FA" ,getValue(HIL_b_AB_Gurtwarn_Reihe4_FA), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Gurtwarn_Reihe4_MI" ,getValue(HIL_b_AB_Gurtwarn_Reihe4_MI), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Lampe" ,getValue(HIL_b_AB_Lampe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Systemfehler" ,getValue(HIL_b_AB_Systemfehler), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AB_Versorgungsspannung" ,getValue(HIL_b_AB_Versorgungsspannung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_eCall_Funktionsstatus" ,getValue(HIL_b_eCall_Funktionsstatus), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SC_PreCrash_Texte" ,getValue(HIL_b_SC_PreCrash_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SC_PreCrash_Warnung" ,getValue(HIL_b_SC_PreCrash_Warnung), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe4_links_blinken" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe4_links_blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe4_links_gesteckt" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe4_links_gesteckt), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe4_links_verbaut" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe4_links_verbaut), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe4_mitte_blinken" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe4_mitte_blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe4_mitte_gesteckt" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe4_mitte_gesteckt), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe4_mitte_verbaut" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe4_mitte_verbaut), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe4_rechts_blinken" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe4_rechts_blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe4_rechts_gesteckt" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe4_rechts_gesteckt), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_AB_Gurtschloss_Reihe4_rechts_verbaut" ,getValue(HIL_hmi_AB_Gurtschloss_Reihe4_rechts_verbaut), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gurtschloss_optisch_4_links" ,getValue(HIL_s_gurtschloss_optisch_4_links), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gurtschloss_optisch_4_mitte" ,getValue(HIL_s_gurtschloss_optisch_4_mitte), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gurtschloss_optisch_4_rechts" ,getValue(HIL_s_gurtschloss_optisch_4_rechts), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Airbag" ,getValue(HIL_s_LED_Airbag), profileFile);
    writeProfileInt("Settings" ,"HIL_s_warnfall_fond_retrigger_event" ,getValue(HIL_s_warnfall_fond_retrigger_event), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RW_Gesamt_Reichweite" ,getValue(HIL_b_RW_Gesamt_Reichweite), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RW_Primaer_Reichweite" ,getValue(HIL_b_RW_Primaer_Reichweite), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RW_Primaer_Reichweite_Anzeige" ,getValue(HIL_b_RW_Primaer_Reichweite_Anzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RW_Reichweite_Einheit_Anzeige" ,getValue(HIL_b_RW_Reichweite_Einheit_Anzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RW_Sekundaer_Reichweite" ,getValue(HIL_b_RW_Sekundaer_Reichweite), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RW_Sekundaer_Reichweite_Anzeige" ,getValue(HIL_b_RW_Sekundaer_Reichweite_Anzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_CANRW_Gesamt_Max_sonderbehandlung" ,getValue(HIL_hmi_CANRW_Gesamt_Max_sonderbehandlung), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_CANRW_Gesamt_sonderbehandlung" ,getValue(HIL_hmi_CANRW_Gesamt_sonderbehandlung), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_CANRW_Primaer_sonderbehandlung" ,getValue(HIL_hmi_CANRW_Primaer_sonderbehandlung), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_CANRW_Sekundaer_sonderbehandlung" ,getValue(HIL_hmi_CANRW_Sekundaer_sonderbehandlung), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_reichweite_e1_available" ,getValue(HIL_hmi_reichweite_e1_available), profileFile);
    writeProfileInt("Settings" ,"HIL_s_CANRW_Primaer_Anzeigefreigabe_Bargraph" ,getValue(HIL_s_CANRW_Primaer_Anzeigefreigabe_Bargraph), profileFile);
    writeProfileInt("Settings" ,"HIL_s_CANRW_Sekundaer_Anzeigefreigabe_Bargraph" ,getValue(HIL_s_CANRW_Sekundaer_Anzeigefreigabe_Bargraph), profileFile);
    writeProfileInt("Settings" ,"HIL_s_CANRW_Systemfehler" ,getValue(HIL_s_CANRW_Systemfehler), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RW_Gesamt_Reichweite_Anzeige" ,getValue(HIL_b_RW_Gesamt_Reichweite_Anzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RW_Gesamt_Reichweite_Max_Anzeige" ,getValue(HIL_b_RW_Gesamt_Reichweite_Max_Anzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_b_STH_Heizleistung" ,getValue(HIL_b_STH_Heizleistung), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_CANRW_Gesamt_Reichweite" ,getValue(HIL_hmi_CANRW_Gesamt_Reichweite), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_CANRW_Primaer_Reichweite" ,getValue(HIL_hmi_CANRW_Primaer_Reichweite), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_CANRW_Sekundaer_Reichweite" ,getValue(HIL_hmi_CANRW_Sekundaer_Reichweite), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_reichweite_e2_available" ,getValue(HIL_hmi_reichweite_e2_available), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_reichweite_e3_available" ,getValue(HIL_hmi_reichweite_e3_available), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_BCM1_Aussen_Temp_ungef" ,getValue(HIL_b_BCM1_Aussen_Temp_ungef), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_aussentemperatur" ,getValue(HIL_hmi_aussentemperatur), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_aussentemperatur_einheit" ,getValue(HIL_hmi_aussentemperatur_einheit), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_aussentemperatur_eisstern" ,getValue(HIL_hmi_aussentemperatur_eisstern), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_aussentemperatur_fehler" ,getValue(HIL_hmi_aussentemperatur_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_CANRW_Gesamt_Reichweite_Max" ,getValue(HIL_hmi_CANRW_Gesamt_Reichweite_Max), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_CANRW_Gesamt_Reichweite_Norm" ,getValue(HIL_hmi_CANRW_Gesamt_Reichweite_Norm), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_aussentemp_letzter_wert" ,getValue(HIL_s_aussentemp_letzter_wert), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_aussentemperatur_anzeige_temp" ,getValue(HIL_s_aussentemperatur_anzeige_temp), profileFile);
    writeProfileInt("Settings" ,"HIL_s_eiswarnung" ,getValue(HIL_s_eiswarnung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_motor_warm" ,getValue(HIL_s_motor_warm), profileFile);
    writeProfileInt("Settings" ,"HIL_s_w_blockierung" ,getValue(HIL_s_w_blockierung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_z_blockierung" ,getValue(HIL_s_z_blockierung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM1_FStatus_Aussentemp_ungef" ,getValue(HIL_b_BCM1_FStatus_Aussentemp_ungef), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_EFF_Verbrauch_STH" ,getValue(HIL_b_EFF_Verbrauch_STH), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LSH_Heizleistung" ,getValue(HIL_b_LSH_Heizleistung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LSH_KVS" ,getValue(HIL_b_LSH_KVS), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LSH_KVS_Ueberlauf" ,getValue(HIL_b_LSH_KVS_Ueberlauf), profileFile);
    writeProfileInt("Settings" ,"HIL_b_STH_KVS" ,getValue(HIL_b_STH_KVS), profileFile);
    writeProfileInt("Settings" ,"HIL_b_STH_KVS_Ueberlauf" ,getValue(HIL_b_STH_KVS_Ueberlauf), profileFile);
    writeProfileInt("Settings" ,"HIL_s_aussentemp_in_anzeige" ,getValue(HIL_s_aussentemp_in_anzeige), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_EFF_Verbrauch_STH" ,getValue(HIL_s_EFF_Verbrauch_STH), profileFile);
    writeProfileInt("Settings" ,"HIL_s_STH_KVS" ,getValue(HIL_s_STH_KVS), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsgeschwindigkeit_e1_available" ,getValue(HIL_hmi_durchschnittsgeschwindigkeit_e1_available), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsgeschwindigkeit_e2_available" ,getValue(HIL_hmi_durchschnittsgeschwindigkeit_e2_available), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsgeschwindigkeit_e3" ,getValue(HIL_hmi_durchschnittsgeschwindigkeit_e3), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsgeschwindigkeit_e3_available" ,getValue(HIL_hmi_durchschnittsgeschwindigkeit_e3_available), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsgeschwindigkeit_einheit" ,getValue(HIL_hmi_durchschnittsgeschwindigkeit_einheit), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsgeschwindigkeit_sonderbehandlung_e1" ,getValue(HIL_hmi_durchschnittsgeschwindigkeit_sonderbehandlung_e1), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsgeschwindigkeit_sonderbehandlung_e2" ,getValue(HIL_hmi_durchschnittsgeschwindigkeit_sonderbehandlung_e2), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsgeschwindigkeit_sonderbehandlung_e3" ,getValue(HIL_hmi_durchschnittsgeschwindigkeit_sonderbehandlung_e3), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_durchschnittsgeschwindigkeit_e1" ,getValue(HIL_s_durchschnittsgeschwindigkeit_e1), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_durchschnittsgeschwindigkeit_e2" ,getValue(HIL_s_durchschnittsgeschwindigkeit_e2), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_durchschnittsgeschwindigkeit_e3" ,getValue(HIL_s_durchschnittsgeschwindigkeit_e3), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BMS_Ladevorgang_aktiv" ,getValue(HIL_b_BMS_Ladevorgang_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Freilauf_Status" ,getValue(HIL_b_MO_Freilauf_Status), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_e3_auto_reset" ,getValue(HIL_hmi_bc_e3_auto_reset), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_momentanverbrauch_einheit_gas" ,getValue(HIL_hmi_bc_momentanverbrauch_einheit_gas), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsgeschwindigkeit_e1" ,getValue(HIL_hmi_durchschnittsgeschwindigkeit_e1), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsgeschwindigkeit_e2" ,getValue(HIL_hmi_durchschnittsgeschwindigkeit_e2), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsverbrauch_e1_available" ,getValue(HIL_hmi_durchschnittsverbrauch_e1_available), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsverbrauch_e2_available" ,getValue(HIL_hmi_durchschnittsverbrauch_e2_available), profileFile);
    writeProfileInt("Settings" ,"HIL_s_at_zeitkonstante" ,getValue(HIL_s_at_zeitkonstante), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bc_reset_durchschnittsgeschwindigkeit_e1" ,getValue(HIL_s_bc_reset_durchschnittsgeschwindigkeit_e1), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bc_reset_durchschnittsgeschwindigkeit_e2" ,getValue(HIL_s_bc_reset_durchschnittsgeschwindigkeit_e2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bc_reset_durchschnittsgeschwindigkeit_e3" ,getValue(HIL_s_bc_reset_durchschnittsgeschwindigkeit_e3), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bc_reset_durchschnittsverbrauch_e1" ,getValue(HIL_s_bc_reset_durchschnittsverbrauch_e1), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bc_reset_durchschnittsverbrauch_e2" ,getValue(HIL_s_bc_reset_durchschnittsverbrauch_e2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bc_reset_durchschnittsverbrauch_e3" ,getValue(HIL_s_bc_reset_durchschnittsverbrauch_e3), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bc_reset_e1" ,getValue(HIL_s_bc_reset_e1), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bc_reset_e2" ,getValue(HIL_s_bc_reset_e2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bc_reset_e3" ,getValue(HIL_s_bc_reset_e3), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bc_reset_fahrstrecke_e1" ,getValue(HIL_s_bc_reset_fahrstrecke_e1), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bc_reset_fahrstrecke_e2" ,getValue(HIL_s_bc_reset_fahrstrecke_e2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bc_reset_fahrstrecke_e3" ,getValue(HIL_s_bc_reset_fahrstrecke_e3), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bc_reset_fahrzeit_e1" ,getValue(HIL_s_bc_reset_fahrzeit_e1), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bc_reset_fahrzeit_e2" ,getValue(HIL_s_bc_reset_fahrzeit_e2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bc_reset_fahrzeit_e3" ,getValue(HIL_s_bc_reset_fahrzeit_e3), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fallende_tendenz" ,getValue(HIL_s_fallende_tendenz), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_BC_Reset_E1" ,getValue(HIL_s_KBI_BC_Reset_E1), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_BC_Reset_E2" ,getValue(HIL_s_KBI_BC_Reset_E2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_BC_Reset_E3" ,getValue(HIL_s_KBI_BC_Reset_E3), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_QBit_Aussen_Temp_gef" ,getValue(HIL_s_KBI_QBit_Aussen_Temp_gef), profileFile);
    writeProfileInt("Settings" ,"HIL_s_kurzzeit_altwert_ende" ,getValue(HIL_s_kurzzeit_altwert_ende), profileFile);
    writeProfileInt("Settings" ,"HIL_s_kurzzeit_reset" ,getValue(HIL_s_kurzzeit_reset), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tankstop_altwert_ende" ,getValue(HIL_s_tankstop_altwert_ende), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tankstop_reset" ,getValue(HIL_s_tankstop_reset), profileFile);
    writeProfileInt("Settings" ,"HIL_set_hmi_e1_reset" ,getValue(HIL_set_hmi_e1_reset), profileFile);
    writeProfileInt("Settings" ,"HIL_set_hmi_e2_reset" ,getValue(HIL_set_hmi_e2_reset), profileFile);
    writeProfileInt("Settings" ,"HIL_set_hmi_e3_reset" ,getValue(HIL_set_hmi_e3_reset), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_CNG_Ueberlauf" ,getValue(HIL_b_MO_CNG_Ueberlauf), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_KVS" ,getValue(HIL_b_MO_KVS), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_KVS_Ueberlauf" ,getValue(HIL_b_MO_KVS_Ueberlauf), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_LPG_Ueberlauf" ,getValue(HIL_b_MO_LPG_Ueberlauf), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Verbrauch_CNG" ,getValue(HIL_b_MO_Verbrauch_CNG), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Verbrauch_LPG" ,getValue(HIL_b_MO_Verbrauch_LPG), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsverbrauch_e1_sonderbehandlung" ,getValue(HIL_hmi_durchschnittsverbrauch_e1_sonderbehandlung), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_durchschnittsverbrauch_e1" ,getValue(HIL_s_durchschnittsverbrauch_e1), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsverbrauch_e2_sonderbehandlung" ,getValue(HIL_hmi_durchschnittsverbrauch_e2_sonderbehandlung), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsverbrauch_e3_sonderbehandlung" ,getValue(HIL_hmi_durchschnittsverbrauch_e3_sonderbehandlung), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsverbrauch_gas_e1_sonderbehandlung" ,getValue(HIL_hmi_durchschnittsverbrauch_gas_e1_sonderbehandlung), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsverbrauch_gas_e2_sonderbehandlung" ,getValue(HIL_hmi_durchschnittsverbrauch_gas_e2_sonderbehandlung), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_durchschnittsverbrauch_e2" ,getValue(HIL_s_durchschnittsverbrauch_e2), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_durchschnittsverbrauch_e3" ,getValue(HIL_s_durchschnittsverbrauch_e3), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_durchschnittsverbrauch_gas_e1" ,getValue(HIL_s_durchschnittsverbrauch_gas_e1), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_durchschnittsverbrauch_gas_e2" ,getValue(HIL_s_durchschnittsverbrauch_gas_e2), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_durchschnittsverbrauch_e1" ,getValue(HIL_hmi_durchschnittsverbrauch_e1), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_durchschnittsverbrauch_e2" ,getValue(HIL_hmi_durchschnittsverbrauch_e2), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_durchschnittsverbrauch_e3" ,getValue(HIL_hmi_durchschnittsverbrauch_e3), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_durchschnittsverbrauch_gas_e1" ,getValue(HIL_hmi_durchschnittsverbrauch_gas_e1), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsverbrauch_gas_e3_sonderbehandlung" ,getValue(HIL_hmi_durchschnittsverbrauch_gas_e3_sonderbehandlung), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_durchschnittsverbrauch_gas_e3" ,getValue(HIL_s_durchschnittsverbrauch_gas_e3), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsverbrauch_einheit" ,getValue(HIL_hmi_durchschnittsverbrauch_einheit), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_durchschnittsverbrauch_gas_e2" ,getValue(HIL_hmi_durchschnittsverbrauch_gas_e2), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_durchschnittsverbrauch_gas_e3" ,getValue(HIL_hmi_durchschnittsverbrauch_gas_e3), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_KBI_Aussen_Temp_gef" ,getValue(HIL_s_KBI_Aussen_Temp_gef), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_momentanverbrauch_lpro100km" ,getValue(HIL_s_momentanverbrauch_lpro100km), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_momentanverbrauch_lproh" ,getValue(HIL_s_momentanverbrauch_lproh), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_bc_momentanverbrauch" ,getValue(HIL_hmi_bc_momentanverbrauch), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_bc_momentanverbrauch_bargraph" ,getValue(HIL_hmi_bc_momentanverbrauch_bargraph), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_momentanverbrauch_einheit" ,getValue(HIL_hmi_bc_momentanverbrauch_einheit), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_momentanverbrauch_einheit_bargraph" ,getValue(HIL_hmi_bc_momentanverbrauch_einheit_bargraph), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_momentanverbrauch_einheit_gas_bargraph" ,getValue(HIL_hmi_bc_momentanverbrauch_einheit_gas_bargraph), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_bc_momentanverbrauch_gas" ,getValue(HIL_hmi_bc_momentanverbrauch_gas), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_bc_momentanverbrauch_gas_bargraph" ,getValue(HIL_hmi_bc_momentanverbrauch_gas_bargraph), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_momentanverbrauch_gas_not_a_number_bargraph" ,getValue(HIL_hmi_bc_momentanverbrauch_gas_not_a_number_bargraph), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_momentanverbrauch_not_a_number" ,getValue(HIL_hmi_bc_momentanverbrauch_not_a_number), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_momentanverbrauch_not_a_number_bargraph" ,getValue(HIL_hmi_bc_momentanverbrauch_not_a_number_bargraph), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_momentanverbrauch_not_a_number_gas" ,getValue(HIL_hmi_bc_momentanverbrauch_not_a_number_gas), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_momentanverbrauch_e1_available" ,getValue(HIL_hmi_momentanverbrauch_e1_available), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_momentanverbrauch_e2_available" ,getValue(HIL_hmi_momentanverbrauch_e2_available), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_momentanverbrauch_e3_available" ,getValue(HIL_hmi_momentanverbrauch_e3_available), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsverbrauch_einheit_gas" ,getValue(HIL_hmi_durchschnittsverbrauch_einheit_gas), profileFile);
    writeProfileInt("Settings" ,"HIL_s_acc_laeufer" ,getValue(HIL_s_acc_laeufer), profileFile);
    writeProfileInt("Settings" ,"HIL_s_acc_laeufer_hist_negativ" ,getValue(HIL_s_acc_laeufer_hist_negativ), profileFile);
    writeProfileInt("Settings" ,"HIL_s_acc_laeufer_hist_positiv" ,getValue(HIL_s_acc_laeufer_hist_positiv), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_momentanverbrauch_gas_pro100km" ,getValue(HIL_s_momentanverbrauch_gas_pro100km), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_momentanverbrauch_gas_proh" ,getValue(HIL_s_momentanverbrauch_gas_proh), profileFile);
    writeProfileInt("Settings" ,"HIL_s_schubabschaltung" ,getValue(HIL_s_schubabschaltung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_schubabschaltung_gas" ,getValue(HIL_s_schubabschaltung_gas), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_bc_fahrstrecke_e1" ,getValue(HIL_hmi_bc_fahrstrecke_e1), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_gesamt_reichweite_symbol" ,getValue(HIL_hmi_bc_gesamt_reichweite_symbol), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_sekundaer_reichweite_symbol" ,getValue(HIL_hmi_bc_sekundaer_reichweite_symbol), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsverbrauch_e3_available" ,getValue(HIL_hmi_durchschnittsverbrauch_e3_available), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_fahrzeit_e1_available" ,getValue(HIL_hmi_fahrzeit_e1_available), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_fahrzeit_e2_available" ,getValue(HIL_hmi_fahrzeit_e2_available), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_fahrzeit_e3_available" ,getValue(HIL_hmi_fahrzeit_e3_available), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fahrstrecke_e3" ,getValue(HIL_s_fahrstrecke_e3), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_fahrstrecke_e1_available" ,getValue(HIL_hmi_fahrstrecke_e1_available), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_fahrstrecke_e2_available" ,getValue(HIL_hmi_fahrstrecke_e2_available), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_fahrstrecke_e3_available" ,getValue(HIL_hmi_fahrstrecke_e3_available), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_fahrstrecke_einheit" ,getValue(HIL_hmi_fahrstrecke_einheit), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fahrstrecke_e1" ,getValue(HIL_s_fahrstrecke_e1), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fahrstrecke_e2" ,getValue(HIL_s_fahrstrecke_e2), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RW_Prim_rRWB_aktiv" ,getValue(HIL_b_RW_Prim_rRWB_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RW_Prim_rRWB_Reichw_Gesamt_Anz" ,getValue(HIL_b_RW_Prim_rRWB_Reichw_Gesamt_Anz), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_bc_fahrstrecke_e2" ,getValue(HIL_hmi_bc_fahrstrecke_e2), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_bc_fahrstrecke_e3" ,getValue(HIL_hmi_bc_fahrstrecke_e3), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_primaer_reichweite_symbol" ,getValue(HIL_hmi_bc_primaer_reichweite_symbol), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Anzeige_StSt_Symbol" ,getValue(HIL_b_MO_Anzeige_StSt_Symbol), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Anzeige_StSt_Text" ,getValue(HIL_b_MO_Anzeige_StSt_Text), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_AnzeigeGasbetrieb" ,getValue(HIL_b_MO_AnzeigeGasbetrieb), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Effizienzmodus" ,getValue(HIL_b_MO_Effizienzmodus), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_EPCL" ,getValue(HIL_b_MO_EPCL), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Erdgasqualitaet" ,getValue(HIL_b_MO_Erdgasqualitaet), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Ethanol_BS_Texte" ,getValue(HIL_b_MO_Ethanol_BS_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Istgang" ,getValue(HIL_b_MO_Istgang), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_KJS_nicht_bereit" ,getValue(HIL_b_MO_KJS_nicht_bereit), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Motor_laeuft" ,getValue(HIL_b_MO_Motor_laeuft), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Schaltempf_verfbar" ,getValue(HIL_b_MO_Schaltempf_verfbar), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Sollgang" ,getValue(HIL_b_MO_Sollgang), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_StartStopp_Codiert" ,getValue(HIL_b_MO_StartStopp_Codiert), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_StartStopp_PopUp" ,getValue(HIL_b_MO_StartStopp_PopUp), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Tankbereitschaft_Status" ,getValue(HIL_b_MO_Tankbereitschaft_Status), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_MO_Tankmasse_CNG" ,getValue(HIL_b_MO_Tankmasse_CNG), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Text_Motorstart" ,getValue(HIL_b_MO_Text_Motorstart), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Text_Partikelfil_Reg" ,getValue(HIL_b_MO_Text_Partikelfil_Reg), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Vorglueh_Lampe" ,getValue(HIL_b_MO_Vorglueh_Lampe), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_motorstarttexte" ,getValue(HIL_hmi_motorstarttexte), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_EPC" ,getValue(HIL_s_LED_EPC), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Vorgluehlampe" ,getValue(HIL_s_LED_Vorgluehlampe), profileFile);
    writeProfileInt("Settings" ,"HIL_s_MO_akt_Betrieb" ,getValue(HIL_s_MO_akt_Betrieb), profileFile);
    writeProfileInt("Settings" ,"HIL_s_MO_AnzeigeGasbetrieb" ,getValue(HIL_s_MO_AnzeigeGasbetrieb), profileFile);
    writeProfileInt("Settings" ,"HIL_s_MO_Erdgasqualitaet" ,getValue(HIL_s_MO_Erdgasqualitaet), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_Russindex" ,getValue(HIL_b_WIV_Russindex), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_t_max" ,getValue(HIL_b_WIV_t_max), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_t_min" ,getValue(HIL_b_WIV_t_min), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_Verschleissindex" ,getValue(HIL_b_WIV_Verschleissindex), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_W_max" ,getValue(HIL_b_WIV_W_max), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_W_min" ,getValue(HIL_b_WIV_W_min), profileFile);
    writeProfileInt("Settings" ,"HIL_s_insp_reset_stelltaster" ,getValue(HIL_s_insp_reset_stelltaster), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oel_vorwarnung_in_km" ,getValue(HIL_s_oel_vorwarnung_in_km), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oel_vorwarnung_in_tagen" ,getValue(HIL_s_oel_vorwarnung_in_tagen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oil_insp_reset_stelltaster" ,getValue(HIL_s_oil_insp_reset_stelltaster), profileFile);
    writeProfileInt("Settings" ,"HIL_s_service_vorwarnung_aktiv" ,getValue(HIL_s_service_vorwarnung_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_service_warnung_aktiv" ,getValue(HIL_s_service_warnung_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_oil_restlauf_strecke" ,getValue(HIL_hmi_oil_restlauf_strecke), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_service_restlauf_strecke" ,getValue(HIL_hmi_service_restlauf_strecke), profileFile);
    writeProfileInt("Settings" ,"HIL_s_insp_faellig_km" ,getValue(HIL_s_insp_faellig_km), profileFile);
    writeProfileInt("Settings" ,"HIL_s_insp_faellig_tage" ,getValue(HIL_s_insp_faellig_tage), profileFile);
    writeProfileInt("Settings" ,"HIL_s_insp_praediktion_aktiv" ,getValue(HIL_s_insp_praediktion_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_insp_praediktion_aktiv_km" ,getValue(HIL_s_insp_praediktion_aktiv_km), profileFile);
    writeProfileInt("Settings" ,"HIL_s_insp_praediktion_aktiv_tage" ,getValue(HIL_s_insp_praediktion_aktiv_tage), profileFile);
    writeProfileInt("Settings" ,"HIL_s_insp_reset_km_DIAG_event" ,getValue(HIL_s_insp_reset_km_DIAG_event), profileFile);
    writeProfileInt("Settings" ,"HIL_s_insp_reset_km_HMI_event" ,getValue(HIL_s_insp_reset_km_HMI_event), profileFile);
    writeProfileInt("Settings" ,"HIL_s_insp_reset_tage_DIAG_event" ,getValue(HIL_s_insp_reset_tage_DIAG_event), profileFile);
    writeProfileInt("Settings" ,"HIL_s_insp_vorwarnung_in_km" ,getValue(HIL_s_insp_vorwarnung_in_km), profileFile);
    writeProfileInt("Settings" ,"HIL_s_insp_vorwarnung_in_tagen" ,getValue(HIL_s_insp_vorwarnung_in_tagen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_insp_warnung" ,getValue(HIL_s_insp_warnung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Oil_dis" ,getValue(HIL_s_KBI_Oil_dis), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Oil_dis_status" ,getValue(HIL_s_KBI_Oil_dis_status), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Oil_dis_unit" ,getValue(HIL_s_KBI_Oil_dis_unit), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oel_insp_vorwarnung_in_km" ,getValue(HIL_s_oel_insp_vorwarnung_in_km), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oel_insp_vorwarnung_in_tagen" ,getValue(HIL_s_oel_insp_vorwarnung_in_tagen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oel_insp_warnung" ,getValue(HIL_s_oel_insp_warnung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oel_warnung" ,getValue(HIL_s_oel_warnung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oil_faellig_km" ,getValue(HIL_s_oil_faellig_km), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oil_faellig_tage" ,getValue(HIL_s_oil_faellig_tage), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oil_praediktion_aktiv" ,getValue(HIL_s_oil_praediktion_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oil_praediktion_aktiv_km" ,getValue(HIL_s_oil_praediktion_aktiv_km), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oil_praediktion_aktiv_tage" ,getValue(HIL_s_oil_praediktion_aktiv_tage), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oil_reset_DIAG_event" ,getValue(HIL_s_oil_reset_DIAG_event), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oil_reset_HMI_event" ,getValue(HIL_s_oil_reset_HMI_event), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oil_restlauf_nyc" ,getValue(HIL_s_oil_restlauf_nyc), profileFile);
    writeProfileInt("Settings" ,"HIL_s_praediktion_aktiv" ,getValue(HIL_s_praediktion_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Kraftstofffilter_Wasser" ,getValue(HIL_b_MO_Kraftstofffilter_Wasser), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_OBD2_Lampe" ,getValue(HIL_b_MO_OBD2_Lampe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Text_Tankdeckelwarn" ,getValue(HIL_b_MO_Text_Tankdeckelwarn), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_insp_restlauf_strecke" ,getValue(HIL_hmi_insp_restlauf_strecke), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_wiv_Oelmenge" ,getValue(HIL_hmi_wiv_Oelmenge), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_wiv_Oelmenge_Einheit" ,getValue(HIL_hmi_wiv_Oelmenge_Einheit), profileFile);
    writeProfileInt("Settings" ,"HIL_s_insp_reset_tage_HMI_event" ,getValue(HIL_s_insp_reset_tage_HMI_event), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Insp_dis" ,getValue(HIL_s_KBI_Insp_dis), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Insp_time" ,getValue(HIL_s_KBI_Insp_time), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Oil_time" ,getValue(HIL_s_KBI_Oil_time), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_OBD" ,getValue(HIL_s_LED_OBD), profileFile);
    writeProfileInt("Settings" ,"HIL_s_MO_OBD2_Lampe_warn" ,getValue(HIL_s_MO_OBD2_Lampe_warn), profileFile);
    writeProfileInt("Settings" ,"HIL_s_wiv_daten_unplausibel" ,getValue(HIL_s_wiv_daten_unplausibel), profileFile);
    writeProfileInt("Settings" ,"HIL_s_WIV_Russindex_fehler" ,getValue(HIL_s_WIV_Russindex_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_WIV_Verschleissindex_fehler" ,getValue(HIL_s_WIV_Verschleissindex_fehler), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_MO_Anzeige_Leistung_Max" ,getValue(HIL_b_MO_Anzeige_Leistung_Max), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_MO_Ladedruck" ,getValue(HIL_b_MO_Ladedruck), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Leistung" ,getValue(HIL_b_MO_Leistung), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_MO_max_Ladedruck" ,getValue(HIL_b_MO_max_Ladedruck), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_MO_rel_Ladedruck" ,getValue(HIL_b_MO_rel_Ladedruck), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TSK_Status_vMax_FahrerInfo" ,getValue(HIL_b_TSK_Status_vMax_FahrerInfo), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_Ladedruck" ,getValue(HIL_hmi_Ladedruck), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_wiv_Oelstand" ,getValue(HIL_hmi_wiv_Oelstand), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Vorglueh_System_Lampe" ,getValue(HIL_s_KBI_Vorglueh_System_Lampe), profileFile);
    writeProfileInt("Settings" ,"HIL_s_MO_CNG_LPG" ,getValue(HIL_s_MO_CNG_LPG), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Anzahl_Zyl" ,getValue(HIL_b_MO_Anzahl_Zyl), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Anzeige_Drehmoment" ,getValue(HIL_b_MO_Anzeige_Drehmoment), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Anzeige_Drehmoment_Max" ,getValue(HIL_b_MO_Anzeige_Drehmoment_Max), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_MKB_01" ,getValue(HIL_b_MO_MKB_01), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_MKB_02" ,getValue(HIL_b_MO_MKB_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_MKB_03" ,getValue(HIL_b_MO_MKB_03), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_MKB_04" ,getValue(HIL_b_MO_MKB_04), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Zylabsch_Texte_02" ,getValue(HIL_b_MO_Zylabsch_Texte_02), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_anzahl_aktiver_zylinder" ,getValue(HIL_hmi_anzahl_aktiver_zylinder), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_anzahl_zylinder" ,getValue(HIL_hmi_anzahl_zylinder), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_zylinderabschaltung_anzeigen" ,getValue(HIL_hmi_zylinderabschaltung_anzeigen), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_zylinderabschaltung_stoerung" ,getValue(HIL_hmi_zylinderabschaltung_stoerung), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_zylinderabschaltung_uebergangsbetrieb" ,getValue(HIL_hmi_zylinderabschaltung_uebergangsbetrieb), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_ITM_Warnung_Pumpe" ,getValue(HIL_b_MO_ITM_Warnung_Pumpe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SCR_Einheit" ,getValue(HIL_b_SCR_Einheit), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SCR_Nachfuellmenge_Einheit" ,getValue(HIL_b_SCR_Nachfuellmenge_Einheit), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_SCR_Nachfuellmenge_max" ,getValue(HIL_b_SCR_Nachfuellmenge_max), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_SCR_Nachfuellmenge_min" ,getValue(HIL_b_SCR_Nachfuellmenge_min), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SCR_Restreichweite" ,getValue(HIL_b_SCR_Restreichweite), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SCR_Retriggersignal" ,getValue(HIL_b_SCR_Retriggersignal), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SCR_verbaut" ,getValue(HIL_b_SCR_verbaut), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SCR_Zustand" ,getValue(HIL_b_SCR_Zustand), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_oeltemperatur" ,getValue(HIL_hmi_bc_oeltemperatur), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_scr_reichweite" ,getValue(HIL_hmi_scr_reichweite), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Anzeige_Fahrbereitschaft" ,getValue(HIL_b_MO_Anzeige_Fahrbereitschaft), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Anzeige_FMAus_Text" ,getValue(HIL_b_MO_Anzeige_FMAus_Text), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Anzeigedrehz" ,getValue(HIL_b_MO_Anzeigedrehz), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Drehzahl_Warnung" ,getValue(HIL_b_MO_Drehzahl_Warnung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_EFLEX_Lampe" ,getValue(HIL_b_MO_EFLEX_Lampe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Fehler_Oeldrucksensor" ,getValue(HIL_b_MO_Fehler_Oeldrucksensor), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_obere_Drehzahlgrenze" ,getValue(HIL_b_MO_obere_Drehzahlgrenze), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Oelwarnung_max" ,getValue(HIL_b_MO_Oelwarnung_max), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Verbau_StartSys_Q_Diode" ,getValue(HIL_b_MO_Verbau_StartSys_Q_Diode), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_nachfuellanzeige_ein" ,getValue(HIL_b_WIV_nachfuellanzeige_ein), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_Oeldr_Warn_Motor" ,getValue(HIL_b_WIV_Oeldr_Warn_Motor), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_Oelmenge" ,getValue(HIL_b_WIV_Oelmenge), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_Oelmin_Warn" ,getValue(HIL_b_WIV_Oelmin_Warn), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_WIV_Oelstand" ,getValue(HIL_b_WIV_Oelstand), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_Oelsystem_aktiv" ,getValue(HIL_b_WIV_Oelsystem_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_Sensorfehler" ,getValue(HIL_b_WIV_Sensorfehler), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_Ueberfuell_deaktiv" ,getValue(HIL_b_WIV_Ueberfuell_deaktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_Ueberfuell_Warn" ,getValue(HIL_b_WIV_Ueberfuell_Warn), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_Unterfuell_Warn" ,getValue(HIL_b_WIV_Unterfuell_Warn), profileFile);
    writeProfileInt("Settings" ,"HIL_s_drehzahl_displayanzeige" ,getValue(HIL_s_drehzahl_displayanzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_s_dzm_zeigerposition" ,getValue(HIL_s_dzm_zeigerposition), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Vorgluehlampe_blinken" ,getValue(HIL_s_LED_Vorgluehlampe_blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_s_MO_MKB_MUX" ,getValue(HIL_s_MO_MKB_MUX), profileFile);
    writeProfileInt("Settings" ,"HIL_s_MO_Oel_Temp_Client_vorhanden" ,getValue(HIL_s_MO_Oel_Temp_Client_vorhanden), profileFile);
    writeProfileInt("Settings" ,"HIL_s_MO_Oel_Temp_Werte_vorhanden" ,getValue(HIL_s_MO_Oel_Temp_Werte_vorhanden), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_Kuehlmittel_Sensor" ,getValue(HIL_b_BCM_Kuehlmittel_Sensor), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_Kuehlmittel_Sensor_02" ,getValue(HIL_b_BCM_Kuehlmittel_Sensor_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Heissleuchte" ,getValue(HIL_b_MO_Heissleuchte), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_MO_ITM_Kuehlmittel_Temp" ,getValue(HIL_b_MO_ITM_Kuehlmittel_Temp), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Oel_Temp" ,getValue(HIL_b_MO_Oel_Temp), profileFile);
    writeProfileInt("Settings" ,"HIL_b_OLEV_Oelstand_nicht_vorhanden" ,getValue(HIL_b_OLEV_Oelstand_nicht_vorhanden), profileFile);
    writeProfileInt("Settings" ,"HIL_b_OLEV_Systemstoerung" ,getValue(HIL_b_OLEV_Systemstoerung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_Anzeige_aktiv" ,getValue(HIL_b_WIV_Anzeige_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_kuehlmitteltemperatur" ,getValue(HIL_hmi_bc_kuehlmitteltemperatur), profileFile);
    writeProfileInt("Settings" ,"HIL_s_kuehlmittel_kalt_warn" ,getValue(HIL_s_kuehlmittel_kalt_warn), profileFile);
    writeProfileInt("Settings" ,"HIL_s_kuehlmittelmangel_warn" ,getValue(HIL_s_kuehlmittelmangel_warn), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_kuehlmitteltemp" ,getValue(HIL_s_kuehlmitteltemp), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_kuehlmitteltemp_analog" ,getValue(HIL_s_kuehlmitteltemp_analog), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_kuehlmitteltemp_displayanzeige" ,getValue(HIL_s_kuehlmitteltemp_displayanzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Kaltleuchte" ,getValue(HIL_s_LED_Kaltleuchte), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Kuehlmittelmangel_blinken" ,getValue(HIL_s_LED_Kuehlmittelmangel_blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_s_MO_Kuehl_Temp_Werte_vorhanden" ,getValue(HIL_s_MO_Kuehl_Temp_Werte_vorhanden), profileFile);
    writeProfileInt("Settings" ,"HIL_s_MO_Oel_Temp" ,getValue(HIL_s_MO_Oel_Temp), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_Bremsfluessigkeit_Sensor" ,getValue(HIL_b_BCM_Bremsfluessigkeit_Sensor), profileFile);
    writeProfileInt("Settings" ,"HIL_b_CHA_Kombi_Texte" ,getValue(HIL_b_CHA_Kombi_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_CHA_Kombi_Texte_02" ,getValue(HIL_b_CHA_Kombi_Texte_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_CHA_Offroad_LED" ,getValue(HIL_b_CHA_Offroad_LED), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ESC_Lernfreigabe_Abrollumfang" ,getValue(HIL_b_ESC_Lernfreigabe_Abrollumfang), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ESP_Meldungen" ,getValue(HIL_b_ESP_Meldungen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ESP_Textanzeigen_03" ,getValue(HIL_b_ESP_Textanzeigen_03), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Anz_Kuehlerluefter" ,getValue(HIL_b_MO_Anz_Kuehlerluefter), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Schaltblitz_Anz" ,getValue(HIL_b_MO_Schaltblitz_Anz), profileFile);
    writeProfileFloat("Settings" ,"HIL_dah_schaltblitz_blinkfrequenz" ,getValue(HIL_dah_schaltblitz_blinkfrequenz), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_analoggeschwindigkeit_digital_einheit" ,getValue(HIL_hmi_analoggeschwindigkeit_digital_einheit), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Bremsbelag_RdW" ,getValue(HIL_s_Bremsbelag_RdW), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gap_mfa" ,getValue(HIL_s_gap_mfa), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gap_texte" ,getValue(HIL_s_gap_texte), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_RDK" ,getValue(HIL_s_LED_RDK), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_RDK_blinken" ,getValue(HIL_s_LED_RDK_blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ESP_Wegimp_VA" ,getValue(HIL_b_ESP_Wegimp_VA), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ESP_Zaehnezahl" ,getValue(HIL_b_ESP_Zaehnezahl), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_gesamtwegstrecke" ,getValue(HIL_s_gesamtwegstrecke), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tageswegstrecke_reset_rueckgaengig" ,getValue(HIL_s_tageswegstrecke_reset_rueckgaengig), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BCM_Bremsbelag_Sensor" ,getValue(HIL_b_BCM_Bremsbelag_Sensor), profileFile);
    writeProfileInt("Settings" ,"HIL_b_EPB_Autoholdlampe_02" ,getValue(HIL_b_EPB_Autoholdlampe_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_EPB_Funktionslampe_02" ,getValue(HIL_b_EPB_Funktionslampe_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_EPB_Texte_02" ,getValue(HIL_b_EPB_Texte_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ESP_Wegimp_Ueberlauf" ,getValue(HIL_b_ESP_Wegimp_Ueberlauf), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RDK_FMVSS138_MIL" ,getValue(HIL_b_RDK_FMVSS138_MIL), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_gesamtwegstrecke" ,getValue(HIL_hmi_gesamtwegstrecke), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_gesamtwegstrecke_einheit" ,getValue(HIL_hmi_gesamtwegstrecke_einheit), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_tageswegstrecke" ,getValue(HIL_hmi_tageswegstrecke), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_tageswegstrecke_einheit" ,getValue(HIL_hmi_tageswegstrecke_einheit), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Bremsbelag_US" ,getValue(HIL_s_Bremsbelag_US), profileFile);
    writeProfileInt("Settings" ,"HIL_s_feststellbremse_warnung" ,getValue(HIL_s_feststellbremse_warnung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gws_teilfehler" ,getValue(HIL_s_gws_teilfehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gws_totalfehler" ,getValue(HIL_s_gws_totalfehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_BVA" ,getValue(HIL_s_LED_BVA), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_EPB_gruen" ,getValue(HIL_s_LED_EPB_gruen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_RDK_mil" ,getValue(HIL_s_RDK_mil), profileFile);
    writeProfileInt("Settings" ,"HIL_s_RDK_Systemstoerung" ,getValue(HIL_s_RDK_Systemstoerung), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_ESP_m_Raddrehz" ,getValue(HIL_b_ESP_m_Raddrehz), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_geschwindigkeit_analog" ,getValue(HIL_s_geschwindigkeit_analog), profileFile);
    writeProfileInt("Settings" ,"HIL_s_geschwindigkeit_plaus2" ,getValue(HIL_s_geschwindigkeit_plaus2), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_KBI_angez_Geschw" ,getValue(HIL_s_KBI_angez_Geschw), profileFile);
    writeProfileInt("Settings" ,"HIL_s_kombi_tachokennlinie_fehler" ,getValue(HIL_s_kombi_tachokennlinie_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_radumfang_max" ,getValue(HIL_s_radumfang_max), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ABS_Lampe" ,getValue(HIL_b_ABS_Lampe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_CHA_Current_Mode_FPA" ,getValue(HIL_b_CHA_Current_Mode_FPA), profileFile);
    writeProfileInt("Settings" ,"HIL_b_DR_Gelbe_Warnlampe" ,getValue(HIL_b_DR_Gelbe_Warnlampe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_EPB_Autohold_Standbyanzeige" ,getValue(HIL_b_EPB_Autohold_Standbyanzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_b_Quersperre_Anz_Sperre_Auslegen" ,getValue(HIL_b_Quersperre_Anz_Sperre_Auslegen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_Quersperre_Anz_Sperre_Einlegen" ,getValue(HIL_b_Quersperre_Anz_Sperre_Einlegen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_Quersperre_Anz_Sperre_Geschl" ,getValue(HIL_b_Quersperre_Anz_Sperre_Geschl), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RDK_Warnungen_02" ,getValue(HIL_b_RDK_Warnungen_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TC_Lampe" ,getValue(HIL_b_TC_Lampe), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_analoggeschwindigkeit" ,getValue(HIL_hmi_analoggeschwindigkeit), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_analoggeschwindigkeit_einheit" ,getValue(HIL_hmi_analoggeschwindigkeit_einheit), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_digital_zweitgeschwindigkeit" ,getValue(HIL_hmi_digital_zweitgeschwindigkeit), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_digital_zweitgeschwindigkeit_einheit" ,getValue(HIL_hmi_digital_zweitgeschwindigkeit_einheit), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bremsfluessigkeitsmangel_warn" ,getValue(HIL_s_bremsfluessigkeitsmangel_warn), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_geschwindigkeit_berechnet" ,getValue(HIL_s_geschwindigkeit_berechnet), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ABS" ,getValue(HIL_s_LED_ABS), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ABS_US" ,getValue(HIL_s_LED_ABS_US), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Autohold_Standby_weiss" ,getValue(HIL_s_LED_Autohold_Standby_weiss), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Quersperre" ,getValue(HIL_s_LED_Quersperre), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Quersperre_blinken" ,getValue(HIL_s_LED_Quersperre_blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_TC" ,getValue(HIL_s_LED_TC), profileFile);
    writeProfileInt("Settings" ,"HIL_s_mittlere_raddrehzahl_fehler" ,getValue(HIL_s_mittlere_raddrehzahl_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BK_Lampe_02" ,getValue(HIL_b_BK_Lampe_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BR_Systemart" ,getValue(HIL_b_BR_Systemart), profileFile);
    writeProfileInt("Settings" ,"HIL_b_EPS_Warnungen" ,getValue(HIL_b_EPS_Warnungen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ESP_BKV_Warnung" ,getValue(HIL_b_ESP_BKV_Warnung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ESP_Lampe" ,getValue(HIL_b_ESP_Lampe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ESP_Off_Lampe" ,getValue(HIL_b_ESP_Off_Lampe), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_GNSS_Ortung_2D_Geschw_ue_Grund" ,getValue(HIL_b_GNSS_Ortung_2D_Geschw_ue_Grund), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_LWI_Lenkradwinkel" ,getValue(HIL_b_LWI_Lenkradwinkel), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LWI_VZ_Lenkradwinkel" ,getValue(HIL_b_LWI_VZ_Lenkradwinkel), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RDK_FMVSS138_Lampe" ,getValue(HIL_b_RDK_FMVSS138_Lampe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RDK_Kalibrierung" ,getValue(HIL_b_RDK_Kalibrierung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RKA_FMVSS138_Lampe" ,getValue(HIL_b_RKA_FMVSS138_Lampe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RKA_FMVSS138_MIL" ,getValue(HIL_b_RKA_FMVSS138_MIL), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RKA_Warnungen_02" ,getValue(HIL_b_RKA_Warnungen_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RLE_Anzeigen" ,getValue(HIL_b_RLE_Anzeigen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ESP_Lampe" ,getValue(HIL_s_ESP_Lampe), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_BKL" ,getValue(HIL_s_LED_BKL), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_BKL_US" ,getValue(HIL_s_LED_BKL_US), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ESP" ,getValue(HIL_s_LED_ESP), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ESP_OFF" ,getValue(HIL_s_LED_ESP_OFF), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Lenkhilfe_gelb" ,getValue(HIL_s_LED_Lenkhilfe_gelb), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Lenkhilfe_gelb_blinken" ,getValue(HIL_s_LED_Lenkhilfe_gelb_blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Lenkhilfe_rot" ,getValue(HIL_s_LED_Lenkhilfe_rot), profileFile);
    writeProfileInt("Settings" ,"HIL_s_RKA_mil" ,getValue(HIL_s_RKA_mil), profileFile);
    writeProfileInt("Settings" ,"HIL_s_RKA_Systemstoerung" ,getValue(HIL_s_RKA_Systemstoerung), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_beschl_x_vorgefiltert" ,getValue(HIL_s_tank_beschl_x_vorgefiltert), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_beschl_y_vorgefiltert" ,getValue(HIL_s_tank_beschl_y_vorgefiltert), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tank_nte_log_error_n" ,getValue(HIL_s_tank_nte_log_error_n), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tank_tankstop" ,getValue(HIL_s_tank_tankstop), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tank_tanksystemwarnung" ,getValue(HIL_s_tank_tanksystemwarnung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tank_tankwarnung" ,getValue(HIL_s_tank_tankwarnung), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_geber_avrg_ntb_log_n" ,getValue(HIL_s_tank_vol_geber_avrg_ntb_log_n), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tank_wsa_log_n" ,getValue(HIL_s_tank_wsa_log_n), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ESP_QBit_Laengsbeschl" ,getValue(HIL_b_ESP_QBit_Laengsbeschl), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ESP_QBit_Querb" ,getValue(HIL_b_ESP_QBit_Querb), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_akt_Betrieb" ,getValue(HIL_b_MO_akt_Betrieb), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bargraph_extern_an" ,getValue(HIL_s_bargraph_extern_an), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bargraph_tnk_aktiv" ,getValue(HIL_s_bargraph_tnk_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bargraph_tnk_intern_an" ,getValue(HIL_s_bargraph_tnk_intern_an), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_gastank_anzeige_dyn_Rotbereich" ,getValue(HIL_s_gastank_anzeige_dyn_Rotbereich), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_gastank_anzeige_winkel" ,getValue(HIL_s_gastank_anzeige_winkel), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_anzeige_relativ" ,getValue(HIL_s_tank_anzeige_relativ), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tank_anzeigefreigabe" ,getValue(HIL_s_tank_anzeigefreigabe), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tank_delta_event" ,getValue(HIL_s_tank_delta_event), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_geber_kopplung_beschl_x" ,getValue(HIL_s_tank_geber_kopplung_beschl_x), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tank_lookup_vol_nte_zu" ,getValue(HIL_s_tank_lookup_vol_nte_zu), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tank_obd_warnung" ,getValue(HIL_s_tank_obd_warnung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tank_ottodiesel_anzeigefreigabe" ,getValue(HIL_s_tank_ottodiesel_anzeigefreigabe), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tank_zustand_v_gr_0" ,getValue(HIL_s_tank_zustand_v_gr_0), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_nachtankmenge_sonderbehandlung" ,getValue(HIL_hmi_bc_nachtankmenge_sonderbehandlung), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_nachtankmenge_vorhanden" ,getValue(HIL_hmi_bc_nachtankmenge_vorhanden), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_gastank_anzeige_prozent" ,getValue(HIL_s_gastank_anzeige_prozent), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_nachtankvolumen" ,getValue(HIL_s_nachtankvolumen), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_anzeige_dyn_Rotbereich" ,getValue(HIL_s_tank_anzeige_dyn_Rotbereich), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_anzeige_prozent" ,getValue(HIL_s_tank_anzeige_prozent), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_anzeige_winkel" ,getValue(HIL_s_tank_anzeige_winkel), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_CNG_LPG" ,getValue(HIL_b_MO_CNG_LPG), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_CNG_Tankstopp" ,getValue(HIL_b_MO_CNG_Tankstopp), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_MO_Fuellungsgrad_CNG" ,getValue(HIL_b_MO_Fuellungsgrad_CNG), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_MO_Fuellungsgrad_LPG" ,getValue(HIL_b_MO_Fuellungsgrad_LPG), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_LPG_Tankstopp" ,getValue(HIL_b_MO_LPG_Tankstopp), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bargraph_gastnk_aktiv" ,getValue(HIL_s_bargraph_gastnk_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bargraph_gastnk_intern_an" ,getValue(HIL_s_bargraph_gastnk_intern_an), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gasbargraph_extern_an" ,getValue(HIL_s_gasbargraph_extern_an), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_gastank_anzeige_relativ" ,getValue(HIL_s_gastank_anzeige_relativ), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gastank_anzeigefreigabe" ,getValue(HIL_s_gastank_anzeigefreigabe), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_gastank_fuellungsgrad" ,getValue(HIL_s_gastank_fuellungsgrad), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gastank_systemfehler_cng" ,getValue(HIL_s_gastank_systemfehler_cng), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gastank_systemfehler_lpg" ,getValue(HIL_s_gastank_systemfehler_lpg), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gastank_warnung_cng_LED" ,getValue(HIL_s_gastank_warnung_cng_LED), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gastank_warnung_lpg" ,getValue(HIL_s_gastank_warnung_lpg), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_CNG_Reserve" ,getValue(HIL_s_LED_CNG_Reserve), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_guete_g3" ,getValue(HIL_s_adc_guete_g3), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_guete_g4" ,getValue(HIL_s_adc_guete_g4), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_ohmwert_skaliert_g2" ,getValue(HIL_s_adc_ohmwert_skaliert_g2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_ohmwert_skaliert_g3" ,getValue(HIL_s_adc_ohmwert_skaliert_g3), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_r1s" ,getValue(HIL_s_adc_r1s), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_r12_gemessen" ,getValue(HIL_s_adc_r12_gemessen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_r32_gemessen" ,getValue(HIL_s_adc_r32_gemessen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_guete_g1" ,getValue(HIL_s_adc_guete_g1), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_ohmwert_skaliert_g4" ,getValue(HIL_s_adc_ohmwert_skaliert_g4), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_r2s" ,getValue(HIL_s_adc_r2s), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_r3s" ,getValue(HIL_s_adc_r3s), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_r4s" ,getValue(HIL_s_adc_r4s), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_r21_gemessen" ,getValue(HIL_s_adc_r21_gemessen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_r31_gemessen" ,getValue(HIL_s_adc_r31_gemessen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_r11_gemessen" ,getValue(HIL_s_adc_r11_gemessen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_r11_r1s" ,getValue(HIL_s_adc_r11_r1s), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_r21_r2s" ,getValue(HIL_s_adc_r21_r2s), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_r31_r3s" ,getValue(HIL_s_adc_r31_r3s), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_r41_gemessen" ,getValue(HIL_s_adc_r41_gemessen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_r41_r4s" ,getValue(HIL_s_adc_r41_r4s), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_guete_g2" ,getValue(HIL_s_adc_guete_g2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_ohmwert_skaliert_g1" ,getValue(HIL_s_adc_ohmwert_skaliert_g1), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_r22_gemessen" ,getValue(HIL_s_adc_r22_gemessen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_r42_gemessen" ,getValue(HIL_s_adc_r42_gemessen), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_geber_1_kalibriert" ,getValue(HIL_s_tank_vol_geber_1_kalibriert), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tankwarnung_klassisch" ,getValue(HIL_s_tankwarnung_klassisch), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tankwarnung_klassisch_0km" ,getValue(HIL_s_tankwarnung_klassisch_0km), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tankwarnung_phev_batterie" ,getValue(HIL_s_tankwarnung_phev_batterie), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tankwarnung_phev_tank" ,getValue(HIL_s_tankwarnung_phev_tank), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tankwarnung_phev_tank_0km" ,getValue(HIL_s_tankwarnung_phev_tank_0km), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tankwarnung_phev_tank_0km_batterie" ,getValue(HIL_s_tankwarnung_phev_tank_0km_batterie), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tankwarnung_phev_tank_batterie" ,getValue(HIL_s_tankwarnung_phev_tank_batterie), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tankwarnung_phev_tank_leistung" ,getValue(HIL_s_tankwarnung_phev_tank_leistung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tankwarnung_twin_cng" ,getValue(HIL_s_tankwarnung_twin_cng), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tankwarnung_twin_tank" ,getValue(HIL_s_tankwarnung_twin_tank), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tankwarnung_twin_tank_0km" ,getValue(HIL_s_tankwarnung_twin_tank_0km), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tankwarnung_twin_tank_0km_cng" ,getValue(HIL_s_tankwarnung_twin_tank_0km_cng), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tankwarnung_twin_tank_cng" ,getValue(HIL_s_tankwarnung_twin_tank_cng), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_geber_kopplung" ,getValue(HIL_s_tank_geber_kopplung), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_geber_kopplung_beschl_y" ,getValue(HIL_s_tank_geber_kopplung_beschl_y), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_geber_kopplung_v" ,getValue(HIL_s_tank_geber_kopplung_v), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_geber_kopplung_vol" ,getValue(HIL_s_tank_geber_kopplung_vol), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tank_zustand_avrg_gueltig" ,getValue(HIL_s_tank_zustand_avrg_gueltig), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tank_zustand_avrg_schnell_gueltig" ,getValue(HIL_s_tank_zustand_avrg_schnell_gueltig), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tank_zustand_nte" ,getValue(HIL_s_tank_zustand_nte), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tank_zustand_ref_gebildet" ,getValue(HIL_s_tank_zustand_ref_gebildet), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tank_kvs_gew" ,getValue(HIL_s_tank_kvs_gew), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_geber_1_roh" ,getValue(HIL_s_tank_vol_geber_1_roh), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_geber_2_kalibriert" ,getValue(HIL_s_tank_vol_geber_2_kalibriert), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_geber_3_kalibriert" ,getValue(HIL_s_tank_vol_geber_3_kalibriert), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_geber_4_kalibriert" ,getValue(HIL_s_tank_vol_geber_4_kalibriert), profileFile);
    writeProfileInt("Settings" ,"HIL_b_DGN_Verlernzaehler" ,getValue(HIL_b_DGN_Verlernzaehler), profileFile);
    writeProfileInt("Settings" ,"HIL_b_UH_Jahr" ,getValue(HIL_b_UH_Jahr), profileFile);
    writeProfileInt("Settings" ,"HIL_b_UH_Minute" ,getValue(HIL_b_UH_Minute), profileFile);
    writeProfileInt("Settings" ,"HIL_b_UH_Monat" ,getValue(HIL_b_UH_Monat), profileFile);
    writeProfileInt("Settings" ,"HIL_b_UH_Sekunde" ,getValue(HIL_b_UH_Sekunde), profileFile);
    writeProfileInt("Settings" ,"HIL_b_UH_Stunde" ,getValue(HIL_b_UH_Stunde), profileFile);
    writeProfileInt("Settings" ,"HIL_b_UH_Tag" ,getValue(HIL_b_UH_Tag), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_event_display_off" ,getValue(HIL_hmi_event_display_off), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_event_display_on" ,getValue(HIL_hmi_event_display_on), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_inszenierung_beendet" ,getValue(HIL_hmi_inszenierung_beendet), profileFile);
    writeProfileInt("Settings" ,"HIL_s_externe_taste_fehler" ,getValue(HIL_s_externe_taste_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fsp_kombi_nicht_codiert" ,getValue(HIL_s_fsp_kombi_nicht_codiert), profileFile);
    writeProfileInt("Settings" ,"HIL_s_inszenierung_beendet" ,getValue(HIL_s_inszenierung_beendet), profileFile);
    writeProfileInt("Settings" ,"HIL_s_inszenierung_start" ,getValue(HIL_s_inszenierung_start), profileFile);
    writeProfileInt("Settings" ,"HIL_s_meldungsfreigabe_ftuer" ,getValue(HIL_s_meldungsfreigabe_ftuer), profileFile);
    writeProfileInt("Settings" ,"HIL_s_taste_check" ,getValue(HIL_s_taste_check), profileFile);
    writeProfileInt("Settings" ,"HIL_s_taste_check_fehler" ,getValue(HIL_s_taste_check_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_taste_check_hil" ,getValue(HIL_s_taste_check_hil), profileFile);
    writeProfileInt("Settings" ,"HIL_s_taste_menue" ,getValue(HIL_s_taste_menue), profileFile);
    writeProfileInt("Settings" ,"HIL_s_taste_menue_fehler" ,getValue(HIL_s_taste_menue_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_taste_menue_hil" ,getValue(HIL_s_taste_menue_hil), profileFile);
    writeProfileInt("Settings" ,"HIL_s_taste_twsa" ,getValue(HIL_s_taste_twsa), profileFile);
    writeProfileInt("Settings" ,"HIL_s_taste_twsa_fehler" ,getValue(HIL_s_taste_twsa_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_taste_twsa_hil" ,getValue(HIL_s_taste_twsa_hil), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ub_dauerhaft_hoch" ,getValue(HIL_s_ub_dauerhaft_hoch), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ub_dauerhaft_niedrig" ,getValue(HIL_s_ub_dauerhaft_niedrig), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ub_kurzzeitig_hoch" ,getValue(HIL_s_ub_kurzzeitig_hoch), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ub_nio" ,getValue(HIL_s_ub_nio), profileFile);
    writeProfileInt("Settings" ,"HIL_b_Perso_Kontonummer" ,getValue(HIL_b_Perso_Kontonummer), profileFile);
    writeProfileInt("Settings" ,"HIL_b_Perso_Status" ,getValue(HIL_b_Perso_Status), profileFile);
    writeProfileInt("Settings" ,"HIL_b_Perso_Steuerung" ,getValue(HIL_b_Perso_Steuerung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_Perso_Steuerungsparameter" ,getValue(HIL_b_Perso_Steuerungsparameter), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SI_P_Mode" ,getValue(HIL_b_SI_P_Mode), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SI_P_Mode_gueltig" ,getValue(HIL_b_SI_P_Mode_gueltig), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_ego_fahrzeug" ,getValue(HIL_hmi_ego_fahrzeug), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_v_kunde_aktiv" ,getValue(HIL_hmi_v_kunde_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_v_kunde_einheit" ,getValue(HIL_hmi_v_kunde_einheit), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_v_kunde_sollgeschwindigkeit" ,getValue(HIL_hmi_v_kunde_sollgeschwindigkeit), profileFile);
    writeProfileInt("Settings" ,"HIL_s_blinktakt" ,getValue(HIL_s_blinktakt), profileFile);
    writeProfileInt("Settings" ,"HIL_s_hmi_blinktakt_request" ,getValue(HIL_s_hmi_blinktakt_request), profileFile);
    writeProfileInt("Settings" ,"HIL_s_hmi_blinktakt_reset_event" ,getValue(HIL_s_hmi_blinktakt_reset_event), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Kombi_RAM_defekt" ,getValue(HIL_s_Kombi_RAM_defekt), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Kombi_ROM_defekt" ,getValue(HIL_s_Kombi_ROM_defekt), profileFile);
    writeProfileInt("Settings" ,"HIL_s_kontrolllampenmanager_blinktakt_request" ,getValue(HIL_s_kontrolllampenmanager_blinktakt_request), profileFile);
    writeProfileInt("Settings" ,"HIL_s_kontrolllampenmanager_blinktakt_reset_event" ,getValue(HIL_s_kontrolllampenmanager_blinktakt_reset_event), profileFile);
    writeProfileInt("Settings" ,"HIL_s_selektiertes_design" ,getValue(HIL_s_selektiertes_design), profileFile);
    writeProfileInt("Settings" ,"HIL_s_v_kunde_aktiv" ,getValue(HIL_s_v_kunde_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_v_kunde_sollgeschwindigkeit" ,getValue(HIL_s_v_kunde_sollgeschwindigkeit), profileFile);
    writeProfileInt("Settings" ,"HIL_s_v_warnung_gesetzlich" ,getValue(HIL_s_v_warnung_gesetzlich), profileFile);
    writeProfileInt("Settings" ,"HIL_s_v_warnung_kunde" ,getValue(HIL_s_v_warnung_kunde), profileFile);
    writeProfileInt("Settings" ,"HIL_s_v_Warnung_Stufe_1_Akustik" ,getValue(HIL_s_v_Warnung_Stufe_1_Akustik), profileFile);
    writeProfileInt("Settings" ,"HIL_s_v_warnung_winterreifen" ,getValue(HIL_s_v_warnung_winterreifen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_zpm_blinktakt_request" ,getValue(HIL_s_zpm_blinktakt_request), profileFile);
    writeProfileInt("Settings" ,"HIL_s_zpm_blinktakt_reset_event" ,getValue(HIL_s_zpm_blinktakt_reset_event), profileFile);
    writeProfileInt("Settings" ,"HIL_b_KBI_Kilometerstand" ,getValue(HIL_b_KBI_Kilometerstand), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Anzeige_StSt_gueltig" ,getValue(HIL_b_MO_Anzeige_StSt_gueltig), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Kuppl_schalter" ,getValue(HIL_b_MO_Kuppl_schalter), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ZAS_Kl_15" ,getValue(HIL_b_ZAS_Kl_15), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ZAS_Kl_S" ,getValue(HIL_b_ZAS_Kl_S), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_klemme15" ,getValue(HIL_hmi_klemme15), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_klemmeS" ,getValue(HIL_hmi_klemmeS), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_motorkennbuchstaben_anzeigen" ,getValue(HIL_hmi_motorkennbuchstaben_anzeigen), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_t_FreezeKlemme15Aus_ms" ,getValue(HIL_hmi_t_FreezeKlemme15Aus_ms), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_t_FreezeKlemme15Ein_ms" ,getValue(HIL_hmi_t_FreezeKlemme15Ein_ms), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_transportmodus_anzeigen" ,getValue(HIL_hmi_transportmodus_anzeigen), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_ZV_verriegelt" ,getValue(HIL_hmi_ZV_verriegelt), profileFile);
    writeProfileInt("Settings" ,"HIL_s_hmi_display_status" ,getValue(HIL_s_hmi_display_status), profileFile);
    writeProfileInt("Settings" ,"HIL_s_HMI_LastMode_hmi_MFA_store" ,getValue(HIL_s_HMI_LastMode_hmi_MFA_store), profileFile);
    writeProfileInt("Settings" ,"HIL_s_HMI_LastMode_hmi_ShowTrackChangePopup" ,getValue(HIL_s_HMI_LastMode_hmi_ShowTrackChangePopup), profileFile);
    writeProfileInt("Settings" ,"HIL_s_klemme_15" ,getValue(HIL_s_klemme_15), profileFile);
    writeProfileInt("Settings" ,"HIL_s_klemme_15_timeout" ,getValue(HIL_s_klemme_15_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_v_Warnung_Stufe_1" ,getValue(HIL_s_v_Warnung_Stufe_1), profileFile);
    writeProfileInt("Settings" ,"HIL_s_v_Warnung_Stufe_2" ,getValue(HIL_s_v_Warnung_Stufe_2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_verstellmodus_aktiv" ,getValue(HIL_s_verstellmodus_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_zpm_zentrale_warnlampe" ,getValue(HIL_s_zpm_zentrale_warnlampe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_DI_Display_Nachtdesign" ,getValue(HIL_b_DI_Display_Nachtdesign), profileFile);
    writeProfileInt("Settings" ,"HIL_b_DI_KL_58xd" ,getValue(HIL_b_DI_KL_58xd), profileFile);
    writeProfileInt("Settings" ,"HIL_b_DI_KL_58xs" ,getValue(HIL_b_DI_KL_58xs), profileFile);
    writeProfileInt("Settings" ,"HIL_b_DI_KL_58xt" ,getValue(HIL_b_DI_KL_58xt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ESP_07_alt" ,getValue(HIL_b_ESP_07_alt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ESP_Rollenmodus_Deaktivieren" ,getValue(HIL_b_ESP_Rollenmodus_Deaktivieren), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Fahrzeugtyp" ,getValue(HIL_b_MO_Fahrzeugtyp), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Hybridfahrzeug" ,getValue(HIL_b_MO_Hybridfahrzeug), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Kraftstoffart" ,getValue(HIL_b_MO_Kraftstoffart), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Verbau_StartSys_RSG_MV" ,getValue(HIL_b_MO_Verbau_StartSys_RSG_MV), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Verbau_StartSys_RSG_NV" ,getValue(HIL_b_MO_Verbau_StartSys_RSG_NV), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fhrz_typ" ,getValue(HIL_s_fhrz_typ), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fhrz_typ_prim_antr" ,getValue(HIL_s_fhrz_typ_prim_antr), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fhrz_typ_sek_antr" ,getValue(HIL_s_fhrz_typ_sek_antr), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fusi_lampe_abs" ,getValue(HIL_s_fusi_lampe_abs), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fusi_lampe_airbag" ,getValue(HIL_s_fusi_lampe_airbag), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fusi_lampe_bkl" ,getValue(HIL_s_fusi_lampe_bkl), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fusi_lampe_epb_status" ,getValue(HIL_s_fusi_lampe_epb_status), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fusi_lampe_eps_rot" ,getValue(HIL_s_fusi_lampe_eps_rot), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fusi_lampe_esc" ,getValue(HIL_s_fusi_lampe_esc), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fusi_zwl_gelb" ,getValue(HIL_s_fusi_zwl_gelb), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fusi_zwl_rot" ,getValue(HIL_s_fusi_zwl_rot), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Display_Ausfall" ,getValue(HIL_s_KBI_Display_Ausfall), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_FoD_PopUP_Quittiert" ,getValue(HIL_s_KBI_FoD_PopUP_Quittiert), profileFile);
    writeProfileInt("Settings" ,"HIL_s_mfl_joker_hinweisfehler" ,getValue(HIL_s_mfl_joker_hinweisfehler), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AZK_Kessy_defekt" ,getValue(HIL_b_AZK_Kessy_defekt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AZK_Kessy_nicht_gefunden" ,getValue(HIL_b_AZK_Kessy_nicht_gefunden), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AZK_MobileKey_defekt" ,getValue(HIL_b_AZK_MobileKey_defekt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AZK_Mobilgeraet_nicht_gefunden" ,getValue(HIL_b_AZK_Mobilgeraet_nicht_gefunden), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AZK_Schluessel_im_Fzg" ,getValue(HIL_b_AZK_Schluessel_im_Fzg), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AZK_Weiterfahrt_mit_Mobilgeraet" ,getValue(HIL_b_AZK_Weiterfahrt_mit_Mobilgeraet), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AZK_Weiterfahrt_mit_Schluessel" ,getValue(HIL_b_AZK_Weiterfahrt_mit_Schluessel), profileFile);
    writeProfileInt("Settings" ,"HIL_b_FoD_Anz_Funktionsabschaltung" ,getValue(HIL_b_FoD_Anz_Funktionsabschaltung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WFS_Fahrerhinweise" ,getValue(HIL_b_WFS_Fahrerhinweise), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WFS_LZ" ,getValue(HIL_b_WFS_LZ), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WFS_Safe" ,getValue(HIL_b_WFS_Safe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WFS_Schluessel_Fahrberecht" ,getValue(HIL_b_WFS_Schluessel_Fahrberecht), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WFS_Schluessel_Ist" ,getValue(HIL_b_WFS_Schluessel_Ist), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WFS_Schluessel_Soll" ,getValue(HIL_b_WFS_Schluessel_Soll), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_global_active_layout" ,getValue(HIL_hmi_global_active_layout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_aktives_design" ,getValue(HIL_s_aktives_design), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Fahrbereitschaft" ,getValue(HIL_s_Fahrbereitschaft), profileFile);
    writeProfileInt("Settings" ,"HIL_s_FoD_Kombi_Variante" ,getValue(HIL_s_FoD_Kombi_Variante), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fsp_D10000" ,getValue(HIL_s_fsp_D10000), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fsp_D30000" ,getValue(HIL_s_fsp_D30000), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fsp_EA6100" ,getValue(HIL_s_fsp_EA6100), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fsp_EA6200" ,getValue(HIL_s_fsp_EA6200), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fsp_EA6400" ,getValue(HIL_s_fsp_EA6400), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Kombi_KompSchutz" ,getValue(HIL_s_Kombi_KompSchutz), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ks_safe" ,getValue(HIL_s_ks_safe), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ks_safe_text" ,getValue(HIL_s_ks_safe_text), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ZWL_gelb" ,getValue(HIL_s_LED_ZWL_gelb), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ZWL_gelb_Blinken" ,getValue(HIL_s_LED_ZWL_gelb_Blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ZWL_rot" ,getValue(HIL_s_LED_ZWL_rot), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ZWL_rot_Blinken" ,getValue(HIL_s_LED_ZWL_rot_Blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_s_mfl_joker_hinweis" ,getValue(HIL_s_mfl_joker_hinweis), profileFile);
    writeProfileInt("Settings" ,"HIL_s_WFS_Diag_LF_Aktiv_02" ,getValue(HIL_s_WFS_Diag_LF_Aktiv_02), profileFile);
    writeProfileInt("Settings" ,"HIL_s_WFS_LF_aktiv_02" ,getValue(HIL_s_WFS_LF_aktiv_02), profileFile);
    writeProfileInt("Settings" ,"HIL_s_WFS_Transp_Mod_Unterbrechung_02" ,getValue(HIL_s_WFS_Transp_Mod_Unterbrechung_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_HRE_Anzeigetexte" ,getValue(HIL_b_HRE_Anzeigetexte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LDW_Gong" ,getValue(HIL_b_LDW_Gong), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MKE_Stufe" ,getValue(HIL_b_MKE_Stufe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MKE_Texte" ,getValue(HIL_b_MKE_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_PLA_Abstand_zur_Parkluecke" ,getValue(HIL_b_PLA_Abstand_zur_Parkluecke), profileFile);
    writeProfileInt("Settings" ,"HIL_b_PLA_Anf_Akustik" ,getValue(HIL_b_PLA_Anf_Akustik), profileFile);
    writeProfileInt("Settings" ,"HIL_b_PLA_Anf_Anzeige_Bremsfuss" ,getValue(HIL_b_PLA_Anf_Anzeige_Bremsfuss), profileFile);
    writeProfileInt("Settings" ,"HIL_b_PLA_Anf_Anzeige_Mini" ,getValue(HIL_b_PLA_Anf_Anzeige_Mini), profileFile);
    writeProfileInt("Settings" ,"HIL_b_PLA_Anf_Anzeige_Schwellpfeil" ,getValue(HIL_b_PLA_Anf_Anzeige_Schwellpfeil), profileFile);
    writeProfileInt("Settings" ,"HIL_b_PLA_Anf_Anzeigemodus" ,getValue(HIL_b_PLA_Anf_Anzeigemodus), profileFile);
    writeProfileInt("Settings" ,"HIL_b_PLA_Anf_Meldungen" ,getValue(HIL_b_PLA_Anf_Meldungen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_PLA_Anzahl_Segmente_Schwellpfeil" ,getValue(HIL_b_PLA_Anzahl_Segmente_Schwellpfeil), profileFile);
    writeProfileInt("Settings" ,"HIL_b_PLA_Mini_Modus" ,getValue(HIL_b_PLA_Mini_Modus), profileFile);
    writeProfileInt("Settings" ,"HIL_b_PLA_Status_Aktive_Seite" ,getValue(HIL_b_PLA_Status_Aktive_Seite), profileFile);
    writeProfileInt("Settings" ,"HIL_b_PLA_Status_beenden_Mini" ,getValue(HIL_b_PLA_Status_beenden_Mini), profileFile);
    writeProfileInt("Settings" ,"HIL_b_PLA_Status_Funktion" ,getValue(HIL_b_PLA_Status_Funktion), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SWA_Anzeigen" ,getValue(HIL_b_SWA_Anzeigen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SWA_Sta_aktiv" ,getValue(HIL_b_SWA_Sta_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SWA_Sta_passiv" ,getValue(HIL_b_SWA_Sta_passiv), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_pla3_zpm" ,getValue(HIL_hmi_pla3_zpm), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_swa_timeout" ,getValue(HIL_hmi_swa_timeout), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Hands_Off_rot" ,getValue(HIL_s_LED_Hands_Off_rot), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Hands_Off_weiss" ,getValue(HIL_s_LED_Hands_Off_weiss), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_SWA_gelb" ,getValue(HIL_s_LED_SWA_gelb), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_SWA_gruen" ,getValue(HIL_s_LED_SWA_gruen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_SWA_Sta_aktiv" ,getValue(HIL_s_SWA_Sta_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_SWA_Sta_passiv" ,getValue(HIL_s_SWA_Sta_passiv), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AWV_AW_Texte_Zusatzanzeige" ,getValue(HIL_b_AWV_AW_Texte_Zusatzanzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_b_DSSS_Warning" ,getValue(HIL_b_DSSS_Warning), profileFile);
    writeProfileInt("Settings" ,"HIL_b_Heckradar_Kombitexte" ,getValue(HIL_b_Heckradar_Kombitexte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ISA_Status" ,getValue(HIL_b_ISA_Status), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LDW_Lernmodus_seitenabhaengig" ,getValue(HIL_b_LDW_Lernmodus_seitenabhaengig), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LDW_Status_LED_gelb" ,getValue(HIL_b_LDW_Status_LED_gelb), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LDW_Status_LED_gruen" ,getValue(HIL_b_LDW_Status_LED_gruen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LDW_Texte" ,getValue(HIL_b_LDW_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RCTA_Kombitexte" ,getValue(HIL_b_RCTA_Kombitexte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_Spurwechsel" ,getValue(HIL_b_TA_Spurwechsel), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_Status" ,getValue(HIL_b_TA_Status), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_Texte" ,getValue(HIL_b_TA_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TSK_06_alt" ,getValue(HIL_b_TSK_06_alt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TSK_Fahrzeugstatus_GRA" ,getValue(HIL_b_TSK_Fahrzeugstatus_GRA), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TSK_Fahrzeugstatus_Limiter" ,getValue(HIL_b_TSK_Fahrzeugstatus_Limiter), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TSK_Limiter_Anzeige" ,getValue(HIL_b_TSK_Limiter_Anzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TSK_Limiter_Fahrerinfo" ,getValue(HIL_b_TSK_Limiter_Fahrerinfo), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TSK_Status_Anzeige" ,getValue(HIL_b_TSK_Status_Anzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TSK_Texte_Primaeranz" ,getValue(HIL_b_TSK_Texte_Primaeranz), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TSK_Wunschgeschw" ,getValue(HIL_b_TSK_Wunschgeschw), profileFile);
    writeProfileInt("Settings" ,"HIL_s_GRA_Status" ,getValue(HIL_s_GRA_Status), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_LDW_gelb" ,getValue(HIL_s_LED_LDW_gelb), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_LDW_gruen" ,getValue(HIL_s_LED_LDW_gruen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LIM_Status" ,getValue(HIL_s_LIM_Status), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ARA_Aktiver_Grafikmodus" ,getValue(HIL_b_ARA_Aktiver_Grafikmodus), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ARA_Bremsfuss" ,getValue(HIL_b_ARA_Bremsfuss), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ARA_Knickwinkel_Ist" ,getValue(HIL_b_ARA_Knickwinkel_Ist), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ARA_Knickwinkel_Max" ,getValue(HIL_b_ARA_Knickwinkel_Max), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ARA_Knickwinkel_Soll" ,getValue(HIL_b_ARA_Knickwinkel_Soll), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ARA_Modus" ,getValue(HIL_b_ARA_Modus), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ARA_Texte" ,getValue(HIL_b_ARA_Texte), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_ESP_HDC_Regelgeschw" ,getValue(HIL_b_ESP_HDC_Regelgeschw), profileFile);
    writeProfileInt("Settings" ,"HIL_b_VZE_FoD_Status" ,getValue(HIL_b_VZE_FoD_Status), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_ARA_Knickwinkel_Ist" ,getValue(HIL_hmi_ARA_Knickwinkel_Ist), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_ARA_Knickwinkel_Soll" ,getValue(HIL_hmi_ARA_Knickwinkel_Soll), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ara_timeout_reakt" ,getValue(HIL_s_ara_timeout_reakt), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Shiftlock_rot" ,getValue(HIL_s_LED_Shiftlock_rot), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_ACC_Regelgeschw" ,getValue(HIL_b_ACC_Regelgeschw), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Tempolimit" ,getValue(HIL_b_ACC_Tempolimit), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Texte_Sekundaeranz" ,getValue(HIL_b_ACC_Texte_Sekundaeranz), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Warnung_Verkehrszeichen_1" ,getValue(HIL_b_ACC_Warnung_Verkehrszeichen_1), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AWV_AW_Abstand" ,getValue(HIL_b_AWV_AW_Abstand), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AWV_Texte" ,getValue(HIL_b_AWV_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AWV_Warnlevel" ,getValue(HIL_b_AWV_Warnlevel), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AWV_Warnung" ,getValue(HIL_b_AWV_Warnung), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_02_dx" ,getValue(HIL_b_TA_HMI_Obj_02_dx), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_ACC_Regelgeschw" ,getValue(HIL_hmi_ACC_Regelgeschw), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ACC_Ego_rot" ,getValue(HIL_s_LED_ACC_Ego_rot), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ACC_Ego_rot_blinken" ,getValue(HIL_s_LED_ACC_Ego_rot_blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Abstand_Abstandswarner" ,getValue(HIL_b_ACC_Abstand_Abstandswarner), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_ACC_Abstand_RNS" ,getValue(HIL_b_ACC_Abstand_RNS), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Akustik_03" ,getValue(HIL_b_ACC_Akustik_03), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Anzeige_Zeitluecke" ,getValue(HIL_b_ACC_Anzeige_Zeitluecke), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Display_Prio" ,getValue(HIL_b_ACC_Display_Prio), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Einheit_maxSetzgeschw" ,getValue(HIL_b_ACC_Einheit_maxSetzgeschw), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_ENG_Texte" ,getValue(HIL_b_ACC_ENG_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Gesetzte_Zeitluecke" ,getValue(HIL_b_ACC_Gesetzte_Zeitluecke), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_maxSetzgeschw" ,getValue(HIL_b_ACC_maxSetzgeschw), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Modus_Pop_Up" ,getValue(HIL_b_ACC_Modus_Pop_Up), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Optischer_Fahrerhinweis" ,getValue(HIL_b_ACC_Optischer_Fahrerhinweis), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Relevantes_Objekt_02" ,getValue(HIL_b_ACC_Relevantes_Objekt_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_RUV" ,getValue(HIL_b_ACC_RUV), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Tachokranz" ,getValue(HIL_b_ACC_Tachokranz), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Typ_Tachokranz_unten" ,getValue(HIL_b_ACC_Typ_Tachokranz_unten), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Warnhinweis" ,getValue(HIL_b_ACC_Warnhinweis), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_ACC_Wunschgeschw_02" ,getValue(HIL_b_ACC_Wunschgeschw_02), profileFile);
    writeProfileInt("Settings" ,"HIL_s_ACC_Status" ,getValue(HIL_s_ACC_Status), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_ACC_Ego_gruen" ,getValue(HIL_s_LED_ACC_Ego_gruen), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_ACC_Abstand_LNS" ,getValue(HIL_b_ACC_Abstand_LNS), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Abstandsindex_02" ,getValue(HIL_b_ACC_Abstandsindex_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Status_Anzeige" ,getValue(HIL_b_ACC_Status_Anzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Texte_02" ,getValue(HIL_b_ACC_Texte_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Texte_Primaeranz_03" ,getValue(HIL_b_ACC_Texte_Primaeranz_03), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Texte_Zusatzanz_03" ,getValue(HIL_b_ACC_Texte_Zusatzanz_03), profileFile);
    writeProfileInt("Settings" ,"HIL_b_FOD_State_ACC" ,getValue(HIL_b_FOD_State_ACC), profileFile);
    writeProfileInt("Settings" ,"HIL_b_PH_Stoermeldung" ,getValue(HIL_b_PH_Stoermeldung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_PH_Verschmutzungsmeldung" ,getValue(HIL_b_PH_Verschmutzungsmeldung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_PH_WAH_Meldung" ,getValue(HIL_b_PH_WAH_Meldung), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_ACC_Wunschgeschw_02" ,getValue(HIL_hmi_ACC_Wunschgeschw_02), profileFile);
    writeProfileInt("Settings" ,"HIL_s_FOD_State_ACC" ,getValue(HIL_s_FOD_State_ACC), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ASW_Kombitexte" ,getValue(HIL_b_ASW_Kombitexte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AWV_Status_Anzeige" ,getValue(HIL_b_AWV_Status_Anzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_b_EA_Texte" ,getValue(HIL_b_EA_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LoGeWa_C2C_Event_Einheit" ,getValue(HIL_b_LoGeWa_C2C_Event_Einheit), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_LoGeWa_C2C_Event_Entfernung" ,getValue(HIL_b_LoGeWa_C2C_Event_Entfernung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LoGeWa_C2C_Event_Richtung" ,getValue(HIL_b_LoGeWa_C2C_Event_Richtung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LoGeWa_C2C_Event_Status" ,getValue(HIL_b_LoGeWa_C2C_Event_Status), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LoGeWa_C2C_Event_Warnung" ,getValue(HIL_b_LoGeWa_C2C_Event_Warnung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TSK_Texte" ,getValue(HIL_b_TSK_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_VZA_available" ,getValue(HIL_hmi_VZA_available), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LH_Bremslicht_H_aktiv" ,getValue(HIL_b_LH_Bremslicht_H_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_zpm_anzeigeID" ,getValue(HIL_hmi_zpm_anzeigeID), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_zpm_meldungsspeicher_anzahl" ,getValue(HIL_hmi_zpm_meldungsspeicher_anzahl), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_zpm_meldungsspeicher_warningID" ,getValue(HIL_hmi_zpm_meldungsspeicher_warningID), profileFile);
    writeProfileInt("Settings" ,"HIL_s_emv_reku_charge_aktiv" ,getValue(HIL_s_emv_reku_charge_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_emv_reku_fahrz_stand" ,getValue(HIL_s_emv_reku_fahrz_stand), profileFile);
    writeProfileInt("Settings" ,"HIL_b_FT_Tuer_Status" ,getValue(HIL_b_FT_Tuer_Status), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ISA_Regelung_aktiv" ,getValue(HIL_b_ISA_Regelung_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ISA_Tempolimitwarnung" ,getValue(HIL_b_ISA_Tempolimitwarnung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TSK_Fahrzeugstatus_praed_Fkt" ,getValue(HIL_b_TSK_Fahrzeugstatus_praed_Fkt), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TSK_naechstes_Event" ,getValue(HIL_b_TSK_naechstes_Event), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TSK_praediktiver_Hinweis" ,getValue(HIL_b_TSK_praediktiver_Hinweis), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_acc_optischer_fahrerhinweis" ,getValue(HIL_hmi_acc_optischer_fahrerhinweis), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_aktive_Tubenfunktion" ,getValue(HIL_hmi_aktive_Tubenfunktion), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_nachtankmenge" ,getValue(HIL_hmi_bc_nachtankmenge), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_blinken_links" ,getValue(HIL_hmi_blinken_links), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_blinken_rechts" ,getValue(HIL_hmi_blinken_rechts), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_car_outline_aktiv" ,getValue(HIL_hmi_car_outline_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_defekt_anzeigen" ,getValue(HIL_hmi_defekt_anzeigen), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_heckdeckel_offen" ,getValue(HIL_hmi_heckdeckel_offen), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_heckscheibe_offen" ,getValue(HIL_hmi_heckscheibe_offen), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_motorhaube_offen" ,getValue(HIL_hmi_motorhaube_offen), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_pla_akustik" ,getValue(HIL_hmi_pla_akustik), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_pla_bremssymbol" ,getValue(HIL_hmi_pla_bremssymbol), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_pla_schwellpfeil_anzeigen" ,getValue(HIL_hmi_pla_schwellpfeil_anzeigen), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_tankklappe_offen" ,getValue(HIL_hmi_tankklappe_offen), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_tuerzustand_hinten_links" ,getValue(HIL_hmi_tuerzustand_hinten_links), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_tuerzustand_hinten_rechts" ,getValue(HIL_hmi_tuerzustand_hinten_rechts), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_tuerzustand_vorne_links" ,getValue(HIL_hmi_tuerzustand_vorne_links), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_tuerzustand_vorne_rechts" ,getValue(HIL_hmi_tuerzustand_vorne_rechts), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_zpm_meldungsspeicher_anzeigen" ,getValue(HIL_hmi_zpm_meldungsspeicher_anzeigen), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_zpm_piktogrammrolle_anzeigen" ,getValue(HIL_hmi_zpm_piktogrammrolle_anzeigen), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_oeltemperatur_sonderbehandlung" ,getValue(HIL_hmi_bc_oeltemperatur_sonderbehandlung), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_oeltemperatur_vorhanden" ,getValue(HIL_hmi_bc_oeltemperatur_vorhanden), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_BcmE_ConsumerList_available" ,getValue(HIL_hmi_BcmE_ConsumerList_available), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_BcmE_LifeTips_available" ,getValue(HIL_hmi_BcmE_LifeTips_available), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_digitalgeschwindigkeit_available" ,getValue(HIL_hmi_digitalgeschwindigkeit_available), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AGA_ohne_Funktion" ,getValue(HIL_b_AGA_ohne_Funktion), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AGA_Texte" ,getValue(HIL_b_AGA_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BEM_Batteriediagnose" ,getValue(HIL_b_BEM_Batteriediagnose), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BEM_Generatordiagnose" ,getValue(HIL_b_BEM_Generatordiagnose), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BEM_Ladezustand" ,getValue(HIL_b_BEM_Ladezustand), profileFile);
    writeProfileInt("Settings" ,"HIL_b_HVEM_Text_1" ,getValue(HIL_b_HVEM_Text_1), profileFile);
    writeProfileInt("Settings" ,"HIL_b_HVLM_Bat_laden_aktiv" ,getValue(HIL_b_HVLM_Bat_laden_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_b_HVLM_Ladeart" ,getValue(HIL_b_HVLM_Ladeart), profileFile);
    writeProfileInt("Settings" ,"HIL_b_HVLM_Ladesystemhinweise" ,getValue(HIL_b_HVLM_Ladesystemhinweise), profileFile);
    writeProfileInt("Settings" ,"HIL_b_HVLM_Stecker_Status" ,getValue(HIL_b_HVLM_Stecker_Status), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_E_Mode" ,getValue(HIL_b_MO_E_Mode), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_E_Texte" ,getValue(HIL_b_MO_E_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_E_Warnungen" ,getValue(HIL_b_MO_E_Warnungen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_HYB_Fahrbereitschaft" ,getValue(HIL_b_MO_HYB_Fahrbereitschaft), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_RedFahrleistung_Lampe" ,getValue(HIL_b_MO_RedFahrleistung_Lampe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MVK_MV_Netz_Warnungen" ,getValue(HIL_b_MVK_MV_Netz_Warnungen), profileFile);
    writeProfileInt("Settings" ,"HIL_b_NVEM_Batterie_Service" ,getValue(HIL_b_NVEM_Batterie_Service), profileFile);
    writeProfileInt("Settings" ,"HIL_b_NVEM_Bordnetzdiagnose" ,getValue(HIL_b_NVEM_Bordnetzdiagnose), profileFile);
    writeProfileInt("Settings" ,"HIL_b_SI_T_Schutz" ,getValue(HIL_b_SI_T_Schutz), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_momentanrekuperation_not_a_number" ,getValue(HIL_hmi_bc_momentanrekuperation_not_a_number), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_batteriekapazitaet_display" ,getValue(HIL_s_batteriekapazitaet_display), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Fahrbereitschaftsakustik_ausg" ,getValue(HIL_s_Fahrbereitschaftsakustik_ausg), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_Ladezustand_02" ,getValue(HIL_s_Ladezustand_02), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Ladezustand_02_Werte_vorhanden" ,getValue(HIL_s_Ladezustand_02_Werte_vorhanden), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_HYB_Fahrbereitschaft" ,getValue(HIL_s_LED_HYB_Fahrbereitschaft), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_TurtleMode" ,getValue(HIL_s_LED_TurtleMode), profileFile);
    writeProfileInt("Settings" ,"HIL_s_MO_HYB_Fahrbereitschaft_ausg" ,getValue(HIL_s_MO_HYB_Fahrbereitschaft_ausg), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BMS_KundenWarnung" ,getValue(HIL_b_BMS_KundenWarnung), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_fahrzeit_e2" ,getValue(HIL_hmi_bc_fahrzeit_e2), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_fahrzeit_e3" ,getValue(HIL_hmi_bc_fahrzeit_e3), profileFile);
    writeProfileInt("Settings" ,"HIL_s_batteriekapazitaet_anzeigefreigabe" ,getValue(HIL_s_batteriekapazitaet_anzeigefreigabe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_DC_Verbrauch_Ueberlauf" ,getValue(HIL_b_DC_Verbrauch_Ueberlauf), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Rekuperation_EM_Ges_Ueberlauf" ,getValue(HIL_b_MO_Rekuperation_EM_Ges_Ueberlauf), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Rekuperation_Ges_EM" ,getValue(HIL_b_MO_Rekuperation_Ges_EM), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Verbrauch_EM_Ges_Ueberlauf" ,getValue(HIL_b_MO_Verbrauch_EM_Ges_Ueberlauf), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Zust_Antrieb" ,getValue(HIL_b_MO_Zust_Antrieb), profileFile);
    writeProfileInt("Settings" ,"HIL_b_Thermo_Verbrauch_BTL" ,getValue(HIL_b_Thermo_Verbrauch_BTL), profileFile);
    writeProfileInt("Settings" ,"HIL_b_Thermo_Verbrauch_BTL_Ueberlauf" ,getValue(HIL_b_Thermo_Verbrauch_BTL_Ueberlauf), profileFile);
    writeProfileInt("Settings" ,"HIL_s_chrg_reku_gewinn" ,getValue(HIL_s_chrg_reku_gewinn), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BMS_Rekuperation" ,getValue(HIL_b_BMS_Rekuperation), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BMS_Rekuperation_Ueberlauf" ,getValue(HIL_b_BMS_Rekuperation_Ueberlauf), profileFile);
    writeProfileInt("Settings" ,"HIL_b_DC_Verbrauch" ,getValue(HIL_b_DC_Verbrauch), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_Ladezustand_02" ,getValue(HIL_b_Ladezustand_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Verbrauch_EM_Ges" ,getValue(HIL_b_MO_Verbrauch_EM_Ges), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_Ladezustand_02_ausg" ,getValue(HIL_s_Ladezustand_02_ausg), profileFile);
    writeProfileInt("Settings" ,"HIL_b_EV_Rekuperationsstufe" ,getValue(HIL_b_EV_Rekuperationsstufe), profileFile);
    writeProfileInt("Settings" ,"HIL_b_HVLM_Anzeigetexte" ,getValue(HIL_b_HVLM_Anzeigetexte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_HVLM_Restladezeit_HV_Bat_02" ,getValue(HIL_b_HVLM_Restladezeit_HV_Bat_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Waehlpos" ,getValue(HIL_b_MO_Waehlpos), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_RW_Prim_Reichweitenverbrauch" ,getValue(HIL_b_RW_Prim_Reichweitenverbrauch), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RW_Reservewarnung_aktiv" ,getValue(HIL_b_RW_Reservewarnung_aktiv), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_RW_Sek_Reichweitenverbrauch" ,getValue(HIL_b_RW_Sek_Reichweitenverbrauch), profileFile);
    writeProfileInt("Settings" ,"HIL_b_RW_Texte" ,getValue(HIL_b_RW_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_Thermo_Verbrauch_Innen_Ueberlauf" ,getValue(HIL_b_Thermo_Verbrauch_Innen_Ueberlauf), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_chrg_reku_rwgewinn_aktiv" ,getValue(HIL_hmi_chrg_reku_rwgewinn_aktiv), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_MO_ePerformance" ,getValue(HIL_s_MO_ePerformance), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Powermeter_Charge_Grenze" ,getValue(HIL_b_MO_Powermeter_Charge_Grenze), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_MO_Powermeter_Elm_02" ,getValue(HIL_b_MO_Powermeter_Elm_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Powermeter_Grenze_strategisch" ,getValue(HIL_b_MO_Powermeter_Grenze_strategisch), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Powermeter_obere_E_Grenze" ,getValue(HIL_b_MO_Powermeter_obere_E_Grenze), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Powermeter_untere_E_Grenze" ,getValue(HIL_b_MO_Powermeter_untere_E_Grenze), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bargraph_batteriekapazitaet_intern_an" ,getValue(HIL_s_bargraph_batteriekapazitaet_intern_an), profileFile);
    writeProfileInt("Settings" ,"HIL_s_batteriebargraph_extern_an" ,getValue(HIL_s_batteriebargraph_extern_an), profileFile);
    writeProfileInt("Settings" ,"HIL_b_HVK_Gesamtst_Spgfreiheit" ,getValue(HIL_b_HVK_Gesamtst_Spgfreiheit), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Anzeige_Betriebsmodus" ,getValue(HIL_b_MO_Anzeige_Betriebsmodus), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_MO_ePowermeter" ,getValue(HIL_b_MO_ePowermeter), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Powermeter" ,getValue(HIL_b_MO_Powermeter), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Powermeter_Grenze" ,getValue(HIL_b_MO_Powermeter_Grenze), profileFile);
    writeProfileInt("Settings" ,"HIL_s_bargraph_bat_aktiv" ,getValue(HIL_s_bargraph_bat_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_HVK_Gesamtst_Spgfreiheit" ,getValue(HIL_s_HVK_Gesamtst_Spgfreiheit), profileFile);
    writeProfileInt("Settings" ,"HIL_s_powermeter_displayanzeige" ,getValue(HIL_s_powermeter_displayanzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_b_LE_Kuehlmittel_Sensor" ,getValue(HIL_b_LE_Kuehlmittel_Sensor), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_MO_ePerformance" ,getValue(HIL_b_MO_ePerformance), profileFile);
    writeProfileInt("Settings" ,"HIL_b_Thermo_Verbrauch_Innen" ,getValue(HIL_b_Thermo_Verbrauch_Innen), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_chrg_reku_rwgewinn" ,getValue(HIL_hmi_chrg_reku_rwgewinn), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_chrg_reku_rwgewinn_einheit" ,getValue(HIL_hmi_chrg_reku_rwgewinn_einheit), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Batterie_Reserve_BEV" ,getValue(HIL_s_Batterie_Reserve_BEV), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Batterie_Reserve_PHEV" ,getValue(HIL_s_Batterie_Reserve_PHEV), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_ePerformance_displayanzeige" ,getValue(HIL_s_ePerformance_displayanzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Phototransistor" ,getValue(HIL_s_KBI_Phototransistor), profileFile);
    writeProfileInt("Settings" ,"HIL_s_kuehlmittelmangel_LE" ,getValue(HIL_s_kuehlmittelmangel_LE), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fahrzeit_e1" ,getValue(HIL_s_fahrzeit_e1), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fahrzeit_e2" ,getValue(HIL_s_fahrzeit_e2), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_bc_fahrzeit_e1" ,getValue(HIL_hmi_bc_fahrzeit_e1), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fahrzeit_e3" ,getValue(HIL_s_fahrzeit_e3), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsverbrauch_einheit_elektrisch" ,getValue(HIL_hmi_durchschnittsverbrauch_einheit_elektrisch), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_durchschnittsverbrauch_elektrisch_e1" ,getValue(HIL_hmi_durchschnittsverbrauch_elektrisch_e1), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsverbrauch_elektrisch_e1_sonderbehandlung" ,getValue(HIL_hmi_durchschnittsverbrauch_elektrisch_e1_sonderbehandlung), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_durchschnittsverbrauch_elektrisch_e2" ,getValue(HIL_hmi_durchschnittsverbrauch_elektrisch_e2), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsverbrauch_elektrisch_e2_sonderbehandlung" ,getValue(HIL_hmi_durchschnittsverbrauch_elektrisch_e2_sonderbehandlung), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_durchschnittsverbrauch_elektrisch_e3" ,getValue(HIL_hmi_durchschnittsverbrauch_elektrisch_e3), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_durchschnittsverbrauch_elektrisch_e3_sonderbehandlung" ,getValue(HIL_hmi_durchschnittsverbrauch_elektrisch_e3_sonderbehandlung), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_momentanverbrauch_einheit_elektrisch" ,getValue(HIL_hmi_momentanverbrauch_einheit_elektrisch), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_momentanverbrauch_einheit_elektrisch_bargraph" ,getValue(HIL_hmi_momentanverbrauch_einheit_elektrisch_bargraph), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_momentanverbrauch_elektrisch_not_a_number" ,getValue(HIL_hmi_momentanverbrauch_elektrisch_not_a_number), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_momentanverbrauch_elektrisch_not_a_number_bargraph" ,getValue(HIL_hmi_momentanverbrauch_elektrisch_not_a_number_bargraph), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BMS_Verbrauch" ,getValue(HIL_b_BMS_Verbrauch), profileFile);
    writeProfileInt("Settings" ,"HIL_b_BMS_Verbrauch_Ueberlauf" ,getValue(HIL_b_BMS_Verbrauch_Ueberlauf), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_MO_Anzeige_Rekuperation" ,getValue(HIL_b_MO_Anzeige_Rekuperation), profileFile);
    writeProfileInt("Settings" ,"HIL_b_MO_Anzeige_Verbr_Einheit" ,getValue(HIL_b_MO_Anzeige_Verbr_Einheit), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_MO_Anzeige_Verbrauch_oE" ,getValue(HIL_b_MO_Anzeige_Verbrauch_oE), profileFile);
    writeProfileInt("Settings" ,"HIL_s_mv_einheit_verbrauch" ,getValue(HIL_s_mv_einheit_verbrauch), profileFile);
    writeProfileInt("Settings" ,"HIL_s_mv_fahrz_stand" ,getValue(HIL_s_mv_fahrz_stand), profileFile);
    writeProfileInt("Settings" ,"HIL_s_mv_schub_fahrt" ,getValue(HIL_s_mv_schub_fahrt), profileFile);
    writeProfileInt("Settings" ,"HIL_s_mv_schub_stand" ,getValue(HIL_s_mv_schub_stand), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_mv_x_100km" ,getValue(HIL_s_mv_x_100km), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_dv_prozent" ,getValue(HIL_s_dv_prozent), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_dv_prozent_gas" ,getValue(HIL_s_dv_prozent_gas), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_mv_gefiltert" ,getValue(HIL_s_mv_gefiltert), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_mv_mit_hyst" ,getValue(HIL_s_mv_mit_hyst), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_mv_kg_100km_anzverbr" ,getValue(HIL_s_mv_kg_100km_anzverbr), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_mv_mit_reku" ,getValue(HIL_s_mv_mit_reku), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_mv_prozent" ,getValue(HIL_s_mv_prozent), profileFile);
    writeProfileInt("Settings" ,"HIL_s_mv_schub_anzverbr" ,getValue(HIL_s_mv_schub_anzverbr), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_momentanverbrauch_elektrisch" ,getValue(HIL_hmi_momentanverbrauch_elektrisch), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_momentanverbrauch_elektrisch_bargraph" ,getValue(HIL_hmi_momentanverbrauch_elektrisch_bargraph), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_mv_l_100km_anzverbr" ,getValue(HIL_s_mv_l_100km_anzverbr), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_rekuperationsfaktor" ,getValue(HIL_s_rekuperationsfaktor), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_geber_2_roh" ,getValue(HIL_s_tank_vol_geber_2_roh), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_geber_3_roh" ,getValue(HIL_s_tank_vol_geber_3_roh), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_geber_4_roh" ,getValue(HIL_s_tank_vol_geber_4_roh), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_geber_g1_kalibriert_unbegrenzt" ,getValue(HIL_s_tank_vol_geber_g1_kalibriert_unbegrenzt), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_geber_g2_kalibriert_unbegrenzt" ,getValue(HIL_s_tank_vol_geber_g2_kalibriert_unbegrenzt), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_nte_zu" ,getValue(HIL_s_tank_vol_nte_zu), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_geber_g3_kalibriert_unbegrenzt" ,getValue(HIL_s_tank_vol_geber_g3_kalibriert_unbegrenzt), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_geber_g4_kalibriert_unbegrenzt" ,getValue(HIL_s_tank_vol_geber_g4_kalibriert_unbegrenzt), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_geber_gesamt_roh" ,getValue(HIL_s_tank_vol_geber_gesamt_roh), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_zeigerposition_kraftstoffvorrat" ,getValue(HIL_s_zeigerposition_kraftstoffvorrat), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_zeigerposition_kraftstoffvorrat_gas" ,getValue(HIL_s_zeigerposition_kraftstoffvorrat_gas), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_verbr_gewichtung" ,getValue(HIL_s_tank_verbr_gewichtung), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_geber_avrg" ,getValue(HIL_s_tank_vol_geber_avrg), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_geber_avrg_clip" ,getValue(HIL_s_tank_vol_geber_avrg_clip), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_geber_gesamt_kalibriert" ,getValue(HIL_s_tank_vol_geber_gesamt_kalibriert), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_gedaempft" ,getValue(HIL_s_tank_vol_gedaempft), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_ref" ,getValue(HIL_s_tank_vol_ref), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_anzeige" ,getValue(HIL_s_tank_vol_anzeige), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tank_vol_anzeige_alt" ,getValue(HIL_s_tank_vol_anzeige_alt), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_obd_nibble_g1" ,getValue(HIL_s_adc_obd_nibble_g1), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_obd_nibble_g2" ,getValue(HIL_s_adc_obd_nibble_g2), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_obd_nibble_g3" ,getValue(HIL_s_adc_obd_nibble_g3), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_adc_obd_ohmwert_g1" ,getValue(HIL_s_adc_obd_ohmwert_g1), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_adc_obd_ohmwert_g2" ,getValue(HIL_s_adc_obd_ohmwert_g2), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_adc_obd_ohmwert_g3" ,getValue(HIL_s_adc_obd_ohmwert_g3), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_adc_obd_ohmwert_g4" ,getValue(HIL_s_adc_obd_ohmwert_g4), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_ESP_Laengsbeschl" ,getValue(HIL_b_ESP_Laengsbeschl), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_ESP_Querbeschleunigung" ,getValue(HIL_b_ESP_Querbeschleunigung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gastank_warnung_cng" ,getValue(HIL_s_gastank_warnung_cng), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_FStatus_Tank" ,getValue(HIL_s_KBI_FStatus_Tank), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_KBI_Max_Tankinhalt" ,getValue(HIL_s_KBI_Max_Tankinhalt), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_KBI_Min_Tankinhalt" ,getValue(HIL_s_KBI_Min_Tankinhalt), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Tankfuellstand_Prozent" ,getValue(HIL_s_KBI_Tankfuellstand_Prozent), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_KBI_Tankinhalt_hochaufl" ,getValue(HIL_s_KBI_Tankinhalt_hochaufl), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_KBI_Tankinhalt_roh" ,getValue(HIL_s_KBI_Tankinhalt_roh), profileFile);
    writeProfileInt("Settings" ,"HIL_s_adc_obd_nibble_g4" ,getValue(HIL_s_adc_obd_nibble_g4), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Inhalt_Tank" ,getValue(HIL_s_KBI_Inhalt_Tank), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Nachtanken_erkannt" ,getValue(HIL_s_KBI_Nachtanken_erkannt), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Tankwarnung" ,getValue(HIL_s_KBI_Tankwarnung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Tankwarnung_ungueltig" ,getValue(HIL_s_KBI_Tankwarnung_ungueltig), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Anzeige_Objektregelung" ,getValue(HIL_b_ACC_Anzeige_Objektregelung), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_ACC_Sollabstand_1" ,getValue(HIL_b_ACC_Sollabstand_1), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_ACC_Sollabstand_2" ,getValue(HIL_b_ACC_Sollabstand_2), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_ACC_Sollabstand_3" ,getValue(HIL_b_ACC_Sollabstand_3), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_ACC_Sollabstand_4" ,getValue(HIL_b_ACC_Sollabstand_4), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_ACC_Sollabstand_5" ,getValue(HIL_b_ACC_Sollabstand_5), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Statusicon" ,getValue(HIL_b_ACC_Statusicon), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Wunschgeschw_Farbe_02" ,getValue(HIL_b_ACC_Wunschgeschw_Farbe_02), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_aktive_Laengsfunktion_02" ,getValue(HIL_s_KBI_aktive_Laengsfunktion_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Texte_Sekundaeranz_02" ,getValue(HIL_b_ACC_Texte_Sekundaeranz_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Typ_LNS" ,getValue(HIL_b_ACC_Typ_LNS), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Typ_RNS" ,getValue(HIL_b_ACC_Typ_RNS), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Typ_WZO" ,getValue(HIL_b_ACC_Typ_WZO), profileFile);
    writeProfileInt("Settings" ,"HIL_b_PLA_Fortschritt_bis_Zugende" ,getValue(HIL_b_PLA_Fortschritt_bis_Zugende), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Ego_li_Seg1_QuerAbst" ,getValue(HIL_b_TA_HMI_Ego_li_Seg1_QuerAbst), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Ego_li_Typ" ,getValue(HIL_b_TA_HMI_Ego_li_Typ), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Ego_re_Typ" ,getValue(HIL_b_TA_HMI_Ego_re_Typ), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Nachb_li_Typ" ,getValue(HIL_b_TA_HMI_Nachb_li_Typ), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Nachb_re_Typ" ,getValue(HIL_b_TA_HMI_Nachb_re_Typ), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Zoomstufe" ,getValue(HIL_b_TA_HMI_Zoomstufe), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Anzeigefehler_SWA" ,getValue(HIL_s_KBI_Anzeigefehler_SWA), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Anzeigestatus_ACC" ,getValue(HIL_s_KBI_Anzeigestatus_ACC), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_ARA_in_Anzeige" ,getValue(HIL_s_KBI_ARA_in_Anzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Fehler_Anzeige_ACC" ,getValue(HIL_s_KBI_Fehler_Anzeige_ACC), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Konsistenz_ACC" ,getValue(HIL_s_KBI_Konsistenz_ACC), profileFile);
    writeProfileInt("Settings" ,"HIL_s_kbi_pla_in_anzeige" ,getValue(HIL_s_kbi_pla_in_anzeige), profileFile);
    writeProfileInt("Settings" ,"HIL_s_pla_timeout_reakt" ,getValue(HIL_s_pla_timeout_reakt), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Ego_re_Seg1_QuerAbst" ,getValue(HIL_b_TA_HMI_Ego_re_Seg1_QuerAbst), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Nachb_li_Seg1_QuerAbst" ,getValue(HIL_b_TA_HMI_Nachb_li_Seg1_QuerAbst), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Nachb_re_Seg1_QuerAbst" ,getValue(HIL_b_TA_HMI_Nachb_re_Seg1_QuerAbst), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Seg1_Kruemmung" ,getValue(HIL_b_TA_HMI_Seg1_Kruemmung), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Seg2_Beginn" ,getValue(HIL_b_TA_HMI_Seg2_Beginn), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_TrajektSeg2_Beginn" ,getValue(HIL_b_TA_HMI_TrajektSeg2_Beginn), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_01_Typ" ,getValue(HIL_b_TA_HMI_Obj_01_Typ), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Seg1_Gierwinkel" ,getValue(HIL_b_TA_HMI_Seg1_Gierwinkel), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Seg2_Kruemmung" ,getValue(HIL_b_TA_HMI_Seg2_Kruemmung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Spurwechsel_re" ,getValue(HIL_b_TA_HMI_Spurwechsel_re), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_TrajektSeg1_Kruemmung" ,getValue(HIL_b_TA_HMI_TrajektSeg1_Kruemmung), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_TrajektSeg1_QuerAbst" ,getValue(HIL_b_TA_HMI_TrajektSeg1_QuerAbst), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_TrajektSeg2_Kruemmung" ,getValue(HIL_b_TA_HMI_TrajektSeg2_Kruemmung), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_EgoObj_dy" ,getValue(HIL_b_TA_HMI_EgoObj_dy), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Kurvenwarnung" ,getValue(HIL_b_TA_HMI_Kurvenwarnung), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_01_dx" ,getValue(HIL_b_TA_HMI_Obj_01_dx), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_02_Typ" ,getValue(HIL_b_TA_HMI_Obj_02_Typ), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_03_Typ" ,getValue(HIL_b_TA_HMI_Obj_03_Typ), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_04_Typ" ,getValue(HIL_b_TA_HMI_Obj_04_Typ), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_05_Typ" ,getValue(HIL_b_TA_HMI_Obj_05_Typ), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_06_Typ" ,getValue(HIL_b_TA_HMI_Obj_06_Typ), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_07_Typ" ,getValue(HIL_b_TA_HMI_Obj_07_Typ), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_08_Typ" ,getValue(HIL_b_TA_HMI_Obj_08_Typ), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_09_Typ" ,getValue(HIL_b_TA_HMI_Obj_09_Typ), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_10_Typ" ,getValue(HIL_b_TA_HMI_Obj_10_Typ), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_11_Typ" ,getValue(HIL_b_TA_HMI_Obj_11_Typ), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Spurwechsel_li" ,getValue(HIL_b_TA_HMI_Spurwechsel_li), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_TaZoomstufeAktiv" ,getValue(HIL_b_TA_HMI_TaZoomstufeAktiv), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_TrajektSeg1_Gierwinkel" ,getValue(HIL_b_TA_HMI_TrajektSeg1_Gierwinkel), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_TrajektSeg1_Valid" ,getValue(HIL_b_TA_HMI_TrajektSeg1_Valid), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_01_Spurzuordnung" ,getValue(HIL_b_TA_HMI_Obj_01_Spurzuordnung), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_03_dx" ,getValue(HIL_b_TA_HMI_Obj_03_dx), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_04_dx" ,getValue(HIL_b_TA_HMI_Obj_04_dx), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_05_dx" ,getValue(HIL_b_TA_HMI_Obj_05_dx), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_06_dx" ,getValue(HIL_b_TA_HMI_Obj_06_dx), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_07_dx" ,getValue(HIL_b_TA_HMI_Obj_07_dx), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_11_dy" ,getValue(HIL_b_TA_HMI_Obj_11_dy), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_01_dy" ,getValue(HIL_b_TA_HMI_Obj_01_dy), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_02_dy" ,getValue(HIL_b_TA_HMI_Obj_02_dy), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_02_Spurzuordnung" ,getValue(HIL_b_TA_HMI_Obj_02_Spurzuordnung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_03_Spurzuordnung" ,getValue(HIL_b_TA_HMI_Obj_03_Spurzuordnung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_04_Spurzuordnung" ,getValue(HIL_b_TA_HMI_Obj_04_Spurzuordnung), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_08_dx" ,getValue(HIL_b_TA_HMI_Obj_08_dx), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_09_dx" ,getValue(HIL_b_TA_HMI_Obj_09_dx), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_10_dx" ,getValue(HIL_b_TA_HMI_Obj_10_dx), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_11_dx" ,getValue(HIL_b_TA_HMI_Obj_11_dx), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_03_dy" ,getValue(HIL_b_TA_HMI_Obj_03_dy), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_04_dy" ,getValue(HIL_b_TA_HMI_Obj_04_dy), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_05_dy" ,getValue(HIL_b_TA_HMI_Obj_05_dy), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_05_Spurzuordnung" ,getValue(HIL_b_TA_HMI_Obj_05_Spurzuordnung), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_06_dy" ,getValue(HIL_b_TA_HMI_Obj_06_dy), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_06_Spurzuordnung" ,getValue(HIL_b_TA_HMI_Obj_06_Spurzuordnung), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_07_dy" ,getValue(HIL_b_TA_HMI_Obj_07_dy), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_07_Spurzuordnung" ,getValue(HIL_b_TA_HMI_Obj_07_Spurzuordnung), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_08_dy" ,getValue(HIL_b_TA_HMI_Obj_08_dy), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_08_Spurzuordnung" ,getValue(HIL_b_TA_HMI_Obj_08_Spurzuordnung), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_09_dy" ,getValue(HIL_b_TA_HMI_Obj_09_dy), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_TA_HMI_Obj_10_dy" ,getValue(HIL_b_TA_HMI_Obj_10_dy), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_ACC_Abstand_WZO" ,getValue(HIL_b_ACC_Abstand_WZO), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ACC_Status_GRA_Modus" ,getValue(HIL_b_ACC_Status_GRA_Modus), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AWV_AW_Texte" ,getValue(HIL_b_AWV_AW_Texte), profileFile);
    writeProfileInt("Settings" ,"HIL_b_AWV_AW_Zeitluecke" ,getValue(HIL_b_AWV_AW_Zeitluecke), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_01_LaengsRegelung" ,getValue(HIL_b_TA_HMI_Obj_01_LaengsRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_01_QuerRegelung" ,getValue(HIL_b_TA_HMI_Obj_01_QuerRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_02_LaengsRegelung" ,getValue(HIL_b_TA_HMI_Obj_02_LaengsRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_02_QuerRegelung" ,getValue(HIL_b_TA_HMI_Obj_02_QuerRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_03_LaengsRegelung" ,getValue(HIL_b_TA_HMI_Obj_03_LaengsRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_03_QuerRegelung" ,getValue(HIL_b_TA_HMI_Obj_03_QuerRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_04_LaengsRegelung" ,getValue(HIL_b_TA_HMI_Obj_04_LaengsRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_04_QuerRegelung" ,getValue(HIL_b_TA_HMI_Obj_04_QuerRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_05_LaengsRegelung" ,getValue(HIL_b_TA_HMI_Obj_05_LaengsRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_05_QuerRegelung" ,getValue(HIL_b_TA_HMI_Obj_05_QuerRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_06_LaengsRegelung" ,getValue(HIL_b_TA_HMI_Obj_06_LaengsRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_06_QuerRegelung" ,getValue(HIL_b_TA_HMI_Obj_06_QuerRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_07_LaengsRegelung" ,getValue(HIL_b_TA_HMI_Obj_07_LaengsRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_07_QuerRegelung" ,getValue(HIL_b_TA_HMI_Obj_07_QuerRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_08_LaengsRegelung" ,getValue(HIL_b_TA_HMI_Obj_08_LaengsRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_08_QuerRegelung" ,getValue(HIL_b_TA_HMI_Obj_08_QuerRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_09_LaengsRegelung" ,getValue(HIL_b_TA_HMI_Obj_09_LaengsRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_09_QuerRegelung" ,getValue(HIL_b_TA_HMI_Obj_09_QuerRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_09_Spurzuordnung" ,getValue(HIL_b_TA_HMI_Obj_09_Spurzuordnung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_10_LaengsRegelung" ,getValue(HIL_b_TA_HMI_Obj_10_LaengsRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_10_QuerRegelung" ,getValue(HIL_b_TA_HMI_Obj_10_QuerRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_10_Spurzuordnung" ,getValue(HIL_b_TA_HMI_Obj_10_Spurzuordnung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_11_LaengsRegelung" ,getValue(HIL_b_TA_HMI_Obj_11_LaengsRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_11_QuerRegelung" ,getValue(HIL_b_TA_HMI_Obj_11_QuerRegelung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TA_HMI_Obj_11_Spurzuordnung" ,getValue(HIL_b_TA_HMI_Obj_11_Spurzuordnung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Anzeigestatus_GRA" ,getValue(HIL_s_KBI_Anzeigestatus_GRA), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Anzeigestatus_LIM" ,getValue(HIL_s_KBI_Anzeigestatus_LIM), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_GRA" ,getValue(HIL_s_LED_GRA), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_GRA_US" ,getValue(HIL_s_LED_GRA_US), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Laengsregelung" ,getValue(HIL_s_LED_Laengsregelung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Laengsregelung_blinken" ,getValue(HIL_s_LED_Laengsregelung_blinken), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_LIM" ,getValue(HIL_s_LED_LIM), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_LIM_blinken" ,getValue(HIL_s_LED_LIM_blinken), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_FAS_Wunschgeschwindigkeit_in_kodierter_einheit" ,getValue(HIL_hmi_FAS_Wunschgeschwindigkeit_in_kodierter_einheit), profileFile);
    writeProfileInt("Settings" ,"HIL_b_ESC_FBA_Meldungen" ,getValue(HIL_b_ESC_FBA_Meldungen), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_KBI_angez_Geschw_CAN" ,getValue(HIL_s_KBI_angez_Geschw_CAN), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_GAP_Warn_Zeit_abgelaufen" ,getValue(HIL_s_KBI_GAP_Warn_Zeit_abgelaufen), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_KBI_Kilometerstand_HiRes" ,getValue(HIL_s_KBI_Kilometerstand_HiRes), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_MFA_v_Einheit" ,getValue(HIL_s_KBI_MFA_v_Einheit), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_RDK_Kalibrier_Anf" ,getValue(HIL_s_KBI_RDK_Kalibrier_Anf), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_V_Digital" ,getValue(HIL_s_KBI_V_Digital), profileFile);
    writeProfileInt("Settings" ,"HIL_s_radumfang_mittel" ,getValue(HIL_s_radumfang_mittel), profileFile);
    writeProfileInt("Settings" ,"HIL_s_tageswegstrecke_reset" ,getValue(HIL_s_tageswegstrecke_reset), profileFile);
    writeProfileInt("Settings" ,"HIL_b_DBK_Fahrerwarnung" ,getValue(HIL_b_DBK_Fahrerwarnung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_EPB_Fehlermeldungen_02" ,getValue(HIL_b_EPB_Fehlermeldungen_02), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_navi_rg_distancebargraph_available" ,getValue(HIL_hmi_navi_rg_distancebargraph_available), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_navi_rg_timebargraph_available" ,getValue(HIL_hmi_navi_rg_timebargraph_available), profileFile);
    writeProfileInt("Settings" ,"HIL_s_feststellbremse_konv_ausg" ,getValue(HIL_s_feststellbremse_konv_ausg), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Weg_Zaehler" ,getValue(HIL_s_KBI_Weg_Zaehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Weg_Zaehler_F" ,getValue(HIL_s_KBI_Weg_Zaehler_F), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_EPB_NAR_rot" ,getValue(HIL_s_LED_EPB_NAR_rot), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_EPB_RDW_rot" ,getValue(HIL_s_LED_EPB_RDW_rot), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_tageswegstrecke" ,getValue(HIL_s_tageswegstrecke), profileFile);
    writeProfileInt("Settings" ,"HIL_b_KBI_Kilometerstand_HiRes_meter" ,getValue(HIL_b_KBI_Kilometerstand_HiRes_meter), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_HistoryState_LeftTube_PHEV_Skin0" ,getValue(HIL_hmi_HistoryState_LeftTube_PHEV_Skin0), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_HistoryState_LeftTube_PHEV_Skin1" ,getValue(HIL_hmi_HistoryState_LeftTube_PHEV_Skin1), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_HistoryState_LeftTube_PHEV_Skin2" ,getValue(HIL_hmi_HistoryState_LeftTube_PHEV_Skin2), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_HistoryState_Nebenanzeige_Skin0" ,getValue(HIL_hmi_HistoryState_Nebenanzeige_Skin0), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_HistoryState_Nebenanzeige_Skin1" ,getValue(HIL_hmi_HistoryState_Nebenanzeige_Skin1), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_HistoryState_Nebenanzeige_Skin2" ,getValue(HIL_hmi_HistoryState_Nebenanzeige_Skin2), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_HistoryState_Zusatzanzeige_Skin1" ,getValue(HIL_hmi_HistoryState_Zusatzanzeige_Skin1), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_aktive_Nebenanzeige_links" ,getValue(HIL_hmi_aktive_Nebenanzeige_links), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_aktive_Nebenanzeige_rechts" ,getValue(HIL_hmi_aktive_Nebenanzeige_rechts), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_aktiver_View" ,getValue(HIL_hmi_aktiver_View), profileFile);
    writeProfileInt("Settings" ,"HIL_s_DTC_Kombi_defekt" ,getValue(HIL_s_DTC_Kombi_defekt), profileFile);
    writeProfileInt("Settings" ,"HIL_s_DTC_TI_B200FF0" ,getValue(HIL_s_DTC_TI_B200FF0), profileFile);
    writeProfileInt("Settings" ,"HIL_s_DTC_TI_B174404" ,getValue(HIL_s_DTC_TI_B174404), profileFile);
    writeProfileInt("Settings" ,"HIL_s_DTC_TI_B200041" ,getValue(HIL_s_DTC_TI_B200041), profileFile);
    writeProfileInt("Settings" ,"HIL_s_DTC_TI_B200043" ,getValue(HIL_s_DTC_TI_B200043), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Einheit_Datum" ,getValue(HIL_s_KBI_Einheit_Datum), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Einheit_Druck" ,getValue(HIL_s_KBI_Einheit_Druck), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Einheit_Masse" ,getValue(HIL_s_KBI_Einheit_Masse), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Einheit_Streckenanz" ,getValue(HIL_s_KBI_Einheit_Streckenanz), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Einheit_Tacho" ,getValue(HIL_s_KBI_Einheit_Tacho), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Einheit_Temp" ,getValue(HIL_s_KBI_Einheit_Temp), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Einheit_Verbrauch" ,getValue(HIL_s_KBI_Einheit_Verbrauch), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Einheit_Verbrauch_elektr" ,getValue(HIL_s_KBI_Einheit_Verbrauch_elektr), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Einheit_Verbrauch_Gas" ,getValue(HIL_s_KBI_Einheit_Verbrauch_Gas), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Einheit_Volumen" ,getValue(HIL_s_KBI_Einheit_Volumen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_im_Stellgliedtest" ,getValue(HIL_s_KBI_im_Stellgliedtest), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_KD_fehler" ,getValue(HIL_s_KBI_KD_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Variante" ,getValue(HIL_s_KBI_Variante), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Kombi_01_BZ" ,getValue(HIL_s_Kombi_01_BZ), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Kombi_Abschaltstufe" ,getValue(HIL_s_Kombi_Abschaltstufe), profileFile);
    writeProfileInt("Settings" ,"HIL_s_Kombi_Transport_Mode" ,getValue(HIL_s_Kombi_Transport_Mode), profileFile);
    writeProfileInt("Settings" ,"HIL_s_NM_Kombi_CAB" ,getValue(HIL_s_NM_Kombi_CAB), profileFile);
    writeProfileInt("Settings" ,"HIL_s_NM_Kombi_Car_Wakeup" ,getValue(HIL_s_NM_Kombi_Car_Wakeup), profileFile);
    writeProfileInt("Settings" ,"HIL_s_NM_Kombi_NM_aktiv_Buzzer" ,getValue(HIL_s_NM_Kombi_NM_aktiv_Buzzer), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_MO_Anzeige_Leistung" ,getValue(HIL_b_MO_Anzeige_Leistung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TSK_Einheit_vMax_FahrerInfo" ,getValue(HIL_b_TSK_Einheit_vMax_FahrerInfo), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TSK_vMax_FahrerInfo" ,getValue(HIL_b_TSK_vMax_FahrerInfo), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_laufender_Motor" ,getValue(HIL_b_WIV_laufender_Motor), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_nicht_betriebswarm" ,getValue(HIL_b_WIV_nicht_betriebswarm), profileFile);
    writeProfileInt("Settings" ,"HIL_b_WIV_Schieflage" ,getValue(HIL_b_WIV_Schieflage), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_service_sonderbehandlung" ,getValue(HIL_hmi_service_sonderbehandlung), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_WBA_Schaltempfehlung_vorhanden" ,getValue(HIL_hmi_WBA_Schaltempfehlung_vorhanden), profileFile);
    writeProfileInt("Settings" ,"HIL_s_fusi_Auto_P" ,getValue(HIL_s_fusi_Auto_P), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Oelwechsel_durchgefuehrt" ,getValue(HIL_s_KBI_Oelwechsel_durchgefuehrt), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Standzeit_02" ,getValue(HIL_s_KBI_Standzeit_02), profileFile);
    writeProfileInt("Settings" ,"HIL_s_LED_Oeldruck" ,getValue(HIL_s_LED_Oeldruck), profileFile);
    writeProfileInt("Settings" ,"HIL_s_manuell_zeit_datum_monat" ,getValue(HIL_s_manuell_zeit_datum_monat), profileFile);
    writeProfileInt("Settings" ,"HIL_s_manuell_zeit_uhrzeit_sekunde" ,getValue(HIL_s_manuell_zeit_uhrzeit_sekunde), profileFile);
    writeProfileInt("Settings" ,"HIL_s_NM_Kombi_Wakeup" ,getValue(HIL_s_NM_Kombi_Wakeup), profileFile);
    writeProfileInt("Settings" ,"HIL_s_UH_DLS" ,getValue(HIL_s_UH_DLS), profileFile);
    writeProfileInt("Settings" ,"HIL_s_insp_restlauf_km" ,getValue(HIL_s_insp_restlauf_km), profileFile);
    writeProfileInt("Settings" ,"HIL_s_insp_restlauf_tage" ,getValue(HIL_s_insp_restlauf_tage), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oil_ueberschreitung_km" ,getValue(HIL_s_oil_ueberschreitung_km), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oil_ueberschreitung_tage" ,getValue(HIL_s_oil_ueberschreitung_tage), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oil_restlauf_km" ,getValue(HIL_s_oil_restlauf_km), profileFile);
    writeProfileInt("Settings" ,"HIL_s_oil_restlauf_tage" ,getValue(HIL_s_oil_restlauf_tage), profileFile);
    writeProfileInt("Settings" ,"HIL_s_service_restlauf_km" ,getValue(HIL_s_service_restlauf_km), profileFile);
    writeProfileInt("Settings" ,"HIL_s_service_restlauf_tage" ,getValue(HIL_s_service_restlauf_tage), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_gMeter_ax_oben_max" ,getValue(HIL_s_gMeter_ax_oben_max), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_gMeter_ax_unten_max" ,getValue(HIL_s_gMeter_ax_unten_max), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_gMeter_ay_links_max" ,getValue(HIL_s_gMeter_ay_links_max), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_gMeter_ay_rechts_max" ,getValue(HIL_s_gMeter_ay_rechts_max), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gMeter_Winkel" ,getValue(HIL_s_gMeter_Winkel), profileFile);
    writeProfileInt("Settings" ,"HIL_set_HMI_G_max_Reset" ,getValue(HIL_set_HMI_G_max_Reset), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_boot_download_finished" ,getValue(HIL_hmi_boot_download_finished), profileFile);
    writeProfileFloat("Settings" ,"HIL_hmi_laptimer_letzte_rundenzeit" ,getValue(HIL_hmi_laptimer_letzte_rundenzeit), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_laptimer_rundenzeiten" ,getValue(HIL_s_laptimer_rundenzeiten), profileFile);
    writeProfileInt("Settings" ,"HIL_s_manuell_zeit_datum_jahr" ,getValue(HIL_s_manuell_zeit_datum_jahr), profileFile);
    writeProfileInt("Settings" ,"HIL_s_manuell_zeit_datum_tag" ,getValue(HIL_s_manuell_zeit_datum_tag), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_dzm_zeigerposition_drehzahl" ,getValue(HIL_s_dzm_zeigerposition_drehzahl), profileFile);
    writeProfileInt("Settings" ,"HIL_s_emv_reku_delta_dc" ,getValue(HIL_s_emv_reku_delta_dc), profileFile);
    writeProfileInt("Settings" ,"HIL_s_emv_reku_delta_weg" ,getValue(HIL_s_emv_reku_delta_weg), profileFile);
    writeProfileInt("Settings" ,"HIL_s_emv_reku_mv_nebenverbrauch" ,getValue(HIL_s_emv_reku_mv_nebenverbrauch), profileFile);
    writeProfileInt("Settings" ,"HIL_s_emv_reku_delta_antrieb_reku" ,getValue(HIL_s_emv_reku_delta_antrieb_reku), profileFile);
    writeProfileInt("Settings" ,"HIL_s_emv_reku_delta_antrieb_verbr" ,getValue(HIL_s_emv_reku_delta_antrieb_verbr), profileFile);
    writeProfileInt("Settings" ,"HIL_s_emv_reku_delta_tme" ,getValue(HIL_s_emv_reku_delta_tme), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_emv_reku_mv_antrieb_hyst" ,getValue(HIL_s_emv_reku_mv_antrieb_hyst), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_emv_reku_dv_slider_prozent" ,getValue(HIL_s_emv_reku_dv_slider_prozent), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_emv_reku_mv_gesamt_nachfilter" ,getValue(HIL_s_emv_reku_mv_gesamt_nachfilter), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_emv_reku_mv_gesamt_prozent" ,getValue(HIL_s_emv_reku_mv_gesamt_prozent), profileFile);
    writeProfileInt("Settings" ,"HIL_s_emv_reku_stand_umsch_aktiv" ,getValue(HIL_s_emv_reku_stand_umsch_aktiv), profileFile);
    writeProfileInt("Settings" ,"HIL_s_KBI_Kilometerstand" ,getValue(HIL_s_KBI_Kilometerstand), profileFile);
    writeProfileInt("Settings" ,"HIL_b_KBI_Kilometerstand_Extended" ,getValue(HIL_b_KBI_Kilometerstand_Extended), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_emv_reku_mv_antrieb" ,getValue(HIL_s_emv_reku_mv_antrieb), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_GNSS_V_Geschw" ,getValue(HIL_s_GNSS_V_Geschw), profileFile);
    writeProfileInt("Settings" ,"HIL_s_radumfang_korrektur" ,getValue(HIL_s_radumfang_korrektur), profileFile);
    writeProfileInt("Settings" ,"HIL_s_radumfang_opt" ,getValue(HIL_s_radumfang_opt), profileFile);
    writeProfileInt("Settings" ,"HIL_s_radumfang_sync" ,getValue(HIL_s_radumfang_sync), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_GNSS_V_Geschw_2D" ,getValue(HIL_b_GNSS_V_Geschw_2D), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_GNSS_V_Geschw_Vertikal" ,getValue(HIL_b_GNSS_V_Geschw_Vertikal), profileFile);
    writeProfileInt("Settings" ,"HIL_s_GNSS_Geschw_fehler" ,getValue(HIL_s_GNSS_Geschw_fehler), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_sync_ESP_m_Raddrehz" ,getValue(HIL_s_sync_ESP_m_Raddrehz), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_sync_GNSS_V_Geschw" ,getValue(HIL_s_sync_GNSS_V_Geschw), profileFile);
    writeProfileInt("Settings" ,"HIL_b_GNSS_Nachrichtenpaket_ID5" ,getValue(HIL_b_GNSS_Nachrichtenpaket_ID5), profileFile);
    writeProfileInt("Settings" ,"HIL_b_GNSS_Nachrichtenpaket_ID7" ,getValue(HIL_b_GNSS_Nachrichtenpaket_ID7), profileFile);
    writeProfileInt("Settings" ,"HIL_b_GNSS_V_FIX_Typ" ,getValue(HIL_b_GNSS_V_FIX_Typ), profileFile);
    writeProfileInt("Settings" ,"HIL_b_GNSS_V_Latenz_vollstaendig" ,getValue(HIL_b_GNSS_V_Latenz_vollstaendig), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_Gewichtungsfaktor_altersbasiert" ,getValue(HIL_s_Gewichtungsfaktor_altersbasiert), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_Gewichtungsfaktor_geschwindigkeitsbasiert" ,getValue(HIL_s_Gewichtungsfaktor_geschwindigkeitsbasiert), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_Gewichtungsfaktor_Ringspeicher" ,getValue(HIL_s_Gewichtungsfaktor_Ringspeicher), profileFile);
    writeProfileInt("Settings" ,"HIL_s_GNSS_2D_fehler" ,getValue(HIL_s_GNSS_2D_fehler), profileFile);
    writeProfileInt("Settings" ,"HIL_s_GNSS_3D_fehler" ,getValue(HIL_s_GNSS_3D_fehler), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_koeff_lernen_verlernen" ,getValue(HIL_s_koeff_lernen_verlernen), profileFile);
    writeProfileInt("Settings" ,"HIL_s_laenge_puffer_zeitliche_synchronisierung" ,getValue(HIL_s_laenge_puffer_zeitliche_synchronisierung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_n_Eintraege_Ringspeicher" ,getValue(HIL_s_n_Eintraege_Ringspeicher), profileFile);
    writeProfileInt("Settings" ,"HIL_s_trigger_ringspeicher" ,getValue(HIL_s_trigger_ringspeicher), profileFile);
    writeProfileInt("Settings" ,"HIL_b_GNSS_UTC_Zeit" ,getValue(HIL_b_GNSS_UTC_Zeit), profileFile);
    writeProfileInt("Settings" ,"HIL_b_GNSS_V_Daten_Veraltet" ,getValue(HIL_b_GNSS_V_Daten_Veraltet), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_GNSS_V_Geschw_2D_Guete95" ,getValue(HIL_b_GNSS_V_Geschw_2D_Guete95), profileFile);
    writeProfileFloat("Settings" ,"HIL_b_GNSS_V_Geschw_Vertikal_Guete95" ,getValue(HIL_b_GNSS_V_Geschw_Vertikal_Guete95), profileFile);
    writeProfileInt("Settings" ,"HIL_s_sync_GNSS_UTC_Zeit" ,getValue(HIL_s_sync_GNSS_UTC_Zeit), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_gMeter_ax_oben" ,getValue(HIL_s_gMeter_ax_oben), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_gMeter_ax_oben_kz_max" ,getValue(HIL_s_gMeter_ax_oben_kz_max), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_gMeter_ax_unten" ,getValue(HIL_s_gMeter_ax_unten), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_gMeter_ax_unten_kz_max" ,getValue(HIL_s_gMeter_ax_unten_kz_max), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_gMeter_ay_links" ,getValue(HIL_s_gMeter_ay_links), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_gMeter_ay_rechts" ,getValue(HIL_s_gMeter_ay_rechts), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gMeter_ax_oben_kz_max_prozent" ,getValue(HIL_s_gMeter_ax_oben_kz_max_prozent), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gMeter_ax_oben_max_prozent" ,getValue(HIL_s_gMeter_ax_oben_max_prozent), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gMeter_ax_unten_kz_max_prozent" ,getValue(HIL_s_gMeter_ax_unten_kz_max_prozent), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gMeter_ax_unten_max_prozent" ,getValue(HIL_s_gMeter_ax_unten_max_prozent), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gMeter_ay_links_kz_max_prozent" ,getValue(HIL_s_gMeter_ay_links_kz_max_prozent), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gMeter_ay_links_max_prozent" ,getValue(HIL_s_gMeter_ay_links_max_prozent), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gMeter_ay_rechts_kz_max_prozent" ,getValue(HIL_s_gMeter_ay_rechts_kz_max_prozent), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gMeter_ay_rechts_max_prozent" ,getValue(HIL_s_gMeter_ay_rechts_max_prozent), profileFile);
    writeProfileInt("Settings" ,"HIL_b_FDR_M_HL_02" ,getValue(HIL_b_FDR_M_HL_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_FDR_M_HR_02" ,getValue(HIL_b_FDR_M_HR_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_FDR_M_VL_02" ,getValue(HIL_b_FDR_M_VL_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_FDR_M_VR_02" ,getValue(HIL_b_FDR_M_VR_02), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TSL_Warnung" ,getValue(HIL_b_TSL_Warnung), profileFile);
    writeProfileInt("Settings" ,"HIL_b_TSR_Warnung" ,getValue(HIL_b_TSR_Warnung), profileFile);
    writeProfileInt("Settings" ,"HIL_hmi_gmeter_aktuelle_Darstellung" ,getValue(HIL_hmi_gmeter_aktuelle_Darstellung), profileFile);
    writeProfileInt("Settings" ,"HIL_s_gMeter_anzeige_ungueltig" ,getValue(HIL_s_gMeter_anzeige_ungueltig), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_gMeter_ay_links_kz_max" ,getValue(HIL_s_gMeter_ay_links_kz_max), profileFile);
    writeProfileFloat("Settings" ,"HIL_s_gMeter_ay_rechts_kz_max" ,getValue(HIL_s_gMeter_ay_rechts_kz_max), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_Message_Counter_BVT" ,getValue(ENV_UDPNM_Message_Counter_BVT), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_CouplewithCANNM" ,getValue(ENV_UDPNM_CouplewithCANNM), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSynWithKombiSimulationNode" ,getValue(ENV_UDPSynWithKombiSimulationNode), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendKombiSimulationNMMsg" ,getValue(ENV_UDPSendKombiSimulationNMMsg), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendEnabled" ,getValue(ENV_UDPSendEnabled), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_Gateway" ,getValue(ENV_UDPSendNMH_Gateway), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_Gateway_NM_StateS" ,getValue(ENV_UDPNM_Gateway_NM_StateS), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_eCall" ,getValue(ENV_UDPSendNMH_eCall), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_Kombi_NM_StateD" ,getValue(ENV_UDPNM_Kombi_NM_StateD), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineState" ,getValue(ENV_UDPNMHStateMachineState), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHControllerNodeAwake" ,getValue(ENV_UDPNMHControllerNodeAwake), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineEnabled" ,getValue(ENV_UDPNMHStateMachineEnabled), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHState" ,getValue(ENV_UDPNMHState), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHMode" ,getValue(ENV_UDPNMHMode), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendAtOnceNMH_Gateway" ,getValue(ENV_UDPSendAtOnceNMH_Gateway), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHLastState" ,getValue(ENV_UDPNMHLastState), profileFile);
    writeProfileInt("Settings" ,"ENV_ETHPingStartStop" ,getValue(ENV_ETHPingStartStop), profileFile);
    writeProfileInt("Settings" ,"ENV_ETHPingSendCnt" ,getValue(ENV_ETHPingSendCnt), profileFile);
    writeProfileInt("Settings" ,"ENV_ETHPingRecvCnt" ,getValue(ENV_ETHPingRecvCnt), profileFile);
    writeProfileInt("Settings" ,"ENV_ETHPingLostCnt" ,getValue(ENV_ETHPingLostCnt), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_CouplewithCANNM_ETH02" ,getValue(ENV_UDPNM_CouplewithCANNM_ETH02), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendKombiSimulationNMMsg_ETH02" ,getValue(ENV_UDPSendKombiSimulationNMMsg_ETH02), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendEnabled_ETH02" ,getValue(ENV_UDPSendEnabled_ETH02), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_Gateway_ETH02" ,getValue(ENV_UDPSendNMH_Gateway_ETH02), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_Gateway_NM_StateS_ETH02" ,getValue(ENV_UDPNM_Gateway_NM_StateS_ETH02), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_eCall_ETH02" ,getValue(ENV_UDPSendNMH_eCall_ETH02), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineState_ETH02" ,getValue(ENV_UDPNMHStateMachineState_ETH02), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHControllerNodeAwake_ETH02" ,getValue(ENV_UDPNMHControllerNodeAwake_ETH02), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineEnabled_ETH02" ,getValue(ENV_UDPNMHStateMachineEnabled_ETH02), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHState_ETH02" ,getValue(ENV_UDPNMHState_ETH02), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHMode_ETH02" ,getValue(ENV_UDPNMHMode_ETH02), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendAtOnceNMH_Gateway_ETH02" ,getValue(ENV_UDPSendAtOnceNMH_Gateway_ETH02), profileFile);
    writeProfileInt("Settings" ,"ENV_ON_OFF_FSG50_2" ,getValue(ENV_ON_OFF_FSG50_2), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_CouplewithCANNM_ETH03" ,getValue(ENV_UDPNM_CouplewithCANNM_ETH03), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendKombiSimulationNMMsg_ETH03" ,getValue(ENV_UDPSendKombiSimulationNMMsg_ETH03), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendEnabled_ETH03" ,getValue(ENV_UDPSendEnabled_ETH03), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_Gateway_ETH03" ,getValue(ENV_UDPSendNMH_Gateway_ETH03), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_Gateway_NM_StateS_ETH03" ,getValue(ENV_UDPNM_Gateway_NM_StateS_ETH03), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_eCall_ETH03" ,getValue(ENV_UDPSendNMH_eCall_ETH03), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineState_ETH03" ,getValue(ENV_UDPNMHStateMachineState_ETH03), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHControllerNodeAwake_ETH03" ,getValue(ENV_UDPNMHControllerNodeAwake_ETH03), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineEnabled_ETH03" ,getValue(ENV_UDPNMHStateMachineEnabled_ETH03), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHState_ETH03" ,getValue(ENV_UDPNMHState_ETH03), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHMode_ETH03" ,getValue(ENV_UDPNMHMode_ETH03), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendAtOnceNMH_Gateway_ETH03" ,getValue(ENV_UDPSendAtOnceNMH_Gateway_ETH03), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_CouplewithCANNM_ETH04" ,getValue(ENV_UDPNM_CouplewithCANNM_ETH04), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendKombiSimulationNMMsg_ETH04" ,getValue(ENV_UDPSendKombiSimulationNMMsg_ETH04), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendEnabled_ETH04" ,getValue(ENV_UDPSendEnabled_ETH04), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_Gateway_ETH04" ,getValue(ENV_UDPSendNMH_Gateway_ETH04), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_Gateway_NM_StateS_ETH04" ,getValue(ENV_UDPNM_Gateway_NM_StateS_ETH04), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_eCall_ETH04" ,getValue(ENV_UDPSendNMH_eCall_ETH04), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineState_ETH04" ,getValue(ENV_UDPNMHStateMachineState_ETH04), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHControllerNodeAwake_ETH04" ,getValue(ENV_UDPNMHControllerNodeAwake_ETH04), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineEnabled_ETH04" ,getValue(ENV_UDPNMHStateMachineEnabled_ETH04), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHState_ETH04" ,getValue(ENV_UDPNMHState_ETH04), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHMode_ETH04" ,getValue(ENV_UDPNMHMode_ETH04), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendAtOnceNMH_Gateway_ETH04" ,getValue(ENV_UDPSendAtOnceNMH_Gateway_ETH04), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_CouplewithCANNM_ETH05" ,getValue(ENV_UDPNM_CouplewithCANNM_ETH05), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendKombiSimulationNMMsg_ETH05" ,getValue(ENV_UDPSendKombiSimulationNMMsg_ETH05), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendEnabled_ETH05" ,getValue(ENV_UDPSendEnabled_ETH05), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_Gateway_ETH05" ,getValue(ENV_UDPSendNMH_Gateway_ETH05), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_Gateway_NM_StateS_ETH05" ,getValue(ENV_UDPNM_Gateway_NM_StateS_ETH05), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_eCall_ETH05" ,getValue(ENV_UDPSendNMH_eCall_ETH05), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineState_ETH05" ,getValue(ENV_UDPNMHStateMachineState_ETH05), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHControllerNodeAwake_ETH05" ,getValue(ENV_UDPNMHControllerNodeAwake_ETH05), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineEnabled_ETH05" ,getValue(ENV_UDPNMHStateMachineEnabled_ETH05), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHState_ETH05" ,getValue(ENV_UDPNMHState_ETH05), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHMode_ETH05" ,getValue(ENV_UDPNMHMode_ETH05), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendAtOnceNMH_Gateway_ETH05" ,getValue(ENV_UDPSendAtOnceNMH_Gateway_ETH05), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_CouplewithCANNM_ETH06" ,getValue(ENV_UDPNM_CouplewithCANNM_ETH06), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendKombiSimulationNMMsg_ETH06" ,getValue(ENV_UDPSendKombiSimulationNMMsg_ETH06), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendEnabled_ETH06" ,getValue(ENV_UDPSendEnabled_ETH06), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_Gateway_ETH06" ,getValue(ENV_UDPSendNMH_Gateway_ETH06), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_Gateway_NM_StateS_ETH06" ,getValue(ENV_UDPNM_Gateway_NM_StateS_ETH06), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_eCall_ETH06" ,getValue(ENV_UDPSendNMH_eCall_ETH06), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineState_ETH06" ,getValue(ENV_UDPNMHStateMachineState_ETH06), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHControllerNodeAwake_ETH06" ,getValue(ENV_UDPNMHControllerNodeAwake_ETH06), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineEnabled_ETH06" ,getValue(ENV_UDPNMHStateMachineEnabled_ETH06), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHState_ETH06" ,getValue(ENV_UDPNMHState_ETH06), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHMode_ETH06" ,getValue(ENV_UDPNMHMode_ETH06), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendAtOnceNMH_Gateway_ETH06" ,getValue(ENV_UDPSendAtOnceNMH_Gateway_ETH06), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_CouplewithCANNM_ETH07" ,getValue(ENV_UDPNM_CouplewithCANNM_ETH07), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendKombiSimulationNMMsg_ETH07" ,getValue(ENV_UDPSendKombiSimulationNMMsg_ETH07), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendEnabled_ETH07" ,getValue(ENV_UDPSendEnabled_ETH07), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_Gateway_ETH07" ,getValue(ENV_UDPSendNMH_Gateway_ETH07), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_Gateway_NM_StateS_ETH07" ,getValue(ENV_UDPNM_Gateway_NM_StateS_ETH07), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_eCall_ETH07" ,getValue(ENV_UDPSendNMH_eCall_ETH07), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineState_ETH07" ,getValue(ENV_UDPNMHStateMachineState_ETH07), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHControllerNodeAwake_ETH07" ,getValue(ENV_UDPNMHControllerNodeAwake_ETH07), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineEnabled_ETH07" ,getValue(ENV_UDPNMHStateMachineEnabled_ETH07), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHState_ETH07" ,getValue(ENV_UDPNMHState_ETH07), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHMode_ETH07" ,getValue(ENV_UDPNMHMode_ETH07), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendAtOnceNMH_Gateway_ETH07" ,getValue(ENV_UDPSendAtOnceNMH_Gateway_ETH07), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_CouplewithCANNM_ETH08" ,getValue(ENV_UDPNM_CouplewithCANNM_ETH08), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendKombiSimulationNMMsg_ETH08" ,getValue(ENV_UDPSendKombiSimulationNMMsg_ETH08), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendEnabled_ETH08" ,getValue(ENV_UDPSendEnabled_ETH08), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_Gateway_ETH08" ,getValue(ENV_UDPSendNMH_Gateway_ETH08), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_Gateway_NM_StateS_ETH08" ,getValue(ENV_UDPNM_Gateway_NM_StateS_ETH08), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_eCall_ETH08" ,getValue(ENV_UDPSendNMH_eCall_ETH08), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineState_ETH08" ,getValue(ENV_UDPNMHStateMachineState_ETH08), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHControllerNodeAwake_ETH08" ,getValue(ENV_UDPNMHControllerNodeAwake_ETH08), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineEnabled_ETH08" ,getValue(ENV_UDPNMHStateMachineEnabled_ETH08), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHState_ETH08" ,getValue(ENV_UDPNMHState_ETH08), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHMode_ETH08" ,getValue(ENV_UDPNMHMode_ETH08), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendAtOnceNMH_Gateway_ETH08" ,getValue(ENV_UDPSendAtOnceNMH_Gateway_ETH08), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_CouplewithCANNM_ETH09" ,getValue(ENV_UDPNM_CouplewithCANNM_ETH09), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendKombiSimulationNMMsg_ETH09" ,getValue(ENV_UDPSendKombiSimulationNMMsg_ETH09), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendEnabled_ETH09" ,getValue(ENV_UDPSendEnabled_ETH09), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_Gateway_ETH09" ,getValue(ENV_UDPSendNMH_Gateway_ETH09), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_Gateway_NM_StateS_ETH09" ,getValue(ENV_UDPNM_Gateway_NM_StateS_ETH09), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_eCall_ETH09" ,getValue(ENV_UDPSendNMH_eCall_ETH09), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineState_ETH09" ,getValue(ENV_UDPNMHStateMachineState_ETH09), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHControllerNodeAwake_ETH09" ,getValue(ENV_UDPNMHControllerNodeAwake_ETH09), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineEnabled_ETH09" ,getValue(ENV_UDPNMHStateMachineEnabled_ETH09), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHState_ETH09" ,getValue(ENV_UDPNMHState_ETH09), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHMode_ETH09" ,getValue(ENV_UDPNMHMode_ETH09), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendAtOnceNMH_Gateway_ETH09" ,getValue(ENV_UDPSendAtOnceNMH_Gateway_ETH09), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_CouplewithCANNM_ETH10" ,getValue(ENV_UDPNM_CouplewithCANNM_ETH10), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendKombiSimulationNMMsg_ETH10" ,getValue(ENV_UDPSendKombiSimulationNMMsg_ETH10), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendEnabled_ETH10" ,getValue(ENV_UDPSendEnabled_ETH10), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_Gateway_ETH10" ,getValue(ENV_UDPSendNMH_Gateway_ETH10), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_Gateway_NM_StateS_ETH10" ,getValue(ENV_UDPNM_Gateway_NM_StateS_ETH10), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_eCall_ETH10" ,getValue(ENV_UDPSendNMH_eCall_ETH10), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineState_ETH10" ,getValue(ENV_UDPNMHStateMachineState_ETH10), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHControllerNodeAwake_ETH10" ,getValue(ENV_UDPNMHControllerNodeAwake_ETH10), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineEnabled_ETH10" ,getValue(ENV_UDPNMHStateMachineEnabled_ETH10), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHState_ETH10" ,getValue(ENV_UDPNMHState_ETH10), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHMode_ETH10" ,getValue(ENV_UDPNMHMode_ETH10), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendAtOnceNMH_Gateway_ETH10" ,getValue(ENV_UDPSendAtOnceNMH_Gateway_ETH10), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_CouplewithCANNM_ETH11" ,getValue(ENV_UDPNM_CouplewithCANNM_ETH11), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendKombiSimulationNMMsg_ETH11" ,getValue(ENV_UDPSendKombiSimulationNMMsg_ETH11), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendEnabled_ETH11" ,getValue(ENV_UDPSendEnabled_ETH11), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_Gateway_ETH11" ,getValue(ENV_UDPSendNMH_Gateway_ETH11), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_Gateway_NM_StateS_ETH11" ,getValue(ENV_UDPNM_Gateway_NM_StateS_ETH11), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_eCall_ETH11" ,getValue(ENV_UDPSendNMH_eCall_ETH11), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineState_ETH11" ,getValue(ENV_UDPNMHStateMachineState_ETH11), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHControllerNodeAwake_ETH11" ,getValue(ENV_UDPNMHControllerNodeAwake_ETH11), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineEnabled_ETH11" ,getValue(ENV_UDPNMHStateMachineEnabled_ETH11), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHState_ETH11" ,getValue(ENV_UDPNMHState_ETH11), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHMode_ETH11" ,getValue(ENV_UDPNMHMode_ETH11), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendAtOnceNMH_Gateway_ETH11" ,getValue(ENV_UDPSendAtOnceNMH_Gateway_ETH11), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_CouplewithCANNM_ETH12" ,getValue(ENV_UDPNM_CouplewithCANNM_ETH12), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendKombiSimulationNMMsg_ETH12" ,getValue(ENV_UDPSendKombiSimulationNMMsg_ETH12), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendEnabled_ETH12" ,getValue(ENV_UDPSendEnabled_ETH12), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_Gateway_ETH12" ,getValue(ENV_UDPSendNMH_Gateway_ETH12), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNM_Gateway_NM_StateS_ETH12" ,getValue(ENV_UDPNM_Gateway_NM_StateS_ETH12), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendNMH_eCall_ETH12" ,getValue(ENV_UDPSendNMH_eCall_ETH12), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineState_ETH12" ,getValue(ENV_UDPNMHStateMachineState_ETH12), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHControllerNodeAwake_ETH12" ,getValue(ENV_UDPNMHControllerNodeAwake_ETH12), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHStateMachineEnabled_ETH12" ,getValue(ENV_UDPNMHStateMachineEnabled_ETH12), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHState_ETH12" ,getValue(ENV_UDPNMHState_ETH12), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPNMHMode_ETH12" ,getValue(ENV_UDPNMHMode_ETH12), profileFile);
    writeProfileInt("Settings" ,"ENV_UDPSendAtOnceNMH_Gateway_ETH12" ,getValue(ENV_UDPSendAtOnceNMH_Gateway_ETH12), profileFile);
    writeProfileInt("Settings" ,"ENV_VideoType_Ch01" ,getValue(ENV_VideoType_Ch01), profileFile);
    writeProfileInt("Settings" ,"ENV_VideoType_Ch02" ,getValue(ENV_VideoType_Ch02), profileFile);
    writeProfileInt("Settings" ,"ENV_VideoType_Ch03" ,getValue(ENV_VideoType_Ch03), profileFile);
    writeProfileInt("Settings" ,"ENV_VideoType_Ch04" ,getValue(ENV_VideoType_Ch04), profileFile);
    writeProfileInt("Settings" ,"ENV_VideoType_Ch05" ,getValue(ENV_VideoType_Ch05), profileFile);
    writeProfileInt("Settings" ,"ENV_VideoType_Ch06" ,getValue(ENV_VideoType_Ch06), profileFile);
    writeProfileInt("Settings" ,"ENV_VideoType_Ch07" ,getValue(ENV_VideoType_Ch07), profileFile);
    writeProfileInt("Settings" ,"ENV_VideoType_Ch08" ,getValue(ENV_VideoType_Ch08), profileFile);
    writeProfileInt("Settings" ,"ENV_VideoType_Ch09" ,getValue(ENV_VideoType_Ch09), profileFile);
    writeProfileInt("Settings" ,"ENV_VideoType_Ch10" ,getValue(ENV_VideoType_Ch10), profileFile);
    writeProfileInt("Settings" ,"ENV_VideoType_Ch11" ,getValue(ENV_VideoType_Ch11), profileFile);
    writeProfileInt("Settings" ,"ENV_VideoType_Ch12" ,getValue(ENV_VideoType_Ch12), profileFile);
    writeProfileInt("Settings" ,"ENV_NMHControllerNodeAwake" ,getValue(ENV_NMHControllerNodeAwake), profileFile);
    writeProfileInt("Settings" ,"ENV_EthernetLEDLinkStatus" ,getValue(ENV_EthernetLEDLinkStatus), profileFile);

}


void loadSettings( char profileFile[] )
{
    //putValue( eSaveSettings_To_ini, getProfileInt( "Settings", "eSaveSettings_To_ini", 1, profileFile ) );/*Loading the value of Save settings widget from ini file*/
    
    loadSettings_AAA_01( profileFile );
    loadSettings_ACC_19( profileFile );
    loadSettings_AGA_01( profileFile );
    loadSettings_Airbag_01( profileFile );
    loadSettings_Airbag_02( profileFile );
    loadSettings_Airbag_04( profileFile );
    loadSettings_Airbag_06( profileFile );
    loadSettings_Anhaenger_01( profileFile );
    loadSettings_ARA_Status_01( profileFile );
    loadSettings_ARC_HUD_Req_FD( profileFile );
    loadSettings_ARC_HUD_Resp_FD( profileFile );
    loadSettings_AWV_02( profileFile );
    loadSettings_AZK_01( profileFile );
    loadSettings_BCM_01( profileFile );
    loadSettings_BCM_03( profileFile );
    loadSettings_BCM_04( profileFile );
    loadSettings_BCM_Taster_02( profileFile );
    loadSettings_BCM_Taster_03( profileFile );
    loadSettings_BEM_02( profileFile );
    loadSettings_BEM_06( profileFile );
    loadSettings_Blinkmodi_02( profileFile );
    loadSettings_BMS_05( profileFile );
    loadSettings_BMS_07( profileFile );
    loadSettings_Bremse_EV_02( profileFile );
    loadSettings_Charisma_03( profileFile );
    loadSettings_Daempfer_01( profileFile );
    loadSettings_Daempfer_05( profileFile );
    loadSettings_DCDC_02( profileFile );
    loadSettings_DEV_SmaLi_Tx_01( profileFile );
    loadSettings_DEV_ZR_Produktion_1_Rx_1D( profileFile );
    loadSettings_DEV_ZR_Produktion_1_Tx_1C( profileFile );
    loadSettings_DEV_ZR_Req_0D( profileFile );
    loadSettings_DEV_ZR_Resp_00( profileFile );
    loadSettings_DEV_ZR_SmaLi_01_Tx( profileFile );
    loadSettings_DEV_ZR_Tx_14( profileFile );
    loadSettings_DEV_ZR_Tx_15( profileFile );
    loadSettings_DIA_ABT_1_Req( profileFile );
    loadSettings_DIA_ABT_1_Resp( profileFile );
    loadSettings_Diagnose_01( profileFile );
    loadSettings_DiETa_01( profileFile );
    loadSettings_Dimmung_01( profileFile );
    loadSettings_DispKBI_FS_01( profileFile );
    loadSettings_DispKBI_FS_DispPos_Req_FD( profileFile );
    loadSettings_DispKBI_FS_DispPos_Resp_FD( profileFile );
    loadSettings_Display_1_03( profileFile );
    loadSettings_DispPos_DispKBI_FS_Req_FD( profileFile );
    loadSettings_DispPos_DispKBI_FS_Resp_FD( profileFile );
    loadSettings_EA_02( profileFile );
    loadSettings_ELV_01( profileFile );
    loadSettings_EML_06( profileFile );
    loadSettings_EML_07( profileFile );
    loadSettings_Entfernungen_01( profileFile );
    loadSettings_EPB_03( profileFile );
    loadSettings_ESC_50( profileFile );
    loadSettings_ESC_51( profileFile );
    loadSettings_ESP_10( profileFile );
    loadSettings_ESP_20( profileFile );
    loadSettings_ESP_21( profileFile );
    loadSettings_ESP_24( profileFile );
    loadSettings_ESP_30( profileFile );
    loadSettings_FAS_Anzeigen_01( profileFile );
    loadSettings_FoD_01( profileFile );
    loadSettings_FoD_Kombi_Req( profileFile );
    loadSettings_FoD_Kombi_Resp( profileFile );
    loadSettings_FoD_ZR_Req( profileFile );
    loadSettings_FoD_ZR_Resp( profileFile );
    loadSettings_Gateway_71( profileFile );
    loadSettings_Gateway_73( profileFile );
    loadSettings_Getriebe_16( profileFile );
    loadSettings_Heckradar_01( profileFile );
    loadSettings_HID_DispKBI_FS_ZR_Req_FD( profileFile );
    loadSettings_HID_DispKBI_FS_ZR_Resp_FD( profileFile );
    loadSettings_HID_HUD_ZR_Req_FD( profileFile );
    loadSettings_HID_HUD_ZR_Resp_FD( profileFile );
    loadSettings_HID_ZR_DispKBI_FS_Req_FD( profileFile );
    loadSettings_HID_ZR_DispKBI_FS_Resp_FD( profileFile );
    loadSettings_HID_ZR_HUD_Req_FD( profileFile );
    loadSettings_HID_ZR_HUD_Resp_FD( profileFile );
    loadSettings_HUD_ARC_Req_FD( profileFile );
    loadSettings_HUD_ARC_Resp_FD( profileFile );
    loadSettings_HVK_01( profileFile );
    loadSettings_IPA_02( profileFile );
    loadSettings_ISO_Funktionaler_Req_All( profileFile );
    loadSettings_ISO_HUD_Req( profileFile );
    loadSettings_ISO_HUD_Resp( profileFile );
    loadSettings_ISO_Kombi_Req( profileFile );
    loadSettings_ISO_Kombi_Resp( profileFile );
    loadSettings_ISO_NFCIApp_NFCIServ_Req( profileFile );
    loadSettings_ISO_NFCIApp_NFCIServ_Resp( profileFile );
    loadSettings_ISO_NFCIServ_NFCIApp_Req( profileFile );
    loadSettings_ISO_NFCIServ_NFCIApp_Resp( profileFile );
    loadSettings_ISOx_DispKBI_FS_Req( profileFile );
    loadSettings_ISOx_DispKBI_FS_Req_FD( profileFile );
    loadSettings_ISOx_DispKBI_FS_Resp( profileFile );
    loadSettings_ISOx_DispKBI_FS_Resp_FD( profileFile );
    loadSettings_ISOx_Funkt_Req_All_FD( profileFile );
    loadSettings_ISOx_HUD_Req_FD( profileFile );
    loadSettings_ISOx_HUD_Resp_FD( profileFile );
    loadSettings_ISOx_Kombi_Req_FD( profileFile );
    loadSettings_ISOx_Kombi_Resp_FD( profileFile );
    loadSettings_ISOx_SmLi_01_Req( profileFile );
    loadSettings_ISOx_SmLi_01_Req_FD( profileFile );
    loadSettings_ISOx_SmLi_01_Resp( profileFile );
    loadSettings_ISOx_SmLi_01_Resp_FD( profileFile );
    loadSettings_ISOx_WLC1_Req( profileFile );
    loadSettings_ISOx_WLC1_Resp( profileFile );
    loadSettings_Kessy_04( profileFile );
    loadSettings_Klemmen_Status_01( profileFile );
    loadSettings_Klemmen_Status_02( profileFile );
    loadSettings_Klemmen_Steuerung_01( profileFile );
    loadSettings_Klima_03( profileFile );
    loadSettings_Klima_06( profileFile );
    loadSettings_Klima_12( profileFile );
    loadSettings_Klima_16( profileFile );
    loadSettings_Klima_Sensor_02( profileFile );
    loadSettings_KN_DispKBI_FS( profileFile );
    loadSettings_KN_Gateway( profileFile );
    loadSettings_KN_HUD( profileFile );
    loadSettings_KN_Info_El( profileFile );
    loadSettings_KN_Kombi( profileFile );
    loadSettings_KN_SmLi_1( profileFile );
    loadSettings_Kombi_01( profileFile );
    loadSettings_Kombi_02( profileFile );
    loadSettings_Kombi_03( profileFile );
    loadSettings_Kombi_08( profileFile );
    loadSettings_Kombi_21( profileFile );
    loadSettings_Kombi_HUD_01( profileFile );
    loadSettings_KonzernrollenModus_01( profileFile );
    loadSettings_KS_ICAS3Sys01_Req_FD( profileFile );
    loadSettings_KS_ICAS3Sys01_Resp_FD( profileFile );
    loadSettings_KS_Info_El_Req_FD( profileFile );
    loadSettings_KS_Info_El_Resp_FD( profileFile );
    loadSettings_KS_Kombi_Req_FD( profileFile );
    loadSettings_KS_Kombi_Resp_FD( profileFile );
    loadSettings_KS_SSN_ABT_1_Req( profileFile );
    loadSettings_KS_SSN_ABT_1_Resp( profileFile );
    loadSettings_LDW_02( profileFile );
    loadSettings_LH_EPS_01( profileFile );
    loadSettings_Licht_Anf_01( profileFile );
    loadSettings_Licht_hinten_01( profileFile );
    loadSettings_Licht_vorne_01( profileFile );
    loadSettings_LiSi_01( profileFile );
    loadSettings_LWI_01( profileFile );
    loadSettings_MainUnit_01( profileFile );
    loadSettings_Mem_BFS_01( profileFile );
    loadSettings_Mem_FS_01( profileFile );
    loadSettings_MFG_01( profileFile );
    loadSettings_MFL_01( profileFile );
    loadSettings_MFL_02( profileFile );
    loadSettings_MFL_Anf_01( profileFile );
    loadSettings_MFL_Tasten_Kon_01( profileFile );
    loadSettings_Motor_14( profileFile );
    loadSettings_Motor_18( profileFile );
    loadSettings_Motor_26( profileFile );
    loadSettings_Motor_41( profileFile );
    loadSettings_Motor_51( profileFile );
    loadSettings_Motor_52( profileFile );
    loadSettings_Motor_53( profileFile );
    loadSettings_Motor_54( profileFile );
    loadSettings_Motor_57( profileFile );
    loadSettings_Motor_Hybrid_06( profileFile );
    loadSettings_NavData_01( profileFile );
    loadSettings_NavData_02( profileFile );
    loadSettings_NavData_03( profileFile );
    loadSettings_NavData_04( profileFile );
    loadSettings_NavPos_01( profileFile );
    loadSettings_NavPos_02_Map_Matched( profileFile );
    loadSettings_NFC_01( profileFile );
    loadSettings_NFC_MiKo_01( profileFile );
    loadSettings_NMH_DispKBI_FS( profileFile );
    loadSettings_NMH_Gateway( profileFile );
    loadSettings_NMH_HUD( profileFile );
    loadSettings_NMH_Info_El( profileFile );
    loadSettings_NMH_Kombi( profileFile );
    loadSettings_NMH_SmLi_01( profileFile );
    loadSettings_OBDC_DispKBI_FS_Req_FD( profileFile );
    loadSettings_OBDC_DispKBI_FS_Resp_FD( profileFile );
    loadSettings_OBDC_Funktionaler_Req_All( profileFile );
    loadSettings_OBDC_Funktionaler_Req_All_FD( profileFile );
    loadSettings_OBDC_HUD_Req_FD( profileFile );
    loadSettings_OBDC_HUD_Resp_FD( profileFile );
    loadSettings_OBDC_Kombi_Req_FD( profileFile );
    loadSettings_OBDC_Kombi_Resp_FD( profileFile );
    loadSettings_OBDC_SmLi_01_Req_FD( profileFile );
    loadSettings_OBDC_SmLi_01_Resp_FD( profileFile );
    loadSettings_OBDC_SSN_ABT_1_Req( profileFile );
    loadSettings_OBDC_SSN_ABT_1_Resp( profileFile );
    loadSettings_OBDC_WLC1_Req( profileFile );
    loadSettings_OBDC_WLC1_Resp( profileFile );
    loadSettings_OBDx_allOBD_Req( profileFile );
    loadSettings_ORU_01( profileFile );
    loadSettings_Parkhilfe_01( profileFile );
    loadSettings_Parkhilfe_04( profileFile );
    loadSettings_Personalisierung_01( profileFile );
    loadSettings_PreCrash_02( profileFile );
    loadSettings_PSD_04( profileFile );
    loadSettings_PSD_05( profileFile );
    loadSettings_PSD_06( profileFile );
    loadSettings_PSD_LR_01( profileFile );
    loadSettings_Radio_01( profileFile );
    loadSettings_Rear_View_04( profileFile );
    loadSettings_Rear_View_06( profileFile );
    loadSettings_Reichweite_01( profileFile );
    loadSettings_Reichweite_02( profileFile );
    loadSettings_Reichweite_03( profileFile );
    loadSettings_RKA_01( profileFile );
    loadSettings_RLS_01( profileFile );
    loadSettings_RLS_02( profileFile );
    loadSettings_SAL_01( profileFile );
    loadSettings_SAM_01( profileFile );
    loadSettings_Sensorik_Dimmung_01( profileFile );
    loadSettings_SmaLi_Control_Frame_01( profileFile );
    loadSettings_SmaLi_Daten_Frame_01( profileFile );
    loadSettings_SmaLi_Daten_Frame_02( profileFile );
    loadSettings_SmaLi_Daten_Frame_03( profileFile );
    loadSettings_SmaLi_Daten_Frame_04( profileFile );
    loadSettings_SmaLi_Response_Frame_01( profileFile );
    loadSettings_SMLS_01( profileFile );
    loadSettings_Systeminfo_01( profileFile );
    loadSettings_TA_01( profileFile );
    loadSettings_Temperaturen_01( profileFile );
    loadSettings_Thermo_Verbrauch_01( profileFile );
    loadSettings_TM_01( profileFile );
    loadSettings_TSG_BT_01( profileFile );
    loadSettings_TSG_FT_01( profileFile );
    loadSettings_TSG_FT_02( profileFile );
    loadSettings_TSG_HBFS_01( profileFile );
    loadSettings_TSG_HFS_01( profileFile );
    loadSettings_UserStateServer_01( profileFile );
    loadSettings_VIN_01( profileFile );
    loadSettings_VLK_01( profileFile );
    loadSettings_VZE_04( profileFile );
    loadSettings_WBA_03( profileFile );
    loadSettings_WFS_01( profileFile );
    loadSettings_WFS_Transponder_Req_02( profileFile );
    loadSettings_WFS_Transponder_Resp_02( profileFile );
    loadSettings_WFS_Transponder_Status_02( profileFile );
    loadSettings_Wischer_01( profileFile );
    loadSettings_WLC1_01( profileFile );
    loadSettings_XCP_SmaLi_CRO_01( profileFile );
    loadSettings_XCP_SmaLi_DTO_01( profileFile );
    loadSettings_Zeitmaster_02( profileFile );
    loadSettings_Zentralrechner_01( profileFile );
    loadSettings_ZV_02( profileFile );
    loadSettings_ZV_04( profileFile );

    loadENVars( profileFile );
}

void loadSettings_AAA_01( char profileFile[] )
{
    putValue( KCAN_AAA_Abbruchgrund, getProfileInt( "AAA_01", "AAA_Abbruchgrund", 0, profileFile ) );
    putValue( KCAN_AAA_Anf_Meldungen, getProfileInt( "AAA_01", "AAA_Anf_Meldungen", 0, profileFile ) );
    putValue( KCAN_AAA_Anf_Sonder_Funktion_Status, getProfileInt( "AAA_01", "AAA_Anf_Sonder_Funktion_Status", 0, profileFile ) );
    putValue( KCAN_AAA_Anf_Sonder_Klemme_15, getProfileInt( "AAA_01", "AAA_Anf_Sonder_Klemme_15", 0, profileFile ) );
    putValue( KCAN_AAA_Anf_WFS_Freigabe, getProfileInt( "AAA_01", "AAA_Anf_WFS_Freigabe", 0, profileFile ) );
    putValue( KCAN_AAA_Klauenerkennung_aktivieren, getProfileInt( "AAA_01", "AAA_Klauenerkennung_aktivieren", 0, profileFile ) );
    putValue( KCAN_AAA_Klauenerkennung_Reset, getProfileInt( "AAA_01", "AAA_Klauenerkennung_Reset", 0, profileFile ) );
    putValue( KCAN_AAA_PaCo_FunctionState, getProfileInt( "AAA_01", "AAA_PaCo_FunctionState", 0, profileFile ) );
    putValue( KCAN_AAA_PaCo_MainState, getProfileInt( "AAA_01", "AAA_PaCo_MainState", 0, profileFile ) );
    putValue( KCAN_AAA_PaCo_RemoteState, getProfileInt( "AAA_01", "AAA_PaCo_RemoteState", 0, profileFile ) );

}


void loadSettings_ACC_19( char profileFile[] )
{
    putValue( KCAN_AbstWarn_LRR_FAS_Fkt_Status, getProfileInt( "ACC_19", "AbstWarn_LRR_FAS_Fkt_Status", 0, profileFile ) );
    putValue( KCAN_ACA_Hinweistexte, getProfileInt( "ACC_19", "ACA_Hinweistexte", 0, profileFile ) );
    putValue( KCAN_ACA_Querfuehrung, getProfileInt( "ACC_19", "ACA_Querfuehrung", 0, profileFile ) );
    putValue( KCAN_ACA_Querfuehrung_Texte, getProfileInt( "ACC_19", "ACA_Querfuehrung_Texte", 0, profileFile ) );
    putValue( KCAN_ACC_Abstand_Abstandswarner, getProfileInt( "ACC_19", "ACC_Abstand_Abstandswarner", 0, profileFile ) );
    putValue( KCAN_ACC_Abstand_LNS, getProfileFloat( "ACC_19", "ACC_Abstand_LNS", 0, profileFile ) );
    putValue( KCAN_ACC_Abstand_RNS, getProfileFloat( "ACC_19", "ACC_Abstand_RNS", 0, profileFile ) );
    putValue( KCAN_ACC_Abstand_WZO, getProfileFloat( "ACC_19", "ACC_Abstand_WZO", 0, profileFile ) );
    putValue( KCAN_ACC_Abstandsindex_02, getProfileInt( "ACC_19", "ACC_Abstandsindex_02", 0, profileFile ) );
    putValue( KCAN_ACC_Akustik_03, getProfileInt( "ACC_19", "ACC_Akustik_03", 0, profileFile ) );
    putValue( KCAN_ACC_Anzeige_Maximalabstand, getProfileInt( "ACC_19", "ACC_Anzeige_Maximalabstand", 0, profileFile ) );
    putValue( KCAN_ACC_Anzeige_Objektregelung, getProfileInt( "ACC_19", "ACC_Anzeige_Objektregelung", 0, profileFile ) );
    putValue( KCAN_ACC_Anzeige_Zeitluecke, getProfileInt( "ACC_19", "ACC_Anzeige_Zeitluecke", 0, profileFile ) );
    putValue( KCAN_ACC_Display_Prio, getProfileInt( "ACC_19", "ACC_Display_Prio", 0, profileFile ) );
    putValue( KCAN_ACC_EGO_Fahrzeug, getProfileInt( "ACC_19", "ACC_EGO_Fahrzeug", 0, profileFile ) );
    putValue( KCAN_ACC_Einheit_Abstandswarner, getProfileInt( "ACC_19", "ACC_Einheit_Abstandswarner", 0, profileFile ) );
    putValue( KCAN_ACC_Einheit_maxSetzgeschw, getProfileInt( "ACC_19", "ACC_Einheit_maxSetzgeschw", 0, profileFile ) );
    putValue( KCAN_ACC_ENG_Texte, getProfileInt( "ACC_19", "ACC_ENG_Texte", 0, profileFile ) );
    putValue( KCAN_ACC_FoD_Status, getProfileInt( "ACC_19", "ACC_FoD_Status", 0, profileFile ) );
    putValue( KCAN_ACC_Geschw_Zielfahrzeug, getProfileFloat( "ACC_19", "ACC_Geschw_Zielfahrzeug", 0, profileFile ) );
    putValue( KCAN_ACC_Gesetzte_Zeitluecke, getProfileInt( "ACC_19", "ACC_Gesetzte_Zeitluecke", 0, profileFile ) );
    putValue( KCAN_ACC_Kurvenassistent, getProfileInt( "ACC_19", "ACC_Kurvenassistent", 0, profileFile ) );
    putValue( KCAN_ACC_maxRegelgeschw, getProfileFloat( "ACC_19", "ACC_maxRegelgeschw", 0, profileFile ) );
    putValue( KCAN_ACC_maxSetzgeschw, getProfileInt( "ACC_19", "ACC_maxSetzgeschw", 0, profileFile ) );
    putValue( KCAN_ACC_minRegelgeschw, getProfileFloat( "ACC_19", "ACC_minRegelgeschw", 0, profileFile ) );
    putValue( KCAN_ACC_Modus_Pop_Up, getProfileInt( "ACC_19", "ACC_Modus_Pop_Up", 0, profileFile ) );
    putValue( KCAN_ACC_Optischer_Fahrerhinweis, getProfileInt( "ACC_19", "ACC_Optischer_Fahrerhinweis", 0, profileFile ) );
    putValue( KCAN_ACC_Regelgeschw, getProfileFloat( "ACC_19", "ACC_Regelgeschw", 0, profileFile ) );
    putValue( KCAN_ACC_Regelung_AIO, getProfileInt( "ACC_19", "ACC_Regelung_AIO", 0, profileFile ) );
    putValue( KCAN_ACC_rel_Objekt_Zusatzanz, getProfileInt( "ACC_19", "ACC_rel_Objekt_Zusatzanz", 0, profileFile ) );
    putValue( KCAN_ACC_Relevantes_Objekt_02, getProfileInt( "ACC_19", "ACC_Relevantes_Objekt_02", 0, profileFile ) );
    putValue( KCAN_ACC_RUV, getProfileInt( "ACC_19", "ACC_RUV", 0, profileFile ) );
    putValue( KCAN_ACC_Sollabstand_1, getProfileFloat( "ACC_19", "ACC_Sollabstand_1", 0, profileFile ) );
    putValue( KCAN_ACC_Sollabstand_2, getProfileFloat( "ACC_19", "ACC_Sollabstand_2", 0, profileFile ) );
    putValue( KCAN_ACC_Sollabstand_3, getProfileFloat( "ACC_19", "ACC_Sollabstand_3", 0, profileFile ) );
    putValue( KCAN_ACC_Sollabstand_4, getProfileFloat( "ACC_19", "ACC_Sollabstand_4", 0, profileFile ) );
    putValue( KCAN_ACC_Sollabstand_5, getProfileFloat( "ACC_19", "ACC_Sollabstand_5", 0, profileFile ) );
    putValue( KCAN_ACC_STA_Text, getProfileInt( "ACC_19", "ACC_STA_Text", 0, profileFile ) );
    putValue( KCAN_ACC_Status_Anzeige, getProfileInt( "ACC_19", "ACC_Status_Anzeige", 0, profileFile ) );
    putValue( KCAN_ACC_Status_GRA_Modus, getProfileInt( "ACC_19", "ACC_Status_GRA_Modus", 0, profileFile ) );
    putValue( KCAN_ACC_Status_Stauende, getProfileInt( "ACC_19", "ACC_Status_Stauende", 0, profileFile ) );
    putValue( KCAN_ACC_Statusicon, getProfileInt( "ACC_19", "ACC_Statusicon", 0, profileFile ) );
    putValue( KCAN_ACC_Tachokranz, getProfileInt( "ACC_19", "ACC_Tachokranz", 0, profileFile ) );
    putValue( KCAN_ACC_Tempolimit, getProfileInt( "ACC_19", "ACC_Tempolimit", 0, profileFile ) );
    putValue( KCAN_ACC_Tempolimit_Einheit, getProfileInt( "ACC_19", "ACC_Tempolimit_Einheit", 0, profileFile ) );
    putValue( KCAN_ACC_Tempolimitassistent_02, getProfileInt( "ACC_19", "ACC_Tempolimitassistent_02", 0, profileFile ) );
    putValue( KCAN_ACC_Texte_02, getProfileInt( "ACC_19", "ACC_Texte_02", 0, profileFile ) );
    putValue( KCAN_ACC_Texte_Abstandswarner, getProfileInt( "ACC_19", "ACC_Texte_Abstandswarner", 0, profileFile ) );
    putValue( KCAN_ACC_Texte_Primaeranz_03, getProfileInt( "ACC_19", "ACC_Texte_Primaeranz_03", 0, profileFile ) );
    putValue( KCAN_ACC_Texte_Sekundaeranz, getProfileInt( "ACC_19", "ACC_Texte_Sekundaeranz", 0, profileFile ) );
    putValue( KCAN_ACC_Texte_Sekundaeranz_02, getProfileInt( "ACC_19", "ACC_Texte_Sekundaeranz_02", 0, profileFile ) );
    putValue( KCAN_ACC_Texte_Zusatzanz_03, getProfileInt( "ACC_19", "ACC_Texte_Zusatzanz_03", 0, profileFile ) );
    putValue( KCAN_ACC_Typ_LNS, getProfileInt( "ACC_19", "ACC_Typ_LNS", 0, profileFile ) );
    putValue( KCAN_ACC_Typ_RNS, getProfileInt( "ACC_19", "ACC_Typ_RNS", 0, profileFile ) );
    putValue( KCAN_ACC_Typ_Tachokranz, getProfileInt( "ACC_19", "ACC_Typ_Tachokranz", 0, profileFile ) );
    putValue( KCAN_ACC_Typ_Tachokranz_unten, getProfileInt( "ACC_19", "ACC_Typ_Tachokranz_unten", 0, profileFile ) );
    putValue( KCAN_ACC_Typ_WZO, getProfileInt( "ACC_19", "ACC_Typ_WZO", 0, profileFile ) );
    putValue( KCAN_ACC_Vorz_Abstandswarner, getProfileInt( "ACC_19", "ACC_Vorz_Abstandswarner", 0, profileFile ) );
    putValue( KCAN_ACC_Warnhinweis, getProfileInt( "ACC_19", "ACC_Warnhinweis", 0, profileFile ) );
    putValue( KCAN_ACC_Warnung_Verkehrszeichen_1, getProfileInt( "ACC_19", "ACC_Warnung_Verkehrszeichen_1", 0, profileFile ) );
    putValue( KCAN_ACC_Wunschgeschw_02, getProfileFloat( "ACC_19", "ACC_Wunschgeschw_02", 0, profileFile ) );
    putValue( KCAN_ACC_Wunschgeschw_erreicht, getProfileInt( "ACC_19", "ACC_Wunschgeschw_erreicht", 0, profileFile ) );
    putValue( KCAN_ACC_Wunschgeschw_Farbe, getProfileInt( "ACC_19", "ACC_Wunschgeschw_Farbe", 0, profileFile ) );
    putValue( KCAN_ACC_Wunschgeschw_Farbe_02, getProfileInt( "ACC_19", "ACC_Wunschgeschw_Farbe_02", 0, profileFile ) );
    putValue( KCAN_ACC_Zeitluecke_Abstandswarner, getProfileFloat( "ACC_19", "ACC_Zeitluecke_Abstandswarner", 0, profileFile ) );
    putValue( KCAN_FAS_Licht_Anf, getProfileInt( "ACC_19", "FAS_Licht_Anf", 0, profileFile ) );
    putValue( KCAN_STA_Primaeranz, getProfileInt( "ACC_19", "STA_Primaeranz", 0, profileFile ) );
    putValue( KCAN_STA_Texte, getProfileInt( "ACC_19", "STA_Texte", 0, profileFile ) );
    putValue( KCAN_STA_Zusatzanz, getProfileInt( "ACC_19", "STA_Zusatzanz", 0, profileFile ) );

}


void loadSettings_AGA_01( char profileFile[] )
{
    putValue( KCAN_AGA_Charisma_FahrPr, getProfileInt( "AGA_01", "AGA_Charisma_FahrPr", 0, profileFile ) );
    putValue( KCAN_AGA_Charisma_Status, getProfileInt( "AGA_01", "AGA_Charisma_Status", 0, profileFile ) );
    putValue( KCAN_AGA_ohne_Funktion, getProfileInt( "AGA_01", "AGA_ohne_Funktion", 0, profileFile ) );
    putValue( KCAN_AGA_Texte, getProfileInt( "AGA_01", "AGA_Texte", 0, profileFile ) );
    putValue( KCAN_AGA_Verstaerker_Mute, getProfileInt( "AGA_01", "AGA_Verstaerker_Mute", 0, profileFile ) );
    putValue( KCAN_E_Sound_verbaut, getProfileInt( "AGA_01", "E_Sound_verbaut", 0, profileFile ) );

}


void loadSettings_Airbag_01( char profileFile[] )
{
    putValue( KCAN_AB_Anzeige_Fussg, getProfileInt( "Airbag_01", "AB_Anzeige_Fussg", 0, profileFile ) );
    putValue( KCAN_AB_Belegung_VF, getProfileInt( "Airbag_01", "AB_Belegung_VF", 0, profileFile ) );
    putValue( KCAN_AB_Crash_Int, getProfileInt( "Airbag_01", "AB_Crash_Int", 0, profileFile ) );
    putValue( KCAN_AB_Deaktiviert, getProfileInt( "Airbag_01", "AB_Deaktiviert", 0, profileFile ) );
    putValue( KCAN_AB_Deaktivierung_HV, getProfileInt( "Airbag_01", "AB_Deaktivierung_HV", 0, profileFile ) );
    putValue( KCAN_AB_Diagnose, getProfileInt( "Airbag_01", "AB_Diagnose", 0, profileFile ) );
    putValue( KCAN_AB_EDR_Trigger, getProfileInt( "Airbag_01", "AB_EDR_Trigger", 0, profileFile ) );
    putValue( KCAN_AB_Erh_Auf_VB, getProfileInt( "Airbag_01", "AB_Erh_Auf_VB", 0, profileFile ) );
    putValue( KCAN_AB_Front_Crash, getProfileInt( "Airbag_01", "AB_Front_Crash", 0, profileFile ) );
    putValue( KCAN_AB_Gurtschloss_FA_ext, getProfileInt( "Airbag_01", "AB_Gurtschloss_FA_ext", 0, profileFile ) );
    putValue( KCAN_AB_Gurtschloss_FA_ext_aktiv, getProfileInt( "Airbag_01", "AB_Gurtschloss_FA_ext_aktiv", 0, profileFile ) );
    putValue( KCAN_AB_Gurtwarn_VB, getProfileInt( "Airbag_01", "AB_Gurtwarn_VB", 0, profileFile ) );
    putValue( KCAN_AB_Gurtwarn_VF, getProfileInt( "Airbag_01", "AB_Gurtwarn_VF", 0, profileFile ) );
    putValue( KCAN_AB_Heck_Crash, getProfileInt( "Airbag_01", "AB_Heck_Crash", 0, profileFile ) );
    putValue( KCAN_AB_Lampe, getProfileInt( "Airbag_01", "AB_Lampe", 0, profileFile ) );
    putValue( KCAN_AB_MKB_Anforderung, getProfileInt( "Airbag_01", "AB_MKB_Anforderung", 0, profileFile ) );
    putValue( KCAN_AB_MKB_gueltig, getProfileInt( "Airbag_01", "AB_MKB_gueltig", 0, profileFile ) );
    putValue( KCAN_AB_PAO_Leuchte_Anf, getProfileInt( "Airbag_01", "AB_PAO_Leuchte_Anf", 0, profileFile ) );
    putValue( KCAN_AB_RGS_Anst, getProfileInt( "Airbag_01", "AB_RGS_Anst", 0, profileFile ) );
    putValue( KCAN_AB_Rollover_Crash, getProfileInt( "Airbag_01", "AB_Rollover_Crash", 0, profileFile ) );
    putValue( KCAN_AB_SB_Crash, getProfileInt( "Airbag_01", "AB_SB_Crash", 0, profileFile ) );
    putValue( KCAN_AB_SF_Crash, getProfileInt( "Airbag_01", "AB_SF_Crash", 0, profileFile ) );
    putValue( KCAN_AB_Stellgliedtest, getProfileInt( "Airbag_01", "AB_Stellgliedtest", 0, profileFile ) );
    putValue( KCAN_AB_Systemfehler, getProfileInt( "Airbag_01", "AB_Systemfehler", 0, profileFile ) );
    putValue( KCAN_AB_Texte_AKS, getProfileInt( "Airbag_01", "AB_Texte_AKS", 0, profileFile ) );
    putValue( KCAN_AB_VB_deaktiviert, getProfileInt( "Airbag_01", "AB_VB_deaktiviert", 0, profileFile ) );
    putValue( KCAN_AB_Versorgungsspannung, getProfileInt( "Airbag_01", "AB_Versorgungsspannung", 0, profileFile ) );
    putValue( KCAN_ASM_Masterzeit, getProfileFloat( "Airbag_01", "ASM_Masterzeit", 0, profileFile ) );

}


void loadSettings_Airbag_02( char profileFile[] )
{
    putValue( KCAN_AB_Abschaltanf_SIH_BF, getProfileInt( "Airbag_02", "AB_Abschaltanf_SIH_BF", 0, profileFile ) );
    putValue( KCAN_AB_Anforderung_eCall, getProfileInt( "Airbag_02", "AB_Anforderung_eCall", 0, profileFile ) );
    putValue( KCAN_AB_Anforderung_USM, getProfileInt( "Airbag_02", "AB_Anforderung_USM", 0, profileFile ) );
    putValue( KCAN_AB_Anprall_FGS, getProfileInt( "Airbag_02", "AB_Anprall_FGS", 0, profileFile ) );
    putValue( KCAN_AB_Anprall_Front_Beifahrer, getProfileInt( "Airbag_02", "AB_Anprall_Front_Beifahrer", 0, profileFile ) );
    putValue( KCAN_AB_Anprall_Front_Fahrer, getProfileInt( "Airbag_02", "AB_Anprall_Front_Fahrer", 0, profileFile ) );
    putValue( KCAN_AB_Anprall_Heck_Beifahrer, getProfileInt( "Airbag_02", "AB_Anprall_Heck_Beifahrer", 0, profileFile ) );
    putValue( KCAN_AB_Anprall_Heck_Fahrer, getProfileInt( "Airbag_02", "AB_Anprall_Heck_Fahrer", 0, profileFile ) );
    putValue( KCAN_AB_Anprall_Rollover, getProfileInt( "Airbag_02", "AB_Anprall_Rollover", 0, profileFile ) );
    putValue( KCAN_AB_Anprall_Seite_Beifahrer, getProfileInt( "Airbag_02", "AB_Anprall_Seite_Beifahrer", 0, profileFile ) );
    putValue( KCAN_AB_Anprall_Seite_Fahrer, getProfileInt( "Airbag_02", "AB_Anprall_Seite_Fahrer", 0, profileFile ) );
    putValue( KCAN_AB_Belegung_VB, getProfileInt( "Airbag_02", "AB_Belegung_VB", 0, profileFile ) );
    putValue( KCAN_AB_Crashschwere, getProfileInt( "Airbag_02", "AB_Crashschwere", 0, profileFile ) );
    putValue( KCAN_AB_Gurtschloss_BF, getProfileInt( "Airbag_02", "AB_Gurtschloss_BF", 0, profileFile ) );
    putValue( KCAN_AB_Gurtschloss_FA, getProfileInt( "Airbag_02", "AB_Gurtschloss_FA", 0, profileFile ) );
    putValue( KCAN_AB_Gurtschloss_Reihe2_BF, getProfileInt( "Airbag_02", "AB_Gurtschloss_Reihe2_BF", 0, profileFile ) );
    putValue( KCAN_AB_Gurtschloss_Reihe2_FA, getProfileInt( "Airbag_02", "AB_Gurtschloss_Reihe2_FA", 0, profileFile ) );
    putValue( KCAN_AB_Gurtschloss_Reihe2_MI, getProfileInt( "Airbag_02", "AB_Gurtschloss_Reihe2_MI", 0, profileFile ) );
    putValue( KCAN_AB_Gurtschloss_Reihe3_BF, getProfileInt( "Airbag_02", "AB_Gurtschloss_Reihe3_BF", 0, profileFile ) );
    putValue( KCAN_AB_Gurtschloss_Reihe3_FA, getProfileInt( "Airbag_02", "AB_Gurtschloss_Reihe3_FA", 0, profileFile ) );
    putValue( KCAN_AB_Gurtschloss_Reihe3_MI, getProfileInt( "Airbag_02", "AB_Gurtschloss_Reihe3_MI", 0, profileFile ) );
    putValue( KCAN_AB_Sitzpos_Sens_BF, getProfileInt( "Airbag_02", "AB_Sitzpos_Sens_BF", 0, profileFile ) );
    putValue( KCAN_AB_Sitzpos_Sens_FA, getProfileInt( "Airbag_02", "AB_Sitzpos_Sens_FA", 0, profileFile ) );
    putValue( KCAN_AB_Wickelklappung_Reihe2_BF, getProfileInt( "Airbag_02", "AB_Wickelklappung_Reihe2_BF", 0, profileFile ) );
    putValue( KCAN_AB_Wickelklappung_Reihe2_FA, getProfileInt( "Airbag_02", "AB_Wickelklappung_Reihe2_FA", 0, profileFile ) );
    putValue( KCAN_AB_Wickelklappung_Reihe2_MI, getProfileInt( "Airbag_02", "AB_Wickelklappung_Reihe2_MI", 0, profileFile ) );
    putValue( KCAN_LoGeWa_Event_Kombiwarnung, getProfileInt( "Airbag_02", "LoGeWa_Event_Kombiwarnung", 0, profileFile ) );
    putValue( KCAN_SC_PAO_OFF_Anf, getProfileInt( "Airbag_02", "SC_PAO_OFF_Anf", 0, profileFile ) );
    putValue( KCAN_SC_PAO_ON_Anf, getProfileInt( "Airbag_02", "SC_PAO_ON_Anf", 0, profileFile ) );
    putValue( KCAN_SC_PAO_Schriftzug_Anf, getProfileInt( "Airbag_02", "SC_PAO_Schriftzug_Anf", 0, profileFile ) );

}


void loadSettings_Airbag_04( char profileFile[] )
{
    putValue( KCAN_AB_Anprall_Front, getProfileInt( "Airbag_04", "AB_Anprall_Front", 0, profileFile ) );
    putValue( KCAN_AB_Anprall_Heck, getProfileInt( "Airbag_04", "AB_Anprall_Heck", 0, profileFile ) );
    putValue( KCAN_AB_Belegung_VF_ext, getProfileInt( "Airbag_04", "AB_Belegung_VF_ext", 0, profileFile ) );
    putValue( KCAN_AB_Belegung_VF_ext_aktiv, getProfileInt( "Airbag_04", "AB_Belegung_VF_ext_aktiv", 0, profileFile ) );
    putValue( KCAN_AB_Gurtwarn_Reihe2_BF, getProfileInt( "Airbag_04", "AB_Gurtwarn_Reihe2_BF", 0, profileFile ) );
    putValue( KCAN_AB_Gurtwarn_Reihe2_FA, getProfileInt( "Airbag_04", "AB_Gurtwarn_Reihe2_FA", 0, profileFile ) );
    putValue( KCAN_AB_Gurtwarn_Reihe2_MI, getProfileInt( "Airbag_04", "AB_Gurtwarn_Reihe2_MI", 0, profileFile ) );
    putValue( KCAN_AB_Gurtwarn_Reihe3_BF, getProfileInt( "Airbag_04", "AB_Gurtwarn_Reihe3_BF", 0, profileFile ) );
    putValue( KCAN_AB_Gurtwarn_Reihe3_FA, getProfileInt( "Airbag_04", "AB_Gurtwarn_Reihe3_FA", 0, profileFile ) );
    putValue( KCAN_AB_Gurtwarn_Reihe3_MI, getProfileInt( "Airbag_04", "AB_Gurtwarn_Reihe3_MI", 0, profileFile ) );
    putValue( KCAN_AB_Gurtwarn_Reihe4_BF, getProfileInt( "Airbag_04", "AB_Gurtwarn_Reihe4_BF", 0, profileFile ) );
    putValue( KCAN_AB_Gurtwarn_Reihe4_FA, getProfileInt( "Airbag_04", "AB_Gurtwarn_Reihe4_FA", 0, profileFile ) );
    putValue( KCAN_AB_Gurtwarn_Reihe4_MI, getProfileInt( "Airbag_04", "AB_Gurtwarn_Reihe4_MI", 0, profileFile ) );
    putValue( KCAN_AB_SBR_hinten_verbau, getProfileInt( "Airbag_04", "AB_SBR_hinten_verbau", 0, profileFile ) );
    putValue( KCAN_AbstWarn_MV_FAS_Fkt_Status, getProfileInt( "Airbag_04", "AbstWarn_MV_FAS_Fkt_Status", 0, profileFile ) );
    putValue( KCAN_AWV_Einstellung_System_ASG, getProfileInt( "Airbag_04", "AWV_Einstellung_System_ASG", 0, profileFile ) );
    putValue( KCAN_AWV_Einstellung_Warnung_ASG, getProfileInt( "Airbag_04", "AWV_Einstellung_Warnung_ASG", 0, profileFile ) );
    putValue( KCAN_LGI_FAS_Fkt_Status, getProfileInt( "Airbag_04", "LGI_FAS_Fkt_Status", 0, profileFile ) );
    putValue( KCAN_PreCrash_FAS_Fkt_Status, getProfileInt( "Airbag_04", "PreCrash_FAS_Fkt_Status", 0, profileFile ) );
    putValue( KCAN_SC_PreSense_Modus_System_KAS, getProfileInt( "Airbag_04", "SC_PreSense_Modus_System_KAS", 0, profileFile ) );
    putValue( KCAN_SC_PreSense_Modus_System_MV, getProfileInt( "Airbag_04", "SC_PreSense_Modus_System_MV", 0, profileFile ) );
    putValue( KCAN_SC_PreSense_Modus_System_NV, getProfileInt( "Airbag_04", "SC_PreSense_Modus_System_NV", 0, profileFile ) );
    putValue( KCAN_SC_PreSense_Modus_Warnung_MV, getProfileInt( "Airbag_04", "SC_PreSense_Modus_Warnung_MV", 0, profileFile ) );
    putValue( KCAN_SC_PreSense_Modus_Warnung_NV, getProfileInt( "Airbag_04", "SC_PreSense_Modus_Warnung_NV", 0, profileFile ) );
    putValue( KCAN_WarnBrems_Charisma_FahrPr, getProfileInt( "Airbag_04", "WarnBrems_Charisma_FahrPr", 0, profileFile ) );
    putValue( KCAN_WarnBrems_Charisma_Status, getProfileInt( "Airbag_04", "WarnBrems_Charisma_Status", 0, profileFile ) );

}


void loadSettings_Airbag_06( char profileFile[] )
{
    putValue( KCAN_AB_Gurtschloss_MI, getProfileInt( "Airbag_06", "AB_Gurtschloss_MI", 0, profileFile ) );
    putValue( KCAN_AB_Gurtschloss_Reihe4_BF, getProfileInt( "Airbag_06", "AB_Gurtschloss_Reihe4_BF", 0, profileFile ) );
    putValue( KCAN_AB_Gurtschloss_Reihe4_FA, getProfileInt( "Airbag_06", "AB_Gurtschloss_Reihe4_FA", 0, profileFile ) );
    putValue( KCAN_AB_Gurtschloss_Reihe4_MI, getProfileInt( "Airbag_06", "AB_Gurtschloss_Reihe4_MI", 0, profileFile ) );
    putValue( KCAN_AB_Gurtwarn_VM, getProfileInt( "Airbag_06", "AB_Gurtwarn_VM", 0, profileFile ) );
    putValue( KCAN_AB_wSBR_Batteriestatus, getProfileInt( "Airbag_06", "AB_wSBR_Batteriestatus", 0, profileFile ) );

}


void loadSettings_Anhaenger_01( char profileFile[] )
{
    putValue( KCAN_AAG_Anhaenger_abgesteckt, getProfileInt( "Anhaenger_01", "AAG_Anhaenger_abgesteckt", 0, profileFile ) );
    putValue( KCAN_AAG_Anhaenger_erkannt, getProfileInt( "Anhaenger_01", "AAG_Anhaenger_erkannt", 0, profileFile ) );
    putValue( KCAN_AAG_AVS_Fehler_02, getProfileInt( "Anhaenger_01", "AAG_AVS_Fehler_02", 0, profileFile ) );
    putValue( KCAN_AAG_AVS_Fehler_02_inv, getProfileInt( "Anhaenger_01", "AAG_AVS_Fehler_02_inv", 0, profileFile ) );
    putValue( KCAN_AAG_AVS_Stati, getProfileInt( "Anhaenger_01", "AAG_AVS_Stati", 0, profileFile ) );
    putValue( KCAN_AAG_Blinker_H_aktiv, getProfileInt( "Anhaenger_01", "AAG_Blinker_H_aktiv", 0, profileFile ) );
    putValue( KCAN_AAG_Blinker_HL_def, getProfileInt( "Anhaenger_01", "AAG_Blinker_HL_def", 0, profileFile ) );
    putValue( KCAN_AAG_Blinker_HR_def, getProfileInt( "Anhaenger_01", "AAG_Blinker_HR_def", 0, profileFile ) );
    putValue( KCAN_AAG_Bremsl_durch_ECD, getProfileInt( "Anhaenger_01", "AAG_Bremsl_durch_ECD", 0, profileFile ) );
    putValue( KCAN_AAG_Bremslicht_H_def, getProfileInt( "Anhaenger_01", "AAG_Bremslicht_H_def", 0, profileFile ) );
    putValue( KCAN_AAG_Bremslicht_Reku, getProfileInt( "Anhaenger_01", "AAG_Bremslicht_Reku", 0, profileFile ) );
    putValue( KCAN_AAG_LED_aktiv, getProfileInt( "Anhaenger_01", "AAG_LED_aktiv", 0, profileFile ) );
    putValue( KCAN_AAG_NSL_aktiv, getProfileInt( "Anhaenger_01", "AAG_NSL_aktiv", 0, profileFile ) );
    putValue( KCAN_AAG_Schlusslicht_HL_def, getProfileInt( "Anhaenger_01", "AAG_Schlusslicht_HL_def", 0, profileFile ) );
    putValue( KCAN_AAG_Schlusslicht_HR_def, getProfileInt( "Anhaenger_01", "AAG_Schlusslicht_HR_def", 0, profileFile ) );

}


void loadSettings_ARA_Status_01( char profileFile[] )
{
    putValue( KCAN_ARA_Aktiver_Grafikmodus, getProfileInt( "ARA_Status_01", "ARA_Aktiver_Grafikmodus", 0, profileFile ) );
    putValue( KCAN_ARA_Anf_Meldungen, getProfileInt( "ARA_Status_01", "ARA_Anf_Meldungen", 0, profileFile ) );
    putValue( KCAN_ARA_Bremsfuss, getProfileInt( "ARA_Status_01", "ARA_Bremsfuss", 0, profileFile ) );
    putValue( KCAN_ARA_Deaktivierung_sperren, getProfileInt( "ARA_Status_01", "ARA_Deaktivierung_sperren", 0, profileFile ) );
    putValue( KCAN_ARA_Knickwinkel_Ist, getProfileInt( "ARA_Status_01", "ARA_Knickwinkel_Ist", 0, profileFile ) );
    putValue( KCAN_ARA_Knickwinkel_Komfort, getProfileInt( "ARA_Status_01", "ARA_Knickwinkel_Komfort", 0, profileFile ) );
    putValue( KCAN_ARA_Knickwinkel_konfidenz, getProfileInt( "ARA_Status_01", "ARA_Knickwinkel_konfidenz", 0, profileFile ) );
    putValue( KCAN_ARA_Knickwinkel_Max, getProfileInt( "ARA_Status_01", "ARA_Knickwinkel_Max", 0, profileFile ) );
    putValue( KCAN_ARA_Knickwinkel_Soll, getProfileInt( "ARA_Status_01", "ARA_Knickwinkel_Soll", 0, profileFile ) );
    putValue( KCAN_ARA_Modus, getProfileInt( "ARA_Status_01", "ARA_Modus", 0, profileFile ) );
    putValue( KCAN_ARA_Modus_Anf, getProfileInt( "ARA_Status_01", "ARA_Modus_Anf", 0, profileFile ) );
    putValue( KCAN_ARA_Sensor_Aktivierung, getProfileInt( "ARA_Status_01", "ARA_Sensor_Aktivierung", 0, profileFile ) );
    putValue( KCAN_ARA_Status, getProfileInt( "ARA_Status_01", "ARA_Status", 0, profileFile ) );
    putValue( KCAN_ARA_Texte, getProfileInt( "ARA_Status_01", "ARA_Texte", 0, profileFile ) );

}


void loadSettings_ARC_HUD_Req_FD( char profileFile[] )
{

}


void loadSettings_ARC_HUD_Resp_FD( char profileFile[] )
{

}


void loadSettings_AWV_02( char profileFile[] )
{
    putValue( KCAN_AWV_AW_Abstand, getProfileInt( "AWV_02", "AWV_AW_Abstand", 0, profileFile ) );
    putValue( KCAN_AWV_AW_Texte, getProfileInt( "AWV_02", "AWV_AW_Texte", 0, profileFile ) );
    putValue( KCAN_AWV_AW_Texte_Zusatzanzeige, getProfileInt( "AWV_02", "AWV_AW_Texte_Zusatzanzeige", 0, profileFile ) );
    putValue( KCAN_AWV_AW_Zeitluecke, getProfileInt( "AWV_02", "AWV_AW_Zeitluecke", 0, profileFile ) );
    putValue( KCAN_AWV_Einstellung_System_FSG, getProfileInt( "AWV_02", "AWV_Einstellung_System_FSG", 0, profileFile ) );
    putValue( KCAN_AWV_Einstellung_Warnung_FSG, getProfileInt( "AWV_02", "AWV_Einstellung_Warnung_FSG", 0, profileFile ) );
    putValue( KCAN_AWV_KA_ObjektFront, getProfileInt( "AWV_02", "AWV_KA_ObjektFront", 0, profileFile ) );
    putValue( KCAN_AWV_Kamera_Objekt_ID, getProfileInt( "AWV_02", "AWV_Kamera_Objekt_ID", 0, profileFile ) );
    putValue( KCAN_AWV_LED_Leiste, getProfileInt( "AWV_02", "AWV_LED_Leiste", 0, profileFile ) );
    putValue( KCAN_AWV_Priowarnung, getProfileInt( "AWV_02", "AWV_Priowarnung", 0, profileFile ) );
    putValue( KCAN_AWV_Status_Anzeige, getProfileInt( "AWV_02", "AWV_Status_Anzeige", 0, profileFile ) );
    putValue( KCAN_AWV_Texte, getProfileInt( "AWV_02", "AWV_Texte", 0, profileFile ) );
    putValue( KCAN_AWV_Warnlevel, getProfileInt( "AWV_02", "AWV_Warnlevel", 0, profileFile ) );
    putValue( KCAN_AWV_Warnung, getProfileInt( "AWV_02", "AWV_Warnung", 0, profileFile ) );
    putValue( KCAN_AWV_Warnung_Richtung, getProfileInt( "AWV_02", "AWV_Warnung_Richtung", 0, profileFile ) );

}


void loadSettings_AZK_01( char profileFile[] )
{
    putValue( KCAN_AZK_Kessy_defekt, getProfileInt( "AZK_01", "AZK_Kessy_defekt", 0, profileFile ) );
    putValue( KCAN_AZK_Kessy_nicht_gefunden, getProfileInt( "AZK_01", "AZK_Kessy_nicht_gefunden", 0, profileFile ) );
    putValue( KCAN_AZK_MobileKey_defekt, getProfileInt( "AZK_01", "AZK_MobileKey_defekt", 0, profileFile ) );
    putValue( KCAN_AZK_Mobilgeraet_nicht_gefunden, getProfileInt( "AZK_01", "AZK_Mobilgeraet_nicht_gefunden", 0, profileFile ) );
    putValue( KCAN_AZK_Schluessel_im_Fzg, getProfileInt( "AZK_01", "AZK_Schluessel_im_Fzg", 0, profileFile ) );
    putValue( KCAN_AZK_Weiterfahrt_mit_Mobilgeraet, getProfileInt( "AZK_01", "AZK_Weiterfahrt_mit_Mobilgeraet", 0, profileFile ) );
    putValue( KCAN_AZK_Weiterfahrt_mit_Schluessel, getProfileInt( "AZK_01", "AZK_Weiterfahrt_mit_Schluessel", 0, profileFile ) );

}


void loadSettings_BCM_01( char profileFile[] )
{
    putValue( KCAN_APS_Tongeber_defekt, getProfileInt( "BCM_01", "APS_Tongeber_defekt", 0, profileFile ) );
    putValue( KCAN_BCM1_AFS_Lampe, getProfileInt( "BCM_01", "BCM1_AFS_Lampe", 0, profileFile ) );
    putValue( KCAN_BCM1_EasyEntry_Status, getProfileInt( "BCM_01", "BCM1_EasyEntry_Status", 0, profileFile ) );
    putValue( KCAN_BCM1_Kl_15_HW_erkannt, getProfileInt( "BCM_01", "BCM1_Kl_15_HW_erkannt", 0, profileFile ) );
    putValue( KCAN_BCM1_Kl_15_Sig_HW_erkannt, getProfileInt( "BCM_01", "BCM1_Kl_15_Sig_HW_erkannt", 0, profileFile ) );
    putValue( KCAN_BCM1_Lenksaeule_aktiv, getProfileInt( "BCM_01", "BCM1_Lenksaeule_aktiv", 0, profileFile ) );
    putValue( KCAN_BCM1_MH_Schalter, getProfileInt( "BCM_01", "BCM1_MH_Schalter", 0, profileFile ) );
    putValue( KCAN_BCM1_MH_WIV_Schalter, getProfileInt( "BCM_01", "BCM1_MH_WIV_Schalter", 0, profileFile ) );
    putValue( KCAN_BCM1_NV_Taster, getProfileInt( "BCM_01", "BCM1_NV_Taster", 0, profileFile ) );
    putValue( KCAN_BCM1_Reisemodus_Texte, getProfileInt( "BCM_01", "BCM1_Reisemodus_Texte", 0, profileFile ) );
    putValue( KCAN_BCM1_Rueckfahrlicht_Schalter, getProfileInt( "BCM_01", "BCM1_Rueckfahrlicht_Schalter", 0, profileFile ) );
    putValue( KCAN_BCM1_Spannungs_Anf, getProfileInt( "BCM_01", "BCM1_Spannungs_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_Valet_Parking_Taster, getProfileInt( "BCM_01", "BCM1_Valet_Parking_Taster", 0, profileFile ) );
    putValue( KCAN_BCM1_Warnblink_Taster, getProfileInt( "BCM_01", "BCM1_Warnblink_Taster", 0, profileFile ) );
    putValue( KCAN_BCM_Anf_AAW_MoLaWa, getProfileInt( "BCM_01", "BCM_Anf_AAW_MoLaWa", 0, profileFile ) );
    putValue( KCAN_BCM_Bremsbelag_Sensor, getProfileInt( "BCM_01", "BCM_Bremsbelag_Sensor", 0, profileFile ) );
    putValue( KCAN_BCM_Bremsfluessigkeit_Sensor, getProfileInt( "BCM_01", "BCM_Bremsfluessigkeit_Sensor", 0, profileFile ) );
    putValue( KCAN_BCM_Charisma_Taste2, getProfileInt( "BCM_01", "BCM_Charisma_Taste2", 0, profileFile ) );
    putValue( KCAN_BCM_Eco_Charisma_Taste, getProfileInt( "BCM_01", "BCM_Eco_Charisma_Taste", 0, profileFile ) );
    putValue( KCAN_BCM_Handbremse_Hinweis, getProfileInt( "BCM_01", "BCM_Handbremse_Hinweis", 0, profileFile ) );
    putValue( KCAN_BCM_HDF_betaetigt, getProfileInt( "BCM_01", "BCM_HDF_betaetigt", 0, profileFile ) );
    putValue( KCAN_BCM_Hybrid_StartStopp_Taste, getProfileInt( "BCM_01", "BCM_Hybrid_StartStopp_Taste", 0, profileFile ) );
    putValue( KCAN_BCM_Hybrid_StSt_Taste_Fehler, getProfileInt( "BCM_01", "BCM_Hybrid_StSt_Taste_Fehler", 0, profileFile ) );
    putValue( KCAN_BCM_Kuehlmittel_Sensor, getProfileInt( "BCM_01", "BCM_Kuehlmittel_Sensor", 0, profileFile ) );
    putValue( KCAN_BCM_Kuehlmittel_Sensor_02, getProfileInt( "BCM_01", "BCM_Kuehlmittel_Sensor_02", 0, profileFile ) );
    putValue( KCAN_BCM_Offroad_Taste, getProfileInt( "BCM_01", "BCM_Offroad_Taste", 0, profileFile ) );
    putValue( KCAN_BCM_ValetTaster_Fkts_LED, getProfileInt( "BCM_01", "BCM_ValetTaster_Fkts_LED", 0, profileFile ) );
    putValue( KCAN_BCM_Waschwasser_Sensor, getProfileInt( "BCM_01", "BCM_Waschwasser_Sensor", 0, profileFile ) );
    putValue( KCAN_Gong_TFL_Umschaltung, getProfileInt( "BCM_01", "Gong_TFL_Umschaltung", 0, profileFile ) );
    putValue( KCAN_LRH_Taster, getProfileInt( "BCM_01", "LRH_Taster", 0, profileFile ) );

}


void loadSettings_BCM_03( char profileFile[] )
{
    putValue( KCAN_BCM_anf_VLW, getProfileInt( "BCM_03", "BCM_anf_VLW", 0, profileFile ) );
    putValue( KCAN_BCM_LTM_Allwetterl_Status, getProfileInt( "BCM_03", "BCM_LTM_Allwetterl_Status", 0, profileFile ) );
    putValue( KCAN_BCM_LTM_Nebell_Status, getProfileInt( "BCM_03", "BCM_LTM_Nebell_Status", 0, profileFile ) );
    putValue( KCAN_BCM_LTM_Nebelschluss_Status, getProfileInt( "BCM_03", "BCM_LTM_Nebelschluss_Status", 0, profileFile ) );
    putValue( KCAN_BCM_LTM_PopUp_Anf, getProfileInt( "BCM_03", "BCM_LTM_PopUp_Anf", 0, profileFile ) );
    putValue( KCAN_BCM_LTM_PopUp_Inhalt, getProfileInt( "BCM_03", "BCM_LTM_PopUp_Inhalt", 0, profileFile ) );
    putValue( KCAN_BCM_LTM_PopUp_Status, getProfileInt( "BCM_03", "BCM_LTM_PopUp_Status", 0, profileFile ) );
    putValue( KCAN_BCM_LTM_PopUp_Texte, getProfileInt( "BCM_03", "BCM_LTM_PopUp_Texte", 0, profileFile ) );

}


void loadSettings_BCM_04( char profileFile[] )
{
    putValue( KCAN_BCM_RGB_Blau, getProfileInt( "BCM_04", "BCM_RGB_Blau", 0, profileFile ) );
    putValue( KCAN_BCM_RGB_Gruen, getProfileInt( "BCM_04", "BCM_RGB_Gruen", 0, profileFile ) );
    putValue( KCAN_BCM_RGB_Rot, getProfileInt( "BCM_04", "BCM_RGB_Rot", 0, profileFile ) );

}


void loadSettings_BCM_Taster_02( char profileFile[] )
{
    putValue( KCAN_FAS_Profile_Taster, getProfileInt( "BCM_Taster_02", "FAS_Profile_Taster", 0, profileFile ) );
    putValue( KCAN_LIM_bCall_Taster, getProfileInt( "BCM_Taster_02", "LIM_bCall_Taster", 0, profileFile ) );
    putValue( KCAN_LIM_iCall_Taster, getProfileInt( "BCM_Taster_02", "LIM_iCall_Taster", 0, profileFile ) );
    putValue( KCAN_LIM_S_Rollo_hi, getProfileInt( "BCM_Taster_02", "LIM_S_Rollo_hi", 0, profileFile ) );
    putValue( KCAN_LIM_S_Rollo_vo, getProfileInt( "BCM_Taster_02", "LIM_S_Rollo_vo", 0, profileFile ) );
    putValue( KCAN_LIM_S_SAD_hi, getProfileInt( "BCM_Taster_02", "LIM_S_SAD_hi", 0, profileFile ) );
    putValue( KCAN_LIM_S_SAD_Vo, getProfileInt( "BCM_Taster_02", "LIM_S_SAD_Vo", 0, profileFile ) );
    putValue( KCAN_LINDa_Touch_Event, getProfileInt( "BCM_Taster_02", "LINDa_Touch_Event", 0, profileFile ) );
    putValue( KCAN_Tuerkontakt_Innenlicht_Taste, getProfileInt( "BCM_Taster_02", "Tuerkontakt_Innenlicht_Taste", 0, profileFile ) );

}


void loadSettings_BCM_Taster_03( char profileFile[] )
{
    putValue( KCAN_LINDa_HL_SR3_Touch_Event, getProfileInt( "BCM_Taster_03", "LINDa_HL_SR3_Touch_Event", 0, profileFile ) );
    putValue( KCAN_LINDa_HL_Touch_Event, getProfileInt( "BCM_Taster_03", "LINDa_HL_Touch_Event", 0, profileFile ) );
    putValue( KCAN_LINDa_HR_SR3_Touch_Event, getProfileInt( "BCM_Taster_03", "LINDa_HR_SR3_Touch_Event", 0, profileFile ) );
    putValue( KCAN_LINDa_HR_Touch_Event, getProfileInt( "BCM_Taster_03", "LINDa_HR_Touch_Event", 0, profileFile ) );

}


void loadSettings_BEM_02( char profileFile[] )
{
    putValue( KCAN_BEM_Anf_KL15_schalten, getProfileInt( "BEM_02", "BEM_Anf_KL15_schalten", 0, profileFile ) );
    putValue( KCAN_BEM_Batt_Ab, getProfileInt( "BEM_02", "BEM_Batt_Ab", 0, profileFile ) );
    putValue( KCAN_BEM_Batteriediagnose, getProfileInt( "BEM_02", "BEM_Batteriediagnose", 0, profileFile ) );
    putValue( KCAN_BEM_DFM, getProfileFloat( "BEM_02", "BEM_DFM", 0, profileFile ) );
    putValue( KCAN_BEM_EMLIN_ungueltig, getProfileInt( "BEM_02", "BEM_EMLIN_ungueltig", 0, profileFile ) );
    putValue( KCAN_BEM_Generatordiagnose, getProfileInt( "BEM_02", "BEM_Generatordiagnose", 0, profileFile ) );
    putValue( KCAN_BEM_HL_Kontingentierung, getProfileInt( "BEM_02", "BEM_HL_Kontingentierung", 0, profileFile ) );
    putValue( KCAN_BEM_HL_Regelung_Status, getProfileInt( "BEM_02", "BEM_HL_Regelung_Status", 0, profileFile ) );
    putValue( KCAN_BEM_Ladezustand, getProfileInt( "BEM_02", "BEM_Ladezustand", 0, profileFile ) );
    putValue( KCAN_BEM_MMI_Vorwarnung, getProfileInt( "BEM_02", "BEM_MMI_Vorwarnung", 0, profileFile ) );
    putValue( KCAN_BEM_Red_Innengeblaese, getProfileInt( "BEM_02", "BEM_Red_Innengeblaese", 0, profileFile ) );
    putValue( KCAN_BEM_REK_aktiv, getProfileInt( "BEM_02", "BEM_REK_aktiv", 0, profileFile ) );
    putValue( KCAN_BEM_STH_Einschaltverbot, getProfileInt( "BEM_02", "BEM_STH_Einschaltverbot", 0, profileFile ) );
    putValue( KCAN_BEM_STH_Zielzeit, getProfileInt( "BEM_02", "BEM_STH_Zielzeit", 0, profileFile ) );
    putValue( KCAN_BEM_UBDM, getProfileFloat( "BEM_02", "BEM_UBDM", 0, profileFile ) );
    putValue( KCAN_BEM_UGenSoll, getProfileFloat( "BEM_02", "BEM_UGenSoll", 0, profileFile ) );
    putValue( KCAN_MIB_Stromsparmodus, getProfileInt( "BEM_02", "MIB_Stromsparmodus", 0, profileFile ) );
    putValue( KCAN_NVEM_Abschaltstufe, getProfileInt( "BEM_02", "NVEM_Abschaltstufe", 0, profileFile ) );
    putValue( KCAN_NVEM_Anf_SD_schalten, getProfileInt( "BEM_02", "NVEM_Anf_SD_schalten", 0, profileFile ) );
    putValue( KCAN_NVEM_Batterie_Service, getProfileInt( "BEM_02", "NVEM_Batterie_Service", 0, profileFile ) );
    putValue( KCAN_NVEM_Freigabe_OnlineUpdate, getProfileInt( "BEM_02", "NVEM_Freigabe_OnlineUpdate", 0, profileFile ) );
    putValue( KCAN_NVEM_Freigabe_ORU4, getProfileInt( "BEM_02", "NVEM_Freigabe_ORU4", 0, profileFile ) );
    putValue( KCAN_NVEM_Freigabe_ZusBatt_Laden, getProfileInt( "BEM_02", "NVEM_Freigabe_ZusBatt_Laden", 0, profileFile ) );
    putValue( KCAN_NVEM_Verbraucherabsch_Anz, getProfileInt( "BEM_02", "NVEM_Verbraucherabsch_Anz", 0, profileFile ) );

}


void loadSettings_BEM_06( char profileFile[] )
{
    putValue( KCAN_HLR_PTC_linear_Freigabe, getProfileInt( "BEM_06", "HLR_PTC_linear_Freigabe", 0, profileFile ) );
    putValue( KCAN_NVEM_Bordnetzdiagnose, getProfileInt( "BEM_06", "NVEM_Bordnetzdiagnose", 0, profileFile ) );
    putValue( KCAN_NVEM_Energie_Klima_Vorgabe, getProfileInt( "BEM_06", "NVEM_Energie_Klima_Vorgabe", 0, profileFile ) );
    putValue( KCAN_NVEM_Last_Anf, getProfileInt( "BEM_06", "NVEM_Last_Anf", 0, profileFile ) );
    putValue( KCAN_NVEM_PTC_Sollstufe, getProfileInt( "BEM_06", "NVEM_PTC_Sollstufe", 0, profileFile ) );
    putValue( KCAN_NVEM_Red_KomfortVerbrauch, getProfileInt( "BEM_06", "NVEM_Red_KomfortVerbrauch", 0, profileFile ) );
    putValue( KCAN_NVEM_STH_ZielzeitLang, getProfileInt( "BEM_06", "NVEM_STH_ZielzeitLang", 0, profileFile ) );

}


void loadSettings_Blinkmodi_02( char profileFile[] )
{
    putValue( KCAN_Blinken_li_Fzg_Takt, getProfileInt( "Blinkmodi_02", "Blinken_li_Fzg_Takt", 0, profileFile ) );
    putValue( KCAN_Blinken_li_Kombi_Takt, getProfileInt( "Blinkmodi_02", "Blinken_li_Kombi_Takt", 0, profileFile ) );
    putValue( KCAN_Blinken_re_Fzg_Takt, getProfileInt( "Blinkmodi_02", "Blinken_re_Fzg_Takt", 0, profileFile ) );
    putValue( KCAN_Blinken_re_Kombi_Takt, getProfileInt( "Blinkmodi_02", "Blinken_re_Kombi_Takt", 0, profileFile ) );
    putValue( KCAN_BM_Autobahn, getProfileInt( "Blinkmodi_02", "BM_Autobahn", 0, profileFile ) );
    putValue( KCAN_BM_Crash, getProfileInt( "Blinkmodi_02", "BM_Crash", 0, profileFile ) );
    putValue( KCAN_BM_DWA_Alarm, getProfileInt( "Blinkmodi_02", "BM_DWA_Alarm", 0, profileFile ) );
    putValue( KCAN_BM_DWA_ein, getProfileInt( "Blinkmodi_02", "BM_DWA_ein", 0, profileFile ) );
    putValue( KCAN_BM_GDO, getProfileInt( "Blinkmodi_02", "BM_GDO", 0, profileFile ) );
    putValue( KCAN_BM_HD_Oeffnung_angelernt, getProfileInt( "Blinkmodi_02", "BM_HD_Oeffnung_angelernt", 0, profileFile ) );
    putValue( KCAN_BM_links, getProfileInt( "Blinkmodi_02", "BM_links", 0, profileFile ) );
    putValue( KCAN_BM_NBA_n_codiert_n_aktiv, getProfileInt( "Blinkmodi_02", "BM_NBA_n_codiert_n_aktiv", 0, profileFile ) );
    putValue( KCAN_BM_NBA_Status, getProfileInt( "Blinkmodi_02", "BM_NBA_Status", 0, profileFile ) );
    putValue( KCAN_BM_Not_Bremsung, getProfileInt( "Blinkmodi_02", "BM_Not_Bremsung", 0, profileFile ) );
    putValue( KCAN_BM_Panik, getProfileInt( "Blinkmodi_02", "BM_Panik", 0, profileFile ) );
    putValue( KCAN_BM_PiloPa, getProfileInt( "Blinkmodi_02", "BM_PiloPa", 0, profileFile ) );
    putValue( KCAN_BM_Recas, getProfileInt( "Blinkmodi_02", "BM_Recas", 0, profileFile ) );
    putValue( KCAN_BM_rechts, getProfileInt( "Blinkmodi_02", "BM_rechts", 0, profileFile ) );
    putValue( KCAN_BM_Rollenmodus_Blinken, getProfileInt( "Blinkmodi_02", "BM_Rollenmodus_Blinken", 0, profileFile ) );
    putValue( KCAN_BM_Taxi_Notalarm, getProfileInt( "Blinkmodi_02", "BM_Taxi_Notalarm", 0, profileFile ) );
    putValue( KCAN_BM_Telematik, getProfileInt( "Blinkmodi_02", "BM_Telematik", 0, profileFile ) );
    putValue( KCAN_BM_Telematik_Abbruchgrund, getProfileInt( "Blinkmodi_02", "BM_Telematik_Abbruchgrund", 0, profileFile ) );
    putValue( KCAN_BM_Warnblinken, getProfileInt( "Blinkmodi_02", "BM_Warnblinken", 0, profileFile ) );
    putValue( KCAN_BM_WBT_Beleuchtung, getProfileInt( "Blinkmodi_02", "BM_WBT_Beleuchtung", 0, profileFile ) );
    putValue( KCAN_BM_Wischblinken, getProfileInt( "Blinkmodi_02", "BM_Wischblinken", 0, profileFile ) );
    putValue( KCAN_BM_ZV_auf, getProfileInt( "Blinkmodi_02", "BM_ZV_auf", 0, profileFile ) );
    putValue( KCAN_BM_ZV_zu, getProfileInt( "Blinkmodi_02", "BM_ZV_zu", 0, profileFile ) );
    putValue( KCAN_SAL_TA_Blinken_Status, getProfileInt( "Blinkmodi_02", "SAL_TA_Blinken_Status", 0, profileFile ) );

}


void loadSettings_BMS_05( char profileFile[] )
{
    putValue( KCAN_BMC_Spannung, getProfileFloat( "BMS_05", "BMC_Spannung", 0, profileFile ) );
    putValue( KCAN_BMS_As_Entladezaehler, getProfileInt( "BMS_05", "BMS_As_Entladezaehler", 0, profileFile ) );
    putValue( KCAN_BMS_As_Entladezaehler_Ueberlauf, getProfileInt( "BMS_05", "BMS_As_Entladezaehler_Ueberlauf", 0, profileFile ) );
    putValue( KCAN_BMS_Rekuperation, getProfileInt( "BMS_05", "BMS_Rekuperation", 0, profileFile ) );
    putValue( KCAN_BMS_Rekuperation_Ueberlauf, getProfileInt( "BMS_05", "BMS_Rekuperation_Ueberlauf", 0, profileFile ) );
    putValue( KCAN_BMS_Verbrauch, getProfileInt( "BMS_05", "BMS_Verbrauch", 0, profileFile ) );
    putValue( KCAN_BMS_Verbrauch_Ueberlauf, getProfileInt( "BMS_05", "BMS_Verbrauch_Ueberlauf", 0, profileFile ) );

}


void loadSettings_BMS_07( char profileFile[] )
{
    putValue( KCAN_BMS_Ausgleichsladung_Anf, getProfileInt( "BMS_07", "BMS_Ausgleichsladung_Anf", 0, profileFile ) );
    putValue( KCAN_BMS_Batteriediagnose, getProfileInt( "BMS_07", "BMS_Batteriediagnose", 0, profileFile ) );
    putValue( KCAN_BMS_Energieinhalt, getProfileInt( "BMS_07", "BMS_Energieinhalt", 0, profileFile ) );
    putValue( KCAN_BMS_Gesamtst_Spgfreiheit, getProfileInt( "BMS_07", "BMS_Gesamtst_Spgfreiheit", 0, profileFile ) );
    putValue( KCAN_BMS_KundenWarnung, getProfileInt( "BMS_07", "BMS_KundenWarnung", 0, profileFile ) );
    putValue( KCAN_BMS_MaxEnergieinhalt, getProfileInt( "BMS_07", "BMS_MaxEnergieinhalt", 0, profileFile ) );

}


void loadSettings_Bremse_EV_02( char profileFile[] )
{
    putValue( KCAN_EBKV_BKL_Warnungen, getProfileInt( "Bremse_EV_02", "EBKV_BKL_Warnungen", 0, profileFile ) );
    putValue( KCAN_EBKV_Charisma_FahrPr, getProfileInt( "Bremse_EV_02", "EBKV_Charisma_FahrPr", 0, profileFile ) );
    putValue( KCAN_EBKV_Charisma_Status, getProfileInt( "Bremse_EV_02", "EBKV_Charisma_Status", 0, profileFile ) );
    putValue( KCAN_EBKV_Hinweise, getProfileInt( "Bremse_EV_02", "EBKV_Hinweise", 0, profileFile ) );
    putValue( KCAN_EBKV_SpannungsAnf, getProfileInt( "Bremse_EV_02", "EBKV_SpannungsAnf", 0, profileFile ) );
    putValue( KCAN_EBKV_Warnungen, getProfileInt( "Bremse_EV_02", "EBKV_Warnungen", 0, profileFile ) );
    putValue( KCAN_EPB_Fehlermeldung_ext, getProfileInt( "Bremse_EV_02", "EPB_Fehlermeldung_ext", 0, profileFile ) );
    putValue( KCAN_EPB_Funktionslampe_ext, getProfileInt( "Bremse_EV_02", "EPB_Funktionslampe_ext", 0, profileFile ) );

}


void loadSettings_Charisma_03( char profileFile[] )
{
    putValue( KCAN_CHA_Charge_LED, getProfileInt( "Charisma_03", "CHA_Charge_LED", 0, profileFile ) );
    putValue( KCAN_CHA_Charisma_Taste2_LED, getProfileInt( "Charisma_03", "CHA_Charisma_Taste2_LED", 0, profileFile ) );
    putValue( KCAN_CHA_Current_Mode, getProfileInt( "Charisma_03", "CHA_Current_Mode", 0, profileFile ) );
    putValue( KCAN_CHA_Current_Mode_BMA, getProfileInt( "Charisma_03", "CHA_Current_Mode_BMA", 0, profileFile ) );
    putValue( KCAN_CHA_Current_Mode_FPA, getProfileInt( "Charisma_03", "CHA_Current_Mode_FPA", 0, profileFile ) );
    putValue( KCAN_CHA_Eco_Charisma_LED, getProfileInt( "Charisma_03", "CHA_Eco_Charisma_LED", 0, profileFile ) );
    putValue( KCAN_CHA_EV_LED, getProfileInt( "Charisma_03", "CHA_EV_LED", 0, profileFile ) );
    putValue( KCAN_CHA_Fahrer_Umschaltung, getProfileInt( "Charisma_03", "CHA_Fahrer_Umschaltung", 0, profileFile ) );
    putValue( KCAN_CHA_Kombi_Texte, getProfileInt( "Charisma_03", "CHA_Kombi_Texte", 0, profileFile ) );
    putValue( KCAN_CHA_Kombi_Texte_02, getProfileInt( "Charisma_03", "CHA_Kombi_Texte_02", 0, profileFile ) );
    putValue( KCAN_CHA_Offroad_LED, getProfileInt( "Charisma_03", "CHA_Offroad_LED", 0, profileFile ) );
    putValue( KCAN_CHA_Ziel_FahrPr_03_01, getProfileInt( "Charisma_03", "CHA_Ziel_FahrPr_03_01", 0, profileFile ) );
    putValue( KCAN_CHA_Ziel_FahrPr_03_02, getProfileInt( "Charisma_03", "CHA_Ziel_FahrPr_03_02", 0, profileFile ) );
    putValue( KCAN_CHA_Ziel_FahrPr_AMB, getProfileInt( "Charisma_03", "CHA_Ziel_FahrPr_AMB", 0, profileFile ) );
    putValue( KCAN_CHA_Ziel_FahrPr_HSP, getProfileInt( "Charisma_03", "CHA_Ziel_FahrPr_HSP", 0, profileFile ) );
    putValue( KCAN_CHA_Ziel_FahrPr_IVB, getProfileInt( "Charisma_03", "CHA_Ziel_FahrPr_IVB", 0, profileFile ) );
    putValue( KCAN_CHA_Ziel_FahrPr_KL, getProfileInt( "Charisma_03", "CHA_Ziel_FahrPr_KL", 0, profileFile ) );
    putValue( KCAN_CHA_Ziel_FahrPr_RWB, getProfileInt( "Charisma_03", "CHA_Ziel_FahrPr_RWB", 0, profileFile ) );

}


void loadSettings_Daempfer_01( char profileFile[] )
{
    putValue( KCAN_DR_Gelbe_Warnlampe, getProfileInt( "Daempfer_01", "DR_Gelbe_Warnlampe", 0, profileFile ) );

}


void loadSettings_Daempfer_05( char profileFile[] )
{
    putValue( KCAN_DR_DCCMonitor_I_Add, getProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_Add", 0, profileFile ) );
    putValue( KCAN_DR_DCCMonitor_I_HL, getProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_HL", 0, profileFile ) );
    putValue( KCAN_DR_DCCMonitor_I_HR, getProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_HR", 0, profileFile ) );
    putValue( KCAN_DR_DCCMonitor_I_SZ_Add, getProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_SZ_Add", 0, profileFile ) );
    putValue( KCAN_DR_DCCMonitor_I_SZ_HL, getProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_SZ_HL", 0, profileFile ) );
    putValue( KCAN_DR_DCCMonitor_I_SZ_HR, getProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_SZ_HR", 0, profileFile ) );
    putValue( KCAN_DR_DCCMonitor_I_SZ_VL, getProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_SZ_VL", 0, profileFile ) );
    putValue( KCAN_DR_DCCMonitor_I_SZ_VR, getProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_SZ_VR", 0, profileFile ) );
    putValue( KCAN_DR_DCCMonitor_I_VL, getProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_VL", 0, profileFile ) );
    putValue( KCAN_DR_DCCMonitor_I_VR, getProfileFloat( "Daempfer_05", "DR_DCCMonitor_I_VR", 0, profileFile ) );

}


void loadSettings_DCDC_02( char profileFile[] )
{
    putValue( KCAN_DC_HYB_Auslastungsgrad, getProfileFloat( "DCDC_02", "DC_HYB_Auslastungsgrad", 0, profileFile ) );
    putValue( KCAN_DC_ReserveStrom_NV, getProfileInt( "DCDC_02", "DC_ReserveStrom_NV", 0, profileFile ) );
    putValue( KCAN_DC_Verbrauch, getProfileInt( "DCDC_02", "DC_Verbrauch", 0, profileFile ) );
    putValue( KCAN_DC_Verbrauch_Ueberlauf, getProfileInt( "DCDC_02", "DC_Verbrauch_Ueberlauf", 0, profileFile ) );
    putValue( KCAN_DC_Verlustleistung, getProfileInt( "DCDC_02", "DC_Verlustleistung", 0, profileFile ) );

}


void loadSettings_DEV_SmaLi_Tx_01( char profileFile[] )
{

}


void loadSettings_DEV_ZR_Produktion_1_Rx_1D( char profileFile[] )
{

}


void loadSettings_DEV_ZR_Produktion_1_Tx_1C( char profileFile[] )
{

}


void loadSettings_DEV_ZR_Req_0D( char profileFile[] )
{

}


void loadSettings_DEV_ZR_Resp_00( char profileFile[] )
{

}


void loadSettings_DEV_ZR_SmaLi_01_Tx( char profileFile[] )
{

}


void loadSettings_DEV_ZR_Tx_14( char profileFile[] )
{

}


void loadSettings_DEV_ZR_Tx_15( char profileFile[] )
{
    putValue( KCAN_DEV_ZR_Tx_15_Data, getProfileInt( "DEV_ZR_Tx_15", "DEV_ZR_Tx_15_Data", 0, profileFile ) );
    putValue( KCAN_MMI_State_DEV_ZR_Tx_15, getProfileInt( "DEV_ZR_Tx_15", "MMI_State_DEV_ZR_Tx_15", 0, profileFile ) );
    putValue( KCAN_Reset_Counter, getProfileInt( "DEV_ZR_Tx_15", "Reset_Counter", 0, profileFile ) );
    putValue( KCAN_Routeg_aktiv, getProfileInt( "DEV_ZR_Tx_15", "Routeg_aktiv", 0, profileFile ) );
    putValue( KCAN_SI_MOST_Status, getProfileInt( "DEV_ZR_Tx_15", "SI_MOST_Status", 0, profileFile ) );
    putValue( KCAN_Tel_aktiv, getProfileInt( "DEV_ZR_Tx_15", "Tel_aktiv", 0, profileFile ) );
    putValue( KCAN_Tel_SIM_aktiv, getProfileInt( "DEV_ZR_Tx_15", "Tel_SIM_aktiv", 0, profileFile ) );
    putValue( KCAN_ZR_KL_30F, getProfileFloat( "DEV_ZR_Tx_15", "ZR_KL_30F", 0, profileFile ) );
    putValue( KCAN_ZR_LastOn, getProfileInt( "DEV_ZR_Tx_15", "ZR_LastOn", 0, profileFile ) );
    putValue( KCAN_ZR_State_DU_1_DEV_ZR_Tx_15, getProfileInt( "DEV_ZR_Tx_15", "ZR_State_DU_1_DEV_ZR_Tx_15", 0, profileFile ) );
    putValue( KCAN_ZR_TempSens, getProfileInt( "DEV_ZR_Tx_15", "ZR_TempSens", 0, profileFile ) );

}


void loadSettings_DIA_ABT_1_Req( char profileFile[] )
{

}


void loadSettings_DIA_ABT_1_Resp( char profileFile[] )
{

}


void loadSettings_Diagnose_01( char profileFile[] )
{
    putValue( KCAN_DGN_Verlernzaehler, getProfileInt( "Diagnose_01", "DGN_Verlernzaehler", 0, profileFile ) );
    putValue( KCAN_KBI_Kilometerstand, getProfileInt( "Diagnose_01", "KBI_Kilometerstand", 0, profileFile ) );
    putValue( KCAN_Kombi_02_alt, getProfileInt( "Diagnose_01", "Kombi_02_alt", 0, profileFile ) );
    putValue( KCAN_UH_Jahr, getProfileInt( "Diagnose_01", "UH_Jahr", 0, profileFile ) );
    putValue( KCAN_UH_Minute, getProfileInt( "Diagnose_01", "UH_Minute", 0, profileFile ) );
    putValue( KCAN_UH_Monat, getProfileInt( "Diagnose_01", "UH_Monat", 0, profileFile ) );
    putValue( KCAN_UH_Sekunde, getProfileInt( "Diagnose_01", "UH_Sekunde", 0, profileFile ) );
    putValue( KCAN_UH_Stunde, getProfileInt( "Diagnose_01", "UH_Stunde", 0, profileFile ) );
    putValue( KCAN_UH_Tag, getProfileInt( "Diagnose_01", "UH_Tag", 0, profileFile ) );
    putValue( KCAN_Uhrzeit_01_alt, getProfileInt( "Diagnose_01", "Uhrzeit_01_alt", 0, profileFile ) );
    putValue( KCAN_Vehicle_Driving_Cycle, getProfileInt( "Diagnose_01", "Vehicle_Driving_Cycle", 0, profileFile ) );

}


void loadSettings_DiETa_01( char profileFile[] )
{
    putValue( KCAN_DiETa_Car, getProfileInt( "DiETa_01", "DiETa_Car", 0, profileFile ) );
    putValue( KCAN_DiETa_Defrost_Taste, getProfileInt( "DiETa_01", "DiETa_Defrost_Taste", 0, profileFile ) );
    putValue( KCAN_DiETa_FAS_Stufe, getProfileInt( "DiETa_01", "DiETa_FAS_Stufe", 0, profileFile ) );
    putValue( KCAN_DiETa_FSH_Taste, getProfileInt( "DiETa_01", "DiETa_FSH_Taste", 0, profileFile ) );
    putValue( KCAN_DiETa_HSH_Taste, getProfileInt( "DiETa_01", "DiETa_HSH_Taste", 0, profileFile ) );
    putValue( KCAN_DiETa_Klima, getProfileInt( "DiETa_01", "DiETa_Klima", 0, profileFile ) );
    putValue( KCAN_DiETa_Lock_Unlock_Taste, getProfileInt( "DiETa_01", "DiETa_Lock_Unlock_Taste", 0, profileFile ) );
    putValue( KCAN_DiETa_Mode, getProfileInt( "DiETa_01", "DiETa_Mode", 0, profileFile ) );
    putValue( KCAN_DiETa_Mode2, getProfileInt( "DiETa_01", "DiETa_Mode2", 0, profileFile ) );
    putValue( KCAN_DiETa_Mode_roh, getProfileInt( "DiETa_01", "DiETa_Mode_roh", 0, profileFile ) );
    putValue( KCAN_DiETa_PAO_OFF_Status, getProfileInt( "DiETa_01", "DiETa_PAO_OFF_Status", 0, profileFile ) );
    putValue( KCAN_DiETa_PAO_ON_Status, getProfileInt( "DiETa_01", "DiETa_PAO_ON_Status", 0, profileFile ) );
    putValue( KCAN_DiETa_Parken, getProfileInt( "DiETa_01", "DiETa_Parken", 0, profileFile ) );
    putValue( KCAN_DiETa_Reserve_Byte2_4, getProfileInt( "DiETa_01", "DiETa_Reserve_Byte2_4", 0, profileFile ) );
    putValue( KCAN_DiETa_Reserve_Byte6_6, getProfileInt( "DiETa_01", "DiETa_Reserve_Byte6_6", 0, profileFile ) );
    putValue( KCAN_DiETa_Reserve_Byte7_4, getProfileInt( "DiETa_01", "DiETa_Reserve_Byte7_4", 0, profileFile ) );
    putValue( KCAN_DiETa_Reserve_Byte8, getProfileInt( "DiETa_01", "DiETa_Reserve_Byte8", 0, profileFile ) );
    putValue( KCAN_DiETa_ResponseError, getProfileInt( "DiETa_01", "DiETa_ResponseError", 0, profileFile ) );
    putValue( KCAN_DiETa_Status, getProfileInt( "DiETa_01", "DiETa_Status", 0, profileFile ) );
    putValue( KCAN_DiETa_Touch_Event, getProfileInt( "DiETa_01", "DiETa_Touch_Event", 0, profileFile ) );
    putValue( KCAN_DiETa_Warnblink_Taste, getProfileInt( "DiETa_01", "DiETa_Warnblink_Taste", 0, profileFile ) );
    putValue( KCAN_ESP_Off_Taster, getProfileInt( "DiETa_01", "ESP_Off_Taster", 0, profileFile ) );

}


void loadSettings_Dimmung_01( char profileFile[] )
{
    putValue( KCAN_BCM1_Stellgroesse_Kl_58s, getProfileInt( "Dimmung_01", "BCM1_Stellgroesse_Kl_58s", 0, profileFile ) );
    putValue( KCAN_DI_Display_Nachtdesign, getProfileInt( "Dimmung_01", "DI_Display_Nachtdesign", 0, profileFile ) );
    putValue( KCAN_DI_Fotosensor, getProfileInt( "Dimmung_01", "DI_Fotosensor", 0, profileFile ) );
    putValue( KCAN_DI_KL_58xd, getProfileInt( "Dimmung_01", "DI_KL_58xd", 0, profileFile ) );
    putValue( KCAN_DI_KL_58xs, getProfileInt( "Dimmung_01", "DI_KL_58xs", 0, profileFile ) );
    putValue( KCAN_DI_KL_58xt, getProfileInt( "Dimmung_01", "DI_KL_58xt", 0, profileFile ) );

}


void loadSettings_DispKBI_FS_01( char profileFile[] )
{
    putValue( KCAN_DispKBI_FS_Systemstatus, getProfileInt( "DispKBI_FS_01", "DispKBI_FS_Systemstatus", 0, profileFile ) );

}


void loadSettings_DispKBI_FS_DispPos_Req_FD( char profileFile[] )
{

}


void loadSettings_DispKBI_FS_DispPos_Resp_FD( char profileFile[] )
{

}


void loadSettings_Display_1_03( char profileFile[] )
{
    putValue( KCAN_DU1_Fehlerstatus, getProfileInt( "Display_1_03", "DU1_Fehlerstatus", 0, profileFile ) );
    putValue( KCAN_DU1_HWR_Fehlerstatus, getProfileInt( "Display_1_03", "DU1_HWR_Fehlerstatus", 0, profileFile ) );
    putValue( KCAN_DU1_KS_aktiv_anderer_Grund, getProfileInt( "Display_1_03", "DU1_KS_aktiv_anderer_Grund", 0, profileFile ) );
    putValue( KCAN_DU1_KS_aktiv_falsche_Auth, getProfileInt( "Display_1_03", "DU1_KS_aktiv_falsche_Auth", 0, profileFile ) );
    putValue( KCAN_DU1_KS_aktiv_Manipulationsschutz, getProfileInt( "Display_1_03", "DU1_KS_aktiv_Manipulationsschutz", 0, profileFile ) );
    putValue( KCAN_DU1_KS_FIS_unplausibel, getProfileInt( "Display_1_03", "DU1_KS_FIS_unplausibel", 0, profileFile ) );
    putValue( KCAN_DU1_KS_keine_Grundeinstellung, getProfileInt( "Display_1_03", "DU1_KS_keine_Grundeinstellung", 0, profileFile ) );
    putValue( KCAN_DU1_KS_SHE_keine_Grundeinst, getProfileInt( "Display_1_03", "DU1_KS_SHE_keine_Grundeinst", 0, profileFile ) );
    putValue( KCAN_DU1_Slider_Locked, getProfileInt( "Display_1_03", "DU1_Slider_Locked", 0, profileFile ) );
    putValue( KCAN_DU1_Touchstatus, getProfileInt( "Display_1_03", "DU1_Touchstatus", 0, profileFile ) );

}


void loadSettings_DispPos_DispKBI_FS_Req_FD( char profileFile[] )
{

}


void loadSettings_DispPos_DispKBI_FS_Resp_FD( char profileFile[] )
{

}


void loadSettings_EA_02( char profileFile[] )
{
    putValue( KCAN_ACF_Lampe_Hands_Off, getProfileInt( "EA_02", "ACF_Lampe_Hands_Off", 0, profileFile ) );
    putValue( KCAN_EA_Blinken, getProfileInt( "EA_02", "EA_Blinken", 0, profileFile ) );
    putValue( KCAN_EA_Bremslichtblinken, getProfileInt( "EA_02", "EA_Bremslichtblinken", 0, profileFile ) );
    putValue( KCAN_EA_eCall_Anf, getProfileInt( "EA_02", "EA_eCall_Anf", 0, profileFile ) );
    putValue( KCAN_EA_Fahrzeughupe_Anf, getProfileInt( "EA_02", "EA_Fahrzeughupe_Anf", 0, profileFile ) );
    putValue( KCAN_EA_Infotainment_Anf, getProfileInt( "EA_02", "EA_Infotainment_Anf", 0, profileFile ) );
    putValue( KCAN_EA_Innenraumlicht_Anf, getProfileInt( "EA_02", "EA_Innenraumlicht_Anf", 0, profileFile ) );
    putValue( KCAN_EA_Texte, getProfileInt( "EA_02", "EA_Texte", 0, profileFile ) );
    putValue( KCAN_EA_Tueren_Anf, getProfileInt( "EA_02", "EA_Tueren_Anf", 0, profileFile ) );
    putValue( KCAN_EA_Warnlevel, getProfileInt( "EA_02", "EA_Warnlevel", 0, profileFile ) );
    putValue( KCAN_STP_Primaeranz, getProfileInt( "EA_02", "STP_Primaeranz", 0, profileFile ) );
    putValue( KCAN_zFAS_Warnblinken, getProfileInt( "EA_02", "zFAS_Warnblinken", 0, profileFile ) );

}


void loadSettings_ELV_01( char profileFile[] )
{
    putValue( KCAN_ELV_01_Sendestatus, getProfileInt( "ELV_01", "ELV_01_Sendestatus", 0, profileFile ) );
    putValue( KCAN_ELV_Abbruch_Anf_Klemmenfreigabe, getProfileInt( "ELV_01", "ELV_Abbruch_Anf_Klemmenfreigabe", 0, profileFile ) );
    putValue( KCAN_ELV_Anf_Klemme_15, getProfileInt( "ELV_01", "ELV_Anf_Klemme_15", 0, profileFile ) );
    putValue( KCAN_ELV_Anf_Klemme_50, getProfileInt( "ELV_01", "ELV_Anf_Klemme_50", 0, profileFile ) );
    putValue( KCAN_ELV_Anf_Klemme_S, getProfileInt( "ELV_01", "ELV_Anf_Klemme_S", 0, profileFile ) );
    putValue( KCAN_ELV_Anlernmodus, getProfileInt( "ELV_01", "ELV_Anlernmodus", 0, profileFile ) );
    putValue( KCAN_ELV_Entriegelt, getProfileInt( "ELV_01", "ELV_Entriegelt", 0, profileFile ) );
    putValue( KCAN_ELV_Klemmenfreigabe, getProfileInt( "ELV_01", "ELV_Klemmenfreigabe", 0, profileFile ) );
    putValue( KCAN_ELV_Lebenszustand, getProfileInt( "ELV_01", "ELV_Lebenszustand", 0, profileFile ) );
    putValue( KCAN_ELV_LED_Gelb, getProfileInt( "ELV_01", "ELV_LED_Gelb", 0, profileFile ) );
    putValue( KCAN_ELV_LED_Rot, getProfileInt( "ELV_01", "ELV_LED_Rot", 0, profileFile ) );
    putValue( KCAN_ELV_P_verriegelt, getProfileInt( "ELV_01", "ELV_P_verriegelt", 0, profileFile ) );
    putValue( KCAN_ELV_Txt_Bremse, getProfileInt( "ELV_01", "ELV_Txt_Bremse", 0, profileFile ) );
    putValue( KCAN_ELV_Txt_Defekt, getProfileInt( "ELV_01", "ELV_Txt_Defekt", 0, profileFile ) );
    putValue( KCAN_ELV_Txt_Kupplung, getProfileInt( "ELV_01", "ELV_Txt_Kupplung", 0, profileFile ) );
    putValue( KCAN_ELV_Txt_Lkg_Bewegen, getProfileInt( "ELV_01", "ELV_Txt_Lkg_Bewegen", 0, profileFile ) );
    putValue( KCAN_ELV_Txt_P_Gang, getProfileInt( "ELV_01", "ELV_Txt_P_Gang", 0, profileFile ) );
    putValue( KCAN_ELV_Txt_Panikabschaltung, getProfileInt( "ELV_01", "ELV_Txt_Panikabschaltung", 0, profileFile ) );
    putValue( KCAN_ELV_Txt_PN_Gang, getProfileInt( "ELV_01", "ELV_Txt_PN_Gang", 0, profileFile ) );
    putValue( KCAN_ELV_Txt_Werkstatt, getProfileInt( "ELV_01", "ELV_Txt_Werkstatt", 0, profileFile ) );
    putValue( KCAN_ELV_Verriegelt, getProfileInt( "ELV_01", "ELV_Verriegelt", 0, profileFile ) );
    putValue( KCAN_ELV_ZAT_betaetigt, getProfileInt( "ELV_01", "ELV_ZAT_betaetigt", 0, profileFile ) );
    putValue( KCAN_KST_Anf_ZV_Verriegelung_ELV_01, getProfileInt( "ELV_01", "KST_Anf_ZV_Verriegelung_ELV_01", 0, profileFile ) );
    putValue( KCAN_KST_aut_Abschaltung_Zuendung_ELV_01, getProfileInt( "ELV_01", "KST_aut_Abschaltung_Zuendung_ELV_01", 0, profileFile ) );
    putValue( KCAN_KST_Txt_Komfortabschaltung_ELV_01, getProfileInt( "ELV_01", "KST_Txt_Komfortabschaltung_ELV_01", 0, profileFile ) );
    putValue( KCAN_KST_Unterdr_Zuendungsmeldung_ELV_01, getProfileInt( "ELV_01", "KST_Unterdr_Zuendungsmeldung_ELV_01", 0, profileFile ) );

}


void loadSettings_EML_06( char profileFile[] )
{
    putValue( KCAN_EML_AnzeigeGeschw_EML_06, getProfileFloat( "EML_06", "EML_AnzeigeGeschw_EML_06", 0, profileFile ) );
    putValue( KCAN_EML_BeschlX, getProfileFloat( "EML_06", "EML_BeschlX", 0, profileFile ) );
    putValue( KCAN_EML_BeschlXCF, getProfileInt( "EML_06", "EML_BeschlXCF", 0, profileFile ) );
    putValue( KCAN_EML_BeschlY, getProfileFloat( "EML_06", "EML_BeschlY", 0, profileFile ) );
    putValue( KCAN_EML_BeschlYCF, getProfileInt( "EML_06", "EML_BeschlYCF", 0, profileFile ) );
    putValue( KCAN_EML_Fahrtrichtungswahrsch, getProfileInt( "EML_06", "EML_Fahrtrichtungswahrsch", 0, profileFile ) );
    putValue( KCAN_EML_Fahrwerksregeleingriff, getProfileInt( "EML_06", "EML_Fahrwerksregeleingriff", 0, profileFile ) );
    putValue( KCAN_EML_GeschwX, getProfileFloat( "EML_06", "EML_GeschwX", 0, profileFile ) );
    putValue( KCAN_EML_GeschwXStdA, getProfileFloat( "EML_06", "EML_GeschwXStdA", 0, profileFile ) );
    putValue( KCAN_EML_GierRate, getProfileFloat( "EML_06", "EML_GierRate", 0, profileFile ) );
    putValue( KCAN_EML_GierRateCF, getProfileInt( "EML_06", "EML_GierRateCF", 0, profileFile ) );
    putValue( KCAN_EML_GierRateStdA, getProfileFloat( "EML_06", "EML_GierRateStdA", 0, profileFile ) );
    putValue( KCAN_EML_Gierwinkel, getProfileFloat( "EML_06", "EML_Gierwinkel", 0, profileFile ) );
    putValue( KCAN_EML_GierwinkelCF, getProfileInt( "EML_06", "EML_GierwinkelCF", 0, profileFile ) );
    putValue( KCAN_EML_GierwinkelStdA, getProfileFloat( "EML_06", "EML_GierwinkelStdA", 0, profileFile ) );
    putValue( KCAN_EML_Hoehe2USK, getProfileFloat( "EML_06", "EML_Hoehe2USK", 0, profileFile ) );
    putValue( KCAN_EML_Hoehe2USKStdA, getProfileFloat( "EML_06", "EML_Hoehe2USKStdA", 0, profileFile ) );
    putValue( KCAN_EML_Hoehe_Nick_Wankwinkel2USKCF, getProfileInt( "EML_06", "EML_Hoehe_Nick_Wankwinkel2USKCF", 0, profileFile ) );
    putValue( KCAN_EML_Kurvenkruemmung, getProfileFloat( "EML_06", "EML_Kurvenkruemmung", 0, profileFile ) );
    putValue( KCAN_EML_LenkWnklVL, getProfileFloat( "EML_06", "EML_LenkWnklVL", 0, profileFile ) );
    putValue( KCAN_EML_LenkWnklVR, getProfileFloat( "EML_06", "EML_LenkWnklVR", 0, profileFile ) );
    putValue( KCAN_EML_MessZeitpunkt, getProfileFloat( "EML_06", "EML_MessZeitpunkt", 0, profileFile ) );
    putValue( KCAN_EML_Nickwinkel, getProfileFloat( "EML_06", "EML_Nickwinkel", 0, profileFile ) );
    putValue( KCAN_EML_Nickwinkel2USK, getProfileFloat( "EML_06", "EML_Nickwinkel2USK", 0, profileFile ) );
    putValue( KCAN_EML_Nickwinkel2USKStdA, getProfileFloat( "EML_06", "EML_Nickwinkel2USKStdA", 0, profileFile ) );
    putValue( KCAN_EML_Pose_Qualifier, getProfileInt( "EML_06", "EML_Pose_Qualifier", 0, profileFile ) );
    putValue( KCAN_EML_PositionCF, getProfileInt( "EML_06", "EML_PositionCF", 0, profileFile ) );
    putValue( KCAN_EML_PositionX, getProfileFloat( "EML_06", "EML_PositionX", 0, profileFile ) );
    putValue( KCAN_EML_PositionXStdA, getProfileFloat( "EML_06", "EML_PositionXStdA", 0, profileFile ) );
    putValue( KCAN_EML_PositionY, getProfileFloat( "EML_06", "EML_PositionY", 0, profileFile ) );
    putValue( KCAN_EML_PositionYStdA, getProfileFloat( "EML_06", "EML_PositionYStdA", 0, profileFile ) );
    putValue( KCAN_EML_QBit_Anzeigegeschw_EML_06, getProfileInt( "EML_06", "EML_QBit_Anzeigegeschw_EML_06", 0, profileFile ) );
    putValue( KCAN_EML_QBit_Fahrtrichtungswahrsch, getProfileInt( "EML_06", "EML_QBit_Fahrtrichtungswahrsch", 0, profileFile ) );
    putValue( KCAN_EML_QBit_Kurvenkruemmung, getProfileInt( "EML_06", "EML_QBit_Kurvenkruemmung", 0, profileFile ) );
    putValue( KCAN_EML_QBit_Nickwinkel, getProfileInt( "EML_06", "EML_QBit_Nickwinkel", 0, profileFile ) );
    putValue( KCAN_EML_QBit_Stillstandswahrsch, getProfileInt( "EML_06", "EML_QBit_Stillstandswahrsch", 0, profileFile ) );
    putValue( KCAN_EML_Stillstandswahrsch, getProfileInt( "EML_06", "EML_Stillstandswahrsch", 0, profileFile ) );
    putValue( KCAN_EML_Wankwinkel2USK, getProfileFloat( "EML_06", "EML_Wankwinkel2USK", 0, profileFile ) );
    putValue( KCAN_EML_Wankwinkel2USKStdA, getProfileFloat( "EML_06", "EML_Wankwinkel2USKStdA", 0, profileFile ) );

}


void loadSettings_EML_07( char profileFile[] )
{
    putValue( KCAN_EML_AnzeigeGeschw, getProfileFloat( "EML_07", "EML_AnzeigeGeschw", 0, profileFile ) );
    putValue( KCAN_EML_QBit_Anzeigegeschw_EML_07, getProfileInt( "EML_07", "EML_QBit_Anzeigegeschw_EML_07", 0, profileFile ) );

}


void loadSettings_Entfernungen_01( char profileFile[] )
{
    putValue( KCAN_KBI_Kilometerstand_Extended, getProfileInt( "Entfernungen_01", "KBI_Kilometerstand_Extended", 0, profileFile ) );

}


void loadSettings_EPB_03( char profileFile[] )
{
    putValue( KCAN_EPB_Autohold_Standbyanzeige, getProfileInt( "EPB_03", "EPB_Autohold_Standbyanzeige", 0, profileFile ) );
    putValue( KCAN_EPB_Autoholdlampe_02, getProfileInt( "EPB_03", "EPB_Autoholdlampe_02", 0, profileFile ) );
    putValue( KCAN_EPB_Fehlermeldungen_02, getProfileInt( "EPB_03", "EPB_Fehlermeldungen_02", 0, profileFile ) );
    putValue( KCAN_EPB_Funktionslampe_02, getProfileInt( "EPB_03", "EPB_Funktionslampe_02", 0, profileFile ) );
    putValue( KCAN_EPB_Parkanzeige, getProfileInt( "EPB_03", "EPB_Parkanzeige", 0, profileFile ) );
    putValue( KCAN_EPB_Texte_02, getProfileInt( "EPB_03", "EPB_Texte_02", 0, profileFile ) );

}


void loadSettings_ESC_50( char profileFile[] )
{
    putValue( KCAN_ECD_Bremslicht_ESC_50, getProfileInt( "ESC_50", "ECD_Bremslicht_ESC_50", 0, profileFile ) );
    putValue( KCAN_ECD_Fehler, getProfileInt( "ESC_50", "ECD_Fehler", 0, profileFile ) );
    putValue( KCAN_ECD_nicht_verfuegbar, getProfileInt( "ESC_50", "ECD_nicht_verfuegbar", 0, profileFile ) );
    putValue( KCAN_EPB_DAA_Randbed_erf, getProfileInt( "ESC_50", "EPB_DAA_Randbed_erf", 0, profileFile ) );
    putValue( KCAN_EPB_Fehlerstatus_02, getProfileInt( "ESC_50", "EPB_Fehlerstatus_02", 0, profileFile ) );
    putValue( KCAN_EPB_Freig_Verzoeg_Anf, getProfileInt( "ESC_50", "EPB_Freig_Verzoeg_Anf", 0, profileFile ) );
    putValue( KCAN_EPB_Pedalweg_Kuppl_ESC_50, getProfileFloat( "ESC_50", "EPB_Pedalweg_Kuppl_ESC_50", 0, profileFile ) );
    putValue( KCAN_EPB_QBit_Pedalweg_Kuppl_ESC_50, getProfileInt( "ESC_50", "EPB_QBit_Pedalweg_Kuppl_ESC_50", 0, profileFile ) );
    putValue( KCAN_EPB_QBit_Schalterpos, getProfileInt( "ESC_50", "EPB_QBit_Schalterpos", 0, profileFile ) );
    putValue( KCAN_EPB_Schalterposition, getProfileInt( "ESC_50", "EPB_Schalterposition", 0, profileFile ) );
    putValue( KCAN_EPB_Spannkraft, getProfileInt( "ESC_50", "EPB_Spannkraft", 0, profileFile ) );
    putValue( KCAN_EPB_Status, getProfileInt( "ESC_50", "EPB_Status", 0, profileFile ) );
    putValue( KCAN_EPB_Status_02_ESC_50, getProfileInt( "ESC_50", "EPB_Status_02_ESC_50", 0, profileFile ) );
    putValue( KCAN_EPB_Verzoeg_Anf, getProfileFloat( "ESC_50", "EPB_Verzoeg_Anf", 0, profileFile ) );
    putValue( KCAN_ESC_Bremsdruckgradient, getProfileInt( "ESC_50", "ESC_Bremsdruckgradient", 0, profileFile ) );
    putValue( KCAN_ESC_Fahrerbremswunsch, getProfileFloat( "ESC_50", "ESC_Fahrerbremswunsch", 0, profileFile ) );
    putValue( KCAN_ESC_Hydr_Fkt_aktiv, getProfileInt( "ESC_50", "ESC_Hydr_Fkt_aktiv", 0, profileFile ) );
    putValue( KCAN_ESC_Motorstartverzoegerung, getProfileInt( "ESC_50", "ESC_Motorstartverzoegerung", 0, profileFile ) );
    putValue( KCAN_ESC_QBit_Fahrerbremswunsch, getProfileInt( "ESC_50", "ESC_QBit_Fahrerbremswunsch", 0, profileFile ) );
    putValue( KCAN_ESC_Raddruck_max, getProfileInt( "ESC_50", "ESC_Raddruck_max", 0, profileFile ) );
    putValue( KCAN_ESC_SeitenwindAssistent_Eingriff, getProfileInt( "ESC_50", "ESC_SeitenwindAssistent_Eingriff", 0, profileFile ) );
    putValue( KCAN_ESC_Unterdruckmangel_erkannt, getProfileInt( "ESC_50", "ESC_Unterdruckmangel_erkannt", 0, profileFile ) );
    putValue( KCAN_ESCGeneratorSollMoment, getProfileInt( "ESC_50", "ESCGeneratorSollMoment", 0, profileFile ) );
    putValue( KCAN_ESP_Abrutschen_Stillstand, getProfileInt( "ESC_50", "ESP_Abrutschen_Stillstand", 0, profileFile ) );
    putValue( KCAN_ESP_ANB_CM_Rueckk_Umsetz, getProfileInt( "ESC_50", "ESP_ANB_CM_Rueckk_Umsetz", 0, profileFile ) );
    putValue( KCAN_ESP_Anforderung_EPB, getProfileInt( "ESC_50", "ESP_Anforderung_EPB", 0, profileFile ) );
    putValue( KCAN_ESP_Anschleppstart_Freigabe, getProfileInt( "ESC_50", "ESP_Anschleppstart_Freigabe", 0, profileFile ) );
    putValue( KCAN_ESP_Autohold_aktiv, getProfileInt( "ESC_50", "ESP_Autohold_aktiv", 0, profileFile ) );
    putValue( KCAN_ESP_Autohold_Standby, getProfileInt( "ESC_50", "ESP_Autohold_Standby", 0, profileFile ) );
    putValue( KCAN_ESP_BKV_Unterdruck, getProfileInt( "ESC_50", "ESP_BKV_Unterdruck", 0, profileFile ) );
    putValue( KCAN_ESP_Bremsdruck, getProfileFloat( "ESC_50", "ESP_Bremsdruck", 0, profileFile ) );
    putValue( KCAN_ESP_Bremsruck_AWV2, getProfileInt( "ESC_50", "ESP_Bremsruck_AWV2", 0, profileFile ) );
    putValue( KCAN_ESP_Eingr_HL, getProfileInt( "ESC_50", "ESP_Eingr_HL", 0, profileFile ) );
    putValue( KCAN_ESP_Eingr_HR, getProfileInt( "ESC_50", "ESP_Eingr_HR", 0, profileFile ) );
    putValue( KCAN_ESP_Eingr_VL, getProfileInt( "ESC_50", "ESP_Eingr_VL", 0, profileFile ) );
    putValue( KCAN_ESP_Eingr_VR, getProfileInt( "ESC_50", "ESP_Eingr_VR", 0, profileFile ) );
    putValue( KCAN_ESP_Fahrer_bremst, getProfileInt( "ESC_50", "ESP_Fahrer_bremst", 0, profileFile ) );
    putValue( KCAN_ESP_Fahrer_tritt_ZBR_Schw, getProfileInt( "ESC_50", "ESP_Fahrer_tritt_ZBR_Schw", 0, profileFile ) );
    putValue( KCAN_ESP_FStatus_Anfahrhilfe, getProfileInt( "ESC_50", "ESP_FStatus_Anfahrhilfe", 0, profileFile ) );
    putValue( KCAN_ESP_Gierrate, getProfileFloat( "ESC_50", "ESP_Gierrate", 0, profileFile ) );
    putValue( KCAN_ESP_HBA_aktiv, getProfileInt( "ESC_50", "ESP_HBA_aktiv", 0, profileFile ) );
    putValue( KCAN_ESP_HDC_aktiv, getProfileInt( "ESC_50", "ESP_HDC_aktiv", 0, profileFile ) );
    putValue( KCAN_ESP_HDC_Standby_ESC_50, getProfileInt( "ESC_50", "ESP_HDC_Standby_ESC_50", 0, profileFile ) );
    putValue( KCAN_ESP_Konsistenz_ACC_Botschaft, getProfileInt( "ESC_50", "ESP_Konsistenz_ACC_Botschaft", 0, profileFile ) );
    putValue( KCAN_ESP_Konsistenz_AWV2, getProfileInt( "ESC_50", "ESP_Konsistenz_AWV2", 0, profileFile ) );
    putValue( KCAN_ESP_Konsistenz_TSK, getProfileInt( "ESC_50", "ESP_Konsistenz_TSK", 0, profileFile ) );
    putValue( KCAN_ESP_Laengsbeschl, getProfileFloat( "ESC_50", "ESP_Laengsbeschl", 0, profileFile ) );
    putValue( KCAN_ESP_Lenkeingriff_ADS, getProfileInt( "ESC_50", "ESP_Lenkeingriff_ADS", 0, profileFile ) );
    putValue( KCAN_ESP_Notbremsanzeige, getProfileInt( "ESC_50", "ESP_Notbremsanzeige", 0, profileFile ) );
    putValue( KCAN_ESP_PLA_Abbruch, getProfileInt( "ESC_50", "ESP_PLA_Abbruch", 0, profileFile ) );
    putValue( KCAN_ESP_Prefill_ausgeloest, getProfileInt( "ESC_50", "ESP_Prefill_ausgeloest", 0, profileFile ) );
    putValue( KCAN_ESP_QBit_Bremsdruck, getProfileInt( "ESC_50", "ESP_QBit_Bremsdruck", 0, profileFile ) );
    putValue( KCAN_ESP_QBit_Fahrer_bremst, getProfileInt( "ESC_50", "ESP_QBit_Fahrer_bremst", 0, profileFile ) );
    putValue( KCAN_ESP_QBit_Gierrate, getProfileInt( "ESC_50", "ESP_QBit_Gierrate", 0, profileFile ) );
    putValue( KCAN_ESP_QBit_Laengsbeschl, getProfileInt( "ESC_50", "ESP_QBit_Laengsbeschl", 0, profileFile ) );
    putValue( KCAN_ESP_QBit_Querb, getProfileInt( "ESC_50", "ESP_QBit_Querb", 0, profileFile ) );
    putValue( KCAN_ESP_QBit_v_ref, getProfileInt( "ESC_50", "ESP_QBit_v_ref", 0, profileFile ) );
    putValue( KCAN_ESP_Querbeschleunigung, getProfileFloat( "ESC_50", "ESP_Querbeschleunigung", 0, profileFile ) );
    putValue( KCAN_ESP_Rueckwaertsfahrt_erkannt, getProfileInt( "ESC_50", "ESP_Rueckwaertsfahrt_erkannt", 0, profileFile ) );
    putValue( KCAN_ESP_Schwelle_Unterdruck, getProfileInt( "ESC_50", "ESP_Schwelle_Unterdruck", 0, profileFile ) );
    putValue( KCAN_ESP_SpannungsAnf, getProfileInt( "ESC_50", "ESP_SpannungsAnf", 0, profileFile ) );
    putValue( KCAN_ESP_StartStopp_Info, getProfileInt( "ESC_50", "ESP_StartStopp_Info", 0, profileFile ) );
    putValue( KCAN_ESP_Status_Anfahrhilfe, getProfileInt( "ESC_50", "ESP_Status_Anfahrhilfe", 0, profileFile ) );
    putValue( KCAN_ESP_Status_Bremsdruck, getProfileInt( "ESC_50", "ESP_Status_Bremsdruck", 0, profileFile ) );
    putValue( KCAN_ESP_Status_Bremsentemp, getProfileInt( "ESC_50", "ESP_Status_Bremsentemp", 0, profileFile ) );
    putValue( KCAN_ESP_Status_Bremsentemp_02_ESC_50, getProfileInt( "ESC_50", "ESP_Status_Bremsentemp_02_ESC_50", 0, profileFile ) );
    putValue( KCAN_ESP_Status_ESP_PLA, getProfileInt( "ESC_50", "ESP_Status_ESP_PLA", 0, profileFile ) );
    putValue( KCAN_ESP_Stillstandsphase_erschoepft, getProfileInt( "ESC_50", "ESP_Stillstandsphase_erschoepft", 0, profileFile ) );
    putValue( KCAN_ESP_Tuerkontakt_Fahrertuer, getProfileInt( "ESC_50", "ESP_Tuerkontakt_Fahrertuer", 0, profileFile ) );
    putValue( KCAN_ESP_v_ref, getProfileFloat( "ESC_50", "ESP_v_ref", 0, profileFile ) );
    putValue( KCAN_ESP_v_ref_Fahrtrichtung, getProfileInt( "ESC_50", "ESP_v_ref_Fahrtrichtung", 0, profileFile ) );
    putValue( KCAN_ESP_Verz_EPB_aktiv, getProfileInt( "ESC_50", "ESP_Verz_EPB_aktiv", 0, profileFile ) );
    putValue( KCAN_ESP_Verz_TSK_aktiv, getProfileInt( "ESC_50", "ESP_Verz_TSK_aktiv", 0, profileFile ) );
    putValue( KCAN_ESP_Verzoeg_EPB_verf, getProfileInt( "ESC_50", "ESP_Verzoeg_EPB_verf", 0, profileFile ) );
    putValue( KCAN_ESP_VZ_Gierrate, getProfileInt( "ESC_50", "ESP_VZ_Gierrate", 0, profileFile ) );
    putValue( KCAN_ESP_ZT_Rueckk_Umsetz, getProfileInt( "ESC_50", "ESP_ZT_Rueckk_Umsetz", 0, profileFile ) );

}


void loadSettings_ESC_51( char profileFile[] )
{
    putValue( KCAN_ESC_Achsdrehzahl_Max, getProfileFloat( "ESC_51", "ESC_Achsdrehzahl_Max", 0, profileFile ) );
    putValue( KCAN_ESC_Achsdrehzahl_Max_sek, getProfileFloat( "ESC_51", "ESC_Achsdrehzahl_Max_sek", 0, profileFile ) );
    putValue( KCAN_ESC_Achsdrehzahl_Min, getProfileFloat( "ESC_51", "ESC_Achsdrehzahl_Min", 0, profileFile ) );
    putValue( KCAN_ESC_Achsdrehzahl_Min_sek, getProfileFloat( "ESC_51", "ESC_Achsdrehzahl_Min_sek", 0, profileFile ) );
    putValue( KCAN_ESC_aktBr_Modus, getProfileInt( "ESC_51", "ESC_aktBr_Modus", 0, profileFile ) );
    putValue( KCAN_ESC_aktBr_Volumenstrom, getProfileFloat( "ESC_51", "ESC_aktBr_Volumenstrom", 0, profileFile ) );
    putValue( KCAN_ESC_Allrad_Anteil_max_sek, getProfileFloat( "ESC_51", "ESC_Allrad_Anteil_max_sek", 0, profileFile ) );
    putValue( KCAN_ESC_Allrad_Anteil_min_sek, getProfileFloat( "ESC_51", "ESC_Allrad_Anteil_min_sek", 0, profileFile ) );
    putValue( KCAN_ESC_Allradverteilung_aktiv, getProfileInt( "ESC_51", "ESC_Allradverteilung_aktiv", 0, profileFile ) );
    putValue( KCAN_ESC_Anf_Mindestreku, getProfileInt( "ESC_51", "ESC_Anf_Mindestreku", 0, profileFile ) );
    putValue( KCAN_ESC_Blending_Solldruck, getProfileFloat( "ESC_51", "ESC_Blending_Solldruck", 0, profileFile ) );
    putValue( KCAN_ESC_Bremsdruck_02, getProfileFloat( "ESC_51", "ESC_Bremsdruck_02", 0, profileFile ) );
    putValue( KCAN_ESC_Bremsdruck_Modell, getProfileFloat( "ESC_51", "ESC_Bremsdruck_Modell", 0, profileFile ) );
    putValue( KCAN_ESC_EBKV_Kraftblending_Modus, getProfileInt( "ESC_51", "ESC_EBKV_Kraftblending_Modus", 0, profileFile ) );
    putValue( KCAN_ESC_GMV_aktiv, getProfileInt( "ESC_51", "ESC_GMV_aktiv", 0, profileFile ) );
    putValue( KCAN_ESC_GMV_nicht_verfuegbar, getProfileInt( "ESC_51", "ESC_GMV_nicht_verfuegbar", 0, profileFile ) );
    putValue( KCAN_ESC_MomRad_Eingriff, getProfileInt( "ESC_51", "ESC_MomRad_Eingriff", 0, profileFile ) );
    putValue( KCAN_ESC_MomRad_Eingriff_sek, getProfileInt( "ESC_51", "ESC_MomRad_Eingriff_sek", 0, profileFile ) );
    putValue( KCAN_ESC_QBit_Bremsdruck_02, getProfileInt( "ESC_51", "ESC_QBit_Bremsdruck_02", 0, profileFile ) );
    putValue( KCAN_ESC_Status_Eingriff, getProfileInt( "ESC_51", "ESC_Status_Eingriff", 0, profileFile ) );
    putValue( KCAN_ESC_Status_Eingriff_sek, getProfileInt( "ESC_51", "ESC_Status_Eingriff_sek", 0, profileFile ) );
    putValue( KCAN_ESC_Status_vRef_Stuetzeingriff, getProfileInt( "ESC_51", "ESC_Status_vRef_Stuetzeingriff", 0, profileFile ) );
    putValue( KCAN_ESP_FDR_uebersteuern, getProfileFloat( "ESC_51", "ESP_FDR_uebersteuern", 0, profileFile ) );
    putValue( KCAN_ESP_FDR_untersteuern, getProfileFloat( "ESC_51", "ESP_FDR_untersteuern", 0, profileFile ) );
    putValue( KCAN_ESP_FZR_uebersteuern, getProfileFloat( "ESC_51", "ESP_FZR_uebersteuern", 0, profileFile ) );
    putValue( KCAN_ESP_FZR_untersteuern, getProfileFloat( "ESC_51", "ESP_FZR_untersteuern", 0, profileFile ) );
    putValue( KCAN_ESP_HL_Bremsmoment, getProfileInt( "ESC_51", "ESP_HL_Bremsmoment", 0, profileFile ) );
    putValue( KCAN_ESP_HL_Radgeschw_02, getProfileFloat( "ESC_51", "ESP_HL_Radgeschw_02", 0, profileFile ) );
    putValue( KCAN_ESP_HR_Bremsmoment, getProfileInt( "ESC_51", "ESP_HR_Bremsmoment", 0, profileFile ) );
    putValue( KCAN_ESP_HR_Radgeschw_02, getProfileFloat( "ESC_51", "ESP_HR_Radgeschw_02", 0, profileFile ) );
    putValue( KCAN_ESP_VL_Bremsmoment, getProfileInt( "ESC_51", "ESP_VL_Bremsmoment", 0, profileFile ) );
    putValue( KCAN_ESP_VL_Radgeschw_02, getProfileFloat( "ESC_51", "ESP_VL_Radgeschw_02", 0, profileFile ) );
    putValue( KCAN_ESP_VR_Bremsmoment, getProfileInt( "ESC_51", "ESP_VR_Bremsmoment", 0, profileFile ) );
    putValue( KCAN_ESP_VR_Radgeschw_02, getProfileFloat( "ESC_51", "ESP_VR_Radgeschw_02", 0, profileFile ) );
    putValue( KCAN_FDR_Allradverteilung_aktiv, getProfileInt( "ESC_51", "FDR_Allradverteilung_aktiv", 0, profileFile ) );
    putValue( KCAN_FDR_Anf_Allradbetrieb, getProfileInt( "ESC_51", "FDR_Anf_Allradbetrieb", 0, profileFile ) );
    putValue( KCAN_TSMomBegrenzung, getProfileInt( "ESC_51", "TSMomBegrenzung", 0, profileFile ) );

}


void loadSettings_ESP_10( char profileFile[] )
{
    putValue( KCAN_ESP_HL_Fahrtrichtung, getProfileInt( "ESP_10", "ESP_HL_Fahrtrichtung", 0, profileFile ) );
    putValue( KCAN_ESP_HR_Fahrtrichtung, getProfileInt( "ESP_10", "ESP_HR_Fahrtrichtung", 0, profileFile ) );
    putValue( KCAN_ESP_QBit_Wegimpuls_HL, getProfileInt( "ESP_10", "ESP_QBit_Wegimpuls_HL", 0, profileFile ) );
    putValue( KCAN_ESP_QBit_Wegimpuls_HR, getProfileInt( "ESP_10", "ESP_QBit_Wegimpuls_HR", 0, profileFile ) );
    putValue( KCAN_ESP_QBit_Wegimpuls_VL, getProfileInt( "ESP_10", "ESP_QBit_Wegimpuls_VL", 0, profileFile ) );
    putValue( KCAN_ESP_QBit_Wegimpuls_VR, getProfileInt( "ESP_10", "ESP_QBit_Wegimpuls_VR", 0, profileFile ) );
    putValue( KCAN_ESP_VL_Fahrtrichtung, getProfileInt( "ESP_10", "ESP_VL_Fahrtrichtung", 0, profileFile ) );
    putValue( KCAN_ESP_VR_Fahrtrichtung, getProfileInt( "ESP_10", "ESP_VR_Fahrtrichtung", 0, profileFile ) );
    putValue( KCAN_ESP_Wegimpuls_HL, getProfileInt( "ESP_10", "ESP_Wegimpuls_HL", 0, profileFile ) );
    putValue( KCAN_ESP_Wegimpuls_HR, getProfileInt( "ESP_10", "ESP_Wegimpuls_HR", 0, profileFile ) );
    putValue( KCAN_ESP_Wegimpuls_VL, getProfileInt( "ESP_10", "ESP_Wegimpuls_VL", 0, profileFile ) );
    putValue( KCAN_ESP_Wegimpuls_VR, getProfileInt( "ESP_10", "ESP_Wegimpuls_VR", 0, profileFile ) );

}


void loadSettings_ESP_20( char profileFile[] )
{
    putValue( KCAN_BR_QBit_Reifenumfang, getProfileInt( "ESP_20", "BR_QBit_Reifenumfang", 0, profileFile ) );
    putValue( KCAN_BR_Reifenumfang, getProfileInt( "ESP_20", "BR_Reifenumfang", 0, profileFile ) );
    putValue( KCAN_BR_Systemart, getProfileInt( "ESP_20", "BR_Systemart", 0, profileFile ) );
    putValue( KCAN_ESP_Charisma_FahrPr, getProfileInt( "ESP_20", "ESP_Charisma_FahrPr", 0, profileFile ) );
    putValue( KCAN_ESP_Charisma_Status, getProfileInt( "ESP_20", "ESP_Charisma_Status", 0, profileFile ) );
    putValue( KCAN_ESP_Dachrelingsensor, getProfileInt( "ESP_20", "ESP_Dachrelingsensor", 0, profileFile ) );
    putValue( KCAN_ESP_SpannungsAnf_02, getProfileInt( "ESP_20", "ESP_SpannungsAnf_02", 0, profileFile ) );
    putValue( KCAN_ESP_Stoppverbot_Anz_01, getProfileInt( "ESP_20", "ESP_Stoppverbot_Anz_01", 0, profileFile ) );
    putValue( KCAN_ESP_Stoppverbot_Anz_02, getProfileInt( "ESP_20", "ESP_Stoppverbot_Anz_02", 0, profileFile ) );
    putValue( KCAN_ESP_Stoppverbot_Anz_03, getProfileInt( "ESP_20", "ESP_Stoppverbot_Anz_03", 0, profileFile ) );
    putValue( KCAN_ESP_Stoppverbot_Anz_04, getProfileInt( "ESP_20", "ESP_Stoppverbot_Anz_04", 0, profileFile ) );
    putValue( KCAN_ESP_Stoppverbot_Anz_05, getProfileInt( "ESP_20", "ESP_Stoppverbot_Anz_05", 0, profileFile ) );
    putValue( KCAN_ESP_Stoppverbot_Anz_06, getProfileInt( "ESP_20", "ESP_Stoppverbot_Anz_06", 0, profileFile ) );
    putValue( KCAN_ESP_Stoppverbot_Anz_07, getProfileInt( "ESP_20", "ESP_Stoppverbot_Anz_07", 0, profileFile ) );
    putValue( KCAN_ESP_Stoppverbot_Anz_08, getProfileInt( "ESP_20", "ESP_Stoppverbot_Anz_08", 0, profileFile ) );
    putValue( KCAN_ESP_Stoppverbot_Anz_Std, getProfileInt( "ESP_20", "ESP_Stoppverbot_Anz_Std", 0, profileFile ) );
    putValue( KCAN_ESP_Wiederstart_Anz_01, getProfileInt( "ESP_20", "ESP_Wiederstart_Anz_01", 0, profileFile ) );
    putValue( KCAN_ESP_Wiederstart_Anz_02, getProfileInt( "ESP_20", "ESP_Wiederstart_Anz_02", 0, profileFile ) );
    putValue( KCAN_ESP_Wiederstart_Anz_03, getProfileInt( "ESP_20", "ESP_Wiederstart_Anz_03", 0, profileFile ) );
    putValue( KCAN_ESP_Wiederstart_Anz_04, getProfileInt( "ESP_20", "ESP_Wiederstart_Anz_04", 0, profileFile ) );
    putValue( KCAN_ESP_Zaehnezahl, getProfileInt( "ESP_20", "ESP_Zaehnezahl", 0, profileFile ) );
    putValue( KCAN_HDC_Charisma_FahrPr, getProfileInt( "ESP_20", "HDC_Charisma_FahrPr", 0, profileFile ) );
    putValue( KCAN_HDC_Charisma_Status, getProfileInt( "ESP_20", "HDC_Charisma_Status", 0, profileFile ) );

}


void loadSettings_ESP_21( char profileFile[] )
{
    putValue( KCAN_ABS_Bremsung_ESP_21, getProfileInt( "ESP_21", "ABS_Bremsung_ESP_21", 0, profileFile ) );
    putValue( KCAN_ASR_Anf, getProfileInt( "ESP_21", "ASR_Anf", 0, profileFile ) );
    putValue( KCAN_ASR_Schalteingriff, getProfileInt( "ESP_21", "ASR_Schalteingriff", 0, profileFile ) );
    putValue( KCAN_ASR_Tastung_passiv, getProfileInt( "ESP_21", "ASR_Tastung_passiv", 0, profileFile ) );
    putValue( KCAN_BR_Eingriffsmoment, getProfileInt( "ESP_21", "BR_Eingriffsmoment", 0, profileFile ) );
    putValue( KCAN_EBV_Eingriff, getProfileInt( "ESP_21", "EBV_Eingriff", 0, profileFile ) );
    putValue( KCAN_EDS_Eingriff, getProfileInt( "ESP_21", "EDS_Eingriff", 0, profileFile ) );
    putValue( KCAN_ESC_Reku_Freigabe, getProfileInt( "ESP_21", "ESC_Reku_Freigabe", 0, profileFile ) );
    putValue( KCAN_ESC_v_Signal_Qualifier_High_Low, getProfileInt( "ESP_21", "ESC_v_Signal_Qualifier_High_Low", 0, profileFile ) );
    putValue( KCAN_ESP_Anhaltevorgang_ACC_aktiv, getProfileInt( "ESP_21", "ESP_Anhaltevorgang_ACC_aktiv", 0, profileFile ) );
    putValue( KCAN_ESP_ASP, getProfileInt( "ESP_21", "ESP_ASP", 0, profileFile ) );
    putValue( KCAN_ESP_AWV3_Brems_aktiv, getProfileInt( "ESP_21", "ESP_AWV3_Brems_aktiv", 0, profileFile ) );
    putValue( KCAN_ESP_Diagnose, getProfileInt( "ESP_21", "ESP_Diagnose", 0, profileFile ) );
    putValue( KCAN_ESP_Eingriff_ESP_21, getProfileInt( "ESP_21", "ESP_Eingriff_ESP_21", 0, profileFile ) );
    putValue( KCAN_ESP_Haltebestaetigung, getProfileInt( "ESP_21", "ESP_Haltebestaetigung", 0, profileFile ) );
    putValue( KCAN_ESP_MKB_Abbruch_Geschw_ESP_21, getProfileInt( "ESP_21", "ESP_MKB_Abbruch_Geschw_ESP_21", 0, profileFile ) );
    putValue( KCAN_ESP_PLA_Bremseingriff, getProfileInt( "ESP_21", "ESP_PLA_Bremseingriff", 0, profileFile ) );
    putValue( KCAN_ESP_QBit_v_Signal, getProfileInt( "ESP_21", "ESP_QBit_v_Signal", 0, profileFile ) );
    putValue( KCAN_ESP_Systemstatus, getProfileInt( "ESP_21", "ESP_Systemstatus", 0, profileFile ) );
    putValue( KCAN_ESP_Tastung_passiv, getProfileInt( "ESP_21", "ESP_Tastung_passiv", 0, profileFile ) );
    putValue( KCAN_ESP_v_Signal, getProfileFloat( "ESP_21", "ESP_v_Signal", 0, profileFile ) );
    putValue( KCAN_ESP_Vorsteuerung, getProfileInt( "ESP_21", "ESP_Vorsteuerung", 0, profileFile ) );
    putValue( KCAN_MSR_Anf, getProfileInt( "ESP_21", "MSR_Anf", 0, profileFile ) );
    putValue( KCAN_OBD_QBit_Schlechtweg, getProfileInt( "ESP_21", "OBD_QBit_Schlechtweg", 0, profileFile ) );
    putValue( KCAN_OBD_Schlechtweg, getProfileInt( "ESP_21", "OBD_Schlechtweg", 0, profileFile ) );

}


void loadSettings_ESP_24( char profileFile[] )
{
    putValue( KCAN_ABS_Lampe, getProfileInt( "ESP_24", "ABS_Lampe", 0, profileFile ) );
    putValue( KCAN_BK_Lampe_02, getProfileInt( "ESP_24", "BK_Lampe_02", 0, profileFile ) );
    putValue( KCAN_ESP_BKV_Warnung, getProfileInt( "ESP_24", "ESP_BKV_Warnung", 0, profileFile ) );
    putValue( KCAN_ESP_Fehlerstatus_Wegimp, getProfileInt( "ESP_24", "ESP_Fehlerstatus_Wegimp", 0, profileFile ) );
    putValue( KCAN_ESP_HDC_FktLampe, getProfileInt( "ESP_24", "ESP_HDC_FktLampe", 0, profileFile ) );
    putValue( KCAN_ESP_HDC_Regelgeschw, getProfileFloat( "ESP_24", "ESP_HDC_Regelgeschw", 0, profileFile ) );
    putValue( KCAN_ESP_Lampe, getProfileInt( "ESP_24", "ESP_Lampe", 0, profileFile ) );
    putValue( KCAN_ESP_m_Raddrehz, getProfileFloat( "ESP_24", "ESP_m_Raddrehz", 0, profileFile ) );
    putValue( KCAN_ESP_Meldungen, getProfileInt( "ESP_24", "ESP_Meldungen", 0, profileFile ) );
    putValue( KCAN_ESP_Off_Lampe, getProfileInt( "ESP_24", "ESP_Off_Lampe", 0, profileFile ) );
    putValue( KCAN_ESP_QBit_Wegimp_VA, getProfileInt( "ESP_24", "ESP_QBit_Wegimp_VA", 0, profileFile ) );
    putValue( KCAN_ESP_Textanzeigen_03, getProfileInt( "ESP_24", "ESP_Textanzeigen_03", 0, profileFile ) );
    putValue( KCAN_ESP_Wegimp_Ueberlauf, getProfileInt( "ESP_24", "ESP_Wegimp_Ueberlauf", 0, profileFile ) );
    putValue( KCAN_ESP_Wegimp_VA, getProfileInt( "ESP_24", "ESP_Wegimp_VA", 0, profileFile ) );
    putValue( KCAN_TC_Lampe, getProfileInt( "ESP_24", "TC_Lampe", 0, profileFile ) );

}


void loadSettings_ESP_30( char profileFile[] )
{
    putValue( KCAN_DBK_Fahrerwarnung, getProfileInt( "ESP_30", "DBK_Fahrerwarnung", 0, profileFile ) );
    putValue( KCAN_EDS_Charisma_FahrPr, getProfileInt( "ESP_30", "EDS_Charisma_FahrPr", 0, profileFile ) );
    putValue( KCAN_EDS_Charisma_Status, getProfileInt( "ESP_30", "EDS_Charisma_Status", 0, profileFile ) );
    putValue( KCAN_ESC_Anf_KL, getProfileFloat( "ESP_30", "ESC_Anf_KL", 0, profileFile ) );
    putValue( KCAN_ESC_Anf_KV, getProfileInt( "ESP_30", "ESC_Anf_KV", 0, profileFile ) );
    putValue( KCAN_ESC_FBA_Meldungen, getProfileInt( "ESP_30", "ESC_FBA_Meldungen", 0, profileFile ) );
    putValue( KCAN_ESC_Lernfreigabe_Abrollumfang, getProfileInt( "ESP_30", "ESC_Lernfreigabe_Abrollumfang", 0, profileFile ) );
    putValue( KCAN_ESC_MBK_Meldungen, getProfileInt( "ESP_30", "ESC_MBK_Meldungen", 0, profileFile ) );
    putValue( KCAN_ESC_Texte_eBKV_Betaetigung, getProfileInt( "ESP_30", "ESC_Texte_eBKV_Betaetigung", 0, profileFile ) );
    putValue( KCAN_HHC_Charisma_FahrPr, getProfileInt( "ESP_30", "HHC_Charisma_FahrPr", 0, profileFile ) );
    putValue( KCAN_HHC_Charisma_Status, getProfileInt( "ESP_30", "HHC_Charisma_Status", 0, profileFile ) );
    putValue( KCAN_HMS_EML_Steig_Exkl, getProfileFloat( "ESP_30", "HMS_EML_Steig_Exkl", 0, profileFile ) );
    putValue( KCAN_RLE_Anzeigen, getProfileInt( "ESP_30", "RLE_Anzeigen", 0, profileFile ) );

}


void loadSettings_FAS_Anzeigen_01( char profileFile[] )
{
    putValue( KCAN_KBI_aktive_Laengsfunktion_02, getProfileInt( "FAS_Anzeigen_01", "KBI_aktive_Laengsfunktion_02", 0, profileFile ) );
    putValue( KCAN_KBI_Anzeigefehler_LDW, getProfileInt( "FAS_Anzeigen_01", "KBI_Anzeigefehler_LDW", 0, profileFile ) );
    putValue( KCAN_KBI_Anzeigestatus_ACC, getProfileInt( "FAS_Anzeigen_01", "KBI_Anzeigestatus_ACC", 0, profileFile ) );
    putValue( KCAN_KBI_Anzeigestatus_GRA, getProfileInt( "FAS_Anzeigen_01", "KBI_Anzeigestatus_GRA", 0, profileFile ) );
    putValue( KCAN_KBI_Anzeigestatus_LIM, getProfileInt( "FAS_Anzeigen_01", "KBI_Anzeigestatus_LIM", 0, profileFile ) );
    putValue( KCAN_KBI_Fehler_Anzeige_ACC, getProfileInt( "FAS_Anzeigen_01", "KBI_Fehler_Anzeige_ACC", 0, profileFile ) );
    putValue( KCAN_KBI_Konsistenz_ACC, getProfileInt( "FAS_Anzeigen_01", "KBI_Konsistenz_ACC", 0, profileFile ) );

}


void loadSettings_FoD_01( char profileFile[] )
{
    putValue( KCAN_FoD_Anz_Funktionsabschaltung, getProfileInt( "FoD_01", "FoD_Anz_Funktionsabschaltung", 0, profileFile ) );
    putValue( KCAN_FoD_Transmission_Info, getProfileInt( "FoD_01", "FoD_Transmission_Info", 0, profileFile ) );
    putValue( KCAN_GRA_FoD_Status, getProfileInt( "FoD_01", "GRA_FoD_Status", 0, profileFile ) );

}


void loadSettings_FoD_Kombi_Req( char profileFile[] )
{

}


void loadSettings_FoD_Kombi_Resp( char profileFile[] )
{

}


void loadSettings_FoD_ZR_Req( char profileFile[] )
{

}


void loadSettings_FoD_ZR_Resp( char profileFile[] )
{

}


void loadSettings_Gateway_71( char profileFile[] )
{
    putValue( KCAN_ABS_Bremsung_Gateway_71, getProfileInt( "Gateway_71", "ABS_Bremsung_Gateway_71", 0, profileFile ) );
    putValue( KCAN_ECD_Bremslicht_Gateway_71, getProfileInt( "Gateway_71", "ECD_Bremslicht_Gateway_71", 0, profileFile ) );
    putValue( KCAN_EPB_01_alt, getProfileInt( "Gateway_71", "EPB_01_alt", 0, profileFile ) );
    putValue( KCAN_EPB_Pedalweg_Kuppl_Gateway_71, getProfileFloat( "Gateway_71", "EPB_Pedalweg_Kuppl_Gateway_71", 0, profileFile ) );
    putValue( KCAN_EPB_QBit_Pedalweg_Kuppl_Gateway_71, getProfileInt( "Gateway_71", "EPB_QBit_Pedalweg_Kuppl_Gateway_71", 0, profileFile ) );
    putValue( KCAN_EPB_Status_Gateway_71, getProfileInt( "Gateway_71", "EPB_Status_Gateway_71", 0, profileFile ) );
    putValue( KCAN_ESP_05_alt, getProfileInt( "Gateway_71", "ESP_05_alt", 0, profileFile ) );
    putValue( KCAN_ESP_21_alt, getProfileInt( "Gateway_71", "ESP_21_alt", 0, profileFile ) );
    putValue( KCAN_ESP_Eingriff_Gateway_71, getProfileInt( "Gateway_71", "ESP_Eingriff_Gateway_71", 0, profileFile ) );
    putValue( KCAN_ESP_HDC_Standby_Gateway_71, getProfileInt( "Gateway_71", "ESP_HDC_Standby_Gateway_71", 0, profileFile ) );
    putValue( KCAN_ESP_MKB_Abbruch_Geschw_Gateway_71, getProfileInt( "Gateway_71", "ESP_MKB_Abbruch_Geschw_Gateway_71", 0, profileFile ) );
    putValue( KCAN_ESP_QBit_v_Signal_Gateway_71, getProfileInt( "Gateway_71", "ESP_QBit_v_Signal_Gateway_71", 0, profileFile ) );
    putValue( KCAN_ESP_v_Signal_Gateway_71, getProfileFloat( "Gateway_71", "ESP_v_Signal_Gateway_71", 0, profileFile ) );
    putValue( KCAN_Kamera_FSH_aktiv, getProfileInt( "Gateway_71", "Kamera_FSH_aktiv", 0, profileFile ) );
    putValue( KCAN_Kamera_Status_alt, getProfileInt( "Gateway_71", "Kamera_Status_alt", 0, profileFile ) );
    putValue( KCAN_LWI_01_alt, getProfileInt( "Gateway_71", "LWI_01_alt", 0, profileFile ) );
    putValue( KCAN_LWI_Lenkradwinkel_Gateway_71, getProfileFloat( "Gateway_71", "LWI_Lenkradwinkel_Gateway_71", 0, profileFile ) );
    putValue( KCAN_LWI_QBit_Lenkradwinkel_Gateway_71, getProfileInt( "Gateway_71", "LWI_QBit_Lenkradwinkel_Gateway_71", 0, profileFile ) );
    putValue( KCAN_LWI_Sensorstatus_Gateway_71, getProfileInt( "Gateway_71", "LWI_Sensorstatus_Gateway_71", 0, profileFile ) );
    putValue( KCAN_LWI_VZ_Lenkradwinkel_Gateway_71, getProfileInt( "Gateway_71", "LWI_VZ_Lenkradwinkel_Gateway_71", 0, profileFile ) );
    putValue( KCAN_Parkhilfe_01_alt, getProfileInt( "Gateway_71", "Parkhilfe_01_alt", 0, profileFile ) );
    putValue( KCAN_PH_Anf_Audioabsenkung_Gateway_71, getProfileInt( "Gateway_71", "PH_Anf_Audioabsenkung_Gateway_71", 0, profileFile ) );
    putValue( KCAN_PH_Systemzustand_Gateway_71, getProfileInt( "Gateway_71", "PH_Systemzustand_Gateway_71", 0, profileFile ) );
    putValue( KCAN_PH_Taster_Gateway_71, getProfileInt( "Gateway_71", "PH_Taster_Gateway_71", 0, profileFile ) );
    putValue( KCAN_PLA_Anf_Aufschaltung_RVC_Gateway_71, getProfileInt( "Gateway_71", "PLA_Anf_Aufschaltung_RVC_Gateway_71", 0, profileFile ) );

}


void loadSettings_Gateway_73( char profileFile[] )
{
    putValue( KCAN_ACC_18_alt, getProfileInt( "Gateway_73", "ACC_18_alt", 0, profileFile ) );
    putValue( KCAN_ACC_Status_ACC, getProfileInt( "Gateway_73", "ACC_Status_ACC", 0, profileFile ) );
    putValue( KCAN_EPB_Status_02_Gateway_73, getProfileInt( "Gateway_73", "EPB_Status_02_Gateway_73", 0, profileFile ) );
    putValue( KCAN_ESP_07_alt, getProfileInt( "Gateway_73", "ESP_07_alt", 0, profileFile ) );
    putValue( KCAN_ESP_50_alt, getProfileInt( "Gateway_73", "ESP_50_alt", 0, profileFile ) );
    putValue( KCAN_ESP_Rollenmodus_Deaktivieren, getProfileInt( "Gateway_73", "ESP_Rollenmodus_Deaktivieren", 0, profileFile ) );
    putValue( KCAN_ESP_Status_Bremsentemp_02_Gateway_73, getProfileInt( "Gateway_73", "ESP_Status_Bremsentemp_02_Gateway_73", 0, profileFile ) );
    putValue( KCAN_GE_Fahrstufe, getProfileInt( "Gateway_73", "GE_Fahrstufe", 0, profileFile ) );
    putValue( KCAN_GE_Freilauf_Status, getProfileInt( "Gateway_73", "GE_Freilauf_Status", 0, profileFile ) );
    putValue( KCAN_GE_Notlauf, getProfileInt( "Gateway_73", "GE_Notlauf", 0, profileFile ) );
    putValue( KCAN_GE_Sperr_Info_WFS, getProfileInt( "Gateway_73", "GE_Sperr_Info_WFS", 0, profileFile ) );
    putValue( KCAN_GE_Ursache_Fahrstufe_N, getProfileInt( "Gateway_73", "GE_Ursache_Fahrstufe_N", 0, profileFile ) );
    putValue( KCAN_Getriebe_11_alt, getProfileInt( "Gateway_73", "Getriebe_11_alt", 0, profileFile ) );
    putValue( KCAN_Getriebe_13_alt, getProfileInt( "Gateway_73", "Getriebe_13_alt", 0, profileFile ) );
    putValue( KCAN_Getriebe_14_alt, getProfileInt( "Gateway_73", "Getriebe_14_alt", 0, profileFile ) );
    putValue( KCAN_Getriebe_17_alt, getProfileInt( "Gateway_73", "Getriebe_17_alt", 0, profileFile ) );
    putValue( KCAN_MKE_Stufe, getProfileInt( "Gateway_73", "MKE_Stufe", 0, profileFile ) );
    putValue( KCAN_MKE_Texte, getProfileInt( "Gateway_73", "MKE_Texte", 0, profileFile ) );
    putValue( KCAN_MO_Drehzahl_01, getProfileFloat( "Gateway_73", "MO_Drehzahl_01", 0, profileFile ) );
    putValue( KCAN_MO_QBit_Drehzahl_01, getProfileInt( "Gateway_73", "MO_QBit_Drehzahl_01", 0, profileFile ) );
    putValue( KCAN_Motor_12_alt, getProfileInt( "Gateway_73", "Motor_12_alt", 0, profileFile ) );
    putValue( KCAN_TSK_06_alt, getProfileInt( "Gateway_73", "TSK_06_alt", 0, profileFile ) );
    putValue( KCAN_TSK_Hauptschalter_GRA_ACC_Gateway_73, getProfileInt( "Gateway_73", "TSK_Hauptschalter_GRA_ACC_Gateway_73", 0, profileFile ) );
    putValue( KCAN_TSK_Limiter_ausgewaehlt_Gateway_73, getProfileInt( "Gateway_73", "TSK_Limiter_ausgewaehlt_Gateway_73", 0, profileFile ) );

}


void loadSettings_Getriebe_16( char profileFile[] )
{
    putValue( KCAN_GE_Ausleuchtung_blinkend, getProfileInt( "Getriebe_16", "GE_Ausleuchtung_blinkend", 0, profileFile ) );
    putValue( KCAN_GE_Ausleuchtung_Fahrstufe, getProfileInt( "Getriebe_16", "GE_Ausleuchtung_Fahrstufe", 0, profileFile ) );
    putValue( KCAN_GE_N_Haltephase, getProfileInt( "Getriebe_16", "GE_N_Haltephase", 0, profileFile ) );
    putValue( KCAN_GE_Soll_Haltemagnet, getProfileInt( "Getriebe_16", "GE_Soll_Haltemagnet", 0, profileFile ) );
    putValue( KCAN_GE_Test_Freigabe, getProfileInt( "Getriebe_16", "GE_Test_Freigabe", 0, profileFile ) );
    putValue( KCAN_GE_Testparameter_1, getProfileInt( "Getriebe_16", "GE_Testparameter_1", 0, profileFile ) );
    putValue( KCAN_GE_Testparameter_2, getProfileInt( "Getriebe_16", "GE_Testparameter_2", 0, profileFile ) );
    putValue( KCAN_GE_WH_Abschalten, getProfileInt( "Getriebe_16", "GE_WH_Abschalten", 0, profileFile ) );
    putValue( KCAN_GE_WH_Mute, getProfileInt( "Getriebe_16", "GE_WH_Mute", 0, profileFile ) );
    putValue( KCAN_GE_WH_Shiftlock, getProfileInt( "Getriebe_16", "GE_WH_Shiftlock", 0, profileFile ) );

}


void loadSettings_Heckradar_01( char profileFile[] )
{
    putValue( KCAN_ASW_Kombitexte, getProfileInt( "Heckradar_01", "ASW_Kombitexte", 0, profileFile ) );
    putValue( KCAN_ASW_Modus, getProfileInt( "Heckradar_01", "ASW_Modus", 0, profileFile ) );
    putValue( KCAN_ASW_Status, getProfileInt( "Heckradar_01", "ASW_Status", 0, profileFile ) );
    putValue( KCAN_ASW_Ton_Richtung_HL, getProfileInt( "Heckradar_01", "ASW_Ton_Richtung_HL", 0, profileFile ) );
    putValue( KCAN_ASW_Ton_Richtung_HR, getProfileInt( "Heckradar_01", "ASW_Ton_Richtung_HR", 0, profileFile ) );
    putValue( KCAN_ASW_Ton_Richtung_VL, getProfileInt( "Heckradar_01", "ASW_Ton_Richtung_VL", 0, profileFile ) );
    putValue( KCAN_ASW_Ton_Richtung_VR, getProfileInt( "Heckradar_01", "ASW_Ton_Richtung_VR", 0, profileFile ) );
    putValue( KCAN_ASW_Warnung_BFS, getProfileInt( "Heckradar_01", "ASW_Warnung_BFS", 0, profileFile ) );
    putValue( KCAN_ASW_Warnung_FS, getProfileInt( "Heckradar_01", "ASW_Warnung_FS", 0, profileFile ) );
    putValue( KCAN_Heckradar_Kombitexte, getProfileInt( "Heckradar_01", "Heckradar_Kombitexte", 0, profileFile ) );
    putValue( KCAN_HRE_Anzeigetexte, getProfileInt( "Heckradar_01", "HRE_Anzeigetexte", 0, profileFile ) );
    putValue( KCAN_RCTA_Kombitexte, getProfileInt( "Heckradar_01", "RCTA_Kombitexte", 0, profileFile ) );
    putValue( KCAN_SWA_Anzeigen, getProfileInt( "Heckradar_01", "SWA_Anzeigen", 0, profileFile ) );
    putValue( KCAN_SWA_Blindheit_erkannt, getProfileInt( "Heckradar_01", "SWA_Blindheit_erkannt", 0, profileFile ) );
    putValue( KCAN_SWA_Blindheitsverdacht, getProfileInt( "Heckradar_01", "SWA_Blindheitsverdacht", 0, profileFile ) );
    putValue( KCAN_SWA_Brightness_Mode_FPM, getProfileInt( "Heckradar_01", "SWA_Brightness_Mode_FPM", 0, profileFile ) );
    putValue( KCAN_SWA_FT_RueckLED, getProfileInt( "Heckradar_01", "SWA_FT_RueckLED", 0, profileFile ) );
    putValue( KCAN_SWA_Gischtzaehler, getProfileInt( "Heckradar_01", "SWA_Gischtzaehler", 0, profileFile ) );
    putValue( KCAN_SWA_LED_Hell_BFS, getProfileInt( "Heckradar_01", "SWA_LED_Hell_BFS", 0, profileFile ) );
    putValue( KCAN_SWA_LED_Hell_FS, getProfileInt( "Heckradar_01", "SWA_LED_Hell_FS", 0, profileFile ) );
    putValue( KCAN_SWA_LED_Modus_BFS, getProfileInt( "Heckradar_01", "SWA_LED_Modus_BFS", 0, profileFile ) );
    putValue( KCAN_SWA_LED_Modus_FS, getProfileInt( "Heckradar_01", "SWA_LED_Modus_FS", 0, profileFile ) );
    putValue( KCAN_SWA_Modus, getProfileInt( "Heckradar_01", "SWA_Modus", 0, profileFile ) );
    putValue( KCAN_SWA_rel_Fehler, getProfileInt( "Heckradar_01", "SWA_rel_Fehler", 0, profileFile ) );
    putValue( KCAN_SWA_rel_Nichtverf, getProfileInt( "Heckradar_01", "SWA_rel_Nichtverf", 0, profileFile ) );
    putValue( KCAN_SWA_Sta_aktiv, getProfileInt( "Heckradar_01", "SWA_Sta_aktiv", 0, profileFile ) );
    putValue( KCAN_SWA_Sta_passiv, getProfileInt( "Heckradar_01", "SWA_Sta_passiv", 0, profileFile ) );
    putValue( KCAN_SWA_Standziele_li, getProfileInt( "Heckradar_01", "SWA_Standziele_li", 0, profileFile ) );
    putValue( KCAN_SWA_Standziele_re, getProfileInt( "Heckradar_01", "SWA_Standziele_re", 0, profileFile ) );
    putValue( KCAN_SWA_Status, getProfileInt( "Heckradar_01", "SWA_Status", 0, profileFile ) );

}


void loadSettings_HID_DispKBI_FS_ZR_Req_FD( char profileFile[] )
{

}


void loadSettings_HID_DispKBI_FS_ZR_Resp_FD( char profileFile[] )
{

}


void loadSettings_HID_HUD_ZR_Req_FD( char profileFile[] )
{

}


void loadSettings_HID_HUD_ZR_Resp_FD( char profileFile[] )
{

}


void loadSettings_HID_ZR_DispKBI_FS_Req_FD( char profileFile[] )
{

}


void loadSettings_HID_ZR_DispKBI_FS_Resp_FD( char profileFile[] )
{

}


void loadSettings_HID_ZR_HUD_Req_FD( char profileFile[] )
{

}


void loadSettings_HID_ZR_HUD_Resp_FD( char profileFile[] )
{

}


void loadSettings_HUD_ARC_Req_FD( char profileFile[] )
{

}


void loadSettings_HUD_ARC_Resp_FD( char profileFile[] )
{

}


void loadSettings_HVK_01( char profileFile[] )
{
    putValue( KCAN_HV_Bordnetz_aktiv, getProfileInt( "HVK_01", "HV_Bordnetz_aktiv", 0, profileFile ) );
    putValue( KCAN_HV_Bordnetz_Fehler, getProfileInt( "HVK_01", "HV_Bordnetz_Fehler", 0, profileFile ) );
    putValue( KCAN_HVK_AktiveEntladung_Anf, getProfileInt( "HVK_01", "HVK_AktiveEntladung_Anf", 0, profileFile ) );
    putValue( KCAN_HVK_BMS_Sollmodus, getProfileInt( "HVK_01", "HVK_BMS_Sollmodus", 0, profileFile ) );
    putValue( KCAN_HVK_DCDC_Sollmodus, getProfileInt( "HVK_01", "HVK_DCDC_Sollmodus", 0, profileFile ) );
    putValue( KCAN_HVK_EKK_Sollmodus, getProfileInt( "HVK_01", "HVK_EKK_Sollmodus", 0, profileFile ) );
    putValue( KCAN_HVK_Gesamtst_Spgfreiheit, getProfileInt( "HVK_01", "HVK_Gesamtst_Spgfreiheit", 0, profileFile ) );
    putValue( KCAN_HVK_HV_Netz_Warnungen, getProfileInt( "HVK_01", "HVK_HV_Netz_Warnungen", 0, profileFile ) );
    putValue( KCAN_HVK_HVEM_Freigabe, getProfileInt( "HVK_01", "HVK_HVEM_Freigabe", 0, profileFile ) );
    putValue( KCAN_HVK_HVLM_Sollmodus, getProfileInt( "HVK_01", "HVK_HVLM_Sollmodus", 0, profileFile ) );
    putValue( KCAN_HVK_HVPTC_Sollmodus, getProfileInt( "HVK_01", "HVK_HVPTC_Sollmodus", 0, profileFile ) );
    putValue( KCAN_HVK_Iso_Messung_Start, getProfileInt( "HVK_01", "HVK_Iso_Messung_Start", 0, profileFile ) );
    putValue( KCAN_HVK_Istmodus_Anf, getProfileInt( "HVK_01", "HVK_Istmodus_Anf", 0, profileFile ) );
    putValue( KCAN_HVK_Ladebereit, getProfileInt( "HVK_01", "HVK_Ladebereit", 0, profileFile ) );
    putValue( KCAN_HVK_Notabschaltung_Anf, getProfileInt( "HVK_01", "HVK_Notabschaltung_Anf", 0, profileFile ) );
    putValue( KCAN_HVK_PPulsFreigabe, getProfileInt( "HVK_01", "HVK_PPulsFreigabe", 0, profileFile ) );
    putValue( KCAN_HVK_TN1_Sollmodus, getProfileInt( "HVK_01", "HVK_TN1_Sollmodus", 0, profileFile ) );
    putValue( KCAN_HVK_Vorladung_aktiv, getProfileInt( "HVK_01", "HVK_Vorladung_aktiv", 0, profileFile ) );

}


void loadSettings_IPA_02( char profileFile[] )
{
    putValue( KCAN_IPA_Anf_Meldungen, getProfileInt( "IPA_02", "IPA_Anf_Meldungen", 0, profileFile ) );
    putValue( KCAN_Parken_aktives_System_02, getProfileInt( "IPA_02", "Parken_aktives_System_02", 0, profileFile ) );
    putValue( KCAN_Parken_Aktivierungslicht_Anf, getProfileInt( "IPA_02", "Parken_Aktivierungslicht_Anf", 0, profileFile ) );
    putValue( KCAN_Parken_Bestaetigungsblinken_Anf, getProfileInt( "IPA_02", "Parken_Bestaetigungsblinken_Anf", 0, profileFile ) );
    putValue( KCAN_Parken_Fahrbereitschaftlicht_Anf, getProfileInt( "IPA_02", "Parken_Fahrbereitschaftlicht_Anf", 0, profileFile ) );
    putValue( KCAN_Parken_Fahrerhinweise_Anf, getProfileInt( "IPA_02", "Parken_Fahrerhinweise_Anf", 0, profileFile ) );
    putValue( KCAN_Parken_Fahrtrichtungslicht_Anf, getProfileInt( "IPA_02", "Parken_Fahrtrichtungslicht_Anf", 0, profileFile ) );
    putValue( KCAN_Parken_FFB_LED_Anf, getProfileInt( "IPA_02", "Parken_FFB_LED_Anf", 0, profileFile ) );
    putValue( KCAN_Parken_Lichtnachlauf_Anf, getProfileInt( "IPA_02", "Parken_Lichtnachlauf_Anf", 0, profileFile ) );
    putValue( KCAN_Parken_Lichtsteuerung_Anf, getProfileInt( "IPA_02", "Parken_Lichtsteuerung_Anf", 0, profileFile ) );
    putValue( KCAN_Parken_Schluesselsuche_Anf, getProfileInt( "IPA_02", "Parken_Schluesselsuche_Anf", 0, profileFile ) );
    putValue( KCAN_Parken_Seitenspiegel_Anf, getProfileInt( "IPA_02", "Parken_Seitenspiegel_Anf", 0, profileFile ) );
    putValue( KCAN_Parken_Wegfahrsperren_Anf, getProfileInt( "IPA_02", "Parken_Wegfahrsperren_Anf", 0, profileFile ) );
    putValue( KCAN_Parken_ZR_Sondermodus_Anf, getProfileInt( "IPA_02", "Parken_ZR_Sondermodus_Anf", 0, profileFile ) );
    putValue( KCAN_Parken_ZV_Schliessen, getProfileInt( "IPA_02", "Parken_ZV_Schliessen", 0, profileFile ) );

}


void loadSettings_ISO_Funktionaler_Req_All( char profileFile[] )
{

}


void loadSettings_ISO_HUD_Req( char profileFile[] )
{

}


void loadSettings_ISO_HUD_Resp( char profileFile[] )
{

}


void loadSettings_ISO_Kombi_Req( char profileFile[] )
{

}


void loadSettings_ISO_Kombi_Resp( char profileFile[] )
{

}


void loadSettings_ISO_NFCIApp_NFCIServ_Req( char profileFile[] )
{

}


void loadSettings_ISO_NFCIApp_NFCIServ_Resp( char profileFile[] )
{

}


void loadSettings_ISO_NFCIServ_NFCIApp_Req( char profileFile[] )
{

}


void loadSettings_ISO_NFCIServ_NFCIApp_Resp( char profileFile[] )
{

}


void loadSettings_ISOx_DispKBI_FS_Req( char profileFile[] )
{

}


void loadSettings_ISOx_DispKBI_FS_Req_FD( char profileFile[] )
{

}


void loadSettings_ISOx_DispKBI_FS_Resp( char profileFile[] )
{

}


void loadSettings_ISOx_DispKBI_FS_Resp_FD( char profileFile[] )
{

}


void loadSettings_ISOx_Funkt_Req_All_FD( char profileFile[] )
{

}


void loadSettings_ISOx_HUD_Req_FD( char profileFile[] )
{

}


void loadSettings_ISOx_HUD_Resp_FD( char profileFile[] )
{

}


void loadSettings_ISOx_Kombi_Req_FD( char profileFile[] )
{

}


void loadSettings_ISOx_Kombi_Resp_FD( char profileFile[] )
{

}


void loadSettings_ISOx_SmLi_01_Req( char profileFile[] )
{

}


void loadSettings_ISOx_SmLi_01_Req_FD( char profileFile[] )
{

}


void loadSettings_ISOx_SmLi_01_Resp( char profileFile[] )
{

}


void loadSettings_ISOx_SmLi_01_Resp_FD( char profileFile[] )
{

}


void loadSettings_ISOx_WLC1_Req( char profileFile[] )
{

}


void loadSettings_ISOx_WLC1_Resp( char profileFile[] )
{

}


void loadSettings_Kessy_04( char profileFile[] )
{
    putValue( KCAN_KY_Aktive_LFScans, getProfileInt( "Kessy_04", "KY_Aktive_LFScans", 0, profileFile ) );
    putValue( KCAN_KY_AnzKoord_Info, getProfileInt( "Kessy_04", "KY_AnzKoord_Info", 0, profileFile ) );
    putValue( KCAN_KY_EasyClose_Abbruch, getProfileInt( "Kessy_04", "KY_EasyClose_Abbruch", 0, profileFile ) );
    putValue( KCAN_KY_EasyClose_Status, getProfileInt( "Kessy_04", "KY_EasyClose_Status", 0, profileFile ) );
    putValue( KCAN_KY_Fzg_Verlassen_erkannt, getProfileInt( "Kessy_04", "KY_Fzg_Verlassen_erkannt", 0, profileFile ) );
    putValue( KCAN_KY_Fzg_Zugang_erkannt, getProfileInt( "Kessy_04", "KY_Fzg_Zugang_erkannt", 0, profileFile ) );
    putValue( KCAN_KY_Gestik_HD, getProfileInt( "Kessy_04", "KY_Gestik_HD", 0, profileFile ) );
    putValue( KCAN_KY_Gong_600, getProfileInt( "Kessy_04", "KY_Gong_600", 0, profileFile ) );
    putValue( KCAN_KY_HD_Auffahrt, getProfileInt( "Kessy_04", "KY_HD_Auffahrt", 0, profileFile ) );
    putValue( KCAN_KY_HD_Zufahrt, getProfileInt( "Kessy_04", "KY_HD_Zufahrt", 0, profileFile ) );
    putValue( KCAN_KY_ID_Geber1_im_Fzg, getProfileInt( "Kessy_04", "KY_ID_Geber1_im_Fzg", 0, profileFile ) );
    putValue( KCAN_KY_ID_Geber2_im_Fzg, getProfileInt( "Kessy_04", "KY_ID_Geber2_im_Fzg", 0, profileFile ) );
    putValue( KCAN_KY_ID_Geber3_im_Fzg, getProfileInt( "Kessy_04", "KY_ID_Geber3_im_Fzg", 0, profileFile ) );
    putValue( KCAN_KY_ID_Geber4_im_Fzg, getProfileInt( "Kessy_04", "KY_ID_Geber4_im_Fzg", 0, profileFile ) );
    putValue( KCAN_KY_ID_Geber_Suche, getProfileInt( "Kessy_04", "KY_ID_Geber_Suche", 0, profileFile ) );
    putValue( KCAN_KY_LF_Aktiv, getProfileInt( "Kessy_04", "KY_LF_Aktiv", 0, profileFile ) );
    putValue( KCAN_KY_Meldungen, getProfileInt( "Kessy_04", "KY_Meldungen", 0, profileFile ) );
    putValue( KCAN_KY_Passiv_Autolock, getProfileInt( "Kessy_04", "KY_Passiv_Autolock", 0, profileFile ) );
    putValue( KCAN_KY_Passiv_Autolock_Akt, getProfileInt( "Kessy_04", "KY_Passiv_Autolock_Akt", 0, profileFile ) );
    putValue( KCAN_KY_Passiv_Autolock_Menue, getProfileInt( "Kessy_04", "KY_Passiv_Autolock_Menue", 0, profileFile ) );
    putValue( KCAN_KY_Passiv_Autounlock, getProfileInt( "Kessy_04", "KY_Passiv_Autounlock", 0, profileFile ) );
    putValue( KCAN_KY_Schluesselposition_1, getProfileInt( "Kessy_04", "KY_Schluesselposition_1", 0, profileFile ) );
    putValue( KCAN_KY_Schluesselposition_2, getProfileInt( "Kessy_04", "KY_Schluesselposition_2", 0, profileFile ) );
    putValue( KCAN_KY_Schluesselposition_3, getProfileInt( "Kessy_04", "KY_Schluesselposition_3", 0, profileFile ) );
    putValue( KCAN_KY_Schluesselposition_4, getProfileInt( "Kessy_04", "KY_Schluesselposition_4", 0, profileFile ) );
    putValue( KCAN_KY_Schluesselposition_5, getProfileInt( "Kessy_04", "KY_Schluesselposition_5", 0, profileFile ) );
    putValue( KCAN_KY_Schluesselposition_6, getProfileInt( "Kessy_04", "KY_Schluesselposition_6", 0, profileFile ) );
    putValue( KCAN_KY_Schluesselposition_7, getProfileInt( "Kessy_04", "KY_Schluesselposition_7", 0, profileFile ) );
    putValue( KCAN_KY_Schluesselposition_8, getProfileInt( "Kessy_04", "KY_Schluesselposition_8", 0, profileFile ) );
    putValue( KCAN_KY_Startknopf_Bel, getProfileInt( "Kessy_04", "KY_Startknopf_Bel", 0, profileFile ) );
    putValue( KCAN_KY_StartStopp_Info, getProfileInt( "Kessy_04", "KY_StartStopp_Info", 0, profileFile ) );

}


void loadSettings_Klemmen_Status_01( char profileFile[] )
{
    putValue( KCAN_BCM_Ausparken_Betrieb, getProfileInt( "Klemmen_Status_01", "BCM_Ausparken_Betrieb", 0, profileFile ) );
    putValue( KCAN_KST_Fahrerhinweis_1, getProfileInt( "Klemmen_Status_01", "KST_Fahrerhinweis_1", 0, profileFile ) );
    putValue( KCAN_KST_Fahrerhinweis_2, getProfileInt( "Klemmen_Status_01", "KST_Fahrerhinweis_2", 0, profileFile ) );
    putValue( KCAN_KST_Fahrerhinweis_4, getProfileInt( "Klemmen_Status_01", "KST_Fahrerhinweis_4", 0, profileFile ) );
    putValue( KCAN_KST_Fahrerhinweis_5, getProfileInt( "Klemmen_Status_01", "KST_Fahrerhinweis_5", 0, profileFile ) );
    putValue( KCAN_KST_Fahrerhinweis_6, getProfileInt( "Klemmen_Status_01", "KST_Fahrerhinweis_6", 0, profileFile ) );
    putValue( KCAN_KST_Warn_P1_ZST_def, getProfileInt( "Klemmen_Status_01", "KST_Warn_P1_ZST_def", 0, profileFile ) );
    putValue( KCAN_KST_Warn_P2_ZST_def, getProfileInt( "Klemmen_Status_01", "KST_Warn_P2_ZST_def", 0, profileFile ) );
    putValue( KCAN_RSt_Fahrerhinweise, getProfileInt( "Klemmen_Status_01", "RSt_Fahrerhinweise", 0, profileFile ) );
    putValue( KCAN_ZAS_Kl_15, getProfileInt( "Klemmen_Status_01", "ZAS_Kl_15", 0, profileFile ) );
    putValue( KCAN_ZAS_Kl_50_Startanforderung, getProfileInt( "Klemmen_Status_01", "ZAS_Kl_50_Startanforderung", 0, profileFile ) );
    putValue( KCAN_ZAS_Kl_Infotainment, getProfileInt( "Klemmen_Status_01", "ZAS_Kl_Infotainment", 0, profileFile ) );
    putValue( KCAN_ZAS_Kl_S, getProfileInt( "Klemmen_Status_01", "ZAS_Kl_S", 0, profileFile ) );
    putValue( KCAN_ZAS_Kl_X, getProfileInt( "Klemmen_Status_01", "ZAS_Kl_X", 0, profileFile ) );

}


void loadSettings_Klemmen_Status_02( char profileFile[] )
{
    putValue( KCAN_KST_ComfortReadyStatus, getProfileInt( "Klemmen_Status_02", "KST_ComfortReadyStatus", 0, profileFile ) );
    putValue( KCAN_KST_Sonderzustand_Anforderung, getProfileInt( "Klemmen_Status_02", "KST_Sonderzustand_Anforderung", 0, profileFile ) );
    putValue( KCAN_KST_Sonderzustand_Status, getProfileInt( "Klemmen_Status_02", "KST_Sonderzustand_Status", 0, profileFile ) );
    putValue( KCAN_KST_WFS_Fahrfreigabe_Anforderung, getProfileInt( "Klemmen_Status_02", "KST_WFS_Fahrfreigabe_Anforderung", 0, profileFile ) );

}


void loadSettings_Klemmen_Steuerung_01( char profileFile[] )
{
    putValue( KCAN_KST_Anf_Klemme_15, getProfileInt( "Klemmen_Steuerung_01", "KST_Anf_Klemme_15", 0, profileFile ) );
    putValue( KCAN_KST_Anf_Klemme_50, getProfileInt( "Klemmen_Steuerung_01", "KST_Anf_Klemme_50", 0, profileFile ) );
    putValue( KCAN_KST_Anf_Klemme_S, getProfileInt( "Klemmen_Steuerung_01", "KST_Anf_Klemme_S", 0, profileFile ) );
    putValue( KCAN_KST_Anf_Klemmenfreigabe_ELV, getProfileInt( "Klemmen_Steuerung_01", "KST_Anf_Klemmenfreigabe_ELV", 0, profileFile ) );
    putValue( KCAN_KST_Anf_Klemmenfreigabe_WFS, getProfileInt( "Klemmen_Steuerung_01", "KST_Anf_Klemmenfreigabe_WFS", 0, profileFile ) );
    putValue( KCAN_KST_Anf_ZV_Verriegelung_Klemmen_Steuerung_01, getProfileInt( "Klemmen_Steuerung_01", "KST_Anf_ZV_Verriegelung_Klemmen_Steuerung_01", 0, profileFile ) );
    putValue( KCAN_KST_aut_Abschaltung_Zuendung_Klemmen_Steuerung_01, getProfileInt( "Klemmen_Steuerung_01", "KST_aut_Abschaltung_Zuendung_Klemmen_Steuerung_01", 0, profileFile ) );
    putValue( KCAN_KST_Fahrer_Info_Text, getProfileInt( "Klemmen_Steuerung_01", "KST_Fahrer_Info_Text", 0, profileFile ) );
    putValue( KCAN_KST_Txt_Komfortabschaltung_Klemmen_Steuerung_01, getProfileInt( "Klemmen_Steuerung_01", "KST_Txt_Komfortabschaltung_Klemmen_Steuerung_01", 0, profileFile ) );
    putValue( KCAN_KST_Txt_P_Gang, getProfileInt( "Klemmen_Steuerung_01", "KST_Txt_P_Gang", 0, profileFile ) );
    putValue( KCAN_KST_Txt_Panikabschaltung, getProfileInt( "Klemmen_Steuerung_01", "KST_Txt_Panikabschaltung", 0, profileFile ) );
    putValue( KCAN_KST_Txt_Werkstatt, getProfileInt( "Klemmen_Steuerung_01", "KST_Txt_Werkstatt", 0, profileFile ) );
    putValue( KCAN_KST_Unterdr_Zuendungsmeldung_Klemmen_Steuerung_01, getProfileInt( "Klemmen_Steuerung_01", "KST_Unterdr_Zuendungsmeldung_Klemmen_Steuerung_01", 0, profileFile ) );
    putValue( KCAN_KST_ZAT_betaetigt, getProfileInt( "Klemmen_Steuerung_01", "KST_ZAT_betaetigt", 0, profileFile ) );
    putValue( KCAN_KST_Zuendungswarnung, getProfileInt( "Klemmen_Steuerung_01", "KST_Zuendungswarnung", 0, profileFile ) );
    putValue( KCAN_Relais_VoKo_angesteuert, getProfileInt( "Klemmen_Steuerung_01", "Relais_VoKo_angesteuert", 0, profileFile ) );
    putValue( KCAN_RSt_Anforderung_HMS, getProfileInt( "Klemmen_Steuerung_01", "RSt_Anforderung_HMS", 0, profileFile ) );

}


void loadSettings_Klima_03( char profileFile[] )
{
    putValue( KCAN_KL_Anf_AussenspiegelHzg, getProfileInt( "Klima_03", "KL_Anf_AussenspiegelHzg", 0, profileFile ) );
    putValue( KCAN_KL_BCmE_Livetip_Freigabe, getProfileInt( "Klima_03", "KL_BCmE_Livetip_Freigabe", 0, profileFile ) );
    putValue( KCAN_KL_ErwVK_Anf, getProfileInt( "Klima_03", "KL_ErwVK_Anf", 0, profileFile ) );
    putValue( KCAN_KL_FSH_Automatikbetrieb, getProfileInt( "Klima_03", "KL_FSH_Automatikbetrieb", 0, profileFile ) );
    putValue( KCAN_KL_Geblaese_Fond_Status, getProfileInt( "Klima_03", "KL_Geblaese_Fond_Status", 0, profileFile ) );
    putValue( KCAN_KL_Geblaese_Status, getProfileInt( "Klima_03", "KL_Geblaese_Status", 0, profileFile ) );
    putValue( KCAN_KL_Heizkreisventilstellung, getProfileInt( "Klima_03", "KL_Heizkreisventilstellung", 0, profileFile ) );
    putValue( KCAN_KL_I_Geblaese_Fond, getProfileFloat( "Klima_03", "KL_I_Geblaese_Fond", 0, profileFile ) );
    putValue( KCAN_KL_Innen_Temp, getProfileFloat( "Klima_03", "KL_Innen_Temp", 0, profileFile ) );
    putValue( KCAN_KL_Kompressorkupplung, getProfileInt( "Klima_03", "KL_Kompressorkupplung", 0, profileFile ) );
    putValue( KCAN_KL_Magnetventil, getProfileInt( "Klima_03", "KL_Magnetventil", 0, profileFile ) );
    putValue( KCAN_KL_Restwaerme_aktiv, getProfileInt( "Klima_03", "KL_Restwaerme_aktiv", 0, profileFile ) );
    putValue( KCAN_KL_SH_Soll_hl, getProfileInt( "Klima_03", "KL_SH_Soll_hl", 0, profileFile ) );
    putValue( KCAN_KL_SH_Soll_hr, getProfileInt( "Klima_03", "KL_SH_Soll_hr", 0, profileFile ) );
    putValue( KCAN_KL_SIH_LEH_Verteilung_VL, getProfileInt( "Klima_03", "KL_SIH_LEH_Verteilung_VL", 0, profileFile ) );
    putValue( KCAN_KL_SIH_LEH_Verteilung_VR, getProfileInt( "Klima_03", "KL_SIH_LEH_Verteilung_VR", 0, profileFile ) );
    putValue( KCAN_KL_SIH_LEL_Verteilung_VL, getProfileInt( "Klima_03", "KL_SIH_LEL_Verteilung_VL", 0, profileFile ) );
    putValue( KCAN_KL_SIH_LEL_Verteilung_VR, getProfileInt( "Klima_03", "KL_SIH_LEL_Verteilung_VR", 0, profileFile ) );
    putValue( KCAN_KL_Solarluefter_aktiv, getProfileInt( "Klima_03", "KL_Solarluefter_aktiv", 0, profileFile ) );
    putValue( KCAN_KL_STH_aktiv, getProfileInt( "Klima_03", "KL_STH_aktiv", 0, profileFile ) );
    putValue( KCAN_KL_STH_Ansteuerung, getProfileInt( "Klima_03", "KL_STH_Ansteuerung", 0, profileFile ) );
    putValue( KCAN_KL_STH_Betriebsdauer, getProfileInt( "Klima_03", "KL_STH_Betriebsdauer", 0, profileFile ) );
    putValue( KCAN_KL_STL_aktiv, getProfileInt( "Klima_03", "KL_STL_aktiv", 0, profileFile ) );
    putValue( KCAN_KL_Umluft_Taste, getProfileInt( "Klima_03", "KL_Umluft_Taste", 0, profileFile ) );
    putValue( KCAN_KL_WaPu, getProfileInt( "Klima_03", "KL_WaPu", 0, profileFile ) );

}


void loadSettings_Klima_06( char profileFile[] )
{
    putValue( KCAN_KL_Betriebsmodus_FH, getProfileInt( "Klima_06", "KL_Betriebsmodus_FH", 0, profileFile ) );
    putValue( KCAN_KL_ErwVK_Beifahrerzone, getProfileInt( "Klima_06", "KL_ErwVK_Beifahrerzone", 0, profileFile ) );
    putValue( KCAN_KL_ErwVK_Fahrerzone, getProfileInt( "Klima_06", "KL_ErwVK_Fahrerzone", 0, profileFile ) );
    putValue( KCAN_KL_ErwVK_Heckzone_links, getProfileInt( "Klima_06", "KL_ErwVK_Heckzone_links", 0, profileFile ) );
    putValue( KCAN_Kl_ErwVK_Heckzone_rechts, getProfileInt( "Klima_06", "Kl_ErwVK_Heckzone_rechts", 0, profileFile ) );
    putValue( KCAN_KL_ErwVK_Scheibenheizung, getProfileInt( "Klima_06", "KL_ErwVK_Scheibenheizung", 0, profileFile ) );
    putValue( KCAN_KL_ErwVK_Status, getProfileInt( "Klima_06", "KL_ErwVK_Status", 0, profileFile ) );
    putValue( KCAN_KL_Hinweis_Kuehlmodus, getProfileInt( "Klima_06", "KL_Hinweis_Kuehlmodus", 0, profileFile ) );
    putValue( KCAN_KL_Meldung_Status, getProfileInt( "Klima_06", "KL_Meldung_Status", 0, profileFile ) );
    putValue( KCAN_KL_STH_Betriebsdauer_lang, getProfileInt( "Klima_06", "KL_STH_Betriebsdauer_lang", 0, profileFile ) );
    putValue( KCAN_KL_Stopp_Wiederstart_Anz_01, getProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_01", 0, profileFile ) );
    putValue( KCAN_KL_Stopp_Wiederstart_Anz_02, getProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_02", 0, profileFile ) );
    putValue( KCAN_KL_Stopp_Wiederstart_Anz_03, getProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_03", 0, profileFile ) );
    putValue( KCAN_KL_Stopp_Wiederstart_Anz_04, getProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_04", 0, profileFile ) );
    putValue( KCAN_KL_Stopp_Wiederstart_Anz_05, getProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_05", 0, profileFile ) );
    putValue( KCAN_KL_Stopp_Wiederstart_Anz_06, getProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_06", 0, profileFile ) );
    putValue( KCAN_KL_Stopp_Wiederstart_Anz_07, getProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_07", 0, profileFile ) );
    putValue( KCAN_KL_Stopp_Wiederstart_Anz_08, getProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_08", 0, profileFile ) );
    putValue( KCAN_KL_Stopp_Wiederstart_Anz_09, getProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_09", 0, profileFile ) );
    putValue( KCAN_KL_Stopp_Wiederstart_Anz_Std1, getProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_Std1", 0, profileFile ) );
    putValue( KCAN_KL_Stopp_Wiederstart_Anz_Std2, getProfileInt( "Klima_06", "KL_Stopp_Wiederstart_Anz_Std2", 0, profileFile ) );
    putValue( KCAN_KL_ZZ_Betriebsmodus, getProfileInt( "Klima_06", "KL_ZZ_Betriebsmodus", 0, profileFile ) );
    putValue( KCAN_KL_ZZ_Minute, getProfileInt( "Klima_06", "KL_ZZ_Minute", 0, profileFile ) );
    putValue( KCAN_KL_ZZ_Monat, getProfileInt( "Klima_06", "KL_ZZ_Monat", 0, profileFile ) );
    putValue( KCAN_KL_ZZ_Status_Timer, getProfileInt( "Klima_06", "KL_ZZ_Status_Timer", 0, profileFile ) );
    putValue( KCAN_KL_ZZ_Stunde, getProfileInt( "Klima_06", "KL_ZZ_Stunde", 0, profileFile ) );
    putValue( KCAN_KL_ZZ_Tag, getProfileInt( "Klima_06", "KL_ZZ_Tag", 0, profileFile ) );

}


void loadSettings_Klima_12( char profileFile[] )
{
    putValue( KCAN_FSH_Taster, getProfileInt( "Klima_12", "FSH_Taster", 0, profileFile ) );
    putValue( KCAN_HSH_Taster, getProfileInt( "Klima_12", "HSH_Taster", 0, profileFile ) );
    putValue( KCAN_KL_Beschlagsgefahr, getProfileInt( "Klima_12", "KL_Beschlagsgefahr", 0, profileFile ) );
    putValue( KCAN_KL_Geblspng_Fond_Soll, getProfileFloat( "Klima_12", "KL_Geblspng_Fond_Soll", 0, profileFile ) );
    putValue( KCAN_KL_Geblspng_Soll, getProfileFloat( "Klima_12", "KL_Geblspng_Soll", 0, profileFile ) );
    putValue( KCAN_KL_I_Geblaese, getProfileFloat( "Klima_12", "KL_I_Geblaese", 0, profileFile ) );
    putValue( KCAN_KL_Kompressorstrom_soll, getProfileInt( "Klima_12", "KL_Kompressorstrom_soll", 0, profileFile ) );
    putValue( KCAN_KL_LRH_Stufe, getProfileInt( "Klima_12", "KL_LRH_Stufe", 0, profileFile ) );
    putValue( KCAN_KL_LRH_Taster, getProfileInt( "Klima_12", "KL_LRH_Taster", 0, profileFile ) );
    putValue( KCAN_KL_PTC_Verbauinfo, getProfileInt( "Klima_12", "KL_PTC_Verbauinfo", 0, profileFile ) );
    putValue( KCAN_KL_SIH_Soll_li, getProfileInt( "Klima_12", "KL_SIH_Soll_li", 0, profileFile ) );
    putValue( KCAN_KL_SIH_Soll_re, getProfileInt( "Klima_12", "KL_SIH_Soll_re", 0, profileFile ) );
    putValue( KCAN_KL_SIL_Soll_li, getProfileInt( "Klima_12", "KL_SIL_Soll_li", 0, profileFile ) );
    putValue( KCAN_KL_SIL_Soll_re, getProfileInt( "Klima_12", "KL_SIL_Soll_re", 0, profileFile ) );
    putValue( KCAN_KL_Umluftklappe_Status, getProfileInt( "Klima_12", "KL_Umluftklappe_Status", 0, profileFile ) );
    putValue( KCAN_KL_Zuheizer_Freigabe, getProfileInt( "Klima_12", "KL_Zuheizer_Freigabe", 0, profileFile ) );
    putValue( KCAN_KRH_Soll_li, getProfileInt( "Klima_12", "KRH_Soll_li", 0, profileFile ) );
    putValue( KCAN_KRH_Soll_re, getProfileInt( "Klima_12", "KRH_Soll_re", 0, profileFile ) );

}


void loadSettings_Klima_16( char profileFile[] )
{
    putValue( KCAN_FSH_Status, getProfileInt( "Klima_16", "FSH_Status", 0, profileFile ) );
    putValue( KCAN_HSH_Relais_Anf, getProfileInt( "Klima_16", "HSH_Relais_Anf", 0, profileFile ) );
    putValue( KCAN_KL_AL_HL_Anf, getProfileInt( "Klima_16", "KL_AL_HL_Anf", 0, profileFile ) );
    putValue( KCAN_KL_AL_HR_Anf, getProfileInt( "Klima_16", "KL_AL_HR_Anf", 0, profileFile ) );
    putValue( KCAN_KL_AL_VL_Anf, getProfileInt( "Klima_16", "KL_AL_VL_Anf", 0, profileFile ) );
    putValue( KCAN_KL_AL_VR_Anf, getProfileInt( "Klima_16", "KL_AL_VR_Anf", 0, profileFile ) );
    putValue( KCAN_KL_Defrost_LED, getProfileInt( "Klima_16", "KL_Defrost_LED", 0, profileFile ) );
    putValue( KCAN_KL_FSH_LED, getProfileInt( "Klima_16", "KL_FSH_LED", 0, profileFile ) );
    putValue( KCAN_KL_FSH_Soll, getProfileInt( "Klima_16", "KL_FSH_Soll", 0, profileFile ) );
    putValue( KCAN_KL_Heizstufe_LSH, getProfileInt( "Klima_16", "KL_Heizstufe_LSH", 0, profileFile ) );
    putValue( KCAN_KL_HSH_LED, getProfileInt( "Klima_16", "KL_HSH_LED", 0, profileFile ) );
    putValue( KCAN_KL_HSH_Soll, getProfileInt( "Klima_16", "KL_HSH_Soll", 0, profileFile ) );
    putValue( KCAN_KL_HUP_aktiv, getProfileInt( "Klima_16", "KL_HUP_aktiv", 0, profileFile ) );
    putValue( KCAN_KL_Klappe_Status, getProfileInt( "Klima_16", "KL_Klappe_Status", 0, profileFile ) );
    putValue( KCAN_KL_LRH_PWM, getProfileInt( "Klima_16", "KL_LRH_PWM", 0, profileFile ) );
    putValue( KCAN_KL_LRH_Soll, getProfileInt( "Klima_16", "KL_LRH_Soll", 0, profileFile ) );
    putValue( KCAN_KL_LSH_Ansteuerung, getProfileInt( "Klima_16", "KL_LSH_Ansteuerung", 0, profileFile ) );
    putValue( KCAN_KL_LSH_Betriebsdauer, getProfileInt( "Klima_16", "KL_LSH_Betriebsdauer", 0, profileFile ) );
    putValue( KCAN_KL_LSH_DBetr_Bestaet, getProfileInt( "Klima_16", "KL_LSH_DBetr_Bestaet", 0, profileFile ) );
    putValue( KCAN_KL_LSH_DBetr_Ein, getProfileInt( "Klima_16", "KL_LSH_DBetr_Ein", 0, profileFile ) );
    putValue( KCAN_KL_Temp_ZH_Soll, getProfileFloat( "Klima_16", "KL_Temp_ZH_Soll", 0, profileFile ) );
    putValue( KCAN_KL_VoKo_LED, getProfileInt( "Klima_16", "KL_VoKo_LED", 0, profileFile ) );
    putValue( KCAN_KL_Voko_Status, getProfileInt( "Klima_16", "KL_Voko_Status", 0, profileFile ) );
    putValue( KCAN_KL_ZR_Anforderung, getProfileInt( "Klima_16", "KL_ZR_Anforderung", 0, profileFile ) );
    putValue( KCAN_SIH_Stufe_LED_li, getProfileInt( "Klima_16", "SIH_Stufe_LED_li", 0, profileFile ) );
    putValue( KCAN_SIH_Stufe_LED_re, getProfileInt( "Klima_16", "SIH_Stufe_LED_re", 0, profileFile ) );

}


void loadSettings_Klima_Sensor_02( char profileFile[] )
{
    putValue( KCAN_BCM1_Aussen_Temp_ungef, getProfileFloat( "Klima_Sensor_02", "BCM1_Aussen_Temp_ungef", 0, profileFile ) );
    putValue( KCAN_BCM1_FStatus_Aussentemp_ungef, getProfileInt( "Klima_Sensor_02", "BCM1_FStatus_Aussentemp_ungef", 0, profileFile ) );
    putValue( KCAN_BCM1_Kompressorstrom_ist, getProfileInt( "Klima_Sensor_02", "BCM1_Kompressorstrom_ist", 0, profileFile ) );
    putValue( KCAN_BCM1_OBD_FStatus_ATemp, getProfileInt( "Klima_Sensor_02", "BCM1_OBD_FStatus_ATemp", 0, profileFile ) );
    putValue( KCAN_BCM1_PTC_stufig_Status, getProfileInt( "Klima_Sensor_02", "BCM1_PTC_stufig_Status", 0, profileFile ) );
    putValue( KCAN_BCM_Heizungsabsperrventil_Status, getProfileInt( "Klima_Sensor_02", "BCM_Heizungsabsperrventil_Status", 0, profileFile ) );
    putValue( KCAN_BCM_Heizungspumpe_Status, getProfileInt( "Klima_Sensor_02", "BCM_Heizungspumpe_Status", 0, profileFile ) );
    putValue( KCAN_BCM_Kompressorkupplung_Status, getProfileInt( "Klima_Sensor_02", "BCM_Kompressorkupplung_Status", 0, profileFile ) );

}


void loadSettings_KN_DispKBI_FS( char profileFile[] )
{
    putValue( KCAN_DispKBI_FS_Abschaltstufe, getProfileInt( "KN_DispKBI_FS", "DispKBI_FS_Abschaltstufe", 0, profileFile ) );
    putValue( KCAN_DispKBI_FS_KD_Fehler, getProfileInt( "KN_DispKBI_FS", "DispKBI_FS_KD_Fehler", 0, profileFile ) );
    putValue( KCAN_DispKBI_FS_KompSchutz, getProfileInt( "KN_DispKBI_FS", "DispKBI_FS_KompSchutz", 0, profileFile ) );
    putValue( KCAN_DispKBI_FS_Nachlauftyp, getProfileInt( "KN_DispKBI_FS", "DispKBI_FS_Nachlauftyp", 0, profileFile ) );
    putValue( KCAN_DispKBI_FS_Transport_Mode, getProfileInt( "KN_DispKBI_FS", "DispKBI_FS_Transport_Mode", 0, profileFile ) );
    putValue( KCAN_KN_DispKBI_FS_BusKnockOut, getProfileInt( "KN_DispKBI_FS", "KN_DispKBI_FS_BusKnockOut", 0, profileFile ) );
    putValue( KCAN_KN_DispKBI_FS_BusKnockOutTimer, getProfileInt( "KN_DispKBI_FS", "KN_DispKBI_FS_BusKnockOutTimer", 0, profileFile ) );
    putValue( KCAN_KN_DispKBI_FS_DiagPfad, getProfileInt( "KN_DispKBI_FS", "KN_DispKBI_FS_DiagPfad", 0, profileFile ) );
    putValue( KCAN_KN_DispKBI_FS_ECUKnockOut, getProfileInt( "KN_DispKBI_FS", "KN_DispKBI_FS_ECUKnockOut", 0, profileFile ) );
    putValue( KCAN_KN_DispKBI_FS_ECUKnockOutTimer, getProfileInt( "KN_DispKBI_FS", "KN_DispKBI_FS_ECUKnockOutTimer", 0, profileFile ) );
    putValue( KCAN_NM_DispKBI_FS_Wakeup, getProfileInt( "KN_DispKBI_FS", "NM_DispKBI_FS_Wakeup", 0, profileFile ) );

}


void loadSettings_KN_Gateway( char profileFile[] )
{
    putValue( KCAN_Gateway_Abschaltstufe, getProfileInt( "KN_Gateway", "Gateway_Abschaltstufe", 0, profileFile ) );
    putValue( KCAN_Gateway_KompSchutz, getProfileInt( "KN_Gateway", "Gateway_KompSchutz", 0, profileFile ) );
    putValue( KCAN_Gateway_Nachlauftyp, getProfileInt( "KN_Gateway", "Gateway_Nachlauftyp", 0, profileFile ) );
    putValue( KCAN_Gateway_Transport_Mode, getProfileInt( "KN_Gateway", "Gateway_Transport_Mode", 0, profileFile ) );
    putValue( KCAN_GW_KD_Fehler_KN_Gateway, getProfileInt( "KN_Gateway", "GW_KD_Fehler_KN_Gateway", 0, profileFile ) );
    putValue( KCAN_KN_GW_DiagPfad, getProfileInt( "KN_Gateway", "KN_GW_DiagPfad", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_Wakeup, getProfileInt( "KN_Gateway", "NM_Gateway_Wakeup", 0, profileFile ) );

}


void loadSettings_KN_HUD( char profileFile[] )
{
    putValue( KCAN_HUD_Abschaltstufe, getProfileInt( "KN_HUD", "HUD_Abschaltstufe", 0, profileFile ) );
    putValue( KCAN_HUD_KD_Fehler, getProfileInt( "KN_HUD", "HUD_KD_Fehler", 0, profileFile ) );
    putValue( KCAN_HUD_KompSchutz, getProfileInt( "KN_HUD", "HUD_KompSchutz", 0, profileFile ) );
    putValue( KCAN_HUD_Nachlauftyp, getProfileInt( "KN_HUD", "HUD_Nachlauftyp", 0, profileFile ) );
    putValue( KCAN_HUD_Transport_Mode, getProfileInt( "KN_HUD", "HUD_Transport_Mode", 0, profileFile ) );
    putValue( KCAN_KN_HUD_BusKnockOut, getProfileInt( "KN_HUD", "KN_HUD_BusKnockOut", 0, profileFile ) );
    putValue( KCAN_KN_HUD_BusKnockOutTimer, getProfileInt( "KN_HUD", "KN_HUD_BusKnockOutTimer", 0, profileFile ) );
    putValue( KCAN_KN_HUD_DiagPfad, getProfileInt( "KN_HUD", "KN_HUD_DiagPfad", 0, profileFile ) );
    putValue( KCAN_KN_HUD_ECUKnockOut, getProfileInt( "KN_HUD", "KN_HUD_ECUKnockOut", 0, profileFile ) );
    putValue( KCAN_KN_HUD_ECUKnockOutTimer, getProfileInt( "KN_HUD", "KN_HUD_ECUKnockOutTimer", 0, profileFile ) );
    putValue( KCAN_NM_HUD_Wakeup, getProfileInt( "KN_HUD", "NM_HUD_Wakeup", 0, profileFile ) );

}


void loadSettings_KN_Info_El( char profileFile[] )
{
    putValue( KCAN_Info_El_Abschaltstufe, getProfileInt( "KN_Info_El", "Info_El_Abschaltstufe", 0, profileFile ) );
    putValue( KCAN_Info_El_KD_Fehler, getProfileInt( "KN_Info_El", "Info_El_KD_Fehler", 0, profileFile ) );
    putValue( KCAN_Info_El_KompSchutz, getProfileInt( "KN_Info_El", "Info_El_KompSchutz", 0, profileFile ) );
    putValue( KCAN_Info_El_Nachlauftyp, getProfileInt( "KN_Info_El", "Info_El_Nachlauftyp", 0, profileFile ) );
    putValue( KCAN_Info_El_Transport_Mode, getProfileInt( "KN_Info_El", "Info_El_Transport_Mode", 0, profileFile ) );
    putValue( KCAN_KN_Info_El_BusKnockOutTimer, getProfileInt( "KN_Info_El", "KN_Info_El_BusKnockOutTimer", 0, profileFile ) );
    putValue( KCAN_KN_Info_El_DiagPfad, getProfileInt( "KN_Info_El", "KN_Info_El_DiagPfad", 0, profileFile ) );
    putValue( KCAN_NM_Info_El_Wakeup, getProfileInt( "KN_Info_El", "NM_Info_El_Wakeup", 0, profileFile ) );

}


void loadSettings_KN_Kombi( char profileFile[] )
{
    putValue( KCAN_KBI_KD_Fehler, getProfileInt( "KN_Kombi", "KBI_KD_Fehler", 0, profileFile ) );
    putValue( KCAN_KN_KBI_DiagPfad, getProfileInt( "KN_Kombi", "KN_KBI_DiagPfad", 0, profileFile ) );
    putValue( KCAN_KN_Kombi_BusKnockOut, getProfileInt( "KN_Kombi", "KN_Kombi_BusKnockOut", 0, profileFile ) );
    putValue( KCAN_KN_Kombi_BusKnockOutTimer, getProfileInt( "KN_Kombi", "KN_Kombi_BusKnockOutTimer", 0, profileFile ) );
    putValue( KCAN_KN_Kombi_ECUKnockOut, getProfileInt( "KN_Kombi", "KN_Kombi_ECUKnockOut", 0, profileFile ) );
    putValue( KCAN_KN_Kombi_ECUKnockOutTimer, getProfileInt( "KN_Kombi", "KN_Kombi_ECUKnockOutTimer", 0, profileFile ) );
    putValue( KCAN_Kombi_Abschaltstufe, getProfileInt( "KN_Kombi", "Kombi_Abschaltstufe", 0, profileFile ) );
    putValue( KCAN_Kombi_KompSchutz, getProfileInt( "KN_Kombi", "Kombi_KompSchutz", 0, profileFile ) );
    putValue( KCAN_Kombi_Nachlauftyp, getProfileInt( "KN_Kombi", "Kombi_Nachlauftyp", 0, profileFile ) );
    putValue( KCAN_Kombi_Transport_Mode, getProfileInt( "KN_Kombi", "Kombi_Transport_Mode", 0, profileFile ) );
    putValue( KCAN_NM_Kombi_Lokalaktiv, getProfileInt( "KN_Kombi", "NM_Kombi_Lokalaktiv", 0, profileFile ) );
    putValue( KCAN_NM_Kombi_Subsystemaktiv, getProfileInt( "KN_Kombi", "NM_Kombi_Subsystemaktiv", 0, profileFile ) );
    putValue( KCAN_NM_Kombi_Wakeup, getProfileInt( "KN_Kombi", "NM_Kombi_Wakeup", 0, profileFile ) );

}


void loadSettings_KN_SmLi_1( char profileFile[] )
{
    putValue( KCAN_KN_SmLi_01_DiagPfad, getProfileInt( "KN_SmLi_1", "KN_SmLi_01_DiagPfad", 0, profileFile ) );
    putValue( KCAN_KN_SmLi_BusKnockOut, getProfileInt( "KN_SmLi_1", "KN_SmLi_BusKnockOut", 0, profileFile ) );
    putValue( KCAN_KN_SmLi_BusKnockOutTimer, getProfileInt( "KN_SmLi_1", "KN_SmLi_BusKnockOutTimer", 0, profileFile ) );
    putValue( KCAN_KN_SmLi_ECUKnockOut, getProfileInt( "KN_SmLi_1", "KN_SmLi_ECUKnockOut", 0, profileFile ) );
    putValue( KCAN_KN_SmLi_ECUKnockOutTimer, getProfileInt( "KN_SmLi_1", "KN_SmLi_ECUKnockOutTimer", 0, profileFile ) );
    putValue( KCAN_NM_SmLi_01_Wakeup, getProfileInt( "KN_SmLi_1", "NM_SmLi_01_Wakeup", 0, profileFile ) );
    putValue( KCAN_SmLi_01_Abschaltstufe, getProfileInt( "KN_SmLi_1", "SmLi_01_Abschaltstufe", 0, profileFile ) );
    putValue( KCAN_SmLi_01_KD_Fehler, getProfileInt( "KN_SmLi_1", "SmLi_01_KD_Fehler", 0, profileFile ) );
    putValue( KCAN_SmLi_01_KompSchutz, getProfileInt( "KN_SmLi_1", "SmLi_01_KompSchutz", 0, profileFile ) );
    putValue( KCAN_SmLi_01_Nachlauftyp, getProfileInt( "KN_SmLi_1", "SmLi_01_Nachlauftyp", 0, profileFile ) );
    putValue( KCAN_SmLi_01_Transport_Mode, getProfileInt( "KN_SmLi_1", "SmLi_01_Transport_Mode", 0, profileFile ) );

}


void loadSettings_Kombi_01( char profileFile[] )
{
    putValue( KCAN_KBI_Anzeigefehler_LDW_Kombi_01, getProfileInt( "Kombi_01", "KBI_Anzeigefehler_LDW_Kombi_01", 0, profileFile ) );
    putValue( KCAN_KBI_Anzeigefehler_SWA, getProfileInt( "Kombi_01", "KBI_Anzeigefehler_SWA", 0, profileFile ) );
    putValue( KCAN_KBI_ARA_in_Anzeige, getProfileInt( "Kombi_01", "KBI_ARA_in_Anzeige", 0, profileFile ) );
    putValue( KCAN_KBI_Einheit_Tacho, getProfileInt( "Kombi_01", "KBI_Einheit_Tacho", 0, profileFile ) );
    putValue( KCAN_KBI_Handbremse, getProfileInt( "Kombi_01", "KBI_Handbremse", 0, profileFile ) );
    putValue( KCAN_KBI_MFA_v_Einheit_01, getProfileInt( "Kombi_01", "KBI_MFA_v_Einheit_01", 0, profileFile ) );
    putValue( KCAN_KBI_PLA_in_Anzeige, getProfileInt( "Kombi_01", "KBI_PLA_in_Anzeige", 0, profileFile ) );
    putValue( KCAN_KBI_Systemstatus, getProfileInt( "Kombi_01", "KBI_Systemstatus", 0, profileFile ) );
    putValue( KCAN_KBI_Tankwarnung, getProfileInt( "Kombi_01", "KBI_Tankwarnung", 0, profileFile ) );
    putValue( KCAN_KBI_Tankwarnung_ungueltig, getProfileInt( "Kombi_01", "KBI_Tankwarnung_ungueltig", 0, profileFile ) );
    putValue( KCAN_KBI_Taster_Fahrwerk, getProfileInt( "Kombi_01", "KBI_Taster_Fahrwerk", 0, profileFile ) );
    putValue( KCAN_KBI_Taster_Lift, getProfileInt( "Kombi_01", "KBI_Taster_Lift", 0, profileFile ) );
    putValue( KCAN_KBI_V_Digital, getProfileInt( "Kombi_01", "KBI_V_Digital", 0, profileFile ) );
    putValue( KCAN_KBI_Vorglueh_System_Lampe, getProfileInt( "Kombi_01", "KBI_Vorglueh_System_Lampe", 0, profileFile ) );

}


void loadSettings_Kombi_02( char profileFile[] )
{
    putValue( KCAN_KBI_FoD_PopUP_Quittiert, getProfileInt( "Kombi_02", "KBI_FoD_PopUP_Quittiert", 0, profileFile ) );
    putValue( KCAN_KBI_FStatus_Tank, getProfileInt( "Kombi_02", "KBI_FStatus_Tank", 0, profileFile ) );

}


void loadSettings_Kombi_03( char profileFile[] )
{
    putValue( KCAN_KBI_GAP_Warn_Zeit_abgelaufen, getProfileInt( "Kombi_03", "KBI_GAP_Warn_Zeit_abgelaufen", 0, profileFile ) );
    putValue( KCAN_KBI_Max_Tankinhalt, getProfileFloat( "Kombi_03", "KBI_Max_Tankinhalt", 0, profileFile ) );
    putValue( KCAN_KBI_Nachtanken_erkannt, getProfileInt( "Kombi_03", "KBI_Nachtanken_erkannt", 0, profileFile ) );
    putValue( KCAN_KBI_Tankfuellstand_Prozent, getProfileInt( "Kombi_03", "KBI_Tankfuellstand_Prozent", 0, profileFile ) );
    putValue( KCAN_KBI_Tankinhalt_hochaufl, getProfileFloat( "Kombi_03", "KBI_Tankinhalt_hochaufl", 0, profileFile ) );

}


void loadSettings_Kombi_08( char profileFile[] )
{
    putValue( KCAN_AuthTime_Trigger_Distribution, getProfileInt( "Kombi_08", "AuthTime_Trigger_Distribution", 0, profileFile ) );
    putValue( KCAN_KBI_Min_Tankinhalt, getProfileFloat( "Kombi_08", "KBI_Min_Tankinhalt", 0, profileFile ) );
    putValue( KCAN_KBI_Weg_Zaehler, getProfileInt( "Kombi_08", "KBI_Weg_Zaehler", 0, profileFile ) );

}


void loadSettings_Kombi_21( char profileFile[] )
{
    putValue( KCAN_KBI_BC_Reset_E1, getProfileInt( "Kombi_21", "KBI_BC_Reset_E1", 0, profileFile ) );
    putValue( KCAN_KBI_Tankinhalt_roh, getProfileFloat( "Kombi_21", "KBI_Tankinhalt_roh", 0, profileFile ) );

}


void loadSettings_Kombi_HUD_01( char profileFile[] )
{
    putValue( KCAN_KBI_HUD_Data_01, getProfileInt( "Kombi_HUD_01", "KBI_HUD_Data_01", 0, profileFile ) );
    putValue( KCAN_KBI_HUD_Data_02, getProfileInt( "Kombi_HUD_01", "KBI_HUD_Data_02", 0, profileFile ) );
    putValue( KCAN_KBI_HUD_Data_03, getProfileInt( "Kombi_HUD_01", "KBI_HUD_Data_03", 0, profileFile ) );
    putValue( KCAN_KBI_HUD_Data_04, getProfileInt( "Kombi_HUD_01", "KBI_HUD_Data_04", 0, profileFile ) );
    putValue( KCAN_KBI_HUD_Data_05, getProfileInt( "Kombi_HUD_01", "KBI_HUD_Data_05", 0, profileFile ) );
    putValue( KCAN_KBI_HUD_Data_06, getProfileInt( "Kombi_HUD_01", "KBI_HUD_Data_06", 0, profileFile ) );
    putValue( KCAN_KBI_HUD_Data_07, getProfileInt( "Kombi_HUD_01", "KBI_HUD_Data_07", 0, profileFile ) );
    putValue( KCAN_KBI_HUD_Data_08, getProfileInt( "Kombi_HUD_01", "KBI_HUD_Data_08", 0, profileFile ) );

}


void loadSettings_KonzernrollenModus_01( char profileFile[] )
{
    putValue( KCAN_KRM_Fehler_im_Konzernrollenmodus, getProfileInt( "KonzernrollenModus_01", "KRM_Fehler_im_Konzernrollenmodus", 0, profileFile ) );
    putValue( KCAN_KRM_Konzernrollenmodus_aktiv, getProfileInt( "KonzernrollenModus_01", "KRM_Konzernrollenmodus_aktiv", 0, profileFile ) );

}


void loadSettings_KS_ICAS3Sys01_Req_FD( char profileFile[] )
{

}


void loadSettings_KS_ICAS3Sys01_Resp_FD( char profileFile[] )
{

}


void loadSettings_KS_Info_El_Req_FD( char profileFile[] )
{

}


void loadSettings_KS_Info_El_Resp_FD( char profileFile[] )
{

}


void loadSettings_KS_Kombi_Req_FD( char profileFile[] )
{

}


void loadSettings_KS_Kombi_Resp_FD( char profileFile[] )
{

}


void loadSettings_KS_SSN_ABT_1_Req( char profileFile[] )
{

}


void loadSettings_KS_SSN_ABT_1_Resp( char profileFile[] )
{

}


void loadSettings_LDW_02( char profileFile[] )
{
    putValue( KCAN_aLDW_FoD_Status, getProfileInt( "LDW_02", "aLDW_FoD_Status", 0, profileFile ) );
    putValue( KCAN_HC_Uss_Anforderung, getProfileInt( "LDW_02", "HC_Uss_Anforderung", 0, profileFile ) );
    putValue( KCAN_LDW_DLC, getProfileFloat( "LDW_02", "LDW_DLC", 0, profileFile ) );
    putValue( KCAN_LDW_Frueh_Spaet, getProfileInt( "LDW_02", "LDW_Frueh_Spaet", 0, profileFile ) );
    putValue( KCAN_LDW_Gong, getProfileInt( "LDW_02", "LDW_Gong", 0, profileFile ) );
    putValue( KCAN_LDW_Lernmodus_seitenabhaengig, getProfileInt( "LDW_02", "LDW_Lernmodus_seitenabhaengig", 0, profileFile ) );
    putValue( KCAN_LDW_Seite_DLCTLC, getProfileInt( "LDW_02", "LDW_Seite_DLCTLC", 0, profileFile ) );
    putValue( KCAN_LDW_Status_Grid, getProfileInt( "LDW_02", "LDW_Status_Grid", 0, profileFile ) );
    putValue( KCAN_LDW_Status_LED_gelb, getProfileInt( "LDW_02", "LDW_Status_LED_gelb", 0, profileFile ) );
    putValue( KCAN_LDW_Status_LED_gruen, getProfileInt( "LDW_02", "LDW_Status_LED_gruen", 0, profileFile ) );
    putValue( KCAN_LDW_Texte, getProfileInt( "LDW_02", "LDW_Texte", 0, profileFile ) );
    putValue( KCAN_LDW_TLC, getProfileFloat( "LDW_02", "LDW_TLC", 0, profileFile ) );

}


void loadSettings_LH_EPS_01( char profileFile[] )
{
    putValue( KCAN_EPS_Akustiksignal, getProfileInt( "LH_EPS_01", "EPS_Akustiksignal", 0, profileFile ) );
    putValue( KCAN_EPS_Anf_KL, getProfileInt( "LH_EPS_01", "EPS_Anf_KL", 0, profileFile ) );
    putValue( KCAN_EPS_ARA_Status, getProfileInt( "LH_EPS_01", "EPS_ARA_Status", 0, profileFile ) );
    putValue( KCAN_EPS_Charisma_FahrPr, getProfileInt( "LH_EPS_01", "EPS_Charisma_FahrPr", 0, profileFile ) );
    putValue( KCAN_EPS_Charisma_Status, getProfileInt( "LH_EPS_01", "EPS_Charisma_Status", 0, profileFile ) );
    putValue( KCAN_EPS_Endanschlag, getProfileInt( "LH_EPS_01", "EPS_Endanschlag", 0, profileFile ) );
    putValue( KCAN_EPS_Fehlerlampe, getProfileInt( "LH_EPS_01", "EPS_Fehlerlampe", 0, profileFile ) );
    putValue( KCAN_EPS_Lenkerposition, getProfileInt( "LH_EPS_01", "EPS_Lenkerposition", 0, profileFile ) );
    putValue( KCAN_EPS_PLA_Abbruch, getProfileInt( "LH_EPS_01", "EPS_PLA_Abbruch", 0, profileFile ) );
    putValue( KCAN_EPS_PLA_Fehler, getProfileInt( "LH_EPS_01", "EPS_PLA_Fehler", 0, profileFile ) );
    putValue( KCAN_EPS_PLA_Status, getProfileInt( "LH_EPS_01", "EPS_PLA_Status", 0, profileFile ) );
    putValue( KCAN_EPS_SpannungsAnf, getProfileInt( "LH_EPS_01", "EPS_SpannungsAnf", 0, profileFile ) );
    putValue( KCAN_EPS_Warnungen, getProfileInt( "LH_EPS_01", "EPS_Warnungen", 0, profileFile ) );

}


void loadSettings_Licht_Anf_01( char profileFile[] )
{
    putValue( KCAN_BCM1_Abblendlicht_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Abblendlicht_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_Adaptive_Lichtvert_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Adaptive_Lichtvert_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_Allwetterlicht_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Allwetterlicht_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_Autobahnlicht_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Autobahnlicht_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_CH_aktiv, getProfileInt( "Licht_Anf_01", "BCM1_CH_aktiv", 0, profileFile ) );
    putValue( KCAN_BCM1_CH_LH_aktiv, getProfileInt( "Licht_Anf_01", "BCM1_CH_LH_aktiv", 0, profileFile ) );
    putValue( KCAN_BCM1_Fahrlicht_Hinweis, getProfileInt( "Licht_Anf_01", "BCM1_Fahrlicht_Hinweis", 0, profileFile ) );
    putValue( KCAN_BCM1_Fernlicht_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Fernlicht_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_Gleitende_Leuchtw_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Gleitende_Leuchtw_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_GLW_Fernlicht_Anf, getProfileInt( "Licht_Anf_01", "BCM1_GLW_Fernlicht_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_Hinweis_Lichtnachlauf, getProfileInt( "Licht_Anf_01", "BCM1_Hinweis_Lichtnachlauf", 0, profileFile ) );
    putValue( KCAN_BCM1_Kurvenlicht_links_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Kurvenlicht_links_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_Kurvenlicht_rechts_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Kurvenlicht_rechts_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_LH_aktiv, getProfileInt( "Licht_Anf_01", "BCM1_LH_aktiv", 0, profileFile ) );
    putValue( KCAN_BCM1_Lichtwarn_Texte, getProfileInt( "Licht_Anf_01", "BCM1_Lichtwarn_Texte", 0, profileFile ) );
    putValue( KCAN_BCM1_Nebellicht_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Nebellicht_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_Nebelschluss_Ahg_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Nebelschluss_Ahg_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_Nebelschluss_Fzg_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Nebelschluss_Fzg_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_Parklicht_li_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Parklicht_li_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_Parklicht_re_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Parklicht_re_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_Regenlicht_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Regenlicht_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_Schlusslicht_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Schlusslicht_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_Signaturlicht_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Signaturlicht_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_Standlicht_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Standlicht_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_Tagfahrlicht_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Tagfahrlicht_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_Touristen_Licht_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Touristen_Licht_Anf", 0, profileFile ) );
    putValue( KCAN_BCM1_Umfeldleuchten_Anf, getProfileInt( "Licht_Anf_01", "BCM1_Umfeldleuchten_Anf", 0, profileFile ) );
    putValue( KCAN_BCM_Rueckfahrlicht_Anf, getProfileInt( "Licht_Anf_01", "BCM_Rueckfahrlicht_Anf", 0, profileFile ) );
    putValue( KCAN_TFL_Matrix_Variante01_Anf, getProfileInt( "Licht_Anf_01", "TFL_Matrix_Variante01_Anf", 0, profileFile ) );
    putValue( KCAN_TFL_Matrix_Variante02_Anf, getProfileInt( "Licht_Anf_01", "TFL_Matrix_Variante02_Anf", 0, profileFile ) );
    putValue( KCAN_TFL_Matrix_Variante03_Anf, getProfileInt( "Licht_Anf_01", "TFL_Matrix_Variante03_Anf", 0, profileFile ) );
    putValue( KCAN_TFL_Matrix_Variante04_Anf, getProfileInt( "Licht_Anf_01", "TFL_Matrix_Variante04_Anf", 0, profileFile ) );

}


void loadSettings_Licht_hinten_01( char profileFile[] )
{
    putValue( KCAN_BRL_als_SHL, getProfileInt( "Licht_hinten_01", "BRL_als_SHL", 0, profileFile ) );
    putValue( KCAN_LH_3_Bremsl_def, getProfileInt( "Licht_hinten_01", "LH_3_Bremsl_def", 0, profileFile ) );
    putValue( KCAN_LH_Aussenlicht_def, getProfileInt( "Licht_hinten_01", "LH_Aussenlicht_def", 0, profileFile ) );
    putValue( KCAN_LH_Blinker_HL_akt, getProfileInt( "Licht_hinten_01", "LH_Blinker_HL_akt", 0, profileFile ) );
    putValue( KCAN_LH_Blinker_HR_akt, getProfileInt( "Licht_hinten_01", "LH_Blinker_HR_akt", 0, profileFile ) );
    putValue( KCAN_LH_Blinker_li_def, getProfileInt( "Licht_hinten_01", "LH_Blinker_li_def", 0, profileFile ) );
    putValue( KCAN_LH_Blinker_re_def, getProfileInt( "Licht_hinten_01", "LH_Blinker_re_def", 0, profileFile ) );
    putValue( KCAN_LH_Brems_Blk_li_def, getProfileInt( "Licht_hinten_01", "LH_Brems_Blk_li_def", 0, profileFile ) );
    putValue( KCAN_LH_Brems_Blk_re_def, getProfileInt( "Licht_hinten_01", "LH_Brems_Blk_re_def", 0, profileFile ) );
    putValue( KCAN_LH_Bremsl_li_def, getProfileInt( "Licht_hinten_01", "LH_Bremsl_li_def", 0, profileFile ) );
    putValue( KCAN_LH_Bremsl_li_ges_def, getProfileInt( "Licht_hinten_01", "LH_Bremsl_li_ges_def", 0, profileFile ) );
    putValue( KCAN_LH_Bremsl_mi_def, getProfileInt( "Licht_hinten_01", "LH_Bremsl_mi_def", 0, profileFile ) );
    putValue( KCAN_LH_Bremsl_re_def, getProfileInt( "Licht_hinten_01", "LH_Bremsl_re_def", 0, profileFile ) );
    putValue( KCAN_LH_Bremsl_re_ges_def, getProfileInt( "Licht_hinten_01", "LH_Bremsl_re_ges_def", 0, profileFile ) );
    putValue( KCAN_LH_Bremslicht_H_aktiv, getProfileInt( "Licht_hinten_01", "LH_Bremslicht_H_aktiv", 0, profileFile ) );
    putValue( KCAN_LH_Diag_LED_li_def, getProfileInt( "Licht_hinten_01", "LH_Diag_LED_li_def", 0, profileFile ) );
    putValue( KCAN_LH_Diag_LED_re_def, getProfileInt( "Licht_hinten_01", "LH_Diag_LED_re_def", 0, profileFile ) );
    putValue( KCAN_LH_Diag_Status_li_def, getProfileInt( "Licht_hinten_01", "LH_Diag_Status_li_def", 0, profileFile ) );
    putValue( KCAN_LH_Diag_Status_re_def, getProfileInt( "Licht_hinten_01", "LH_Diag_Status_re_def", 0, profileFile ) );
    putValue( KCAN_LH_Kennzl_def, getProfileInt( "Licht_hinten_01", "LH_Kennzl_def", 0, profileFile ) );
    putValue( KCAN_LH_Nebel_li_def, getProfileInt( "Licht_hinten_01", "LH_Nebel_li_def", 0, profileFile ) );
    putValue( KCAN_LH_Nebel_mi_def, getProfileInt( "Licht_hinten_01", "LH_Nebel_mi_def", 0, profileFile ) );
    putValue( KCAN_LH_Nebel_re_def, getProfileInt( "Licht_hinten_01", "LH_Nebel_re_def", 0, profileFile ) );
    putValue( KCAN_LH_Nebelschluss_aktiv, getProfileInt( "Licht_hinten_01", "LH_Nebelschluss_aktiv", 0, profileFile ) );
    putValue( KCAN_LH_Parklicht_HL_aktiv, getProfileInt( "Licht_hinten_01", "LH_Parklicht_HL_aktiv", 0, profileFile ) );
    putValue( KCAN_LH_Parklicht_HR_aktiv, getProfileInt( "Licht_hinten_01", "LH_Parklicht_HR_aktiv", 0, profileFile ) );
    putValue( KCAN_LH_Rueckf_li_def, getProfileInt( "Licht_hinten_01", "LH_Rueckf_li_def", 0, profileFile ) );
    putValue( KCAN_LH_Rueckf_mi_def, getProfileInt( "Licht_hinten_01", "LH_Rueckf_mi_def", 0, profileFile ) );
    putValue( KCAN_LH_Rueckf_re_def, getProfileInt( "Licht_hinten_01", "LH_Rueckf_re_def", 0, profileFile ) );
    putValue( KCAN_LH_Rueckfahrlicht_aktiv, getProfileInt( "Licht_hinten_01", "LH_Rueckfahrlicht_aktiv", 0, profileFile ) );
    putValue( KCAN_LH_Schluss_Brems_li_def, getProfileInt( "Licht_hinten_01", "LH_Schluss_Brems_li_def", 0, profileFile ) );
    putValue( KCAN_LH_Schluss_Brems_mi_def, getProfileInt( "Licht_hinten_01", "LH_Schluss_Brems_mi_def", 0, profileFile ) );
    putValue( KCAN_LH_Schluss_Brems_Nebel_li_def, getProfileInt( "Licht_hinten_01", "LH_Schluss_Brems_Nebel_li_def", 0, profileFile ) );
    putValue( KCAN_LH_Schluss_Brems_Nebel_re_def, getProfileInt( "Licht_hinten_01", "LH_Schluss_Brems_Nebel_re_def", 0, profileFile ) );
    putValue( KCAN_LH_Schluss_Brems_re_def, getProfileInt( "Licht_hinten_01", "LH_Schluss_Brems_re_def", 0, profileFile ) );
    putValue( KCAN_LH_Schluss_Nebel_li_def, getProfileInt( "Licht_hinten_01", "LH_Schluss_Nebel_li_def", 0, profileFile ) );
    putValue( KCAN_LH_Schluss_Nebel_re_def, getProfileInt( "Licht_hinten_01", "LH_Schluss_Nebel_re_def", 0, profileFile ) );
    putValue( KCAN_LH_Schlusslicht_li_def, getProfileInt( "Licht_hinten_01", "LH_Schlusslicht_li_def", 0, profileFile ) );
    putValue( KCAN_LH_Schlusslicht_mi_def, getProfileInt( "Licht_hinten_01", "LH_Schlusslicht_mi_def", 0, profileFile ) );
    putValue( KCAN_LH_Schlusslicht_re_def, getProfileInt( "Licht_hinten_01", "LH_Schlusslicht_re_def", 0, profileFile ) );
    putValue( KCAN_LH_SL_BRL_BLK_li_def, getProfileInt( "Licht_hinten_01", "LH_SL_BRL_BLK_li_def", 0, profileFile ) );
    putValue( KCAN_LH_SL_BRL_BLK_re_def, getProfileInt( "Licht_hinten_01", "LH_SL_BRL_BLK_re_def", 0, profileFile ) );
    putValue( KCAN_LH_Standlicht_H_aktiv, getProfileInt( "Licht_hinten_01", "LH_Standlicht_H_aktiv", 0, profileFile ) );
    putValue( KCAN_LH_Zusatzschlussl_def, getProfileInt( "Licht_hinten_01", "LH_Zusatzschlussl_def", 0, profileFile ) );

}


void loadSettings_Licht_vorne_01( char profileFile[] )
{
    putValue( KCAN_BCM1_Licht_Dunkelheit_aktiv, getProfileInt( "Licht_vorne_01", "BCM1_Licht_Dunkelheit_aktiv", 0, profileFile ) );
    putValue( KCAN_LV_Abbiegelicht_li_def, getProfileInt( "Licht_vorne_01", "LV_Abbiegelicht_li_def", 0, profileFile ) );
    putValue( KCAN_LV_Abbiegelicht_re_def, getProfileInt( "Licht_vorne_01", "LV_Abbiegelicht_re_def", 0, profileFile ) );
    putValue( KCAN_LV_Abblend_Fernlicht_li_def, getProfileInt( "Licht_vorne_01", "LV_Abblend_Fernlicht_li_def", 0, profileFile ) );
    putValue( KCAN_LV_Abblend_Fernlicht_re_def, getProfileInt( "Licht_vorne_01", "LV_Abblend_Fernlicht_re_def", 0, profileFile ) );
    putValue( KCAN_LV_Abblendlicht_Anzeige, getProfileInt( "Licht_vorne_01", "LV_Abblendlicht_Anzeige", 0, profileFile ) );
    putValue( KCAN_LV_Abblendlicht_li_def, getProfileInt( "Licht_vorne_01", "LV_Abblendlicht_li_def", 0, profileFile ) );
    putValue( KCAN_LV_Abblendlicht_re_def, getProfileInt( "Licht_vorne_01", "LV_Abblendlicht_re_def", 0, profileFile ) );
    putValue( KCAN_LV_Abblendlicht_TFL_li_def, getProfileInt( "Licht_vorne_01", "LV_Abblendlicht_TFL_li_def", 0, profileFile ) );
    putValue( KCAN_LV_Abblendlicht_TFL_re_def, getProfileInt( "Licht_vorne_01", "LV_Abblendlicht_TFL_re_def", 0, profileFile ) );
    putValue( KCAN_LV_AFL_aktiv_Anzeige, getProfileInt( "Licht_vorne_01", "LV_AFL_aktiv_Anzeige", 0, profileFile ) );
    putValue( KCAN_LV_AFL_defekt, getProfileInt( "Licht_vorne_01", "LV_AFL_defekt", 0, profileFile ) );
    putValue( KCAN_LV_Aussenlicht_def, getProfileInt( "Licht_vorne_01", "LV_Aussenlicht_def", 0, profileFile ) );
    putValue( KCAN_LV_Blinker_li_def, getProfileInt( "Licht_vorne_01", "LV_Blinker_li_def", 0, profileFile ) );
    putValue( KCAN_LV_Blinker_re_def, getProfileInt( "Licht_vorne_01", "LV_Blinker_re_def", 0, profileFile ) );
    putValue( KCAN_LV_Blinker_VL_aktiv, getProfileInt( "Licht_vorne_01", "LV_Blinker_VL_aktiv", 0, profileFile ) );
    putValue( KCAN_LV_Blinker_VR_aktiv, getProfileInt( "Licht_vorne_01", "LV_Blinker_VR_aktiv", 0, profileFile ) );
    putValue( KCAN_LV_Blk_li_Seite_def, getProfileInt( "Licht_vorne_01", "LV_Blk_li_Seite_def", 0, profileFile ) );
    putValue( KCAN_LV_Blk_re_Seite_def, getProfileInt( "Licht_vorne_01", "LV_Blk_re_Seite_def", 0, profileFile ) );
    putValue( KCAN_LV_Fernlicht_Anzeige, getProfileInt( "Licht_vorne_01", "LV_Fernlicht_Anzeige", 0, profileFile ) );
    putValue( KCAN_LV_Fernlicht_li_def, getProfileInt( "Licht_vorne_01", "LV_Fernlicht_li_def", 0, profileFile ) );
    putValue( KCAN_LV_Fernlicht_re_def, getProfileInt( "Licht_vorne_01", "LV_Fernlicht_re_def", 0, profileFile ) );
    putValue( KCAN_LV_FLA_aktiv_Anzeige, getProfileInt( "Licht_vorne_01", "LV_FLA_aktiv_Anzeige", 0, profileFile ) );
    putValue( KCAN_LV_FLA_defekt, getProfileInt( "Licht_vorne_01", "LV_FLA_defekt", 0, profileFile ) );
    putValue( KCAN_LV_FLA_Sensor_blockiert, getProfileInt( "Licht_vorne_01", "LV_FLA_Sensor_blockiert", 0, profileFile ) );
    putValue( KCAN_LV_LED_Scheinwerfer_li_def, getProfileInt( "Licht_vorne_01", "LV_LED_Scheinwerfer_li_def", 0, profileFile ) );
    putValue( KCAN_LV_LED_Scheinwerfer_re_def, getProfileInt( "Licht_vorne_01", "LV_LED_Scheinwerfer_re_def", 0, profileFile ) );
    putValue( KCAN_LV_MXB_Status_Anzeige, getProfileInt( "Licht_vorne_01", "LV_MXB_Status_Anzeige", 0, profileFile ) );
    putValue( KCAN_LV_Nebellicht_Anzeige, getProfileInt( "Licht_vorne_01", "LV_Nebellicht_Anzeige", 0, profileFile ) );
    putValue( KCAN_LV_Nebellicht_li_def, getProfileInt( "Licht_vorne_01", "LV_Nebellicht_li_def", 0, profileFile ) );
    putValue( KCAN_LV_Nebellicht_re_def, getProfileInt( "Licht_vorne_01", "LV_Nebellicht_re_def", 0, profileFile ) );
    putValue( KCAN_LV_Nebellicht_TFL_li_def, getProfileInt( "Licht_vorne_01", "LV_Nebellicht_TFL_li_def", 0, profileFile ) );
    putValue( KCAN_LV_Nebellicht_TFL_re_def, getProfileInt( "Licht_vorne_01", "LV_Nebellicht_TFL_re_def", 0, profileFile ) );
    putValue( KCAN_LV_Nebelschlusslicht_Anzeige, getProfileInt( "Licht_vorne_01", "LV_Nebelschlusslicht_Anzeige", 0, profileFile ) );
    putValue( KCAN_LV_Standlicht_Anzeige, getProfileInt( "Licht_vorne_01", "LV_Standlicht_Anzeige", 0, profileFile ) );
    putValue( KCAN_LV_Standlicht_li_def, getProfileInt( "Licht_vorne_01", "LV_Standlicht_li_def", 0, profileFile ) );
    putValue( KCAN_LV_Standlicht_re_def, getProfileInt( "Licht_vorne_01", "LV_Standlicht_re_def", 0, profileFile ) );
    putValue( KCAN_LV_Standlicht_TFL_li_def, getProfileInt( "Licht_vorne_01", "LV_Standlicht_TFL_li_def", 0, profileFile ) );
    putValue( KCAN_LV_Standlicht_TFL_re_def, getProfileInt( "Licht_vorne_01", "LV_Standlicht_TFL_re_def", 0, profileFile ) );
    putValue( KCAN_LV_Tagfahrlicht_Anzeige, getProfileInt( "Licht_vorne_01", "LV_Tagfahrlicht_Anzeige", 0, profileFile ) );
    putValue( KCAN_LV_Tagfahrlicht_li_def, getProfileInt( "Licht_vorne_01", "LV_Tagfahrlicht_li_def", 0, profileFile ) );
    putValue( KCAN_LV_Tagfahrlicht_re_def, getProfileInt( "Licht_vorne_01", "LV_Tagfahrlicht_re_def", 0, profileFile ) );

}


void loadSettings_LiSi_01( char profileFile[] )
{
    putValue( KCAN_LiSi_Defrost_Taste, getProfileInt( "LiSi_01", "LiSi_Defrost_Taste", 0, profileFile ) );
    putValue( KCAN_LiSi_FSH_Taste, getProfileInt( "LiSi_01", "LiSi_FSH_Taste", 0, profileFile ) );
    putValue( KCAN_LiSi_HSH_Taste, getProfileInt( "LiSi_01", "LiSi_HSH_Taste", 0, profileFile ) );
    putValue( KCAN_LiSi_Touch_Event, getProfileInt( "LiSi_01", "LiSi_Touch_Event", 0, profileFile ) );
    putValue( KCAN_LTM_Autolicht, getProfileInt( "LiSi_01", "LTM_Autolicht", 0, profileFile ) );
    putValue( KCAN_LTM_Beruehrung, getProfileInt( "LiSi_01", "LTM_Beruehrung", 0, profileFile ) );
    putValue( KCAN_LTM_Lokalaktiv, getProfileInt( "LiSi_01", "LTM_Lokalaktiv", 0, profileFile ) );
    putValue( KCAN_LTM_Nebellicht, getProfileInt( "LiSi_01", "LTM_Nebellicht", 0, profileFile ) );
    putValue( KCAN_LTM_Nebelschlusslicht, getProfileInt( "LiSi_01", "LTM_Nebelschlusslicht", 0, profileFile ) );
    putValue( KCAN_LTM_ResponseError, getProfileInt( "LiSi_01", "LTM_ResponseError", 0, profileFile ) );
    putValue( KCAN_LTM_StatusLichttastenmodul, getProfileInt( "LiSi_01", "LTM_StatusLichttastenmodul", 0, profileFile ) );
    putValue( KCAN_LTM_Variante, getProfileInt( "LiSi_01", "LTM_Variante", 0, profileFile ) );

}


void loadSettings_LWI_01( char profileFile[] )
{
    putValue( KCAN_LWI_Lenkradw_Geschw, getProfileInt( "LWI_01", "LWI_Lenkradw_Geschw", 0, profileFile ) );
    putValue( KCAN_LWI_Lenkradwinkel, getProfileFloat( "LWI_01", "LWI_Lenkradwinkel", 0, profileFile ) );
    putValue( KCAN_LWI_QBit_Lenkradwinkel, getProfileInt( "LWI_01", "LWI_QBit_Lenkradwinkel", 0, profileFile ) );
    putValue( KCAN_LWI_QBit_Sub_Daten, getProfileInt( "LWI_01", "LWI_QBit_Sub_Daten", 0, profileFile ) );
    putValue( KCAN_LWI_Sensorstatus, getProfileInt( "LWI_01", "LWI_Sensorstatus", 0, profileFile ) );
    putValue( KCAN_LWI_Sub_Daten, getProfileInt( "LWI_01", "LWI_Sub_Daten", 0, profileFile ) );
    putValue( KCAN_LWI_VZ_Lenkradw_Geschw, getProfileInt( "LWI_01", "LWI_VZ_Lenkradw_Geschw", 0, profileFile ) );
    putValue( KCAN_LWI_VZ_Lenkradwinkel, getProfileInt( "LWI_01", "LWI_VZ_Lenkradwinkel", 0, profileFile ) );

}


void loadSettings_MainUnit_01( char profileFile[] )
{
    putValue( KCAN_DSSS_Warning, getProfileInt( "MainUnit_01", "DSSS_Warning", 0, profileFile ) );
    putValue( KCAN_MIB_ASW_Diagnose, getProfileInt( "MainUnit_01", "MIB_ASW_Diagnose", 0, profileFile ) );
    putValue( KCAN_MIB_Tongenerator_PH_verfuegbar, getProfileInt( "MainUnit_01", "MIB_Tongenerator_PH_verfuegbar", 0, profileFile ) );
    putValue( KCAN_MMI_Counter_Bedienevent, getProfileInt( "MainUnit_01", "MMI_Counter_Bedienevent", 0, profileFile ) );
    putValue( KCAN_MMI_Gurt_Mic_ref, getProfileInt( "MainUnit_01", "MMI_Gurt_Mic_ref", 0, profileFile ) );
    putValue( KCAN_MMI_SDS_aktiv, getProfileInt( "MainUnit_01", "MMI_SDS_aktiv", 0, profileFile ) );
    putValue( KCAN_MMI_Telefon_aktiv, getProfileInt( "MainUnit_01", "MMI_Telefon_aktiv", 0, profileFile ) );
    putValue( KCAN_MU_SecondDisplay, getProfileInt( "MainUnit_01", "MU_SecondDisplay", 0, profileFile ) );
    putValue( KCAN_MU_Update_Time, getProfileFloat( "MainUnit_01", "MU_Update_Time", 0, profileFile ) );
    putValue( KCAN_Nav_FoD_Status, getProfileInt( "MainUnit_01", "Nav_FoD_Status", 0, profileFile ) );
    putValue( KCAN_ZR_AppConnect_Zustand, getProfileInt( "MainUnit_01", "ZR_AppConnect_Zustand", 0, profileFile ) );
    putValue( KCAN_ZR_Kindersicherung_RSE, getProfileInt( "MainUnit_01", "ZR_Kindersicherung_RSE", 0, profileFile ) );
    putValue( KCAN_ZR_Lichter_Tag, getProfileInt( "MainUnit_01", "ZR_Lichter_Tag", 0, profileFile ) );
    putValue( KCAN_ZR_LoGeWa_Event_Kombiwarnung, getProfileInt( "MainUnit_01", "ZR_LoGeWa_Event_Kombiwarnung", 0, profileFile ) );
    putValue( KCAN_ZR_Parken_Sondermodus, getProfileInt( "MainUnit_01", "ZR_Parken_Sondermodus", 0, profileFile ) );
    putValue( KCAN_ZR_RSE_aktivieren, getProfileInt( "MainUnit_01", "ZR_RSE_aktivieren", 0, profileFile ) );

}


void loadSettings_Mem_BFS_01( char profileFile[] )
{
    putValue( KCAN_BFS_Fond_Bed_Ack, getProfileInt( "Mem_BFS_01", "BFS_Fond_Bed_Ack", 0, profileFile ) );
    putValue( KCAN_BFS_FSV_ausgeklappt, getProfileInt( "Mem_BFS_01", "BFS_FSV_ausgeklappt", 0, profileFile ) );
    putValue( KCAN_BFS_GHV_aktiv, getProfileInt( "Mem_BFS_01", "BFS_GHV_aktiv", 0, profileFile ) );
    putValue( KCAN_BFS_Gurtbringer_Sperre, getProfileInt( "Mem_BFS_01", "BFS_Gurtbringer_Sperre", 0, profileFile ) );
