    putValue( KCAN_BFS_Klapptisch_offen, getProfileInt( "Mem_BFS_01", "BFS_Klapptisch_offen", 0, profileFile ) );
    putValue( KCAN_BFS_KSS_Fahrt_aktiv, getProfileInt( "Mem_BFS_01", "BFS_KSS_Fahrt_aktiv", 0, profileFile ) );
    putValue( KCAN_BFS_KSV_aktiv, getProfileInt( "Mem_BFS_01", "BFS_KSV_aktiv", 0, profileFile ) );
    putValue( KCAN_BFS_Lehne_nicht_verriegelt, getProfileInt( "Mem_BFS_01", "BFS_Lehne_nicht_verriegelt", 0, profileFile ) );
    putValue( KCAN_BFS_LHV_aktiv, getProfileInt( "Mem_BFS_01", "BFS_LHV_aktiv", 0, profileFile ) );
    putValue( KCAN_BFS_LKV_aktiv, getProfileInt( "Mem_BFS_01", "BFS_LKV_aktiv", 0, profileFile ) );
    putValue( KCAN_BFS_LNV_aktiv, getProfileInt( "Mem_BFS_01", "BFS_LNV_aktiv", 0, profileFile ) );
    putValue( KCAN_BFS_LWV_aktiv, getProfileInt( "Mem_BFS_01", "BFS_LWV_aktiv", 0, profileFile ) );
    putValue( KCAN_BFS_MMB_glob_stop, getProfileInt( "Mem_BFS_01", "BFS_MMB_glob_stop", 0, profileFile ) );
    putValue( KCAN_BFS_MMB_lokal_Stop, getProfileInt( "Mem_BFS_01", "BFS_MMB_lokal_Stop", 0, profileFile ) );
    putValue( KCAN_BFS_MMB_storage, getProfileInt( "Mem_BFS_01", "BFS_MMB_storage", 0, profileFile ) );
    putValue( KCAN_BFS_MMB_storage_beep, getProfileInt( "Mem_BFS_01", "BFS_MMB_storage_beep", 0, profileFile ) );
    putValue( KCAN_BFS_MMB_store, getProfileInt( "Mem_BFS_01", "BFS_MMB_store", 0, profileFile ) );
    putValue( KCAN_BFS_MMB_store_LED_on, getProfileInt( "Mem_BFS_01", "BFS_MMB_store_LED_on", 0, profileFile ) );
    putValue( KCAN_BFS_MMB_tast, getProfileInt( "Mem_BFS_01", "BFS_MMB_tast", 0, profileFile ) );
    putValue( KCAN_BFS_MMB_tipp, getProfileInt( "Mem_BFS_01", "BFS_MMB_tipp", 0, profileFile ) );
    putValue( KCAN_BFS_Ruhestellung_Status, getProfileInt( "Mem_BFS_01", "BFS_Ruhestellung_Status", 0, profileFile ) );
    putValue( KCAN_BFS_Seat_Locked, getProfileInt( "Mem_BFS_01", "BFS_Seat_Locked", 0, profileFile ) );
    putValue( KCAN_BFS_SHV_aktiv, getProfileInt( "Mem_BFS_01", "BFS_SHV_aktiv", 0, profileFile ) );
    putValue( KCAN_BFS_Sitzfahrt_aktiv, getProfileInt( "Mem_BFS_01", "BFS_Sitzfahrt_aktiv", 0, profileFile ) );
    putValue( KCAN_BFS_Sitzsym_Fahrt_aktiv, getProfileInt( "Mem_BFS_01", "BFS_Sitzsym_Fahrt_aktiv", 0, profileFile ) );
    putValue( KCAN_BFS_SLV_aktiv, getProfileInt( "Mem_BFS_01", "BFS_SLV_aktiv", 0, profileFile ) );
    putValue( KCAN_BFS_SNV_aktiv, getProfileInt( "Mem_BFS_01", "BFS_SNV_aktiv", 0, profileFile ) );
    putValue( KCAN_BFS_STV_aktiv, getProfileInt( "Mem_BFS_01", "BFS_STV_aktiv", 0, profileFile ) );

}


void loadSettings_Mem_FS_01( char profileFile[] )
{
    putValue( KCAN_FS_BFS_Fond_Verst_enable, getProfileInt( "Mem_FS_01", "FS_BFS_Fond_Verst_enable", 0, profileFile ) );
    putValue( KCAN_FS_BFS_KSS_Anfahrt, getProfileInt( "Mem_FS_01", "FS_BFS_KSS_Anfahrt", 0, profileFile ) );
    putValue( KCAN_FS_BFS_Sitzsym_Anfahrt, getProfileInt( "Mem_FS_01", "FS_BFS_Sitzsym_Anfahrt", 0, profileFile ) );
    putValue( KCAN_FS_EE_BFS_enable, getProfileInt( "Mem_FS_01", "FS_EE_BFS_enable", 0, profileFile ) );
    putValue( KCAN_FS_EE_Fond_BFS_enable, getProfileInt( "Mem_FS_01", "FS_EE_Fond_BFS_enable", 0, profileFile ) );
    putValue( KCAN_FS_EE_Fond_FS_enable, getProfileInt( "Mem_FS_01", "FS_EE_Fond_FS_enable", 0, profileFile ) );
    putValue( KCAN_FS_Fond_Bed_enable, getProfileInt( "Mem_FS_01", "FS_Fond_Bed_enable", 0, profileFile ) );
    putValue( KCAN_FS_GHV_aktiv, getProfileInt( "Mem_FS_01", "FS_GHV_aktiv", 0, profileFile ) );
    putValue( KCAN_FS_Gurtbringer_Sperre, getProfileInt( "Mem_FS_01", "FS_Gurtbringer_Sperre", 0, profileFile ) );
    putValue( KCAN_FS_KSV_aktiv, getProfileInt( "Mem_FS_01", "FS_KSV_aktiv", 0, profileFile ) );
    putValue( KCAN_FS_Lehne_nicht_verriegelt, getProfileInt( "Mem_FS_01", "FS_Lehne_nicht_verriegelt", 0, profileFile ) );
    putValue( KCAN_FS_LHV_aktiv, getProfileInt( "Mem_FS_01", "FS_LHV_aktiv", 0, profileFile ) );
    putValue( KCAN_FS_LKV_aktiv, getProfileInt( "Mem_FS_01", "FS_LKV_aktiv", 0, profileFile ) );
    putValue( KCAN_FS_LNV_aktiv, getProfileInt( "Mem_FS_01", "FS_LNV_aktiv", 0, profileFile ) );
    putValue( KCAN_FS_LWV_aktiv, getProfileInt( "Mem_FS_01", "FS_LWV_aktiv", 0, profileFile ) );
    putValue( KCAN_FS_MMB_glob_stop, getProfileInt( "Mem_FS_01", "FS_MMB_glob_stop", 0, profileFile ) );
    putValue( KCAN_FS_MMB_lokal_Stop, getProfileInt( "Mem_FS_01", "FS_MMB_lokal_Stop", 0, profileFile ) );
    putValue( KCAN_FS_MMB_storage, getProfileInt( "Mem_FS_01", "FS_MMB_storage", 0, profileFile ) );
    putValue( KCAN_FS_MMB_storage_beep, getProfileInt( "Mem_FS_01", "FS_MMB_storage_beep", 0, profileFile ) );
    putValue( KCAN_FS_MMB_store, getProfileInt( "Mem_FS_01", "FS_MMB_store", 0, profileFile ) );
    putValue( KCAN_FS_MMB_store_LED_on, getProfileInt( "Mem_FS_01", "FS_MMB_store_LED_on", 0, profileFile ) );
    putValue( KCAN_FS_MMB_tast, getProfileInt( "Mem_FS_01", "FS_MMB_tast", 0, profileFile ) );
    putValue( KCAN_FS_MMB_tipp, getProfileInt( "Mem_FS_01", "FS_MMB_tipp", 0, profileFile ) );
    putValue( KCAN_FS_SHV_aktiv, getProfileInt( "Mem_FS_01", "FS_SHV_aktiv", 0, profileFile ) );
    putValue( KCAN_FS_Sitzfahrt_aktiv, getProfileInt( "Mem_FS_01", "FS_Sitzfahrt_aktiv", 0, profileFile ) );
    putValue( KCAN_FS_SLV_aktiv, getProfileInt( "Mem_FS_01", "FS_SLV_aktiv", 0, profileFile ) );
    putValue( KCAN_FS_SNV_aktiv, getProfileInt( "Mem_FS_01", "FS_SNV_aktiv", 0, profileFile ) );
    putValue( KCAN_FS_Spezialposition_anfahren, getProfileInt( "Mem_FS_01", "FS_Spezialposition_anfahren", 0, profileFile ) );
    putValue( KCAN_FS_STV_aktiv, getProfileInt( "Mem_FS_01", "FS_STV_aktiv", 0, profileFile ) );

}


void loadSettings_MFG_01( char profileFile[] )
{
    putValue( KCAN_MF_Abzugssperre, getProfileInt( "MFG_01", "MF_Abzugssperre", 0, profileFile ) );
    putValue( KCAN_MF_Alarm_Blinker, getProfileInt( "MFG_01", "MF_Alarm_Blinker", 0, profileFile ) );
    putValue( KCAN_MF_Alarm_Blinkertakt, getProfileInt( "MFG_01", "MF_Alarm_Blinkertakt", 0, profileFile ) );
    putValue( KCAN_MF_Anlassersperre, getProfileInt( "MFG_01", "MF_Anlassersperre", 0, profileFile ) );
    putValue( KCAN_MF_Blk_li, getProfileInt( "MFG_01", "MF_Blk_li", 0, profileFile ) );
    putValue( KCAN_MF_Blk_re, getProfileInt( "MFG_01", "MF_Blk_re", 0, profileFile ) );
    putValue( KCAN_MF_BT_entriegeln, getProfileInt( "MFG_01", "MF_BT_entriegeln", 0, profileFile ) );
    putValue( KCAN_MF_BT_verriegeln, getProfileInt( "MFG_01", "MF_BT_verriegeln", 0, profileFile ) );
    putValue( KCAN_MF_Fahrlicht, getProfileInt( "MFG_01", "MF_Fahrlicht", 0, profileFile ) );
    putValue( KCAN_MF_Fernbed_ein, getProfileInt( "MFG_01", "MF_Fernbed_ein", 0, profileFile ) );
    putValue( KCAN_MF_Fernlicht, getProfileInt( "MFG_01", "MF_Fernlicht", 0, profileFile ) );
    putValue( KCAN_MF_FH_BT_hoch, getProfileInt( "MFG_01", "MF_FH_BT_hoch", 0, profileFile ) );
    putValue( KCAN_MF_FH_BT_tief, getProfileInt( "MFG_01", "MF_FH_BT_tief", 0, profileFile ) );
    putValue( KCAN_MF_FH_FT_hoch, getProfileInt( "MFG_01", "MF_FH_FT_hoch", 0, profileFile ) );
    putValue( KCAN_MF_FH_FT_tief, getProfileInt( "MFG_01", "MF_FH_FT_tief", 0, profileFile ) );
    putValue( KCAN_MF_Frontintervall, getProfileInt( "MFG_01", "MF_Frontintervall", 0, profileFile ) );
    putValue( KCAN_MF_Frontwaschen, getProfileInt( "MFG_01", "MF_Frontwaschen", 0, profileFile ) );
    putValue( KCAN_MF_FT_entriegeln, getProfileInt( "MFG_01", "MF_FT_entriegeln", 0, profileFile ) );
    putValue( KCAN_MF_FT_verriegeln, getProfileInt( "MFG_01", "MF_FT_verriegeln", 0, profileFile ) );
    putValue( KCAN_MF_Fussraumbel, getProfileInt( "MFG_01", "MF_Fussraumbel", 0, profileFile ) );
    putValue( KCAN_MF_HBFS_entriegeln, getProfileInt( "MFG_01", "MF_HBFS_entriegeln", 0, profileFile ) );
    putValue( KCAN_MF_HBFS_verriegeln, getProfileInt( "MFG_01", "MF_HBFS_verriegeln", 0, profileFile ) );
    putValue( KCAN_MF_Heckintervall, getProfileInt( "MFG_01", "MF_Heckintervall", 0, profileFile ) );
    putValue( KCAN_MF_Heckwaschen, getProfileInt( "MFG_01", "MF_Heckwaschen", 0, profileFile ) );
    putValue( KCAN_MF_HFS_entriegeln, getProfileInt( "MFG_01", "MF_HFS_entriegeln", 0, profileFile ) );
    putValue( KCAN_MF_HFS_verriegeln, getProfileInt( "MFG_01", "MF_HFS_verriegeln", 0, profileFile ) );
    putValue( KCAN_MF_Innenraumbel, getProfileInt( "MFG_01", "MF_Innenraumbel", 0, profileFile ) );
    putValue( KCAN_MF_Innenraumbel_Unterdrueck, getProfileInt( "MFG_01", "MF_Innenraumbel_Unterdrueck", 0, profileFile ) );
    putValue( KCAN_MF_interm_Fahrlicht, getProfileInt( "MFG_01", "MF_interm_Fahrlicht", 0, profileFile ) );
    putValue( KCAN_MF_interm_Fernlicht, getProfileInt( "MFG_01", "MF_interm_Fernlicht", 0, profileFile ) );
    putValue( KCAN_MF_interm_Takt, getProfileInt( "MFG_01", "MF_interm_Takt", 0, profileFile ) );
    putValue( KCAN_MF_Laderelais, getProfileInt( "MFG_01", "MF_Laderelais", 0, profileFile ) );
    putValue( KCAN_MF_Lichthupe, getProfileInt( "MFG_01", "MF_Lichthupe", 0, profileFile ) );
    putValue( KCAN_MF_Motorweiterlauf, getProfileInt( "MFG_01", "MF_Motorweiterlauf", 0, profileFile ) );
    putValue( KCAN_MF_nachtr_Stopp_Anf, getProfileInt( "MFG_01", "MF_nachtr_Stopp_Anf", 0, profileFile ) );
    putValue( KCAN_MF_Notstart, getProfileInt( "MFG_01", "MF_Notstart", 0, profileFile ) );
    putValue( KCAN_MF_Schluessel_scan, getProfileInt( "MFG_01", "MF_Schluessel_scan", 0, profileFile ) );
    putValue( KCAN_MF_Signalhorn, getProfileInt( "MFG_01", "MF_Signalhorn", 0, profileFile ) );
    putValue( KCAN_MF_Standlicht, getProfileInt( "MFG_01", "MF_Standlicht", 0, profileFile ) );
    putValue( KCAN_MF_StartStopp_Info, getProfileInt( "MFG_01", "MF_StartStopp_Info", 0, profileFile ) );
    putValue( KCAN_MF_Summer, getProfileInt( "MFG_01", "MF_Summer", 0, profileFile ) );
    putValue( KCAN_MF_TFL_Abschaltung, getProfileInt( "MFG_01", "MF_TFL_Abschaltung", 0, profileFile ) );
    putValue( KCAN_MF_Tippwischen, getProfileInt( "MFG_01", "MF_Tippwischen", 0, profileFile ) );
    putValue( KCAN_MF_Tuerentriegelung_hinten, getProfileInt( "MFG_01", "MF_Tuerentriegelung_hinten", 0, profileFile ) );
    putValue( KCAN_MF_Variante, getProfileInt( "MFG_01", "MF_Variante", 0, profileFile ) );
    putValue( KCAN_MF_Warnblinker, getProfileInt( "MFG_01", "MF_Warnblinker", 0, profileFile ) );
    putValue( KCAN_MF_Wischerstufe_1, getProfileInt( "MFG_01", "MF_Wischerstufe_1", 0, profileFile ) );
    putValue( KCAN_MF_Wischerstufe_2, getProfileInt( "MFG_01", "MF_Wischerstufe_2", 0, profileFile ) );
    putValue( KCAN_MF_ZV_Lock, getProfileInt( "MFG_01", "MF_ZV_Lock", 0, profileFile ) );

}


void loadSettings_MFL_01( char profileFile[] )
{
    putValue( KCAN_MFL_Dummy_0_Signal_1, getProfileInt( "MFL_01", "MFL_Dummy_0_Signal_1", 0, profileFile ) );
    putValue( KCAN_MFL_Dummy_0_Signal_3, getProfileInt( "MFL_01", "MFL_Dummy_0_Signal_3", 0, profileFile ) );
    putValue( KCAN_MFL_ECU_Err, getProfileInt( "MFL_01", "MFL_ECU_Err", 0, profileFile ) );
    putValue( KCAN_MFL_Eventcode_1_MFL_01, getProfileInt( "MFL_01", "MFL_Eventcode_1_MFL_01", 0, profileFile ) );
    putValue( KCAN_MFL_Eventcode_2_MFL_01, getProfileInt( "MFL_01", "MFL_Eventcode_2_MFL_01", 0, profileFile ) );
    putValue( KCAN_MFL_Fehler_Codierung, getProfileInt( "MFL_01", "MFL_Fehler_Codierung", 0, profileFile ) );
    putValue( KCAN_MFL_Lokalaktiv, getProfileInt( "MFL_01", "MFL_Lokalaktiv", 0, profileFile ) );
    putValue( KCAN_MFL_LR_HZG_Err, getProfileInt( "MFL_01", "MFL_LR_HZG_Err", 0, profileFile ) );
    putValue( KCAN_MFL_LR_HZG_Status, getProfileInt( "MFL_01", "MFL_LR_HZG_Status", 0, profileFile ) );
    putValue( KCAN_MFL_M_Taste, getProfileInt( "MFL_01", "MFL_M_Taste", 0, profileFile ) );
    putValue( KCAN_MFL_Marke_MFL_01, getProfileInt( "MFL_01", "MFL_Marke_MFL_01", 0, profileFile ) );
    putValue( KCAN_MFL_Paddle_Verbau, getProfileInt( "MFL_01", "MFL_Paddle_Verbau", 0, profileFile ) );
    putValue( KCAN_MFL_Response_Err, getProfileInt( "MFL_01", "MFL_Response_Err", 0, profileFile ) );
    putValue( KCAN_MFL_SatModul_links_Err, getProfileInt( "MFL_01", "MFL_SatModul_links_Err", 0, profileFile ) );
    putValue( KCAN_MFL_SatModul_rechts_Err, getProfileInt( "MFL_01", "MFL_SatModul_rechts_Err", 0, profileFile ) );
    putValue( KCAN_MFL_Signalhorn, getProfileInt( "MFL_01", "MFL_Signalhorn", 0, profileFile ) );
    putValue( KCAN_MFL_Signalhorn_Err, getProfileInt( "MFL_01", "MFL_Signalhorn_Err", 0, profileFile ) );
    putValue( KCAN_MFL_Taste_links_Err, getProfileInt( "MFL_01", "MFL_Taste_links_Err", 0, profileFile ) );
    putValue( KCAN_MFL_Taste_rechts_Err, getProfileInt( "MFL_01", "MFL_Taste_rechts_Err", 0, profileFile ) );
    putValue( KCAN_MFL_Tastencode_1_MFL_01, getProfileInt( "MFL_01", "MFL_Tastencode_1_MFL_01", 0, profileFile ) );
    putValue( KCAN_MFL_Tastencode_2_MFL_01, getProfileInt( "MFL_01", "MFL_Tastencode_2_MFL_01", 0, profileFile ) );
    putValue( KCAN_MFL_Tip_Down, getProfileInt( "MFL_01", "MFL_Tip_Down", 0, profileFile ) );
    putValue( KCAN_MFL_Tip_links_Err, getProfileInt( "MFL_01", "MFL_Tip_links_Err", 0, profileFile ) );
    putValue( KCAN_MFL_Tip_rechts_Err, getProfileInt( "MFL_01", "MFL_Tip_rechts_Err", 0, profileFile ) );
    putValue( KCAN_MFL_Tip_Up, getProfileInt( "MFL_01", "MFL_Tip_Up", 0, profileFile ) );
    putValue( KCAN_MFL_Toggle, getProfileInt( "MFL_01", "MFL_Toggle", 0, profileFile ) );
    putValue( KCAN_MFL_Variante_MFL_01, getProfileInt( "MFL_01", "MFL_Variante_MFL_01", 0, profileFile ) );
    putValue( KCAN_MFL_Zaehler, getProfileInt( "MFL_01", "MFL_Zaehler", 0, profileFile ) );

}


void loadSettings_MFL_02( char profileFile[] )
{
    putValue( KCAN_MFL_Beruehrungserkennung, getProfileInt( "MFL_02", "MFL_Beruehrungserkennung", 0, profileFile ) );
    putValue( KCAN_MFL_Touch_Event, getProfileInt( "MFL_02", "MFL_Touch_Event", 0, profileFile ) );

}


void loadSettings_MFL_Anf_01( char profileFile[] )
{
    putValue( KCAN_MFL_Taste_SDS_benoetigt, getProfileInt( "MFL_Anf_01", "MFL_Taste_SDS_benoetigt", 0, profileFile ) );
    putValue( KCAN_MFL_Tasten_UpDownOK_benoetigt, getProfileInt( "MFL_Anf_01", "MFL_Tasten_UpDownOK_benoetigt", 0, profileFile ) );
    putValue( KCAN_MFL_Tasten_Volume_benoetigt, getProfileInt( "MFL_Anf_01", "MFL_Tasten_Volume_benoetigt", 0, profileFile ) );
    putValue( KCAN_MFL_Vibrationsimpuls_links, getProfileInt( "MFL_Anf_01", "MFL_Vibrationsimpuls_links", 0, profileFile ) );
    putValue( KCAN_MFL_Vibrationsimpuls_rechts, getProfileInt( "MFL_Anf_01", "MFL_Vibrationsimpuls_rechts", 0, profileFile ) );

}


void loadSettings_MFL_Tasten_Kon_01( char profileFile[] )
{
    putValue( KCAN_MFL_Eventcode_1, getProfileInt( "MFL_Tasten_Kon_01", "MFL_Eventcode_1", 0, profileFile ) );
    putValue( KCAN_MFL_Eventcode_2, getProfileInt( "MFL_Tasten_Kon_01", "MFL_Eventcode_2", 0, profileFile ) );
    putValue( KCAN_MFL_Marke, getProfileInt( "MFL_Tasten_Kon_01", "MFL_Marke", 0, profileFile ) );
    putValue( KCAN_MFL_Tastencode_1, getProfileInt( "MFL_Tasten_Kon_01", "MFL_Tastencode_1", 0, profileFile ) );
    putValue( KCAN_MFL_Tastencode_2, getProfileInt( "MFL_Tasten_Kon_01", "MFL_Tastencode_2", 0, profileFile ) );
    putValue( KCAN_MFL_Variante, getProfileInt( "MFL_Tasten_Kon_01", "MFL_Variante", 0, profileFile ) );

}


void loadSettings_Motor_14( char profileFile[] )
{
    putValue( KCAN_MO_Aussp_Anlass, getProfileInt( "Motor_14", "MO_Aussp_Anlass", 0, profileFile ) );
    putValue( KCAN_MO_BKV_Unterdruckwarnung, getProfileInt( "Motor_14", "MO_BKV_Unterdruckwarnung", 0, profileFile ) );
    putValue( KCAN_MO_BLS, getProfileInt( "Motor_14", "MO_BLS", 0, profileFile ) );
    putValue( KCAN_MO_BMS_NV_Anf_stuetzen, getProfileInt( "Motor_14", "MO_BMS_NV_Anf_stuetzen", 0, profileFile ) );
    putValue( KCAN_MO_EKlKomLeiRed, getProfileInt( "Motor_14", "MO_EKlKomLeiRed", 0, profileFile ) );
    putValue( KCAN_MO_Ext_E_Fahrt_aktiv, getProfileInt( "Motor_14", "MO_Ext_E_Fahrt_aktiv", 0, profileFile ) );
    putValue( KCAN_MO_Fahrer_bremst, getProfileInt( "Motor_14", "MO_Fahrer_bremst", 0, profileFile ) );
    putValue( KCAN_MO_FMAus_aktiv, getProfileInt( "Motor_14", "MO_FMAus_aktiv", 0, profileFile ) );
    putValue( KCAN_MO_FMAus_Startvariante, getProfileInt( "Motor_14", "MO_FMAus_Startvariante", 0, profileFile ) );
    putValue( KCAN_MO_Freig_Anlass, getProfileInt( "Motor_14", "MO_Freig_Anlass", 0, profileFile ) );
    putValue( KCAN_MO_Freig_Reku, getProfileInt( "Motor_14", "MO_Freig_Reku", 0, profileFile ) );
    putValue( KCAN_MO_Freigabe_Segeln, getProfileInt( "Motor_14", "MO_Freigabe_Segeln", 0, profileFile ) );
    putValue( KCAN_MO_Gangposition, getProfileInt( "Motor_14", "MO_Gangposition", 0, profileFile ) );
    putValue( KCAN_MO_Handshake_STH, getProfileInt( "Motor_14", "MO_Handshake_STH", 0, profileFile ) );
    putValue( KCAN_MO_HYB_Fahrbereitschaft, getProfileInt( "Motor_14", "MO_HYB_Fahrbereitschaft", 0, profileFile ) );
    putValue( KCAN_MO_HYB_VM_aktiv, getProfileInt( "Motor_14", "MO_HYB_VM_aktiv", 0, profileFile ) );
    putValue( KCAN_MO_Interlock, getProfileInt( "Motor_14", "MO_Interlock", 0, profileFile ) );
    putValue( KCAN_MO_Kickdown, getProfileInt( "Motor_14", "MO_Kickdown", 0, profileFile ) );
    putValue( KCAN_MO_Kl_50, getProfileInt( "Motor_14", "MO_Kl_50", 0, profileFile ) );
    putValue( KCAN_MO_Kl_75, getProfileInt( "Motor_14", "MO_Kl_75", 0, profileFile ) );
    putValue( KCAN_MO_Klima_Eingr, getProfileInt( "Motor_14", "MO_Klima_Eingr", 0, profileFile ) );
    putValue( KCAN_MO_Konsistenz_Bremsped, getProfileInt( "Motor_14", "MO_Konsistenz_Bremsped", 0, profileFile ) );
    putValue( KCAN_MO_Kuppl_schalter, getProfileInt( "Motor_14", "MO_Kuppl_schalter", 0, profileFile ) );
    putValue( KCAN_MO_Motor_laeuft, getProfileInt( "Motor_14", "MO_Motor_laeuft", 0, profileFile ) );
    putValue( KCAN_MO_PTC_Status, getProfileInt( "Motor_14", "MO_PTC_Status", 0, profileFile ) );
    putValue( KCAN_MO_QBit_Fahrer_bremst, getProfileInt( "Motor_14", "MO_QBit_Fahrer_bremst", 0, profileFile ) );
    putValue( KCAN_MO_QBit_Gangposition, getProfileInt( "Motor_14", "MO_QBit_Gangposition", 0, profileFile ) );
    putValue( KCAN_MO_QBit_KL_75, getProfileInt( "Motor_14", "MO_QBit_KL_75", 0, profileFile ) );
    putValue( KCAN_MO_Remotestart_Betrieb, getProfileInt( "Motor_14", "MO_Remotestart_Betrieb", 0, profileFile ) );
    putValue( KCAN_MO_Remotestart_moeglich, getProfileInt( "Motor_14", "MO_Remotestart_moeglich", 0, profileFile ) );
    putValue( KCAN_MO_Signalquelle_Gangposition, getProfileInt( "Motor_14", "MO_Signalquelle_Gangposition", 0, profileFile ) );
    putValue( KCAN_MO_StartStopp_Fahrerwunsch, getProfileInt( "Motor_14", "MO_StartStopp_Fahrerwunsch", 0, profileFile ) );
    putValue( KCAN_MO_StartStopp_Motorstopp, getProfileInt( "Motor_14", "MO_StartStopp_Motorstopp", 0, profileFile ) );
    putValue( KCAN_MO_StartStopp_Status, getProfileInt( "Motor_14", "MO_StartStopp_Status", 0, profileFile ) );
    putValue( KCAN_MO_StartStopp_Wiederstart, getProfileInt( "Motor_14", "MO_StartStopp_Wiederstart", 0, profileFile ) );
    putValue( KCAN_MO_StartVorauss_erfuellt, getProfileInt( "Motor_14", "MO_StartVorauss_erfuellt", 0, profileFile ) );
    putValue( KCAN_MO_Timeout_ESP, getProfileInt( "Motor_14", "MO_Timeout_ESP", 0, profileFile ) );
    putValue( KCAN_MO_Zylinderabschaltung, getProfileInt( "Motor_14", "MO_Zylinderabschaltung", 0, profileFile ) );

}


void loadSettings_Motor_18( char profileFile[] )
{
    putValue( KCAN_MO1_Freigabe_Info_WFS, getProfileInt( "Motor_18", "MO1_Freigabe_Info_WFS", 0, profileFile ) );
    putValue( KCAN_MO1_Freigabe_Verfallsinfo_WFS, getProfileInt( "Motor_18", "MO1_Freigabe_Verfallsinfo_WFS", 0, profileFile ) );
    putValue( KCAN_MO1_Sperr_Info_WFS, getProfileInt( "Motor_18", "MO1_Sperr_Info_WFS", 0, profileFile ) );
    putValue( KCAN_MO_Abstellzeit, getProfileInt( "Motor_18", "MO_Abstellzeit", 0, profileFile ) );
    putValue( KCAN_MO_Abstellzeit_Status, getProfileInt( "Motor_18", "MO_Abstellzeit_Status", 0, profileFile ) );
    putValue( KCAN_MO_ANC_Kennfeld_Anf, getProfileInt( "Motor_18", "MO_ANC_Kennfeld_Anf", 0, profileFile ) );
    putValue( KCAN_MO_Anzahl_Abgesch_Zyl, getProfileInt( "Motor_18", "MO_Anzahl_Abgesch_Zyl", 0, profileFile ) );
    putValue( KCAN_MO_Bremslicht_Reku, getProfileInt( "Motor_18", "MO_Bremslicht_Reku", 0, profileFile ) );
    putValue( KCAN_MO_Drehzahl_Warnung, getProfileInt( "Motor_18", "MO_Drehzahl_Warnung", 0, profileFile ) );
    putValue( KCAN_MO_EPCL, getProfileInt( "Motor_18", "MO_EPCL", 0, profileFile ) );
    putValue( KCAN_MO_Ethanol_BS_Texte, getProfileInt( "Motor_18", "MO_Ethanol_BS_Texte", 0, profileFile ) );
    putValue( KCAN_MO_Fahrzeugtyp, getProfileInt( "Motor_18", "MO_Fahrzeugtyp", 0, profileFile ) );
    putValue( KCAN_MO_Fehler_Zylabsch, getProfileInt( "Motor_18", "MO_Fehler_Zylabsch", 0, profileFile ) );
    putValue( KCAN_MO_Hybrid_StartStopp_LED, getProfileInt( "Motor_18", "MO_Hybrid_StartStopp_LED", 0, profileFile ) );
    putValue( KCAN_MO_max_Ladedruck, getProfileFloat( "Motor_18", "MO_max_Ladedruck", 0, profileFile ) );
    putValue( KCAN_MO_NMAX_Schaltanzeige, getProfileInt( "Motor_18", "MO_NMAX_Schaltanzeige", 0, profileFile ) );
    putValue( KCAN_MO_obere_Drehzahlgrenze, getProfileInt( "Motor_18", "MO_obere_Drehzahlgrenze", 0, profileFile ) );
    putValue( KCAN_MO_StartStopp_PopUp, getProfileInt( "Motor_18", "MO_StartStopp_PopUp", 0, profileFile ) );
    putValue( KCAN_MO_Zylabsch_Texte, getProfileInt( "Motor_18", "MO_Zylabsch_Texte", 0, profileFile ) );
    putValue( KCAN_MO_Zylabsch_Texte_02, getProfileInt( "Motor_18", "MO_Zylabsch_Texte_02", 0, profileFile ) );

}


void loadSettings_Motor_26( char profileFile[] )
{
    putValue( KCAN_MO_E_Mode, getProfileInt( "Motor_26", "MO_E_Mode", 0, profileFile ) );
    putValue( KCAN_MO_E_Texte, getProfileInt( "Motor_26", "MO_E_Texte", 0, profileFile ) );
    putValue( KCAN_MO_E_Warnungen, getProfileInt( "Motor_26", "MO_E_Warnungen", 0, profileFile ) );
    putValue( KCAN_MO_EFLEX_Lampe, getProfileInt( "Motor_26", "MO_EFLEX_Lampe", 0, profileFile ) );
    putValue( KCAN_MO_Heissleuchte, getProfileInt( "Motor_26", "MO_Heissleuchte", 0, profileFile ) );
    putValue( KCAN_MO_ITM_Warnung_Pumpe, getProfileInt( "Motor_26", "MO_ITM_Warnung_Pumpe", 0, profileFile ) );
    putValue( KCAN_MO_KJS_nicht_bereit, getProfileInt( "Motor_26", "MO_KJS_nicht_bereit", 0, profileFile ) );
    putValue( KCAN_MO_Kuehlerluefter_1, getProfileInt( "Motor_26", "MO_Kuehlerluefter_1", 0, profileFile ) );
    putValue( KCAN_MO_Kuehlerluefter_2, getProfileInt( "Motor_26", "MO_Kuehlerluefter_2", 0, profileFile ) );
    putValue( KCAN_MO_Kuehlerluefter_MUX, getProfileInt( "Motor_26", "MO_Kuehlerluefter_MUX", 0, profileFile ) );
    putValue( KCAN_MO_OBD2_Lampe, getProfileInt( "Motor_26", "MO_OBD2_Lampe", 0, profileFile ) );
    putValue( KCAN_MO_Oelwarnung_max, getProfileInt( "Motor_26", "MO_Oelwarnung_max", 0, profileFile ) );
    putValue( KCAN_MO_Partikel_Lampe, getProfileInt( "Motor_26", "MO_Partikel_Lampe", 0, profileFile ) );
    putValue( KCAN_MO_RedFahrleistung_Lampe, getProfileInt( "Motor_26", "MO_RedFahrleistung_Lampe", 0, profileFile ) );
    putValue( KCAN_MO_Systemlampe, getProfileInt( "Motor_26", "MO_Systemlampe", 0, profileFile ) );
    putValue( KCAN_MO_Tankdeckel_Lampe, getProfileInt( "Motor_26", "MO_Tankdeckel_Lampe", 0, profileFile ) );
    putValue( KCAN_MO_Text_Motorstart, getProfileInt( "Motor_26", "MO_Text_Motorstart", 0, profileFile ) );
    putValue( KCAN_MO_Text_Partikelfil_Reg, getProfileInt( "Motor_26", "MO_Text_Partikelfil_Reg", 0, profileFile ) );
    putValue( KCAN_MO_Text_Tankdeckelwarn, getProfileInt( "Motor_26", "MO_Text_Tankdeckelwarn", 0, profileFile ) );
    putValue( KCAN_MO_Vorglueh_Lampe, getProfileInt( "Motor_26", "MO_Vorglueh_Lampe", 0, profileFile ) );
    putValue( KCAN_MO_Zustand_HWP, getProfileInt( "Motor_26", "MO_Zustand_HWP", 0, profileFile ) );
    putValue( KCAN_OLEV_Oelstand_nicht_vorhanden, getProfileInt( "Motor_26", "OLEV_Oelstand_nicht_vorhanden", 0, profileFile ) );
    putValue( KCAN_OLEV_Systemstoerung, getProfileInt( "Motor_26", "OLEV_Systemstoerung", 0, profileFile ) );
    putValue( KCAN_WIV_Anzeige_aktiv, getProfileInt( "Motor_26", "WIV_Anzeige_aktiv", 0, profileFile ) );
    putValue( KCAN_WIV_laufender_Motor, getProfileInt( "Motor_26", "WIV_laufender_Motor", 0, profileFile ) );
    putValue( KCAN_WIV_nachfuellanzeige_ein, getProfileInt( "Motor_26", "WIV_nachfuellanzeige_ein", 0, profileFile ) );
    putValue( KCAN_WIV_nicht_betriebswarm, getProfileInt( "Motor_26", "WIV_nicht_betriebswarm", 0, profileFile ) );
    putValue( KCAN_WIV_Oeldr_Warn_Motor, getProfileInt( "Motor_26", "WIV_Oeldr_Warn_Motor", 0, profileFile ) );
    putValue( KCAN_WIV_Oeldyn_avl, getProfileInt( "Motor_26", "WIV_Oeldyn_avl", 0, profileFile ) );
    putValue( KCAN_WIV_Oelmenge, getProfileInt( "Motor_26", "WIV_Oelmenge", 0, profileFile ) );
    putValue( KCAN_WIV_Oelmin_Warn, getProfileInt( "Motor_26", "WIV_Oelmin_Warn", 0, profileFile ) );
    putValue( KCAN_WIV_Oelstand, getProfileFloat( "Motor_26", "WIV_Oelstand", 0, profileFile ) );
    putValue( KCAN_WIV_Oelstand_nicht_vorhanden, getProfileInt( "Motor_26", "WIV_Oelstand_nicht_vorhanden", 0, profileFile ) );
    putValue( KCAN_WIV_Oelsystem_aktiv, getProfileInt( "Motor_26", "WIV_Oelsystem_aktiv", 0, profileFile ) );
    putValue( KCAN_WIV_Schieflage, getProfileInt( "Motor_26", "WIV_Schieflage", 0, profileFile ) );
    putValue( KCAN_WIV_Sensorfehler, getProfileInt( "Motor_26", "WIV_Sensorfehler", 0, profileFile ) );
    putValue( KCAN_WIV_Ueberfuell_deaktiv, getProfileInt( "Motor_26", "WIV_Ueberfuell_deaktiv", 0, profileFile ) );
    putValue( KCAN_WIV_Ueberfuell_Warn, getProfileInt( "Motor_26", "WIV_Ueberfuell_Warn", 0, profileFile ) );
    putValue( KCAN_WIV_Unterfuell_Warn, getProfileInt( "Motor_26", "WIV_Unterfuell_Warn", 0, profileFile ) );

}


void loadSettings_Motor_41( char profileFile[] )
{
    putValue( KCAN_FDR_Warnung_ALR, getProfileInt( "Motor_41", "FDR_Warnung_ALR", 0, profileFile ) );
    putValue( KCAN_MO_ADR_Status, getProfileInt( "Motor_41", "MO_ADR_Status", 0, profileFile ) );
    putValue( KCAN_MO_AGA_Sound_Texte, getProfileInt( "Motor_41", "MO_AGA_Sound_Texte", 0, profileFile ) );
    putValue( KCAN_MO_Anz_Kuehlerluefter, getProfileInt( "Motor_41", "MO_Anz_Kuehlerluefter", 0, profileFile ) );
    putValue( KCAN_MO_Anzeige_FMAus_Text, getProfileInt( "Motor_41", "MO_Anzeige_FMAus_Text", 0, profileFile ) );
    putValue( KCAN_MO_Anzeige_StSt_Symbol, getProfileInt( "Motor_41", "MO_Anzeige_StSt_Symbol", 0, profileFile ) );
    putValue( KCAN_MO_Anzeige_StSt_Text, getProfileInt( "Motor_41", "MO_Anzeige_StSt_Text", 0, profileFile ) );
    putValue( KCAN_MO_ElAntrieb_Abschleppwarnung, getProfileInt( "Motor_41", "MO_ElAntrieb_Abschleppwarnung", 0, profileFile ) );
    putValue( KCAN_MO_EM_Ueberhitzungswarnung, getProfileInt( "Motor_41", "MO_EM_Ueberhitzungswarnung", 0, profileFile ) );
    putValue( KCAN_MO_Powermeter_Dauer_Grenze, getProfileInt( "Motor_41", "MO_Powermeter_Dauer_Grenze", 0, profileFile ) );
    putValue( KCAN_MO_Rekuperationsstufe, getProfileInt( "Motor_41", "MO_Rekuperationsstufe", 0, profileFile ) );
    putValue( KCAN_PEA_Texte, getProfileInt( "Motor_41", "PEA_Texte", 0, profileFile ) );
    putValue( KCAN_TSK_Einheit_vMax_FahrerInfo, getProfileInt( "Motor_41", "TSK_Einheit_vMax_FahrerInfo", 0, profileFile ) );
    putValue( KCAN_TSK_Status_vMax_FahrerInfo, getProfileInt( "Motor_41", "TSK_Status_vMax_FahrerInfo", 0, profileFile ) );
    putValue( KCAN_TSK_Ueberstimmt_vMax_FahrerInfo, getProfileInt( "Motor_41", "TSK_Ueberstimmt_vMax_FahrerInfo", 0, profileFile ) );
    putValue( KCAN_TSK_vMax_FahrerInfo, getProfileInt( "Motor_41", "TSK_vMax_FahrerInfo", 0, profileFile ) );

}


void loadSettings_Motor_51( char profileFile[] )
{
    putValue( KCAN_GRA_KuFu_aktiv, getProfileInt( "Motor_51", "GRA_KuFu_aktiv", 0, profileFile ) );
    putValue( KCAN_LIM_KuFu_aktiv, getProfileInt( "Motor_51", "LIM_KuFu_aktiv", 0, profileFile ) );
    putValue( KCAN_MO_Entkopplung_Sollschlupf, getProfileInt( "Motor_51", "MO_Entkopplung_Sollschlupf", 0, profileFile ) );
    putValue( KCAN_MO_Fahrpedalgradient, getProfileInt( "Motor_51", "MO_Fahrpedalgradient", 0, profileFile ) );
    putValue( KCAN_MO_Fahrpedalrohwert_01, getProfileFloat( "Motor_51", "MO_Fahrpedalrohwert_01", 0, profileFile ) );
    putValue( KCAN_MO_Moment_im_Leerlauf, getProfileInt( "Motor_51", "MO_Moment_im_Leerlauf", 0, profileFile ) );
    putValue( KCAN_MO_QBit_Fahrpedalwerte_01, getProfileInt( "Motor_51", "MO_QBit_Fahrpedalwerte_01", 0, profileFile ) );
    putValue( KCAN_MO_rel_Saugrohrdruck, getProfileInt( "Motor_51", "MO_rel_Saugrohrdruck", 0, profileFile ) );
    putValue( KCAN_MO_rel_Saugrohrdruck_gem_err, getProfileInt( "Motor_51", "MO_rel_Saugrohrdruck_gem_err", 0, profileFile ) );
    putValue( KCAN_MO_Schubabschaltung, getProfileInt( "Motor_51", "MO_Schubabschaltung", 0, profileFile ) );
    putValue( KCAN_MO_Sig_Fahrpedalgradient, getProfileInt( "Motor_51", "MO_Sig_Fahrpedalgradient", 0, profileFile ) );
    putValue( KCAN_MO_Solldrehz_Leerlauf, getProfileInt( "Motor_51", "MO_Solldrehz_Leerlauf", 0, profileFile ) );
    putValue( KCAN_MO_StartStopp_StoppVorbereitung, getProfileInt( "Motor_51", "MO_StartStopp_StoppVorbereitung", 0, profileFile ) );
    putValue( KCAN_MO_Status_MaxDrzEingriff, getProfileInt( "Motor_51", "MO_Status_MaxDrzEingriff", 0, profileFile ) );
    putValue( KCAN_MO_Status_MaxDrzEingriff_sek, getProfileInt( "Motor_51", "MO_Status_MaxDrzEingriff_sek", 0, profileFile ) );
    putValue( KCAN_MO_Status_MinDrzEingriff, getProfileInt( "Motor_51", "MO_Status_MinDrzEingriff", 0, profileFile ) );
    putValue( KCAN_MO_Status_MinDrzEingriff_sek, getProfileInt( "Motor_51", "MO_Status_MinDrzEingriff_sek", 0, profileFile ) );
    putValue( KCAN_MO_temporaere_Fahrerabwesenheit, getProfileInt( "Motor_51", "MO_temporaere_Fahrerabwesenheit", 0, profileFile ) );
    putValue( KCAN_TSK_a_Soll_gradientenbegrenzt, getProfileFloat( "Motor_51", "TSK_a_Soll_gradientenbegrenzt", 0, profileFile ) );
    putValue( KCAN_TSK_ax_Getriebe_02, getProfileFloat( "Motor_51", "TSK_ax_Getriebe_02", 0, profileFile ) );
    putValue( KCAN_TSK_Freig_Verzoeg_Anf, getProfileInt( "Motor_51", "TSK_Freig_Verzoeg_Anf", 0, profileFile ) );
    putValue( KCAN_TSK_Freig_WU, getProfileInt( "Motor_51", "TSK_Freig_WU", 0, profileFile ) );
    putValue( KCAN_TSK_Hauptschalter_GRA_ACC, getProfileInt( "Motor_51", "TSK_Hauptschalter_GRA_ACC", 0, profileFile ) );
    putValue( KCAN_TSK_Limiter_ausgewaehlt_Motor_51, getProfileInt( "Motor_51", "TSK_Limiter_ausgewaehlt_Motor_51", 0, profileFile ) );
    putValue( KCAN_TSK_Notstopp_Anf, getProfileInt( "Motor_51", "TSK_Notstopp_Anf", 0, profileFile ) );
    putValue( KCAN_TSK_Radbremsmom, getProfileInt( "Motor_51", "TSK_Radbremsmom", 0, profileFile ) );
    putValue( KCAN_TSK_Radsollmoment, getProfileFloat( "Motor_51", "TSK_Radsollmoment", 0, profileFile ) );
    putValue( KCAN_TSK_SRBM_Anf_ASIL, getProfileInt( "Motor_51", "TSK_SRBM_Anf_ASIL", 0, profileFile ) );
    putValue( KCAN_TSK_SRBM_max_Gradient, getProfileInt( "Motor_51", "TSK_SRBM_max_Gradient", 0, profileFile ) );
    putValue( KCAN_TSK_Standby_Anf_ESP, getProfileInt( "Motor_51", "TSK_Standby_Anf_ESP", 0, profileFile ) );
    putValue( KCAN_TSK_Status, getProfileInt( "Motor_51", "TSK_Status", 0, profileFile ) );
    putValue( KCAN_TSK_v_Begrenzung_aktiv, getProfileInt( "Motor_51", "TSK_v_Begrenzung_aktiv", 0, profileFile ) );
    putValue( KCAN_TSK_Wunsch_Uebersetz, getProfileFloat( "Motor_51", "TSK_Wunsch_Uebersetz", 0, profileFile ) );
    putValue( KCAN_TSK_zul_Regelabw, getProfileFloat( "Motor_51", "TSK_zul_Regelabw", 0, profileFile ) );
    putValue( KCAN_TSK_Zwangszusch_ESP, getProfileInt( "Motor_51", "TSK_Zwangszusch_ESP", 0, profileFile ) );

}


void loadSettings_Motor_52( char profileFile[] )
{
    putValue( KCAN_Ladezustand_02, getProfileFloat( "Motor_52", "Ladezustand_02", 0, profileFile ) );
    putValue( KCAN_Ladezustand_gering, getProfileInt( "Motor_52", "Ladezustand_gering", 0, profileFile ) );
    putValue( KCAN_MO_Anzeige_Drehmoment, getProfileInt( "Motor_52", "MO_Anzeige_Drehmoment", 0, profileFile ) );
    putValue( KCAN_MO_Anzeige_Leistung, getProfileFloat( "Motor_52", "MO_Anzeige_Leistung", 0, profileFile ) );
    putValue( KCAN_MO_Anzeige_Verbr_Einheit, getProfileInt( "Motor_52", "MO_Anzeige_Verbr_Einheit", 0, profileFile ) );
    putValue( KCAN_MO_Anzeigedrehz, getProfileInt( "Motor_52", "MO_Anzeigedrehz", 0, profileFile ) );
    putValue( KCAN_MO_Effizienzmodus, getProfileInt( "Motor_52", "MO_Effizienzmodus", 0, profileFile ) );
    putValue( KCAN_MO_ePerformance, getProfileFloat( "Motor_52", "MO_ePerformance", 0, profileFile ) );
    putValue( KCAN_MO_ePowermeter, getProfileFloat( "Motor_52", "MO_ePowermeter", 0, profileFile ) );
    putValue( KCAN_MO_Fehler_Oeldrucksensor, getProfileInt( "Motor_52", "MO_Fehler_Oeldrucksensor", 0, profileFile ) );
    putValue( KCAN_MO_Hochschaltdrehz, getProfileInt( "Motor_52", "MO_Hochschaltdrehz", 0, profileFile ) );
    putValue( KCAN_MO_Istgang, getProfileInt( "Motor_52", "MO_Istgang", 0, profileFile ) );
    putValue( KCAN_MO_KVS, getProfileInt( "Motor_52", "MO_KVS", 0, profileFile ) );
    putValue( KCAN_MO_KVS_Ueberlauf, getProfileInt( "Motor_52", "MO_KVS_Ueberlauf", 0, profileFile ) );
    putValue( KCAN_MO_Ladedruck, getProfileFloat( "Motor_52", "MO_Ladedruck", 0, profileFile ) );
    putValue( KCAN_MO_Oeldruck, getProfileFloat( "Motor_52", "MO_Oeldruck", 0, profileFile ) );
    putValue( KCAN_MO_Powermeter, getProfileInt( "Motor_52", "MO_Powermeter", 0, profileFile ) );
    putValue( KCAN_MO_Powermeter_Elm_02, getProfileFloat( "Motor_52", "MO_Powermeter_Elm_02", 0, profileFile ) );
    putValue( KCAN_MO_rel_Ladedruck, getProfileFloat( "Motor_52", "MO_rel_Ladedruck", 0, profileFile ) );
    putValue( KCAN_MO_Schaltblitz_Anz, getProfileInt( "Motor_52", "MO_Schaltblitz_Anz", 0, profileFile ) );
    putValue( KCAN_MO_Schaltempf_verfbar, getProfileInt( "Motor_52", "MO_Schaltempf_verfbar", 0, profileFile ) );
    putValue( KCAN_MO_Sollgang, getProfileInt( "Motor_52", "MO_Sollgang", 0, profileFile ) );
    putValue( KCAN_MO_Zust_Antrieb, getProfileInt( "Motor_52", "MO_Zust_Antrieb", 0, profileFile ) );
    putValue( KCAN_MO_Zust_Betriebsstrategie, getProfileInt( "Motor_52", "MO_Zust_Betriebsstrategie", 0, profileFile ) );

}


void loadSettings_Motor_53( char profileFile[] )
{
    putValue( KCAN_MO_Antriebsstrang_Warnung_HS, getProfileInt( "Motor_53", "MO_Antriebsstrang_Warnung_HS", 0, profileFile ) );
    putValue( KCAN_MO_Anzeige_Betriebsmodus, getProfileInt( "Motor_53", "MO_Anzeige_Betriebsmodus", 0, profileFile ) );
    putValue( KCAN_MO_Anzeige_Fahrbereitschaft, getProfileInt( "Motor_53", "MO_Anzeige_Fahrbereitschaft", 0, profileFile ) );
    putValue( KCAN_MO_Anzeige_Rekuperation, getProfileFloat( "Motor_53", "MO_Anzeige_Rekuperation", 0, profileFile ) );
    putValue( KCAN_MO_Anzeige_Verbrauch_oE, getProfileFloat( "Motor_53", "MO_Anzeige_Verbrauch_oE", 0, profileFile ) );
    putValue( KCAN_MO_Boost_aktiv, getProfileInt( "Motor_53", "MO_Boost_aktiv", 0, profileFile ) );
    putValue( KCAN_MO_Boost_verfuegbar, getProfileFloat( "Motor_53", "MO_Boost_verfuegbar", 0, profileFile ) );
    putValue( KCAN_MO_BZS_Charisma_FahrPr, getProfileInt( "Motor_53", "MO_BZS_Charisma_FahrPr", 0, profileFile ) );
    putValue( KCAN_MO_BZS_Charisma_Status, getProfileInt( "Motor_53", "MO_BZS_Charisma_Status", 0, profileFile ) );
    putValue( KCAN_MO_Charisma_FahrPr, getProfileInt( "Motor_53", "MO_Charisma_FahrPr", 0, profileFile ) );
    putValue( KCAN_MO_Charisma_Status, getProfileInt( "Motor_53", "MO_Charisma_Status", 0, profileFile ) );
    putValue( KCAN_MO_Drehzahlbeeinflussung, getProfileFloat( "Motor_53", "MO_Drehzahlbeeinflussung", 0, profileFile ) );
    putValue( KCAN_MO_Luftpfad_aktiv, getProfileInt( "Motor_53", "MO_Luftpfad_aktiv", 0, profileFile ) );
    putValue( KCAN_MO_MAX_Wunschdrehzahl, getProfileInt( "Motor_53", "MO_MAX_Wunschdrehzahl", 0, profileFile ) );
    putValue( KCAN_MO_MIN_Wunschdrehzahl, getProfileInt( "Motor_53", "MO_MIN_Wunschdrehzahl", 0, profileFile ) );
    putValue( KCAN_MO_Motorlaufwarnung, getProfileInt( "Motor_53", "MO_Motorlaufwarnung", 0, profileFile ) );
    putValue( KCAN_MO_NGS_Position, getProfileInt( "Motor_53", "MO_NGS_Position", 0, profileFile ) );
    putValue( KCAN_MO_NGS_Status, getProfileInt( "Motor_53", "MO_NGS_Status", 0, profileFile ) );
    putValue( KCAN_MO_Overboost, getProfileInt( "Motor_53", "MO_Overboost", 0, profileFile ) );
    putValue( KCAN_MO_Prio_MAX_Wunschdrehzahl, getProfileInt( "Motor_53", "MO_Prio_MAX_Wunschdrehzahl", 0, profileFile ) );
    putValue( KCAN_MO_Prio_MIN_Wunschdrehzahl, getProfileInt( "Motor_53", "MO_Prio_MIN_Wunschdrehzahl", 0, profileFile ) );
    putValue( KCAN_MO_Rampenzeit_Generator_Anf, getProfileInt( "Motor_53", "MO_Rampenzeit_Generator_Anf", 0, profileFile ) );
    putValue( KCAN_MO_Sperrung_FahrPr_BZS, getProfileInt( "Motor_53", "MO_Sperrung_FahrPr_BZS", 0, profileFile ) );
    putValue( KCAN_MO_StSt_Charisma_FahrPr, getProfileInt( "Motor_53", "MO_StSt_Charisma_FahrPr", 0, profileFile ) );
    putValue( KCAN_MO_StSt_Charisma_Status, getProfileInt( "Motor_53", "MO_StSt_Charisma_Status", 0, profileFile ) );
    putValue( KCAN_MO_v_Begrenz_Aktivierbar, getProfileInt( "Motor_53", "MO_v_Begrenz_Aktivierbar", 0, profileFile ) );
    putValue( KCAN_MO_v_Begrenzung_Niveau, getProfileInt( "Motor_53", "MO_v_Begrenzung_Niveau", 0, profileFile ) );
    putValue( KCAN_PEA_Abschalttexte, getProfileInt( "Motor_53", "PEA_Abschalttexte", 0, profileFile ) );
    putValue( KCAN_PEA_Ereignisanzeige, getProfileInt( "Motor_53", "PEA_Ereignisanzeige", 0, profileFile ) );
    putValue( KCAN_PEA_Ereignisanzeige_temporaer, getProfileInt( "Motor_53", "PEA_Ereignisanzeige_temporaer", 0, profileFile ) );
    putValue( KCAN_PEA_Fortschrittsanzeige, getProfileInt( "Motor_53", "PEA_Fortschrittsanzeige", 0, profileFile ) );
    putValue( KCAN_PEA_Hinweis, getProfileInt( "Motor_53", "PEA_Hinweis", 0, profileFile ) );
    putValue( KCAN_PEA_Zielgeschw, getProfileInt( "Motor_53", "PEA_Zielgeschw", 0, profileFile ) );
    putValue( KCAN_PEA_Zielgeschw_Einheit, getProfileInt( "Motor_53", "PEA_Zielgeschw_Einheit", 0, profileFile ) );
    putValue( KCAN_TSK_Akustik, getProfileInt( "Motor_53", "TSK_Akustik", 0, profileFile ) );
    putValue( KCAN_TSK_Fahrzeugstatus_GRA, getProfileInt( "Motor_53", "TSK_Fahrzeugstatus_GRA", 0, profileFile ) );
    putValue( KCAN_TSK_Fahrzeugstatus_Limiter, getProfileInt( "Motor_53", "TSK_Fahrzeugstatus_Limiter", 0, profileFile ) );
    putValue( KCAN_TSK_Fahrzeugstatus_praed_Fkt, getProfileInt( "Motor_53", "TSK_Fahrzeugstatus_praed_Fkt", 0, profileFile ) );
    putValue( KCAN_TSK_Limiter_Anzeige, getProfileInt( "Motor_53", "TSK_Limiter_Anzeige", 0, profileFile ) );
    putValue( KCAN_TSK_Limiter_Fahrerinfo, getProfileInt( "Motor_53", "TSK_Limiter_Fahrerinfo", 0, profileFile ) );
    putValue( KCAN_TSK_naechstes_Event, getProfileInt( "Motor_53", "TSK_naechstes_Event", 0, profileFile ) );
    putValue( KCAN_TSK_naechstes_Event_Einheit, getProfileInt( "Motor_53", "TSK_naechstes_Event_Einheit", 0, profileFile ) );
    putValue( KCAN_TSK_praed_Wunschgeschw, getProfileFloat( "Motor_53", "TSK_praed_Wunschgeschw", 0, profileFile ) );
    putValue( KCAN_TSK_praediktiver_Automode, getProfileInt( "Motor_53", "TSK_praediktiver_Automode", 0, profileFile ) );
    putValue( KCAN_TSK_praediktiver_Hinweis, getProfileInt( "Motor_53", "TSK_praediktiver_Hinweis", 0, profileFile ) );
    putValue( KCAN_TSK_Status_Anzeige, getProfileInt( "Motor_53", "TSK_Status_Anzeige", 0, profileFile ) );
    putValue( KCAN_TSK_Texte, getProfileInt( "Motor_53", "TSK_Texte", 0, profileFile ) );
    putValue( KCAN_TSK_Texte_Primaeranz, getProfileInt( "Motor_53", "TSK_Texte_Primaeranz", 0, profileFile ) );
    putValue( KCAN_TSK_Wunschgeschw, getProfileFloat( "Motor_53", "TSK_Wunschgeschw", 0, profileFile ) );

}


void loadSettings_Motor_54( char profileFile[] )
{
    putValue( KCAN_FoD_DTC_TSK_ACC, getProfileInt( "Motor_54", "FoD_DTC_TSK_ACC", 0, profileFile ) );
    putValue( KCAN_FoD_DTC_TSK_GRA, getProfileInt( "Motor_54", "FoD_DTC_TSK_GRA", 0, profileFile ) );
    putValue( KCAN_ISA_Regelung_aktiv, getProfileInt( "Motor_54", "ISA_Regelung_aktiv", 0, profileFile ) );
    putValue( KCAN_ISA_Status, getProfileInt( "Motor_54", "ISA_Status", 0, profileFile ) );
    putValue( KCAN_ISA_Tempolimitwarnung, getProfileInt( "Motor_54", "ISA_Tempolimitwarnung", 0, profileFile ) );
    putValue( KCAN_KVA_Ist_Pos, getProfileInt( "Motor_54", "KVA_Ist_Pos", 0, profileFile ) );
    putValue( KCAN_MO_Anforderung_HMS, getProfileInt( "Motor_54", "MO_Anforderung_HMS", 0, profileFile ) );
    putValue( KCAN_MO_EBoost_verf_praed, getProfileInt( "Motor_54", "MO_EBoost_verf_praed", 0, profileFile ) );
    putValue( KCAN_MO_eLaunch_verf, getProfileInt( "Motor_54", "MO_eLaunch_verf", 0, profileFile ) );
    putValue( KCAN_MO_Fahrbereitschaft, getProfileInt( "Motor_54", "MO_Fahrbereitschaft", 0, profileFile ) );
    putValue( KCAN_MO_Freilauf_Info, getProfileInt( "Motor_54", "MO_Freilauf_Info", 0, profileFile ) );
    putValue( KCAN_MO_Freilauf_Status, getProfileInt( "Motor_54", "MO_Freilauf_Status", 0, profileFile ) );
    putValue( KCAN_MO_Heckspoiler_Anf, getProfileInt( "Motor_54", "MO_Heckspoiler_Anf", 0, profileFile ) );
    putValue( KCAN_MO_Krit_Heckobjekt, getProfileInt( "Motor_54", "MO_Krit_Heckobjekt", 0, profileFile ) );
    putValue( KCAN_MO_LaunchControl, getProfileInt( "Motor_54", "MO_LaunchControl", 0, profileFile ) );
    putValue( KCAN_MO_NGS_Gangpos, getProfileInt( "Motor_54", "MO_NGS_Gangpos", 0, profileFile ) );
    putValue( KCAN_MO_Positionierung_aktiv, getProfileInt( "Motor_54", "MO_Positionierung_aktiv", 0, profileFile ) );
    putValue( KCAN_MO_QBit_Aussen_Temp, getProfileInt( "Motor_54", "MO_QBit_Aussen_Temp", 0, profileFile ) );
    putValue( KCAN_MO_Red_El_Fahrleistung, getProfileInt( "Motor_54", "MO_Red_El_Fahrleistung", 0, profileFile ) );
    putValue( KCAN_MO_Servicemodus, getProfileInt( "Motor_54", "MO_Servicemodus", 0, profileFile ) );
    putValue( KCAN_MO_Startwunsch, getProfileInt( "Motor_54", "MO_Startwunsch", 0, profileFile ) );
    putValue( KCAN_OBD_Abs_Load_Val, getProfileFloat( "Motor_54", "OBD_Abs_Load_Val", 0, profileFile ) );
    putValue( KCAN_OBD_Abs_Pedal_Pos, getProfileFloat( "Motor_54", "OBD_Abs_Pedal_Pos", 0, profileFile ) );
    putValue( KCAN_OBD_Abs_Throttle_Pos, getProfileFloat( "Motor_54", "OBD_Abs_Throttle_Pos", 0, profileFile ) );
    putValue( KCAN_OBD_Aussen_Temp_gef, getProfileInt( "Motor_54", "OBD_Aussen_Temp_gef", 0, profileFile ) );
    putValue( KCAN_OBD_Calc_Load_Val, getProfileFloat( "Motor_54", "OBD_Calc_Load_Val", 0, profileFile ) );
    putValue( KCAN_OBD_ClearMem_Inhibit, getProfileInt( "Motor_54", "OBD_ClearMem_Inhibit", 0, profileFile ) );
    putValue( KCAN_OBD_Driving_Cycle, getProfileInt( "Motor_54", "OBD_Driving_Cycle", 0, profileFile ) );
    putValue( KCAN_OBD_Eng_Cool_Temp, getProfileInt( "Motor_54", "OBD_Eng_Cool_Temp", 0, profileFile ) );
    putValue( KCAN_OBD_Kaltstart_Denominator, getProfileInt( "Motor_54", "OBD_Kaltstart_Denominator", 0, profileFile ) );
    putValue( KCAN_OBD_Minimum_Trip, getProfileInt( "Motor_54", "OBD_Minimum_Trip", 0, profileFile ) );
    putValue( KCAN_OBD_Normed_Trip, getProfileInt( "Motor_54", "OBD_Normed_Trip", 0, profileFile ) );
    putValue( KCAN_OBD_Sperrung_IUMPR, getProfileInt( "Motor_54", "OBD_Sperrung_IUMPR", 0, profileFile ) );
    putValue( KCAN_OBD_Sperrung_Kaltstart_Denom, getProfileInt( "Motor_54", "OBD_Sperrung_Kaltstart_Denom", 0, profileFile ) );
    putValue( KCAN_OBD_Warm_Up_Cycle, getProfileInt( "Motor_54", "OBD_Warm_Up_Cycle", 0, profileFile ) );
    putValue( KCAN_TSK_ACC_FoD_Status, getProfileInt( "Motor_54", "TSK_ACC_FoD_Status", 0, profileFile ) );
    putValue( KCAN_TSK_aktives_System, getProfileInt( "Motor_54", "TSK_aktives_System", 0, profileFile ) );
    putValue( KCAN_TSK_Anf_Antriebsmoment, getProfileInt( "Motor_54", "TSK_Anf_Antriebsmoment", 0, profileFile ) );
    putValue( KCAN_TSK_Einheit_vMax_Fahrerassistenz, getProfileInt( "Motor_54", "TSK_Einheit_vMax_Fahrerassistenz", 0, profileFile ) );
    putValue( KCAN_TSK_erhoehter_Fahrwiderstand, getProfileInt( "Motor_54", "TSK_erhoehter_Fahrwiderstand", 0, profileFile ) );
    putValue( KCAN_TSK_GRA_FoD_Status, getProfileInt( "Motor_54", "TSK_GRA_FoD_Status", 0, profileFile ) );
    putValue( KCAN_TSK_Status_ARA, getProfileInt( "Motor_54", "TSK_Status_ARA", 0, profileFile ) );
    putValue( KCAN_TSK_Status_EA, getProfileInt( "Motor_54", "TSK_Status_EA", 0, profileFile ) );
    putValue( KCAN_TSK_Status_IPA, getProfileInt( "Motor_54", "TSK_Status_IPA", 0, profileFile ) );
    putValue( KCAN_TSK_Status_PLA, getProfileInt( "Motor_54", "TSK_Status_PLA", 0, profileFile ) );
    putValue( KCAN_TSK_vMax_aktuell, getProfileInt( "Motor_54", "TSK_vMax_aktuell", 0, profileFile ) );
    putValue( KCAN_TSK_vMax_Fahrerassistenz, getProfileInt( "Motor_54", "TSK_vMax_Fahrerassistenz", 0, profileFile ) );

}


void loadSettings_Motor_57( char profileFile[] )
{
    putValue( KCAN_MO_Drehzahl_EM, getProfileInt( "Motor_57", "MO_Drehzahl_EM", 0, profileFile ) );
    putValue( KCAN_MO_Drehzahl_EM_sek, getProfileInt( "Motor_57", "MO_Drehzahl_EM_sek", 0, profileFile ) );
    putValue( KCAN_MO_EM1_Generator_Leistung, getProfileInt( "Motor_57", "MO_EM1_Generator_Leistung", 0, profileFile ) );
    putValue( KCAN_MO_EM1_Max_Leistung_Gesamt, getProfileInt( "Motor_57", "MO_EM1_Max_Leistung_Gesamt", 0, profileFile ) );
    putValue( KCAN_MO_EM1_Max_Spannung_Lim, getProfileInt( "Motor_57", "MO_EM1_Max_Spannung_Lim", 0, profileFile ) );
    putValue( KCAN_MO_EM1_Min_Leistung_Gesamt, getProfileInt( "Motor_57", "MO_EM1_Min_Leistung_Gesamt", 0, profileFile ) );
    putValue( KCAN_MO_EM1_Min_Spannung_Lim, getProfileInt( "Motor_57", "MO_EM1_Min_Spannung_Lim", 0, profileFile ) );
    putValue( KCAN_MO_EM2_Generator_Leistung, getProfileInt( "Motor_57", "MO_EM2_Generator_Leistung", 0, profileFile ) );
    putValue( KCAN_MO_EM2_Max_Leistung_Gesamt, getProfileInt( "Motor_57", "MO_EM2_Max_Leistung_Gesamt", 0, profileFile ) );
    putValue( KCAN_MO_EM2_Max_Spannung_Lim, getProfileInt( "Motor_57", "MO_EM2_Max_Spannung_Lim", 0, profileFile ) );
    putValue( KCAN_MO_EM2_Min_Leistung_Gesamt, getProfileInt( "Motor_57", "MO_EM2_Min_Leistung_Gesamt", 0, profileFile ) );
    putValue( KCAN_MO_EM2_Min_Spannung_Lim, getProfileInt( "Motor_57", "MO_EM2_Min_Spannung_Lim", 0, profileFile ) );
    putValue( KCAN_MO_Rekuperation_EM_Ges_Ueberlauf, getProfileInt( "Motor_57", "MO_Rekuperation_EM_Ges_Ueberlauf", 0, profileFile ) );
    putValue( KCAN_MO_Rekuperation_Ges_EM, getProfileInt( "Motor_57", "MO_Rekuperation_Ges_EM", 0, profileFile ) );
    putValue( KCAN_MO_Uebersetzung_EM, getProfileFloat( "Motor_57", "MO_Uebersetzung_EM", 0, profileFile ) );
    putValue( KCAN_MO_Uebersetzung_EM_sek, getProfileFloat( "Motor_57", "MO_Uebersetzung_EM_sek", 0, profileFile ) );
    putValue( KCAN_MO_Verbrauch_EM_Ges, getProfileInt( "Motor_57", "MO_Verbrauch_EM_Ges", 0, profileFile ) );
    putValue( KCAN_MO_Verbrauch_EM_Ges_Ueberlauf, getProfileInt( "Motor_57", "MO_Verbrauch_EM_Ges_Ueberlauf", 0, profileFile ) );

}


void loadSettings_Motor_Hybrid_06( char profileFile[] )
{
    putValue( KCAN_MO_Powermeter_Charge_Grenze, getProfileInt( "Motor_Hybrid_06", "MO_Powermeter_Charge_Grenze", 0, profileFile ) );
    putValue( KCAN_Mo_Powermeter_Grenze, getProfileInt( "Motor_Hybrid_06", "Mo_Powermeter_Grenze", 0, profileFile ) );
    putValue( KCAN_MO_Powermeter_Grenze_strategisch, getProfileInt( "Motor_Hybrid_06", "MO_Powermeter_Grenze_strategisch", 0, profileFile ) );
    putValue( KCAN_MO_Powermeter_Inszenierung_aktiv, getProfileInt( "Motor_Hybrid_06", "MO_Powermeter_Inszenierung_aktiv", 0, profileFile ) );
    putValue( KCAN_MO_Powermeter_obere_E_Grenze, getProfileInt( "Motor_Hybrid_06", "MO_Powermeter_obere_E_Grenze", 0, profileFile ) );
    putValue( KCAN_MO_Powermeter_untere_E_Grenze, getProfileInt( "Motor_Hybrid_06", "MO_Powermeter_untere_E_Grenze", 0, profileFile ) );
    putValue( KCAN_MO_Text_Aktivierung_Antrieb, getProfileInt( "Motor_Hybrid_06", "MO_Text_Aktivierung_Antrieb", 0, profileFile ) );

}


void loadSettings_NavData_01( char profileFile[] )
{
    putValue( KCAN_ND_GDOP, getProfileFloat( "NavData_01", "ND_GDOP", 0, profileFile ) );
    putValue( KCAN_ND_HDOP, getProfileFloat( "NavData_01", "ND_HDOP", 0, profileFile ) );
    putValue( KCAN_ND_Heading, getProfileFloat( "NavData_01", "ND_Heading", 0, profileFile ) );
    putValue( KCAN_ND_Init, getProfileInt( "NavData_01", "ND_Init", 0, profileFile ) );
    putValue( KCAN_ND_PDOP, getProfileFloat( "NavData_01", "ND_PDOP", 0, profileFile ) );
    putValue( KCAN_ND_TDOP, getProfileFloat( "NavData_01", "ND_TDOP", 0, profileFile ) );
    putValue( KCAN_ND_VDOP, getProfileFloat( "NavData_01", "ND_VDOP", 0, profileFile ) );

}


void loadSettings_NavData_02( char profileFile[] )
{
    putValue( KCAN_ND_SatInUse, getProfileInt( "NavData_02", "ND_SatInUse", 0, profileFile ) );
    putValue( KCAN_ND_SatInView, getProfileInt( "NavData_02", "ND_SatInView", 0, profileFile ) );
    putValue( KCAN_ND_UTC, getProfileInt( "NavData_02", "ND_UTC", 0, profileFile ) );
    putValue( KCAN_NP_Altitude, getProfileInt( "NavData_02", "NP_Altitude", 0, profileFile ) );
    putValue( KCAN_POS_Guete_horizontal, getProfileInt( "NavData_02", "POS_Guete_horizontal", 0, profileFile ) );
    putValue( KCAN_POS_Guete_horizontal_verfuegbar, getProfileInt( "NavData_02", "POS_Guete_horizontal_verfuegbar", 0, profileFile ) );

}


void loadSettings_NavData_03( char profileFile[] )
{
    putValue( KCAN_ND_Fuelstation_detected, getProfileInt( "NavData_03", "ND_Fuelstation_detected", 0, profileFile ) );
    putValue( KCAN_ND_NrSameMeasure, getProfileInt( "NavData_03", "ND_NrSameMeasure", 0, profileFile ) );
    putValue( KCAN_ND_RecDelay, getProfileInt( "NavData_03", "ND_RecDelay", 0, profileFile ) );
    putValue( KCAN_ND_RouteType, getProfileInt( "NavData_03", "ND_RouteType", 0, profileFile ) );
    putValue( KCAN_ND_SendDelay, getProfileInt( "NavData_03", "ND_SendDelay", 0, profileFile ) );
    putValue( KCAN_ND_TimeOffset, getProfileInt( "NavData_03", "ND_TimeOffset", 0, profileFile ) );
    putValue( KCAN_ND_TimeToDestination, getProfileInt( "NavData_03", "ND_TimeToDestination", 0, profileFile ) );
    putValue( KCAN_ND_Timezone_DaylightSavingOffset, getProfileInt( "NavData_03", "ND_Timezone_DaylightSavingOffset", 0, profileFile ) );
    putValue( KCAN_ND_Timezone_Offset, getProfileInt( "NavData_03", "ND_Timezone_Offset", 0, profileFile ) );
    putValue( KCAN_ND_Timezone_SignBit, getProfileInt( "NavData_03", "ND_Timezone_SignBit", 0, profileFile ) );
    putValue( KCAN_ND_Timezone_Validity, getProfileInt( "NavData_03", "ND_Timezone_Validity", 0, profileFile ) );
    putValue( KCAN_ND_Velocity, getProfileFloat( "NavData_03", "ND_Velocity", 0, profileFile ) );

}


void loadSettings_NavData_04( char profileFile[] )
{
    putValue( KCAN_ND_Avrg_Speed_RangeData, getProfileInt( "NavData_04", "ND_Avrg_Speed_RangeData", 0, profileFile ) );

}


void loadSettings_NavPos_01( char profileFile[] )
{
    putValue( KCAN_NP_Fix, getProfileInt( "NavPos_01", "NP_Fix", 0, profileFile ) );
    putValue( KCAN_NP_LatDegree, getProfileFloat( "NavPos_01", "NP_LatDegree", 0, profileFile ) );
    putValue( KCAN_NP_LatDirection, getProfileInt( "NavPos_01", "NP_LatDirection", 0, profileFile ) );
    putValue( KCAN_NP_LongDegree, getProfileFloat( "NavPos_01", "NP_LongDegree", 0, profileFile ) );
    putValue( KCAN_NP_LongDirection, getProfileInt( "NavPos_01", "NP_LongDirection", 0, profileFile ) );
    putValue( KCAN_NP_Sat, getProfileInt( "NavPos_01", "NP_Sat", 0, profileFile ) );

}


void loadSettings_NavPos_02_Map_Matched( char profileFile[] )
{
    putValue( KCAN_POS_Heading, getProfileFloat( "NavPos_02_Map_Matched", "POS_Heading", 0, profileFile ) );
    putValue( KCAN_POS_Heading_Trust, getProfileInt( "NavPos_02_Map_Matched", "POS_Heading_Trust", 0, profileFile ) );
    putValue( KCAN_POS_Last_GPS_Sync, getProfileInt( "NavPos_02_Map_Matched", "POS_Last_GPS_Sync", 0, profileFile ) );
    putValue( KCAN_POS_LatDegree, getProfileFloat( "NavPos_02_Map_Matched", "POS_LatDegree", 0, profileFile ) );
    putValue( KCAN_POS_LatDirection, getProfileInt( "NavPos_02_Map_Matched", "POS_LatDirection", 0, profileFile ) );
    putValue( KCAN_POS_LongDegree, getProfileFloat( "NavPos_02_Map_Matched", "POS_LongDegree", 0, profileFile ) );
    putValue( KCAN_POS_LongDirection, getProfileInt( "NavPos_02_Map_Matched", "POS_LongDirection", 0, profileFile ) );
    putValue( KCAN_POS_MUX, getProfileInt( "NavPos_02_Map_Matched", "POS_MUX", 0, profileFile ) );
    putValue( KCAN_POS_ODD_EVEN, getProfileInt( "NavPos_02_Map_Matched", "POS_ODD_EVEN", 0, profileFile ) );
    putValue( KCAN_POS_PosStati, getProfileInt( "NavPos_02_Map_Matched", "POS_PosStati", 0, profileFile ) );
    putValue( KCAN_POS_UTC_REF, getProfileInt( "NavPos_02_Map_Matched", "POS_UTC_REF", 0, profileFile ) );

}


void loadSettings_NFC_01( char profileFile[] )
{
    putValue( KCAN_MDK_Anf_Start_Auth, getProfileInt( "NFC_01", "MDK_Anf_Start_Auth", 0, profileFile ) );
    putValue( KCAN_MDK_BTLE_Spielschutz_aktivieren, getProfileInt( "NFC_01", "MDK_BTLE_Spielschutz_aktivieren", 0, profileFile ) );
    putValue( KCAN_MDK_NFC_Spielschutz_aktivieren, getProfileInt( "NFC_01", "MDK_NFC_Spielschutz_aktivieren", 0, profileFile ) );
    putValue( KCAN_NFC_aktiv, getProfileInt( "NFC_01", "NFC_aktiv", 0, profileFile ) );
    putValue( KCAN_NFC_ESM_aktivieren, getProfileInt( "NFC_01", "NFC_ESM_aktivieren", 0, profileFile ) );
    putValue( KCAN_NFC_Front_Entr_Authorisiert, getProfileInt( "NFC_01", "NFC_Front_Entr_Authorisiert", 0, profileFile ) );
    putValue( KCAN_NFC_Front_Verr_Authorisiert, getProfileInt( "NFC_01", "NFC_Front_Verr_Authorisiert", 0, profileFile ) );
    putValue( KCAN_NFC_FT_Entriegelung_Authorisiert, getProfileInt( "NFC_01", "NFC_FT_Entriegelung_Authorisiert", 0, profileFile ) );
    putValue( KCAN_NFC_FT_Verriegelung_Authorisiert, getProfileInt( "NFC_01", "NFC_FT_Verriegelung_Authorisiert", 0, profileFile ) );
    putValue( KCAN_NFC_HD_Entriegelung_Authorisiert, getProfileInt( "NFC_01", "NFC_HD_Entriegelung_Authorisiert", 0, profileFile ) );
    putValue( KCAN_NFC_HD_Verriegelung_Authorisiert, getProfileInt( "NFC_01", "NFC_HD_Verriegelung_Authorisiert", 0, profileFile ) );
    putValue( KCAN_NFC_Laden_unterbrechen, getProfileInt( "NFC_01", "NFC_Laden_unterbrechen", 0, profileFile ) );
    putValue( KCAN_Stellgliedtest_NFC, getProfileInt( "NFC_01", "Stellgliedtest_NFC", 0, profileFile ) );
    putValue( KCAN_ZV_auf_NFC, getProfileInt( "NFC_01", "ZV_auf_NFC", 0, profileFile ) );
    putValue( KCAN_ZV_zu_NFC, getProfileInt( "NFC_01", "ZV_zu_NFC", 0, profileFile ) );

}


void loadSettings_NFC_MiKo_01( char profileFile[] )
{
    putValue( KCAN_NFC_MiKo_ESM_aktiv, getProfileInt( "NFC_MiKo_01", "NFC_MiKo_ESM_aktiv", 0, profileFile ) );
    putValue( KCAN_NFC_MiKo_Fehler, getProfileInt( "NFC_MiKo_01", "NFC_MiKo_Fehler", 0, profileFile ) );
    putValue( KCAN_NFC_MiKo_Laden_unterbrechen, getProfileInt( "NFC_MiKo_01", "NFC_MiKo_Laden_unterbrechen", 0, profileFile ) );
    putValue( KCAN_NFC_MiKo_NFC_Device_gekoppelt, getProfileInt( "NFC_MiKo_01", "NFC_MiKo_NFC_Device_gekoppelt", 0, profileFile ) );

}


void loadSettings_NMH_DispKBI_FS( char profileFile[] )
{
    putValue( KCAN_NM_DispKBI_FS_CAB_V10, getProfileInt( "NMH_DispKBI_FS", "NM_DispKBI_FS_CAB_V10", 0, profileFile ) );
    putValue( KCAN_NM_DispKBI_FS_CarWakeup, getProfileInt( "NMH_DispKBI_FS", "NM_DispKBI_FS_CarWakeup", 0, profileFile ) );
    putValue( KCAN_NM_DispKBI_FS_CBV_AWB, getProfileInt( "NMH_DispKBI_FS", "NM_DispKBI_FS_CBV_AWB", 0, profileFile ) );
    putValue( KCAN_NM_DispKBI_FS_CBV_CRI, getProfileInt( "NMH_DispKBI_FS", "NM_DispKBI_FS_CBV_CRI", 0, profileFile ) );
    putValue( KCAN_NM_DispKBI_FS_NM_aktiv_Diagnose, getProfileInt( "NMH_DispKBI_FS", "NM_DispKBI_FS_NM_aktiv_Diagnose", 0, profileFile ) );
    putValue( KCAN_NM_DispKBI_FS_NM_aktiv_KL15, getProfileInt( "NMH_DispKBI_FS", "NM_DispKBI_FS_NM_aktiv_KL15", 0, profileFile ) );
    putValue( KCAN_NM_DispKBI_FS_NM_aktiv_Tmin, getProfileInt( "NMH_DispKBI_FS", "NM_DispKBI_FS_NM_aktiv_Tmin", 0, profileFile ) );
    putValue( KCAN_NM_DispKBI_FS_NM_State, getProfileInt( "NMH_DispKBI_FS", "NM_DispKBI_FS_NM_State", 0, profileFile ) );
    putValue( KCAN_NM_DispKBI_FS_UDS_CC, getProfileInt( "NMH_DispKBI_FS", "NM_DispKBI_FS_UDS_CC", 0, profileFile ) );

}


void loadSettings_NMH_Gateway( char profileFile[] )
{
    putValue( KCAN_NM_Gateway_CAB_V10, getProfileInt( "NMH_Gateway", "NM_Gateway_CAB_V10", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_Car_Wakeup, getProfileInt( "NMH_Gateway", "NM_Gateway_Car_Wakeup", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_CBV_AWB, getProfileInt( "NMH_Gateway", "NM_Gateway_CBV_AWB", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_CBV_CRI, getProfileInt( "NMH_Gateway", "NM_Gateway_CBV_CRI", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_NM_aktiv_CAB, getProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_CAB", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_NM_aktiv_Diagnose, getProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_Diagnose", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_NM_aktiv_Energie, getProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_Energie", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_NM_aktiv_FoD, getProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_FoD", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_NM_aktiv_IAA_PSO, getProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_IAA_PSO", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_NM_aktiv_Kessy, getProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_Kessy", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_NM_aktiv_KL15, getProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_KL15", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_NM_aktiv_KS, getProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_KS", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_NM_aktiv_Licht, getProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_Licht", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_NM_aktiv_PaCo, getProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_PaCo", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_NM_aktiv_RTM, getProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_RTM", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_NM_aktiv_Standklima, getProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_Standklima", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_NM_aktiv_Tmin, getProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_Tmin", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_NM_aktiv_USS, getProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_USS", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_NM_aktiv_ZM, getProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_ZM", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_NM_aktiv_ZV, getProfileInt( "NMH_Gateway", "NM_Gateway_NM_aktiv_ZV", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_NM_State, getProfileInt( "NMH_Gateway", "NM_Gateway_NM_State", 0, profileFile ) );
    putValue( KCAN_NM_Gateway_UDS_CC, getProfileInt( "NMH_Gateway", "NM_Gateway_UDS_CC", 0, profileFile ) );

}


void loadSettings_NMH_HUD( char profileFile[] )
{
    putValue( KCAN_NM_HUD_CAB_V10, getProfileInt( "NMH_HUD", "NM_HUD_CAB_V10", 0, profileFile ) );
    putValue( KCAN_NM_HUD_Car_WakeUp, getProfileInt( "NMH_HUD", "NM_HUD_Car_WakeUp", 0, profileFile ) );
    putValue( KCAN_NM_HUD_CBV_AWB, getProfileInt( "NMH_HUD", "NM_HUD_CBV_AWB", 0, profileFile ) );
    putValue( KCAN_NM_HUD_CBV_CRI, getProfileInt( "NMH_HUD", "NM_HUD_CBV_CRI", 0, profileFile ) );
    putValue( KCAN_NM_HUD_NM_aktiv_Diagnose, getProfileInt( "NMH_HUD", "NM_HUD_NM_aktiv_Diagnose", 0, profileFile ) );
    putValue( KCAN_NM_HUD_NM_aktiv_KL15, getProfileInt( "NMH_HUD", "NM_HUD_NM_aktiv_KL15", 0, profileFile ) );
    putValue( KCAN_NM_HUD_NM_aktiv_Tmin, getProfileInt( "NMH_HUD", "NM_HUD_NM_aktiv_Tmin", 0, profileFile ) );
    putValue( KCAN_NM_HUD_NM_State, getProfileInt( "NMH_HUD", "NM_HUD_NM_State", 0, profileFile ) );
    putValue( KCAN_NM_HUD_UDS_CC, getProfileInt( "NMH_HUD", "NM_HUD_UDS_CC", 0, profileFile ) );

}


void loadSettings_NMH_Info_El( char profileFile[] )
{
    putValue( KCAN_NM_Info_El_CAB_V10, getProfileInt( "NMH_Info_El", "NM_Info_El_CAB_V10", 0, profileFile ) );
    putValue( KCAN_NM_Info_El_Car_Wakeup, getProfileInt( "NMH_Info_El", "NM_Info_El_Car_Wakeup", 0, profileFile ) );
    putValue( KCAN_NM_Info_El_CBV_AWB, getProfileInt( "NMH_Info_El", "NM_Info_El_CBV_AWB", 0, profileFile ) );
    putValue( KCAN_NM_Info_El_CBV_CRI, getProfileInt( "NMH_Info_El", "NM_Info_El_CBV_CRI", 0, profileFile ) );
    putValue( KCAN_NM_Info_El_NM_aktiv_BAP_Comm, getProfileInt( "NMH_Info_El", "NM_Info_El_NM_aktiv_BAP_Comm", 0, profileFile ) );
    putValue( KCAN_NM_Info_El_NM_aktiv_Diagnose, getProfileInt( "NMH_Info_El", "NM_Info_El_NM_aktiv_Diagnose", 0, profileFile ) );
    putValue( KCAN_NM_Info_El_NM_aktiv_IAA, getProfileInt( "NMH_Info_El", "NM_Info_El_NM_aktiv_IAA", 0, profileFile ) );
    putValue( KCAN_NM_Info_El_NM_aktiv_KL15, getProfileInt( "NMH_Info_El", "NM_Info_El_NM_aktiv_KL15", 0, profileFile ) );
    putValue( KCAN_NM_Info_El_NM_aktiv_MIBCAN, getProfileInt( "NMH_Info_El", "NM_Info_El_NM_aktiv_MIBCAN", 0, profileFile ) );
    putValue( KCAN_NM_Info_El_NM_aktiv_SmartLight, getProfileInt( "NMH_Info_El", "NM_Info_El_NM_aktiv_SmartLight", 0, profileFile ) );
    putValue( KCAN_NM_Info_El_NM_aktiv_Tmin, getProfileInt( "NMH_Info_El", "NM_Info_El_NM_aktiv_Tmin", 0, profileFile ) );
    putValue( KCAN_NM_Info_El_NM_State, getProfileInt( "NMH_Info_El", "NM_Info_El_NM_State", 0, profileFile ) );
    putValue( KCAN_NM_Info_El_UDS_CC, getProfileInt( "NMH_Info_El", "NM_Info_El_UDS_CC", 0, profileFile ) );

}


void loadSettings_NMH_Kombi( char profileFile[] )
{
    putValue( KCAN_NM_Kombi_CAB_V10, getProfileInt( "NMH_Kombi", "NM_Kombi_CAB_V10", 0, profileFile ) );
    putValue( KCAN_NM_Kombi_Car_Wakeup, getProfileInt( "NMH_Kombi", "NM_Kombi_Car_Wakeup", 0, profileFile ) );
    putValue( KCAN_NM_Kombi_CBV_AWB, getProfileInt( "NMH_Kombi", "NM_Kombi_CBV_AWB", 0, profileFile ) );
    putValue( KCAN_NM_Kombi_CBV_CRI, getProfileInt( "NMH_Kombi", "NM_Kombi_CBV_CRI", 0, profileFile ) );
    putValue( KCAN_NM_Kombi_NM_aktiv_Buzzer, getProfileInt( "NMH_Kombi", "NM_Kombi_NM_aktiv_Buzzer", 0, profileFile ) );
    putValue( KCAN_NM_Kombi_NM_aktiv_Diagnose, getProfileInt( "NMH_Kombi", "NM_Kombi_NM_aktiv_Diagnose", 0, profileFile ) );
    putValue( KCAN_NM_Kombi_NM_aktiv_KL15, getProfileInt( "NMH_Kombi", "NM_Kombi_NM_aktiv_KL15", 0, profileFile ) );
    putValue( KCAN_NM_Kombi_NM_aktiv_Schluesselkomm, getProfileInt( "NMH_Kombi", "NM_Kombi_NM_aktiv_Schluesselkomm", 0, profileFile ) );
    putValue( KCAN_NM_Kombi_NM_aktiv_Tmin, getProfileInt( "NMH_Kombi", "NM_Kombi_NM_aktiv_Tmin", 0, profileFile ) );
    putValue( KCAN_NM_Kombi_NM_aktiv_VLW, getProfileInt( "NMH_Kombi", "NM_Kombi_NM_aktiv_VLW", 0, profileFile ) );
    putValue( KCAN_NM_Kombi_NM_State, getProfileInt( "NMH_Kombi", "NM_Kombi_NM_State", 0, profileFile ) );
    putValue( KCAN_NM_Kombi_UDS_CC, getProfileInt( "NMH_Kombi", "NM_Kombi_UDS_CC", 0, profileFile ) );

}


void loadSettings_NMH_SmLi_01( char profileFile[] )
{
    putValue( KCAN_NM_SmLi_01_CAB_V10, getProfileInt( "NMH_SmLi_01", "NM_SmLi_01_CAB_V10", 0, profileFile ) );
    putValue( KCAN_NM_SmLi_01_CarWakeup, getProfileInt( "NMH_SmLi_01", "NM_SmLi_01_CarWakeup", 0, profileFile ) );
    putValue( KCAN_NM_SmLi_01_CBV_AWB, getProfileInt( "NMH_SmLi_01", "NM_SmLi_01_CBV_AWB", 0, profileFile ) );
    putValue( KCAN_NM_SmLi_01_CBV_CRI, getProfileInt( "NMH_SmLi_01", "NM_SmLi_01_CBV_CRI", 0, profileFile ) );
    putValue( KCAN_NM_SmLi_01_NM_aktiv_Diagnose, getProfileInt( "NMH_SmLi_01", "NM_SmLi_01_NM_aktiv_Diagnose", 0, profileFile ) );
    putValue( KCAN_NM_SmLi_01_NM_aktiv_KL15, getProfileInt( "NMH_SmLi_01", "NM_SmLi_01_NM_aktiv_KL15", 0, profileFile ) );
    putValue( KCAN_NM_SmLi_01_NM_aktiv_Tmin, getProfileInt( "NMH_SmLi_01", "NM_SmLi_01_NM_aktiv_Tmin", 0, profileFile ) );
    putValue( KCAN_NM_SmLi_01_NM_State, getProfileInt( "NMH_SmLi_01", "NM_SmLi_01_NM_State", 0, profileFile ) );
    putValue( KCAN_NM_SmLi_01_UDS_CC, getProfileInt( "NMH_SmLi_01", "NM_SmLi_01_UDS_CC", 0, profileFile ) );

}


void loadSettings_OBDC_DispKBI_FS_Req_FD( char profileFile[] )
{

}


void loadSettings_OBDC_DispKBI_FS_Resp_FD( char profileFile[] )
{

}


void loadSettings_OBDC_Funktionaler_Req_All( char profileFile[] )
{

}


void loadSettings_OBDC_Funktionaler_Req_All_FD( char profileFile[] )
{

}


void loadSettings_OBDC_HUD_Req_FD( char profileFile[] )
{

}


void loadSettings_OBDC_HUD_Resp_FD( char profileFile[] )
{

}


void loadSettings_OBDC_Kombi_Req_FD( char profileFile[] )
{

}


void loadSettings_OBDC_Kombi_Resp_FD( char profileFile[] )
{

}


void loadSettings_OBDC_SmLi_01_Req_FD( char profileFile[] )
{

}


void loadSettings_OBDC_SmLi_01_Resp_FD( char profileFile[] )
{

}


void loadSettings_OBDC_SSN_ABT_1_Req( char profileFile[] )
{

}


void loadSettings_OBDC_SSN_ABT_1_Resp( char profileFile[] )
{

}


void loadSettings_OBDC_WLC1_Req( char profileFile[] )
{

}


void loadSettings_OBDC_WLC1_Resp( char profileFile[] )
{

}


void loadSettings_OBDx_allOBD_Req( char profileFile[] )
{

}


void loadSettings_ORU_01( char profileFile[] )
{
    putValue( KCAN_ORU_EM_Anfrage_Flashdauer, getProfileInt( "ORU_01", "ORU_EM_Anfrage_Flashdauer", 0, profileFile ) );
    putValue( KCAN_ORU_EM_Anfrage_freigegebeneNetze, getProfileInt( "ORU_01", "ORU_EM_Anfrage_freigegebeneNetze", 0, profileFile ) );
    putValue( KCAN_ORU_EM_Anfrage_Stromaufnahme, getProfileFloat( "ORU_01", "ORU_EM_Anfrage_Stromaufnahme", 0, profileFile ) );
    putValue( KCAN_ORU_Status, getProfileInt( "ORU_01", "ORU_Status", 0, profileFile ) );
    putValue( KCAN_ORU_Warnung, getProfileInt( "ORU_01", "ORU_Warnung", 0, profileFile ) );

}


void loadSettings_Parkhilfe_01( char profileFile[] )
{
    putValue( KCAN_PDC_Tonausgabe_Front, getProfileInt( "Parkhilfe_01", "PDC_Tonausgabe_Front", 0, profileFile ) );
    putValue( KCAN_PDC_Tonausgabe_Heck, getProfileInt( "Parkhilfe_01", "PDC_Tonausgabe_Heck", 0, profileFile ) );
    putValue( KCAN_PH_Abschaltursache, getProfileInt( "Parkhilfe_01", "PH_Abschaltursache", 0, profileFile ) );
    putValue( KCAN_PH_Anf_Audioabsenkung, getProfileInt( "Parkhilfe_01", "PH_Anf_Audioabsenkung", 0, profileFile ) );
    putValue( KCAN_PH_Anf_Verdeck, getProfileInt( "Parkhilfe_01", "PH_Anf_Verdeck", 0, profileFile ) );
    putValue( KCAN_PH_defekt, getProfileInt( "Parkhilfe_01", "PH_defekt", 0, profileFile ) );
    putValue( KCAN_PH_Display_Kundenwunsch, getProfileInt( "Parkhilfe_01", "PH_Display_Kundenwunsch", 0, profileFile ) );
    putValue( KCAN_PH_Frequenz_hinten, getProfileInt( "Parkhilfe_01", "PH_Frequenz_hinten", 0, profileFile ) );
    putValue( KCAN_PH_Frequenz_vorn, getProfileInt( "Parkhilfe_01", "PH_Frequenz_vorn", 0, profileFile ) );
    putValue( KCAN_PH_gestoert, getProfileInt( "Parkhilfe_01", "PH_gestoert", 0, profileFile ) );
    putValue( KCAN_PH_Lautstaerke_hinten, getProfileInt( "Parkhilfe_01", "PH_Lautstaerke_hinten", 0, profileFile ) );
    putValue( KCAN_PH_Lautstaerke_vorn, getProfileInt( "Parkhilfe_01", "PH_Lautstaerke_vorn", 0, profileFile ) );
    putValue( KCAN_PH_nachtr_Stopp_Anf, getProfileInt( "Parkhilfe_01", "PH_nachtr_Stopp_Anf", 0, profileFile ) );
    putValue( KCAN_PH_Opt_Anz_H_Hindernis, getProfileInt( "Parkhilfe_01", "PH_Opt_Anz_H_Hindernis", 0, profileFile ) );
    putValue( KCAN_PH_Opt_Anz_V_Hindernis, getProfileInt( "Parkhilfe_01", "PH_Opt_Anz_V_Hindernis", 0, profileFile ) );
    putValue( KCAN_PH_Opt_Anzeige_H_ein, getProfileInt( "Parkhilfe_01", "PH_Opt_Anzeige_H_ein", 0, profileFile ) );
    putValue( KCAN_PH_Opt_Anzeige_V_ein, getProfileInt( "Parkhilfe_01", "PH_Opt_Anzeige_V_ein", 0, profileFile ) );
    putValue( KCAN_PH_StartStopp_Info, getProfileInt( "Parkhilfe_01", "PH_StartStopp_Info", 0, profileFile ) );
    putValue( KCAN_PH_Stoermeldung, getProfileInt( "Parkhilfe_01", "PH_Stoermeldung", 0, profileFile ) );
    putValue( KCAN_PH_Systemzustand_Parkhilfe_01, getProfileInt( "Parkhilfe_01", "PH_Systemzustand_Parkhilfe_01", 0, profileFile ) );
    putValue( KCAN_PH_Taster_Parkhilfe_01, getProfileInt( "Parkhilfe_01", "PH_Taster_Parkhilfe_01", 0, profileFile ) );
    putValue( KCAN_PH_Tongeber_H_aktiv, getProfileInt( "Parkhilfe_01", "PH_Tongeber_H_aktiv", 0, profileFile ) );
    putValue( KCAN_PH_Tongeber_H_verfuegbar, getProfileInt( "Parkhilfe_01", "PH_Tongeber_H_verfuegbar", 0, profileFile ) );
    putValue( KCAN_PH_Tongeber_mute, getProfileInt( "Parkhilfe_01", "PH_Tongeber_mute", 0, profileFile ) );
    putValue( KCAN_PH_Tongeber_V_aktiv, getProfileInt( "Parkhilfe_01", "PH_Tongeber_V_aktiv", 0, profileFile ) );
    putValue( KCAN_PH_Visualisierung, getProfileInt( "Parkhilfe_01", "PH_Visualisierung", 0, profileFile ) );
    putValue( KCAN_PLA_Anf_Aufschaltung_RVC_Parkhilfe_01, getProfileInt( "Parkhilfe_01", "PLA_Anf_Aufschaltung_RVC_Parkhilfe_01", 0, profileFile ) );

}


void loadSettings_Parkhilfe_04( char profileFile[] )
{
    putValue( KCAN_APS_PaCo_WarningTones, getProfileInt( "Parkhilfe_04", "APS_PaCo_WarningTones", 0, profileFile ) );
    putValue( KCAN_APSOPS_PaCo_ApproachingFront, getProfileInt( "Parkhilfe_04", "APSOPS_PaCo_ApproachingFront", 0, profileFile ) );
    putValue( KCAN_APSOPS_PaCo_ApproachingRear, getProfileInt( "Parkhilfe_04", "APSOPS_PaCo_ApproachingRear", 0, profileFile ) );
    putValue( KCAN_APSOPS_PaCo_Button, getProfileInt( "Parkhilfe_04", "APSOPS_PaCo_Button", 0, profileFile ) );
    putValue( KCAN_APSOPS_PaCo_FunctionState, getProfileInt( "Parkhilfe_04", "APSOPS_PaCo_FunctionState", 0, profileFile ) );
    putValue( KCAN_APSOPS_PaCo_MainState, getProfileInt( "Parkhilfe_04", "APSOPS_PaCo_MainState", 0, profileFile ) );
    putValue( KCAN_APSOPS_PaCo_ObstacleDetectFront, getProfileInt( "Parkhilfe_04", "APSOPS_PaCo_ObstacleDetectFront", 0, profileFile ) );
    putValue( KCAN_APSOPS_PaCo_ObstacleDetectRear, getProfileInt( "Parkhilfe_04", "APSOPS_PaCo_ObstacleDetectRear", 0, profileFile ) );
    putValue( KCAN_PDC_Charisma_FahrPr, getProfileInt( "Parkhilfe_04", "PDC_Charisma_FahrPr", 0, profileFile ) );
    putValue( KCAN_PDC_Charisma_Status, getProfileInt( "Parkhilfe_04", "PDC_Charisma_Status", 0, profileFile ) );
    putValue( KCAN_PH_Aufschaltursache, getProfileInt( "Parkhilfe_04", "PH_Aufschaltursache", 0, profileFile ) );
    putValue( KCAN_PH_Ton_Ausgabe, getProfileInt( "Parkhilfe_04", "PH_Ton_Ausgabe", 0, profileFile ) );
    putValue( KCAN_PH_Ton_Lautstaerke, getProfileInt( "Parkhilfe_04", "PH_Ton_Lautstaerke", 0, profileFile ) );
    putValue( KCAN_PH_Ton_Pausenlaenge, getProfileInt( "Parkhilfe_04", "PH_Ton_Pausenlaenge", 0, profileFile ) );
    putValue( KCAN_PH_Ton_Richtung, getProfileInt( "Parkhilfe_04", "PH_Ton_Richtung", 0, profileFile ) );
    putValue( KCAN_PH_Verschmutzungsmeldung, getProfileInt( "Parkhilfe_04", "PH_Verschmutzungsmeldung", 0, profileFile ) );
    putValue( KCAN_PH_WAH_Meldung, getProfileInt( "Parkhilfe_04", "PH_WAH_Meldung", 0, profileFile ) );
    putValue( KCAN_RBF_Anf_Meldungen, getProfileInt( "Parkhilfe_04", "RBF_Anf_Meldungen", 0, profileFile ) );
    putValue( KCAN_RBFMA_PaCo_BrakeIntervention, getProfileInt( "Parkhilfe_04", "RBFMA_PaCo_BrakeIntervention", 0, profileFile ) );
    putValue( KCAN_RBFMA_PaCo_MainState, getProfileInt( "Parkhilfe_04", "RBFMA_PaCo_MainState", 0, profileFile ) );

}


void loadSettings_Personalisierung_01( char profileFile[] )
{
    putValue( KCAN_IAA_Active_User_ID, getProfileInt( "Personalisierung_01", "IAA_Active_User_ID", 0, profileFile ) );
    putValue( KCAN_IAA_Identified_User_ID, getProfileInt( "Personalisierung_01", "IAA_Identified_User_ID", 0, profileFile ) );
    putValue( KCAN_IAA_PSO_wake_up, getProfileInt( "Personalisierung_01", "IAA_PSO_wake_up", 0, profileFile ) );
    putValue( KCAN_Perso_Aktiv, getProfileInt( "Personalisierung_01", "Perso_Aktiv", 0, profileFile ) );
    putValue( KCAN_Perso_Bedienstelle, getProfileInt( "Personalisierung_01", "Perso_Bedienstelle", 0, profileFile ) );
    putValue( KCAN_Perso_Fahrernummer, getProfileInt( "Personalisierung_01", "Perso_Fahrernummer", 0, profileFile ) );
    putValue( KCAN_Perso_Freigabe_Verstellung, getProfileInt( "Personalisierung_01", "Perso_Freigabe_Verstellung", 0, profileFile ) );
    putValue( KCAN_Perso_Kontonummer, getProfileInt( "Personalisierung_01", "Perso_Kontonummer", 0, profileFile ) );
    putValue( KCAN_Perso_Schreibschutz, getProfileInt( "Personalisierung_01", "Perso_Schreibschutz", 0, profileFile ) );
    putValue( KCAN_Perso_Status, getProfileInt( "Personalisierung_01", "Perso_Status", 0, profileFile ) );
    putValue( KCAN_Perso_Steuerung, getProfileInt( "Personalisierung_01", "Perso_Steuerung", 0, profileFile ) );
    putValue( KCAN_Perso_Steuerungsparameter, getProfileInt( "Personalisierung_01", "Perso_Steuerungsparameter", 0, profileFile ) );

}


void loadSettings_PreCrash_02( char profileFile[] )
{
    putValue( KCAN_PreCrash_Anforderung_AFR, getProfileInt( "PreCrash_02", "PreCrash_Anforderung_AFR", 0, profileFile ) );
    putValue( KCAN_PreCrash_BFS_KSV_verfahren, getProfileInt( "PreCrash_02", "PreCrash_BFS_KSV_verfahren", 0, profileFile ) );
    putValue( KCAN_PreCrash_BFS_Laengsverstellung, getProfileInt( "PreCrash_02", "PreCrash_BFS_Laengsverstellung", 0, profileFile ) );
    putValue( KCAN_PreCrash_BFS_Pneumatik_ansteuern, getProfileInt( "PreCrash_02", "PreCrash_BFS_Pneumatik_ansteuern", 0, profileFile ) );
    putValue( KCAN_PreCrash_BFS_Sitzlehne_verfahren, getProfileInt( "PreCrash_02", "PreCrash_BFS_Sitzlehne_verfahren", 0, profileFile ) );
    putValue( KCAN_PreCrash_Blinken, getProfileInt( "PreCrash_02", "PreCrash_Blinken", 0, profileFile ) );
    putValue( KCAN_PreCrash_Charisma_FahrPr, getProfileInt( "PreCrash_02", "PreCrash_Charisma_FahrPr", 0, profileFile ) );
    putValue( KCAN_PreCrash_Charisma_Status, getProfileInt( "PreCrash_02", "PreCrash_Charisma_Status", 0, profileFile ) );
    putValue( KCAN_PreCrash_Fenster_schliessen, getProfileInt( "PreCrash_02", "PreCrash_Fenster_schliessen", 0, profileFile ) );
    putValue( KCAN_PreCrash_Fo_KSV_verfahren, getProfileInt( "PreCrash_02", "PreCrash_Fo_KSV_verfahren", 0, profileFile ) );
    putValue( KCAN_PreCrash_Fo_Pneumatik_ansteuern, getProfileInt( "PreCrash_02", "PreCrash_Fo_Pneumatik_ansteuern", 0, profileFile ) );
    putValue( KCAN_PreCrash_Fo_Sitzlehne_verfahren, getProfileInt( "PreCrash_02", "PreCrash_Fo_Sitzlehne_verfahren", 0, profileFile ) );
    putValue( KCAN_PreCrash_FS_KSV_verfahren, getProfileInt( "PreCrash_02", "PreCrash_FS_KSV_verfahren", 0, profileFile ) );
    putValue( KCAN_PreCrash_FS_Laengsverstellung, getProfileInt( "PreCrash_02", "PreCrash_FS_Laengsverstellung", 0, profileFile ) );
    putValue( KCAN_PreCrash_FS_Pneumatik_ansteuern, getProfileInt( "PreCrash_02", "PreCrash_FS_Pneumatik_ansteuern", 0, profileFile ) );
    putValue( KCAN_PreCrash_FS_Sitzlehne_verfahren, getProfileInt( "PreCrash_02", "PreCrash_FS_Sitzlehne_verfahren", 0, profileFile ) );
    putValue( KCAN_PreCrash_Schiebedach_schliessen, getProfileInt( "PreCrash_02", "PreCrash_Schiebedach_schliessen", 0, profileFile ) );
    putValue( KCAN_PreCrash_Tueren_Verriegeln, getProfileInt( "PreCrash_02", "PreCrash_Tueren_Verriegeln", 0, profileFile ) );
    putValue( KCAN_SC_PreCrash_LED, getProfileInt( "PreCrash_02", "SC_PreCrash_LED", 0, profileFile ) );
    putValue( KCAN_SC_PreCrash_Texte, getProfileInt( "PreCrash_02", "SC_PreCrash_Texte", 0, profileFile ) );
    putValue( KCAN_SC_PreCrash_Warnung, getProfileInt( "PreCrash_02", "SC_PreCrash_Warnung", 0, profileFile ) );
    putValue( KCAN_SC_PreSense_FCWP, getProfileInt( "PreCrash_02", "SC_PreSense_FCWP", 0, profileFile ) );

}


void loadSettings_PSD_04( char profileFile[] )
{
    putValue( KCAN_PSD_Abzweigerichtung, getProfileInt( "PSD_04", "PSD_Abzweigerichtung", 0, profileFile ) );
    putValue( KCAN_PSD_Abzweigewinkel, getProfileFloat( "PSD_04", "PSD_Abzweigewinkel", 0, profileFile ) );
    putValue( KCAN_PSD_ADAS_Qualitaet, getProfileInt( "PSD_04", "PSD_ADAS_Qualitaet", 0, profileFile ) );
    putValue( KCAN_PSD_Anfangskruemmung, getProfileInt( "PSD_04", "PSD_Anfangskruemmung", 0, profileFile ) );
    putValue( KCAN_PSD_Anfangskruemmung_Vorz, getProfileInt( "PSD_04", "PSD_Anfangskruemmung_Vorz", 0, profileFile ) );
    putValue( KCAN_PSD_Bebauung, getProfileInt( "PSD_04", "PSD_Bebauung", 0, profileFile ) );
    putValue( KCAN_PSD_Endkruemmung, getProfileInt( "PSD_04", "PSD_Endkruemmung", 0, profileFile ) );
    putValue( KCAN_PSD_Endkruemmung_Vorz, getProfileInt( "PSD_04", "PSD_Endkruemmung_Vorz", 0, profileFile ) );
    putValue( KCAN_PSD_Fahrspuren_Anzahl, getProfileInt( "PSD_04", "PSD_Fahrspuren_Anzahl", 0, profileFile ) );
    putValue( KCAN_PSD_Geradester_Pfad, getProfileInt( "PSD_04", "PSD_Geradester_Pfad", 0, profileFile ) );
    putValue( KCAN_PSD_Idenditaets_ID, getProfileInt( "PSD_04", "PSD_Idenditaets_ID", 0, profileFile ) );
    putValue( KCAN_PSD_Rampe, getProfileInt( "PSD_04", "PSD_Rampe", 0, profileFile ) );
    putValue( KCAN_PSD_Segment_ID, getProfileInt( "PSD_04", "PSD_Segment_ID", 0, profileFile ) );
    putValue( KCAN_PSD_Segment_Komplett, getProfileInt( "PSD_04", "PSD_Segment_Komplett", 0, profileFile ) );
    putValue( KCAN_PSD_Segmentlaenge, getProfileInt( "PSD_04", "PSD_Segmentlaenge", 0, profileFile ) );
    putValue( KCAN_PSD_Strassenkategorie, getProfileInt( "PSD_04", "PSD_Strassenkategorie", 0, profileFile ) );
    putValue( KCAN_PSD_Vorgaenger_Segment_ID, getProfileInt( "PSD_04", "PSD_Vorgaenger_Segment_ID", 0, profileFile ) );
    putValue( KCAN_PSD_wahrscheinlichster_Pfad, getProfileInt( "PSD_04", "PSD_wahrscheinlichster_Pfad", 0, profileFile ) );

}


void loadSettings_PSD_05( char profileFile[] )
{
    putValue( KCAN_PSD_Attribut_1_ID, getProfileInt( "PSD_05", "PSD_Attribut_1_ID", 0, profileFile ) );
    putValue( KCAN_PSD_Attribut_1_Offset, getProfileInt( "PSD_05", "PSD_Attribut_1_Offset", 0, profileFile ) );
    putValue( KCAN_PSD_Attribut_1_Wert, getProfileInt( "PSD_05", "PSD_Attribut_1_Wert", 0, profileFile ) );
    putValue( KCAN_PSD_Attribut_2_ID, getProfileInt( "PSD_05", "PSD_Attribut_2_ID", 0, profileFile ) );
    putValue( KCAN_PSD_Attribut_2_Offset, getProfileInt( "PSD_05", "PSD_Attribut_2_Offset", 0, profileFile ) );
    putValue( KCAN_PSD_Attribut_2_Wert, getProfileInt( "PSD_05", "PSD_Attribut_2_Wert", 0, profileFile ) );
    putValue( KCAN_PSD_Attribut_Segment_ID_05, getProfileInt( "PSD_05", "PSD_Attribut_Segment_ID_05", 0, profileFile ) );
    putValue( KCAN_PSD_Attribute_Komplett_05, getProfileInt( "PSD_05", "PSD_Attribute_Komplett_05", 0, profileFile ) );
    putValue( KCAN_PSD_Pos_Fahrspur, getProfileInt( "PSD_05", "PSD_Pos_Fahrspur", 0, profileFile ) );
    putValue( KCAN_PSD_Pos_Fehler_Laengsrichtung, getProfileInt( "PSD_05", "PSD_Pos_Fehler_Laengsrichtung", 0, profileFile ) );
    putValue( KCAN_PSD_Pos_Inhibitzeit, getProfileInt( "PSD_05", "PSD_Pos_Inhibitzeit", 0, profileFile ) );
    putValue( KCAN_PSD_Pos_Segment_ID, getProfileInt( "PSD_05", "PSD_Pos_Segment_ID", 0, profileFile ) );
    putValue( KCAN_PSD_Pos_Segmentlaenge, getProfileInt( "PSD_05", "PSD_Pos_Segmentlaenge", 0, profileFile ) );
    putValue( KCAN_PSD_Pos_Standort_Eindeutig, getProfileInt( "PSD_05", "PSD_Pos_Standort_Eindeutig", 0, profileFile ) );

}


void loadSettings_PSD_06( char profileFile[] )
{
    putValue( KCAN_PSD_06_Mux, getProfileInt( "PSD_06", "PSD_06_Mux", 0, profileFile ) );
    putValue( KCAN_PSD_Attribut_3_ID, getProfileInt( "PSD_06", "PSD_Attribut_3_ID", 0, profileFile ) );
    putValue( KCAN_PSD_Attribut_3_Offset, getProfileInt( "PSD_06", "PSD_Attribut_3_Offset", 0, profileFile ) );
    putValue( KCAN_PSD_Attribut_3_Wert, getProfileInt( "PSD_06", "PSD_Attribut_3_Wert", 0, profileFile ) );
    putValue( KCAN_PSD_Attribut_4_ID, getProfileInt( "PSD_06", "PSD_Attribut_4_ID", 0, profileFile ) );
    putValue( KCAN_PSD_Attribut_4_Offset, getProfileInt( "PSD_06", "PSD_Attribut_4_Offset", 0, profileFile ) );
    putValue( KCAN_PSD_Attribut_4_Wert, getProfileInt( "PSD_06", "PSD_Attribut_4_Wert", 0, profileFile ) );
    putValue( KCAN_PSD_Attribut_5_ID, getProfileInt( "PSD_06", "PSD_Attribut_5_ID", 0, profileFile ) );
    putValue( KCAN_PSD_Attribut_5_Offset, getProfileInt( "PSD_06", "PSD_Attribut_5_Offset", 0, profileFile ) );
    putValue( KCAN_PSD_Attribut_5_Wert, getProfileInt( "PSD_06", "PSD_Attribut_5_Wert", 0, profileFile ) );
    putValue( KCAN_PSD_Attribut_Segment_ID, getProfileInt( "PSD_06", "PSD_Attribut_Segment_ID", 0, profileFile ) );
    putValue( KCAN_PSD_Attribute_Komplett_06, getProfileInt( "PSD_06", "PSD_Attribute_Komplett_06", 0, profileFile ) );
    putValue( KCAN_PSD_Baum_Ausrichtung, getProfileFloat( "PSD_06", "PSD_Baum_Ausrichtung", 0, profileFile ) );
    putValue( KCAN_PSD_Baum_Breite, getProfileFloat( "PSD_06", "PSD_Baum_Breite", 0, profileFile ) );
    putValue( KCAN_PSD_Baum_Breite_VZ, getProfileInt( "PSD_06", "PSD_Baum_Breite_VZ", 0, profileFile ) );
    putValue( KCAN_PSD_Baum_Laenge, getProfileFloat( "PSD_06", "PSD_Baum_Laenge", 0, profileFile ) );
    putValue( KCAN_PSD_Baum_Laenge_VZ, getProfileInt( "PSD_06", "PSD_Baum_Laenge_VZ", 0, profileFile ) );
    putValue( KCAN_PSD_Ges_Attribute_Komplett, getProfileInt( "PSD_06", "PSD_Ges_Attribute_Komplett", 0, profileFile ) );
    putValue( KCAN_PSD_Ges_Geschwindigkeit, getProfileInt( "PSD_06", "PSD_Ges_Geschwindigkeit", 0, profileFile ) );
    putValue( KCAN_PSD_Ges_Geschwindigkeit_Gespann, getProfileInt( "PSD_06", "PSD_Ges_Geschwindigkeit_Gespann", 0, profileFile ) );
    putValue( KCAN_PSD_Ges_Geschwindigkeit_Std_Anf, getProfileInt( "PSD_06", "PSD_Ges_Geschwindigkeit_Std_Anf", 0, profileFile ) );
    putValue( KCAN_PSD_Ges_Geschwindigkeit_Std_Ende, getProfileInt( "PSD_06", "PSD_Ges_Geschwindigkeit_Std_Ende", 0, profileFile ) );
    putValue( KCAN_PSD_Ges_Geschwindigkeit_Tag_Anf, getProfileInt( "PSD_06", "PSD_Ges_Geschwindigkeit_Tag_Anf", 0, profileFile ) );
    putValue( KCAN_PSD_Ges_Geschwindigkeit_Tag_Ende, getProfileInt( "PSD_06", "PSD_Ges_Geschwindigkeit_Tag_Ende", 0, profileFile ) );
    putValue( KCAN_PSD_Ges_Geschwindigkeit_Witter, getProfileInt( "PSD_06", "PSD_Ges_Geschwindigkeit_Witter", 0, profileFile ) );
    putValue( KCAN_PSD_Ges_Gesetzlich_Kategorie, getProfileInt( "PSD_06", "PSD_Ges_Gesetzlich_Kategorie", 0, profileFile ) );
    putValue( KCAN_PSD_Ges_Gesetzlich_Zusatz, getProfileInt( "PSD_06", "PSD_Ges_Gesetzlich_Zusatz", 0, profileFile ) );
    putValue( KCAN_PSD_Ges_Offset, getProfileInt( "PSD_06", "PSD_Ges_Offset", 0, profileFile ) );
    putValue( KCAN_PSD_Ges_Segment_ID, getProfileInt( "PSD_06", "PSD_Ges_Segment_ID", 0, profileFile ) );
    putValue( KCAN_PSD_Ges_Spur_Geschw_Begrenzung, getProfileInt( "PSD_06", "PSD_Ges_Spur_Geschw_Begrenzung", 0, profileFile ) );
    putValue( KCAN_PSD_Ges_Typ, getProfileInt( "PSD_06", "PSD_Ges_Typ", 0, profileFile ) );
    putValue( KCAN_PSD_Ges_Ueberholverbot, getProfileInt( "PSD_06", "PSD_Ges_Ueberholverbot", 0, profileFile ) );
    putValue( KCAN_PSD_Ges_Verkehrszeichen_Quelle, getProfileInt( "PSD_06", "PSD_Ges_Verkehrszeichen_Quelle", 0, profileFile ) );
    putValue( KCAN_PSD_Ges_Wechselverkehrszeichen, getProfileInt( "PSD_06", "PSD_Ges_Wechselverkehrszeichen", 0, profileFile ) );
    putValue( KCAN_PSD_Steigung_1_A_Offset, getProfileInt( "PSD_06", "PSD_Steigung_1_A_Offset", 0, profileFile ) );
    putValue( KCAN_PSD_Steigung_1_A_Steigung, getProfileFloat( "PSD_06", "PSD_Steigung_1_A_Steigung", 0, profileFile ) );
    putValue( KCAN_PSD_Steigung_1_A_Vorz, getProfileInt( "PSD_06", "PSD_Steigung_1_A_Vorz", 0, profileFile ) );
    putValue( KCAN_PSD_Steigung_1_Attribute_kompl, getProfileInt( "PSD_06", "PSD_Steigung_1_Attribute_kompl", 0, profileFile ) );
    putValue( KCAN_PSD_Steigung_1_B_Offset, getProfileInt( "PSD_06", "PSD_Steigung_1_B_Offset", 0, profileFile ) );
    putValue( KCAN_PSD_Steigung_1_B_Steigung, getProfileFloat( "PSD_06", "PSD_Steigung_1_B_Steigung", 0, profileFile ) );
    putValue( KCAN_PSD_Steigung_1_B_Vorz, getProfileInt( "PSD_06", "PSD_Steigung_1_B_Vorz", 0, profileFile ) );
    putValue( KCAN_PSD_Steigung_1_Segment_ID, getProfileInt( "PSD_06", "PSD_Steigung_1_Segment_ID", 0, profileFile ) );
    putValue( KCAN_PSD_Steigung_2_Attribute_kompl, getProfileInt( "PSD_06", "PSD_Steigung_2_Attribute_kompl", 0, profileFile ) );
    putValue( KCAN_PSD_Steigung_2_Offset, getProfileInt( "PSD_06", "PSD_Steigung_2_Offset", 0, profileFile ) );
    putValue( KCAN_PSD_Steigung_2_Segment_ID, getProfileInt( "PSD_06", "PSD_Steigung_2_Segment_ID", 0, profileFile ) );
    putValue( KCAN_PSD_Steigung_2_Steigung, getProfileFloat( "PSD_06", "PSD_Steigung_2_Steigung", 0, profileFile ) );
    putValue( KCAN_PSD_Steigung_2_Vorz, getProfileInt( "PSD_06", "PSD_Steigung_2_Vorz", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_Alter_Karte, getProfileInt( "PSD_06", "PSD_Sys_Alter_Karte", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_Geometrieguete, getProfileInt( "PSD_06", "PSD_Sys_Geometrieguete", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_Geometrieguete_erweitert, getProfileInt( "PSD_06", "PSD_Sys_Geometrieguete_erweitert", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_Geschwindigkeit_Einheit, getProfileInt( "PSD_06", "PSD_Sys_Geschwindigkeit_Einheit", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_Laendercode, getProfileInt( "PSD_06", "PSD_Sys_Laendercode", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_Mapmatchingguete, getProfileInt( "PSD_06", "PSD_Sys_Mapmatchingguete", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_Quali_Geometrien, getProfileInt( "PSD_06", "PSD_Sys_Quali_Geometrien", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_Quali_Ortsinfo, getProfileInt( "PSD_06", "PSD_Sys_Quali_Ortsinfo", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_Quali_sonstige_Attribute, getProfileInt( "PSD_06", "PSD_Sys_Quali_sonstige_Attribute", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_Quali_Steigungen, getProfileInt( "PSD_06", "PSD_Sys_Quali_Steigungen", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_Quali_Strassenkennz, getProfileInt( "PSD_06", "PSD_Sys_Quali_Strassenkennz", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_Quali_Tempolimits, getProfileInt( "PSD_06", "PSD_Sys_Quali_Tempolimits", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_Quali_verfuegbar, getProfileInt( "PSD_06", "PSD_Sys_Quali_verfuegbar", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_Quali_Vorfahrtsregelung, getProfileInt( "PSD_06", "PSD_Sys_Quali_Vorfahrtsregelung", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_Segment_ID, getProfileInt( "PSD_06", "PSD_Sys_Segment_ID", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_US_State, getProfileInt( "PSD_06", "PSD_Sys_US_State", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_Verkehrsrichtung, getProfileInt( "PSD_06", "PSD_Sys_Verkehrsrichtung", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_Zielfuehrung, getProfileInt( "PSD_06", "PSD_Sys_Zielfuehrung", 0, profileFile ) );
    putValue( KCAN_PSD_Sys_Zielfuehrung_geaendert, getProfileInt( "PSD_06", "PSD_Sys_Zielfuehrung_geaendert", 0, profileFile ) );
    putValue( KCAN_PSD_Wechselverkehrszeichen_Typ, getProfileInt( "PSD_06", "PSD_Wechselverkehrszeichen_Typ", 0, profileFile ) );

}


void loadSettings_PSD_LR_01( char profileFile[] )
{
    putValue( KCAN_PSD_LR_01_MUX, getProfileInt( "PSD_LR_01", "PSD_LR_01_MUX", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Attribut_1_Offset, getProfileFloat( "PSD_LR_01", "PSD_LR_Attribut_1_Offset", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Attribut_1_Wert, getProfileInt( "PSD_LR_01", "PSD_LR_Attribut_1_Wert", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Attribut_2_Offset, getProfileFloat( "PSD_LR_01", "PSD_LR_Attribut_2_Offset", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Attribut_2_Wert, getProfileInt( "PSD_LR_01", "PSD_LR_Attribut_2_Wert", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Attribut_3_Offset, getProfileFloat( "PSD_LR_01", "PSD_LR_Attribut_3_Offset", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Attribut_3_Wert, getProfileInt( "PSD_LR_01", "PSD_LR_Attribut_3_Wert", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Fahrzeug_Pos, getProfileFloat( "PSD_LR_01", "PSD_LR_Fahrzeug_Pos", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Globale_Steigung, getProfileFloat( "PSD_LR_01", "PSD_LR_Globale_Steigung", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Globale_Steigung_Vorz, getProfileInt( "PSD_LR_01", "PSD_LR_Globale_Steigung_Vorz", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Koeff_1_Amp, getProfileFloat( "PSD_LR_01", "PSD_LR_Koeff_1_Amp", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Koeff_1_Phase, getProfileFloat( "PSD_LR_01", "PSD_LR_Koeff_1_Phase", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Koeff_2_Amp, getProfileFloat( "PSD_LR_01", "PSD_LR_Koeff_2_Amp", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Koeff_2_Phase, getProfileFloat( "PSD_LR_01", "PSD_LR_Koeff_2_Phase", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Koeff_3_Amp, getProfileFloat( "PSD_LR_01", "PSD_LR_Koeff_3_Amp", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Koeff_3_Phase, getProfileFloat( "PSD_LR_01", "PSD_LR_Koeff_3_Phase", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Koeffizientensatz_Nr, getProfileInt( "PSD_LR_01", "PSD_LR_Koeffizientensatz_Nr", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Max_Koeff_Amp, getProfileInt( "PSD_LR_01", "PSD_LR_Max_Koeff_Amp", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Profil_Laenge, getProfileFloat( "PSD_LR_01", "PSD_LR_Profil_Laenge", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Profil_Nummer, getProfileInt( "PSD_LR_01", "PSD_LR_Profil_Nummer", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Reset, getProfileInt( "PSD_LR_01", "PSD_LR_Reset", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Steigung_1_Offset, getProfileFloat( "PSD_LR_01", "PSD_LR_Steigung_1_Offset", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Steigung_1_Vorz, getProfileInt( "PSD_LR_01", "PSD_LR_Steigung_1_Vorz", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Steigung_1_Wert, getProfileFloat( "PSD_LR_01", "PSD_LR_Steigung_1_Wert", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Steigung_2_Offset, getProfileFloat( "PSD_LR_01", "PSD_LR_Steigung_2_Offset", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Steigung_2_Vorz, getProfileInt( "PSD_LR_01", "PSD_LR_Steigung_2_Vorz", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Steigung_2_Wert, getProfileFloat( "PSD_LR_01", "PSD_LR_Steigung_2_Wert", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Steigung_3_Offset, getProfileFloat( "PSD_LR_01", "PSD_LR_Steigung_3_Offset", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Steigung_3_Vorz, getProfileInt( "PSD_LR_01", "PSD_LR_Steigung_3_Vorz", 0, profileFile ) );
    putValue( KCAN_PSD_LR_Steigung_3_Wert, getProfileFloat( "PSD_LR_01", "PSD_LR_Steigung_3_Wert", 0, profileFile ) );

}


void loadSettings_Radio_01( char profileFile[] )
{
    putValue( KCAN_RA_AM_Tuning, getProfileInt( "Radio_01", "RA_AM_Tuning", 0, profileFile ) );
    putValue( KCAN_RA_Frequency, getProfileInt( "Radio_01", "RA_Frequency", 0, profileFile ) );
    putValue( KCAN_RA_Frequency_unit, getProfileInt( "Radio_01", "RA_Frequency_unit", 0, profileFile ) );
    putValue( KCAN_RA_PowerAmpOn, getProfileInt( "Radio_01", "RA_PowerAmpOn", 0, profileFile ) );
    putValue( KCAN_RA_Radio_Error_Flag, getProfileInt( "Radio_01", "RA_Radio_Error_Flag", 0, profileFile ) );
    putValue( KCAN_RA_Radio_mute, getProfileInt( "Radio_01", "RA_Radio_mute", 0, profileFile ) );
    putValue( KCAN_RA_Radio_on, getProfileInt( "Radio_01", "RA_Radio_on", 0, profileFile ) );
    putValue( KCAN_RA_Radio_Surround, getProfileInt( "Radio_01", "RA_Radio_Surround", 0, profileFile ) );
    putValue( KCAN_RA_VNC_OFF, getProfileInt( "Radio_01", "RA_VNC_OFF", 0, profileFile ) );

}


void loadSettings_Rear_View_04( char profileFile[] )
{
    putValue( KCAN_VPS_PaCo_Button, getProfileInt( "Rear_View_04", "VPS_PaCo_Button", 0, profileFile ) );
    putValue( KCAN_VPS_PaCo_CurrentBirdview, getProfileInt( "Rear_View_04", "VPS_PaCo_CurrentBirdview", 0, profileFile ) );
    putValue( KCAN_VPS_PaCo_CurrentMode, getProfileInt( "Rear_View_04", "VPS_PaCo_CurrentMode", 0, profileFile ) );
    putValue( KCAN_VPS_PaCo_CurrentRVCscreen, getProfileInt( "Rear_View_04", "VPS_PaCo_CurrentRVCscreen", 0, profileFile ) );
    putValue( KCAN_VPS_PaCo_CurrentVideoState, getProfileInt( "Rear_View_04", "VPS_PaCo_CurrentVideoState", 0, profileFile ) );
    putValue( KCAN_VPS_PaCo_CurrentView, getProfileInt( "Rear_View_04", "VPS_PaCo_CurrentView", 0, profileFile ) );
    putValue( KCAN_VPS_PaCo_MainState, getProfileInt( "Rear_View_04", "VPS_PaCo_MainState", 0, profileFile ) );

}


void loadSettings_Rear_View_06( char profileFile[] )
{
    putValue( KCAN_Kam_Anf_Meldung, getProfileInt( "Rear_View_06", "Kam_Anf_Meldung", 0, profileFile ) );
    putValue( KCAN_Kam_PaCo_MainState, getProfileInt( "Rear_View_06", "Kam_PaCo_MainState", 0, profileFile ) );

}


void loadSettings_Reichweite_01( char profileFile[] )
{
    putValue( KCAN_RW_Gesamt_Reichweite, getProfileInt( "Reichweite_01", "RW_Gesamt_Reichweite", 0, profileFile ) );
    putValue( KCAN_RW_Gesamt_Reichweite_Max_Anzeige, getProfileInt( "Reichweite_01", "RW_Gesamt_Reichweite_Max_Anzeige", 0, profileFile ) );
    putValue( KCAN_RW_Prim_Reichweitenv_Einheit, getProfileInt( "Reichweite_01", "RW_Prim_Reichweitenv_Einheit", 0, profileFile ) );
    putValue( KCAN_RW_Prim_Reichweitenverbrauch, getProfileFloat( "Reichweite_01", "RW_Prim_Reichweitenverbrauch", 0, profileFile ) );
    putValue( KCAN_RW_Primaer_Reichweite, getProfileInt( "Reichweite_01", "RW_Primaer_Reichweite", 0, profileFile ) );
    putValue( KCAN_RW_Reservewarnung_2_aktiv, getProfileInt( "Reichweite_01", "RW_Reservewarnung_2_aktiv", 0, profileFile ) );
    putValue( KCAN_RW_RWDS_Lastprofil, getProfileInt( "Reichweite_01", "RW_RWDS_Lastprofil", 0, profileFile ) );

}


void loadSettings_Reichweite_02( char profileFile[] )
{
    putValue( KCAN_RW_Gesamt_Reichweite_Anzeige, getProfileInt( "Reichweite_02", "RW_Gesamt_Reichweite_Anzeige", 0, profileFile ) );
    putValue( KCAN_RW_Primaer_Reichweite_Anzeige, getProfileInt( "Reichweite_02", "RW_Primaer_Reichweite_Anzeige", 0, profileFile ) );
    putValue( KCAN_RW_Reichweite_Einheit_Anzeige, getProfileInt( "Reichweite_02", "RW_Reichweite_Einheit_Anzeige", 0, profileFile ) );
    putValue( KCAN_RW_Reservewarnung_aktiv, getProfileInt( "Reichweite_02", "RW_Reservewarnung_aktiv", 0, profileFile ) );
    putValue( KCAN_RW_Sek_Reichweitenv_Einheit, getProfileInt( "Reichweite_02", "RW_Sek_Reichweitenv_Einheit", 0, profileFile ) );
    putValue( KCAN_RW_Sek_Reichweitenverbrauch, getProfileFloat( "Reichweite_02", "RW_Sek_Reichweitenverbrauch", 0, profileFile ) );
    putValue( KCAN_RW_Sekundaer_Reichweite, getProfileInt( "Reichweite_02", "RW_Sekundaer_Reichweite", 0, profileFile ) );
    putValue( KCAN_RW_Sekundaer_Reichweite_Anzeige, getProfileInt( "Reichweite_02", "RW_Sekundaer_Reichweite_Anzeige", 0, profileFile ) );
    putValue( KCAN_RW_Tendenz, getProfileInt( "Reichweite_02", "RW_Tendenz", 0, profileFile ) );
    putValue( KCAN_RW_Texte, getProfileInt( "Reichweite_02", "RW_Texte", 0, profileFile ) );

}


void loadSettings_Reichweite_03( char profileFile[] )
{
    putValue( KCAN_RW_Prim_rRWB_aktiv, getProfileInt( "Reichweite_03", "RW_Prim_rRWB_aktiv", 0, profileFile ) );
    putValue( KCAN_RW_Prim_rRWB_Reichw_Anz, getProfileInt( "Reichweite_03", "RW_Prim_rRWB_Reichw_Anz", 0, profileFile ) );
    putValue( KCAN_RW_Prim_rRWB_Reichw_Gesamt_Anz, getProfileInt( "Reichweite_03", "RW_Prim_rRWB_Reichw_Gesamt_Anz", 0, profileFile ) );
    putValue( KCAN_RW_Prim_rRWB_Reichw_Max_Ges_Anz, getProfileInt( "Reichweite_03", "RW_Prim_rRWB_Reichw_Max_Ges_Anz", 0, profileFile ) );
    putValue( KCAN_RW_Prim_rRWB_Reichw_Rest_E_Anz, getProfileInt( "Reichweite_03", "RW_Prim_rRWB_Reichw_Rest_E_Anz", 0, profileFile ) );
    putValue( KCAN_RW_Prim_statische_Reichw_Anz, getProfileInt( "Reichweite_03", "RW_Prim_statische_Reichw_Anz", 0, profileFile ) );

}


void loadSettings_RKA_01( char profileFile[] )
{
    putValue( KCAN_RKA_FMVSS138_Lampe, getProfileInt( "RKA_01", "RKA_FMVSS138_Lampe", 0, profileFile ) );
    putValue( KCAN_RKA_FMVSS138_MIL, getProfileInt( "RKA_01", "RKA_FMVSS138_MIL", 0, profileFile ) );
    putValue( KCAN_RKA_Reifentyp, getProfileInt( "RKA_01", "RKA_Reifentyp", 0, profileFile ) );
    putValue( KCAN_RKA_Warnungen_02, getProfileInt( "RKA_01", "RKA_Warnungen_02", 0, profileFile ) );

}


void loadSettings_RLS_01( char profileFile[] )
{
    putValue( KCAN_LS_defekt, getProfileInt( "RLS_01", "LS_defekt", 0, profileFile ) );
    putValue( KCAN_LS_Helligkeit_FW_RLS_01, getProfileInt( "RLS_01", "LS_Helligkeit_FW_RLS_01", 0, profileFile ) );
    putValue( KCAN_LS_Helligkeit_IR_RLS_01, getProfileInt( "RLS_01", "LS_Helligkeit_IR_RLS_01", 0, profileFile ) );
    putValue( KCAN_LS_Verbau, getProfileInt( "RLS_01", "LS_Verbau", 0, profileFile ) );
    putValue( KCAN_RLS_Vorfeldhelligkeit_Boost_RLS_01, getProfileInt( "RLS_01", "RLS_Vorfeldhelligkeit_Boost_RLS_01", 0, profileFile ) );
    putValue( KCAN_RS_defekt, getProfileInt( "RLS_01", "RS_defekt", 0, profileFile ) );
    putValue( KCAN_RS_Regenmenge_RLS_01, getProfileInt( "RLS_01", "RS_Regenmenge_RLS_01", 0, profileFile ) );
    putValue( KCAN_RS_Schwall_RLS_01, getProfileInt( "RLS_01", "RS_Schwall_RLS_01", 0, profileFile ) );
    putValue( KCAN_RS_Verbau, getProfileInt( "RLS_01", "RS_Verbau", 0, profileFile ) );
    putValue( KCAN_RS_Verglasung_schliessen_RLS_01, getProfileInt( "RLS_01", "RS_Verglasung_schliessen_RLS_01", 0, profileFile ) );
    putValue( KCAN_RS_Wischergeschwindigkeit_RLS_01, getProfileInt( "RLS_01", "RS_Wischergeschwindigkeit_RLS_01", 0, profileFile ) );
    putValue( KCAN_SLS_Helligkeit_IR, getProfileInt( "RLS_01", "SLS_Helligkeit_IR", 0, profileFile ) );

}


void loadSettings_RLS_02( char profileFile[] )
{
    putValue( KCAN_LS_Autobahnfahrlicht, getProfileInt( "RLS_02", "LS_Autobahnfahrlicht", 0, profileFile ) );
    putValue( KCAN_LS_Dunkel, getProfileInt( "RLS_02", "LS_Dunkel", 0, profileFile ) );
    putValue( KCAN_LS_Error, getProfileInt( "RLS_02", "LS_Error", 0, profileFile ) );
    putValue( KCAN_LS_Helligkeit_FW_RLS_02, getProfileInt( "RLS_02", "LS_Helligkeit_FW_RLS_02", 0, profileFile ) );
    putValue( KCAN_LS_Helligkeit_IR_RLS_02, getProfileInt( "RLS_02", "LS_Helligkeit_IR_RLS_02", 0, profileFile ) );
    putValue( KCAN_LS_Licht_ein, getProfileInt( "RLS_02", "LS_Licht_ein", 0, profileFile ) );
    putValue( KCAN_LS_Licht_ein_invers, getProfileInt( "RLS_02", "LS_Licht_ein_invers", 0, profileFile ) );
    putValue( KCAN_RLS_Qualifizierungsbit, getProfileInt( "RLS_02", "RLS_Qualifizierungsbit", 0, profileFile ) );
    putValue( KCAN_RLS_ResponseError, getProfileInt( "RLS_02", "RLS_ResponseError", 0, profileFile ) );
    putValue( KCAN_RLS_Vorfeldhelligkeit_Boost_RLS_02, getProfileInt( "RLS_02", "RLS_Vorfeldhelligkeit_Boost_RLS_02", 0, profileFile ) );
    putValue( KCAN_RS_AdaptierungError, getProfileInt( "RLS_02", "RS_AdaptierungError", 0, profileFile ) );
    putValue( KCAN_RS_Error, getProfileInt( "RLS_02", "RS_Error", 0, profileFile ) );
    putValue( KCAN_RS_Regenfahrlicht, getProfileInt( "RLS_02", "RS_Regenfahrlicht", 0, profileFile ) );
    putValue( KCAN_RS_Regenmenge_RLS_02, getProfileInt( "RLS_02", "RS_Regenmenge_RLS_02", 0, profileFile ) );
    putValue( KCAN_RS_Schwall_RLS_02, getProfileInt( "RLS_02", "RS_Schwall_RLS_02", 0, profileFile ) );
    putValue( KCAN_RS_Verglasung_schliessen_RLS_02, getProfileInt( "RLS_02", "RS_Verglasung_schliessen_RLS_02", 0, profileFile ) );
    putValue( KCAN_RS_versParklage_Wischer, getProfileInt( "RLS_02", "RS_versParklage_Wischer", 0, profileFile ) );
    putValue( KCAN_RS_Wischergeschwindigkeit_RLS_02, getProfileInt( "RLS_02", "RS_Wischergeschwindigkeit_RLS_02", 0, profileFile ) );

}


void loadSettings_SAL_01( char profileFile[] )
{
    putValue( KCAN_AFS_Lampe, getProfileInt( "SAL_01", "AFS_Lampe", 0, profileFile ) );
    putValue( KCAN_BCM2_Bremsl_durch_ECD, getProfileInt( "SAL_01", "BCM2_Bremsl_durch_ECD", 0, profileFile ) );
    putValue( KCAN_DLI_Ambex_RefStatus, getProfileInt( "SAL_01", "DLI_Ambex_RefStatus", 0, profileFile ) );
    putValue( KCAN_LWR_Lampe, getProfileInt( "SAL_01", "LWR_Lampe", 0, profileFile ) );
    putValue( KCAN_LWR_Reisemodus_Texte, getProfileInt( "SAL_01", "LWR_Reisemodus_Texte", 0, profileFile ) );
    putValue( KCAN_LWR_SollDC, getProfileFloat( "SAL_01", "LWR_SollDC", 0, profileFile ) );
    putValue( KCAN_SAL_Aussenbeleuchtung_defekt, getProfileInt( "SAL_01", "SAL_Aussenbeleuchtung_defekt", 0, profileFile ) );
    putValue( KCAN_SAL_Blinkerzyklus_L, getProfileInt( "SAL_01", "SAL_Blinkerzyklus_L", 0, profileFile ) );
    putValue( KCAN_SAL_Blinkerzyklus_R, getProfileInt( "SAL_01", "SAL_Blinkerzyklus_R", 0, profileFile ) );
    putValue( KCAN_SAL_BLK_L_Anf, getProfileInt( "SAL_01", "SAL_BLK_L_Anf", 0, profileFile ) );
    putValue( KCAN_SAL_BLK_R_Anf, getProfileInt( "SAL_01", "SAL_BLK_R_Anf", 0, profileFile ) );
    putValue( KCAN_SAL_Bremszyklus, getProfileInt( "SAL_01", "SAL_Bremszyklus", 0, profileFile ) );
    putValue( KCAN_SAL_BRL_Anf, getProfileInt( "SAL_01", "SAL_BRL_Anf", 0, profileFile ) );
    putValue( KCAN_SAL_CH_Anf, getProfileInt( "SAL_01", "SAL_CH_Anf", 0, profileFile ) );
    putValue( KCAN_SAL_HGB_Anf, getProfileInt( "SAL_01", "SAL_HGB_Anf", 0, profileFile ) );
    putValue( KCAN_SAL_Kl_15, getProfileInt( "SAL_01", "SAL_Kl_15", 0, profileFile ) );
    putValue( KCAN_SAL_Kl_15_vFzg, getProfileInt( "SAL_01", "SAL_Kl_15_vFzg", 0, profileFile ) );
    putValue( KCAN_SAL_Kl_15_vFzg_S, getProfileInt( "SAL_01", "SAL_Kl_15_vFzg_S", 0, profileFile ) );
    putValue( KCAN_SAL_KL_50, getProfileInt( "SAL_01", "SAL_KL_50", 0, profileFile ) );
    putValue( KCAN_SAL_KL_50_5s, getProfileInt( "SAL_01", "SAL_KL_50_5s", 0, profileFile ) );
    putValue( KCAN_SAL_Kl_75, getProfileInt( "SAL_01", "SAL_Kl_75", 0, profileFile ) );
    putValue( KCAN_SAL_KL_75_vFzg, getProfileInt( "SAL_01", "SAL_KL_75_vFzg", 0, profileFile ) );
    putValue( KCAN_SAL_KL_75a, getProfileInt( "SAL_01", "SAL_KL_75a", 0, profileFile ) );
    putValue( KCAN_SAL_KL_75a_vFzg, getProfileInt( "SAL_01", "SAL_KL_75a_vFzg", 0, profileFile ) );
    putValue( KCAN_SAL_KZL_Anf, getProfileInt( "SAL_01", "SAL_KZL_Anf", 0, profileFile ) );
    putValue( KCAN_SAL_LDS_Abblendlicht_Anf, getProfileInt( "SAL_01", "SAL_LDS_Abblendlicht_Anf", 0, profileFile ) );
    putValue( KCAN_SAL_LDS_Assistenzfahrlicht_Anf, getProfileInt( "SAL_01", "SAL_LDS_Assistenzfahrlicht_Anf", 0, profileFile ) );
    putValue( KCAN_SAL_LDS_Nullstellung_Anf, getProfileInt( "SAL_01", "SAL_LDS_Nullstellung_Anf", 0, profileFile ) );
    putValue( KCAN_SAL_LDS_Standlicht_Anf, getProfileInt( "SAL_01", "SAL_LDS_Standlicht_Anf", 0, profileFile ) );
    putValue( KCAN_SAL_LH_Anf, getProfileInt( "SAL_01", "SAL_LH_Anf", 0, profileFile ) );
    putValue( KCAN_SAL_NSL_Anf, getProfileInt( "SAL_01", "SAL_NSL_Anf", 0, profileFile ) );
    putValue( KCAN_SAL_PL_L_Anf, getProfileInt( "SAL_01", "SAL_PL_L_Anf", 0, profileFile ) );
    putValue( KCAN_SAL_PL_R_Anf, getProfileInt( "SAL_01", "SAL_PL_R_Anf", 0, profileFile ) );
    putValue( KCAN_SAL_RFL_Anf, getProfileInt( "SAL_01", "SAL_RFL_Anf", 0, profileFile ) );
    putValue( KCAN_SAL_SL_Anf, getProfileInt( "SAL_01", "SAL_SL_Anf", 0, profileFile ) );
    putValue( KCAN_SAL_WBT_Bel, getProfileInt( "SAL_01", "SAL_WBT_Bel", 0, profileFile ) );
    putValue( KCAN_SBBR_SL_AnimDimm_Freigabe, getProfileInt( "SAL_01", "SBBR_SL_AnimDimm_Freigabe", 0, profileFile ) );

}


void loadSettings_SAM_01( char profileFile[] )
{
    putValue( KCAN_BCM_Bremsbelag_Sensor_CND, getProfileInt( "SAM_01", "BCM_Bremsbelag_Sensor_CND", 0, profileFile ) );
    putValue( KCAN_BCM_Bremsbelag_Sensor_NAR, getProfileInt( "SAM_01", "BCM_Bremsbelag_Sensor_NAR", 0, profileFile ) );
    putValue( KCAN_BCM_Bremsbelag_Sensor_Rdw, getProfileInt( "SAM_01", "BCM_Bremsbelag_Sensor_Rdw", 0, profileFile ) );
    putValue( KCAN_BCM_Tankklappensteller_Fehler, getProfileInt( "SAM_01", "BCM_Tankklappensteller_Fehler", 0, profileFile ) );
    putValue( KCAN_BRL_Bremslicht_Schalter, getProfileInt( "SAM_01", "BRL_Bremslicht_Schalter", 0, profileFile ) );
    putValue( KCAN_HD_Hauptraste, getProfileInt( "SAM_01", "HD_Hauptraste", 0, profileFile ) );
    putValue( KCAN_HD_Vorraste, getProfileInt( "SAM_01", "HD_Vorraste", 0, profileFile ) );
    putValue( KCAN_HW_Drehfalle_Tuer_HL, getProfileInt( "SAM_01", "HW_Drehfalle_Tuer_HL", 0, profileFile ) );
    putValue( KCAN_HW_Drehfalle_Tuer_HR, getProfileInt( "SAM_01", "HW_Drehfalle_Tuer_HR", 0, profileFile ) );
    putValue( KCAN_HW_HD_Taste_Innenraum, getProfileInt( "SAM_01", "HW_HD_Taste_Innenraum", 0, profileFile ) );
    putValue( KCAN_HW_HSB_erkannt, getProfileInt( "SAM_01", "HW_HSB_erkannt", 0, profileFile ) );
    putValue( KCAN_HW_MH_Schalter1, getProfileInt( "SAM_01", "HW_MH_Schalter1", 0, profileFile ) );
    putValue( KCAN_HW_MH_Schalter2, getProfileInt( "SAM_01", "HW_MH_Schalter2", 0, profileFile ) );
    putValue( KCAN_HW_Softtouch_betaetigt, getProfileInt( "SAM_01", "HW_Softtouch_betaetigt", 0, profileFile ) );
    putValue( KCAN_HW_Status_Schloss_gesafet_HL, getProfileInt( "SAM_01", "HW_Status_Schloss_gesafet_HL", 0, profileFile ) );
    putValue( KCAN_HW_Status_Schloss_gesafet_HR, getProfileInt( "SAM_01", "HW_Status_Schloss_gesafet_HR", 0, profileFile ) );
    putValue( KCAN_HW_Status_Schloss_verriegelt_HL, getProfileInt( "SAM_01", "HW_Status_Schloss_verriegelt_HL", 0, profileFile ) );
    putValue( KCAN_HW_Status_Schloss_verriegelt_HR, getProfileInt( "SAM_01", "HW_Status_Schloss_verriegelt_HR", 0, profileFile ) );
    putValue( KCAN_HW_Tankdeckel_offen, getProfileInt( "SAM_01", "HW_Tankdeckel_offen", 0, profileFile ) );
    putValue( KCAN_HW_Toggle_Taster, getProfileInt( "SAM_01", "HW_Toggle_Taster", 0, profileFile ) );
    putValue( KCAN_KST_BSW_Fehlermode2, getProfileInt( "SAM_01", "KST_BSW_Fehlermode2", 0, profileFile ) );
    putValue( KCAN_KST_BSW_Klemme_15_HW_Ist, getProfileInt( "SAM_01", "KST_BSW_Klemme_15_HW_Ist", 0, profileFile ) );
    putValue( KCAN_KST_BSW_Klemmenhochschalten_Sper, getProfileInt( "SAM_01", "KST_BSW_Klemmenhochschalten_Sper", 0, profileFile ) );
    putValue( KCAN_KST_BSW_Not_Taster_betaetigt, getProfileInt( "SAM_01", "KST_BSW_Not_Taster_betaetigt", 0, profileFile ) );
    putValue( KCAN_KST_BSW_ZAT_betaetigt, getProfileInt( "SAM_01", "KST_BSW_ZAT_betaetigt", 0, profileFile ) );
    putValue( KCAN_SAL_li1_Blinker_Status, getProfileInt( "SAM_01", "SAL_li1_Blinker_Status", 0, profileFile ) );
    putValue( KCAN_SAL_re1_Blinker_Status, getProfileInt( "SAM_01", "SAL_re1_Blinker_Status", 0, profileFile ) );
    putValue( KCAN_SAM_Fehler_DC_LWR, getProfileInt( "SAM_01", "SAM_Fehler_DC_LWR", 0, profileFile ) );

}


void loadSettings_Sensorik_Dimmung_01( char profileFile[] )
{
    putValue( KCAN_KBI_Dimmpoti, getProfileInt( "Sensorik_Dimmung_01", "KBI_Dimmpoti", 0, profileFile ) );
    putValue( KCAN_KBI_Phototransistor, getProfileInt( "Sensorik_Dimmung_01", "KBI_Phototransistor", 0, profileFile ) );

}


void loadSettings_SmaLi_Control_Frame_01( char profileFile[] )
{
    putValue( KCAN_SmaLi_brightness, getProfileInt( "SmaLi_Control_Frame_01", "SmaLi_brightness", 0, profileFile ) );
    putValue( KCAN_SmaLi_Cnt_05, getProfileInt( "SmaLi_Control_Frame_01", "SmaLi_Cnt_05", 0, profileFile ) );
    putValue( KCAN_SmaLi_CtrlCmd_01, getProfileInt( "SmaLi_Control_Frame_01", "SmaLi_CtrlCmd_01", 0, profileFile ) );
    putValue( KCAN_SmaLi_Loops, getProfileInt( "SmaLi_Control_Frame_01", "SmaLi_Loops", 0, profileFile ) );
    putValue( KCAN_SmaLi_MovieBundleVersion, getProfileInt( "SmaLi_Control_Frame_01", "SmaLi_MovieBundleVersion", 0, profileFile ) );
    putValue( KCAN_SmaLi_MovieID, getProfileInt( "SmaLi_Control_Frame_01", "SmaLi_MovieID", 0, profileFile ) );
    putValue( KCAN_SmaLi_SlotID_05, getProfileInt( "SmaLi_Control_Frame_01", "SmaLi_SlotID_05", 0, profileFile ) );

}


void loadSettings_SmaLi_Daten_Frame_01( char profileFile[] )
{
    putValue( KCAN_SmaLi_Cnt_01, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_Cnt_01", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_01, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_01", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_02, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_02", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_03, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_03", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_04, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_04", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_05, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_05", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_06, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_06", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_07, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_07", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_08, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_08", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_09, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_09", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_10, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_10", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_11, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_11", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_12, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_12", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_13, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_13", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_14, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_ColorValue_14", 0, profileFile ) );
    putValue( KCAN_SmaLi_FrameCmd_01, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_FrameCmd_01", 0, profileFile ) );
    putValue( KCAN_SmaLi_length, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_length", 0, profileFile ) );
    putValue( KCAN_SmaLi_SlotID_01, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_SlotID_01", 0, profileFile ) );
    putValue( KCAN_SmaLi_StartIndex, getProfileInt( "SmaLi_Daten_Frame_01", "SmaLi_StartIndex", 0, profileFile ) );

}


void loadSettings_SmaLi_Daten_Frame_02( char profileFile[] )
{
    putValue( KCAN_SmaLi_Cnt_02, getProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_Cnt_02", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_15, getProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_15", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_16, getProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_16", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_17, getProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_17", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_18, getProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_18", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_19, getProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_19", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_20, getProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_20", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_21, getProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_21", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_22, getProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_22", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_23, getProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_23", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_24, getProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_24", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_25, getProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_25", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_26, getProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_26", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_27, getProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_27", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_28, getProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_28", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_29, getProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_ColorValue_29", 0, profileFile ) );
    putValue( KCAN_SmaLi_FrameCmd_02, getProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_FrameCmd_02", 0, profileFile ) );
    putValue( KCAN_SmaLi_SlotID_02, getProfileInt( "SmaLi_Daten_Frame_02", "SmaLi_SlotID_02", 0, profileFile ) );

}


void loadSettings_SmaLi_Daten_Frame_03( char profileFile[] )
{
    putValue( KCAN_SmaLi_Cnt_03, getProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_Cnt_03", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_30, getProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_30", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_31, getProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_31", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_32, getProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_32", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_33, getProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_33", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_34, getProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_34", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_35, getProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_35", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_36, getProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_36", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_37, getProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_37", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_38, getProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_38", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_39, getProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_39", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_40, getProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_40", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_41, getProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_41", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_42, getProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_42", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_43, getProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_43", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_44, getProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_ColorValue_44", 0, profileFile ) );
    putValue( KCAN_SmaLi_FrameCmd_03, getProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_FrameCmd_03", 0, profileFile ) );
    putValue( KCAN_SmaLi_SlotID_03, getProfileInt( "SmaLi_Daten_Frame_03", "SmaLi_SlotID_03", 0, profileFile ) );

}


void loadSettings_SmaLi_Daten_Frame_04( char profileFile[] )
{
    putValue( KCAN_SmaLi_Cnt_04, getProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_Cnt_04", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_45, getProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_45", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_46, getProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_46", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_47, getProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_47", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_48, getProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_48", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_49, getProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_49", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_50, getProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_50", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_51, getProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_51", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_52, getProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_52", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_53, getProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_53", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_54, getProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_54", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_55, getProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_55", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_56, getProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_56", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_57, getProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_57", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_58, getProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_58", 0, profileFile ) );
    putValue( KCAN_SmaLi_ColorValue_59, getProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_ColorValue_59", 0, profileFile ) );
    putValue( KCAN_SmaLi_FrameCmd_04, getProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_FrameCmd_04", 0, profileFile ) );
    putValue( KCAN_SmaLi_SlotID_04, getProfileInt( "SmaLi_Daten_Frame_04", "SmaLi_SlotID_04", 0, profileFile ) );

}


void loadSettings_SmaLi_Response_Frame_01( char profileFile[] )
{
    putValue( KCAN_SmaLi_AppSwVersion, getProfileInt( "SmaLi_Response_Frame_01", "SmaLi_AppSwVersion", 0, profileFile ) );
    putValue( KCAN_SmaLi_availMemory, getProfileInt( "SmaLi_Response_Frame_01", "SmaLi_availMemory", 0, profileFile ) );
    putValue( KCAN_SmaLi_Cnt_06, getProfileInt( "SmaLi_Response_Frame_01", "SmaLi_Cnt_06", 0, profileFile ) );
    putValue( KCAN_SmaLi_CtrlCmdRsp_01, getProfileInt( "SmaLi_Response_Frame_01", "SmaLi_CtrlCmdRsp_01", 0, profileFile ) );
    putValue( KCAN_SmaLi_error_cause, getProfileInt( "SmaLi_Response_Frame_01", "SmaLi_error_cause", 0, profileFile ) );
    putValue( KCAN_SmaLi_InterfaceVersion, getProfileInt( "SmaLi_Response_Frame_01", "SmaLi_InterfaceVersion", 0, profileFile ) );
    putValue( KCAN_SmaLi_MovieIDRsp, getProfileInt( "SmaLi_Response_Frame_01", "SmaLi_MovieIDRsp", 0, profileFile ) );
    putValue( KCAN_SmaLi_numLEDs, getProfileInt( "SmaLi_Response_Frame_01", "SmaLi_numLEDs", 0, profileFile ) );
    putValue( KCAN_SmaLi_numOfSlots, getProfileInt( "SmaLi_Response_Frame_01", "SmaLi_numOfSlots", 0, profileFile ) );
    putValue( KCAN_SmaLi_SavedMovieBundleVersion, getProfileInt( "SmaLi_Response_Frame_01", "SmaLi_SavedMovieBundleVersion", 0, profileFile ) );
    putValue( KCAN_SmaLi_SlotID_06, getProfileInt( "SmaLi_Response_Frame_01", "SmaLi_SlotID_06", 0, profileFile ) );
    putValue( KCAN_SmaLi_xPosCenter, getProfileInt( "SmaLi_Response_Frame_01", "SmaLi_xPosCenter", 0, profileFile ) );
    putValue( KCAN_SmaLi_xPosPassengerLeft, getProfileInt( "SmaLi_Response_Frame_01", "SmaLi_xPosPassengerLeft", 0, profileFile ) );
    putValue( KCAN_SmaLi_xPosPassengerRight, getProfileInt( "SmaLi_Response_Frame_01", "SmaLi_xPosPassengerRight", 0, profileFile ) );

}


void loadSettings_SMLS_01( char profileFile[] )
{
    putValue( KCAN_BH_Blinker_Fehler, getProfileInt( "SMLS_01", "BH_Blinker_Fehler", 0, profileFile ) );
    putValue( KCAN_BH_Blinker_li, getProfileInt( "SMLS_01", "BH_Blinker_li", 0, profileFile ) );
    putValue( KCAN_BH_Blinker_re, getProfileInt( "SMLS_01", "BH_Blinker_re", 0, profileFile ) );
    putValue( KCAN_BH_Fernlicht, getProfileInt( "SMLS_01", "BH_Fernlicht", 0, profileFile ) );
    putValue( KCAN_BH_Lichthupe, getProfileInt( "SMLS_01", "BH_Lichthupe", 0, profileFile ) );
    putValue( KCAN_FAS_Taster, getProfileInt( "SMLS_01", "FAS_Taster", 0, profileFile ) );
    putValue( KCAN_FAS_Taster_Fehler, getProfileInt( "SMLS_01", "FAS_Taster_Fehler", 0, profileFile ) );
    putValue( KCAN_LRH_aktiv, getProfileInt( "SMLS_01", "LRH_aktiv", 0, profileFile ) );
    putValue( KCAN_LRH_on_off, getProfileInt( "SMLS_01", "LRH_on_off", 0, profileFile ) );
    putValue( KCAN_LSS_Tastencode, getProfileInt( "SMLS_01", "LSS_Tastencode", 0, profileFile ) );
    putValue( KCAN_SMLS_Hupe, getProfileInt( "SMLS_01", "SMLS_Hupe", 0, profileFile ) );
    putValue( KCAN_SMLS_P_verriegelt, getProfileInt( "SMLS_01", "SMLS_P_verriegelt", 0, profileFile ) );
    putValue( KCAN_SMLS_P_verriegelt_plausibel, getProfileInt( "SMLS_01", "SMLS_P_verriegelt_plausibel", 0, profileFile ) );
    putValue( KCAN_SMLS_PTT, getProfileInt( "SMLS_01", "SMLS_PTT", 0, profileFile ) );
    putValue( KCAN_WH_Frontwaschen, getProfileInt( "SMLS_01", "WH_Frontwaschen", 0, profileFile ) );
    putValue( KCAN_WH_Heckintervall, getProfileInt( "SMLS_01", "WH_Heckintervall", 0, profileFile ) );
    putValue( KCAN_WH_Heckwaschen, getProfileInt( "SMLS_01", "WH_Heckwaschen", 0, profileFile ) );
    putValue( KCAN_WH_Intervall, getProfileInt( "SMLS_01", "WH_Intervall", 0, profileFile ) );
    putValue( KCAN_WH_Intervallstufen, getProfileInt( "SMLS_01", "WH_Intervallstufen", 0, profileFile ) );
    putValue( KCAN_WH_SRA, getProfileInt( "SMLS_01", "WH_SRA", 0, profileFile ) );
    putValue( KCAN_WH_Tipwischen, getProfileInt( "SMLS_01", "WH_Tipwischen", 0, profileFile ) );
    putValue( KCAN_WH_Tipwischen_lang, getProfileInt( "SMLS_01", "WH_Tipwischen_lang", 0, profileFile ) );
    putValue( KCAN_WH_Wischer_Fehler, getProfileInt( "SMLS_01", "WH_Wischer_Fehler", 0, profileFile ) );
    putValue( KCAN_WH_WischerStufe1, getProfileInt( "SMLS_01", "WH_WischerStufe1", 0, profileFile ) );
    putValue( KCAN_WH_WischerStufe2, getProfileInt( "SMLS_01", "WH_WischerStufe2", 0, profileFile ) );

}


void loadSettings_Systeminfo_01( char profileFile[] )
{
    putValue( KCAN_GW_KD_Fehler, getProfileInt( "Systeminfo_01", "GW_KD_Fehler", 0, profileFile ) );
    putValue( KCAN_SI_BUS_01, getProfileInt( "Systeminfo_01", "SI_BUS_01", 0, profileFile ) );
    putValue( KCAN_SI_BUS_02, getProfileInt( "Systeminfo_01", "SI_BUS_02", 0, profileFile ) );
    putValue( KCAN_SI_BUS_03, getProfileInt( "Systeminfo_01", "SI_BUS_03", 0, profileFile ) );
    putValue( KCAN_SI_BUS_04, getProfileInt( "Systeminfo_01", "SI_BUS_04", 0, profileFile ) );
    putValue( KCAN_SI_BUS_05, getProfileInt( "Systeminfo_01", "SI_BUS_05", 0, profileFile ) );
    putValue( KCAN_SI_BUS_06, getProfileInt( "Systeminfo_01", "SI_BUS_06", 0, profileFile ) );
    putValue( KCAN_SI_BUS_07, getProfileInt( "Systeminfo_01", "SI_BUS_07", 0, profileFile ) );
    putValue( KCAN_SI_BUS_08, getProfileInt( "Systeminfo_01", "SI_BUS_08", 0, profileFile ) );
    putValue( KCAN_SI_BUS_09, getProfileInt( "Systeminfo_01", "SI_BUS_09", 0, profileFile ) );
    putValue( KCAN_SI_BUS_10, getProfileInt( "Systeminfo_01", "SI_BUS_10", 0, profileFile ) );
    putValue( KCAN_SI_BUS_11, getProfileInt( "Systeminfo_01", "SI_BUS_11", 0, profileFile ) );
    putValue( KCAN_SI_BUS_12, getProfileInt( "Systeminfo_01", "SI_BUS_12", 0, profileFile ) );
    putValue( KCAN_SI_BUS_13, getProfileInt( "Systeminfo_01", "SI_BUS_13", 0, profileFile ) );
    putValue( KCAN_SI_BUS_14, getProfileInt( "Systeminfo_01", "SI_BUS_14", 0, profileFile ) );
    putValue( KCAN_SI_BUS_15, getProfileInt( "Systeminfo_01", "SI_BUS_15", 0, profileFile ) );
    putValue( KCAN_SI_Bus_Identifikation, getProfileInt( "Systeminfo_01", "SI_Bus_Identifikation", 0, profileFile ) );
    putValue( KCAN_SI_CAB_V10, getProfileInt( "Systeminfo_01", "SI_CAB_V10", 0, profileFile ) );
    putValue( KCAN_SI_Diagnose_Aktiv, getProfileInt( "Systeminfo_01", "SI_Diagnose_Aktiv", 0, profileFile ) );
    putValue( KCAN_SI_NWDF, getProfileInt( "Systeminfo_01", "SI_NWDF", 0, profileFile ) );
    putValue( KCAN_SI_NWDF_gueltig, getProfileInt( "Systeminfo_01", "SI_NWDF_gueltig", 0, profileFile ) );
    putValue( KCAN_SI_P_Mode, getProfileInt( "Systeminfo_01", "SI_P_Mode", 0, profileFile ) );
    putValue( KCAN_SI_P_Mode_gueltig, getProfileInt( "Systeminfo_01", "SI_P_Mode_gueltig", 0, profileFile ) );
    putValue( KCAN_SI_QRS_Mode, getProfileInt( "Systeminfo_01", "SI_QRS_Mode", 0, profileFile ) );
    putValue( KCAN_SI_Sammel_SG_Fehler, getProfileInt( "Systeminfo_01", "SI_Sammel_SG_Fehler", 0, profileFile ) );
    putValue( KCAN_SI_Sammelfehler, getProfileInt( "Systeminfo_01", "SI_Sammelfehler", 0, profileFile ) );
    putValue( KCAN_SI_T_Mode, getProfileInt( "Systeminfo_01", "SI_T_Mode", 0, profileFile ) );
    putValue( KCAN_SI_T_Schutz, getProfileInt( "Systeminfo_01", "SI_T_Schutz", 0, profileFile ) );

}


void loadSettings_TA_01( char profileFile[] )
{
    putValue( KCAN_TA_ACC_Sollstatus, getProfileInt( "TA_01", "TA_ACC_Sollstatus", 0, profileFile ) );
    putValue( KCAN_TA_FoD_Status, getProfileInt( "TA_01", "TA_FoD_Status", 0, profileFile ) );
    putValue( KCAN_TA_Spurwechsel, getProfileInt( "TA_01", "TA_Spurwechsel", 0, profileFile ) );
    putValue( KCAN_TA_Spurwechsel_Ready, getProfileInt( "TA_01", "TA_Spurwechsel_Ready", 0, profileFile ) );
    putValue( KCAN_TA_Status, getProfileInt( "TA_01", "TA_Status", 0, profileFile ) );
    putValue( KCAN_TA_Texte, getProfileInt( "TA_01", "TA_Texte", 0, profileFile ) );
    putValue( KCAN_TA_Texte_02, getProfileInt( "TA_01", "TA_Texte_02", 0, profileFile ) );

}


void loadSettings_Temperaturen_01( char profileFile[] )
{
    putValue( KCAN_KBI_Aussen_Temp_gef, getProfileFloat( "Temperaturen_01", "KBI_Aussen_Temp_gef", 0, profileFile ) );
    putValue( KCAN_KBI_QBit_Aussen_Temp_gef, getProfileInt( "Temperaturen_01", "KBI_QBit_Aussen_Temp_gef", 0, profileFile ) );

}


void loadSettings_Thermo_Verbrauch_01( char profileFile[] )
{
    putValue( KCAN_Thermo_Pred_Innen_Kunde_Anf, getProfileInt( "Thermo_Verbrauch_01", "Thermo_Pred_Innen_Kunde_Anf", 0, profileFile ) );
    putValue( KCAN_Thermo_Pred_Innen_System_Anf, getProfileInt( "Thermo_Verbrauch_01", "Thermo_Pred_Innen_System_Anf", 0, profileFile ) );
    putValue( KCAN_Thermo_Pred_P_dyn_Innen, getProfileInt( "Thermo_Verbrauch_01", "Thermo_Pred_P_dyn_Innen", 0, profileFile ) );
    putValue( KCAN_Thermo_Pred_P_stat_Innen, getProfileInt( "Thermo_Verbrauch_01", "Thermo_Pred_P_stat_Innen", 0, profileFile ) );
    putValue( KCAN_Thermo_Pred_T_dyn_Innen, getProfileInt( "Thermo_Verbrauch_01", "Thermo_Pred_T_dyn_Innen", 0, profileFile ) );
    putValue( KCAN_Thermo_Verbrauch_BTL, getProfileInt( "Thermo_Verbrauch_01", "Thermo_Verbrauch_BTL", 0, profileFile ) );
    putValue( KCAN_Thermo_Verbrauch_BTL_Ueberlauf, getProfileInt( "Thermo_Verbrauch_01", "Thermo_Verbrauch_BTL_Ueberlauf", 0, profileFile ) );
    putValue( KCAN_Thermo_Verbrauch_Innen, getProfileInt( "Thermo_Verbrauch_01", "Thermo_Verbrauch_Innen", 0, profileFile ) );
    putValue( KCAN_Thermo_Verbrauch_Innen_Ueberlauf, getProfileInt( "Thermo_Verbrauch_01", "Thermo_Verbrauch_Innen_Ueberlauf", 0, profileFile ) );

}


void loadSettings_TM_01( char profileFile[] )
{
    putValue( KCAN_bCall_active, getProfileInt( "TM_01", "bCall_active", 0, profileFile ) );
    putValue( KCAN_eCall_Funktionsstatus, getProfileInt( "TM_01", "eCall_Funktionsstatus", 0, profileFile ) );
    putValue( KCAN_eCall_Funktionsstatus_02, getProfileInt( "TM_01", "eCall_Funktionsstatus_02", 0, profileFile ) );
    putValue( KCAN_iCall_active, getProfileInt( "TM_01", "iCall_active", 0, profileFile ) );
    putValue( KCAN_TM_Door_Lock, getProfileInt( "TM_01", "TM_Door_Lock", 0, profileFile ) );
    putValue( KCAN_TM_Door_Unlock, getProfileInt( "TM_01", "TM_Door_Unlock", 0, profileFile ) );
    putValue( KCAN_TM_Nur_Hupen, getProfileInt( "TM_01", "TM_Nur_Hupen", 0, profileFile ) );
    putValue( KCAN_TM_Panik_Alarm, getProfileInt( "TM_01", "TM_Panik_Alarm", 0, profileFile ) );
    putValue( KCAN_TM_Spiegel_Anklappen, getProfileInt( "TM_01", "TM_Spiegel_Anklappen", 0, profileFile ) );
    putValue( KCAN_TM_Warnblinken, getProfileInt( "TM_01", "TM_Warnblinken", 0, profileFile ) );
    putValue( KCAN_TM_ZV_Signatur, getProfileInt( "TM_01", "TM_ZV_Signatur", 0, profileFile ) );

}


void loadSettings_TSG_BT_01( char profileFile[] )
{
    putValue( KCAN_ASW_Warnung_aktiv_BFS, getProfileInt( "TSG_BT_01", "ASW_Warnung_aktiv_BFS", 0, profileFile ) );
    putValue( KCAN_BFS_Status_eTAG, getProfileInt( "TSG_BT_01", "BFS_Status_eTAG", 0, profileFile ) );
    putValue( KCAN_BT_ASW_HMI_defekt, getProfileInt( "TSG_BT_01", "BT_ASW_HMI_defekt", 0, profileFile ) );
    putValue( KCAN_BT_EC_Spiegel_Helligkeit, getProfileFloat( "TSG_BT_01", "BT_EC_Spiegel_Helligkeit", 0, profileFile ) );
    putValue( KCAN_BT_FH_Bew_hoch, getProfileInt( "TSG_BT_01", "BT_FH_Bew_hoch", 0, profileFile ) );
    putValue( KCAN_BT_FH_Bew_tief, getProfileInt( "TSG_BT_01", "BT_FH_Bew_tief", 0, profileFile ) );
    putValue( KCAN_BT_FH_Block, getProfileInt( "TSG_BT_01", "BT_FH_Block", 0, profileFile ) );
    putValue( KCAN_BT_FH_Fang, getProfileInt( "TSG_BT_01", "BT_FH_Fang", 0, profileFile ) );
    putValue( KCAN_BT_FH_normiert, getProfileInt( "TSG_BT_01", "BT_FH_normiert", 0, profileFile ) );
    putValue( KCAN_BT_FH_Oeffnung, getProfileFloat( "TSG_BT_01", "BT_FH_Oeffnung", 0, profileFile ) );
    putValue( KCAN_BT_FH_Pos_oben, getProfileInt( "TSG_BT_01", "BT_FH_Pos_oben", 0, profileFile ) );
    putValue( KCAN_BT_FH_S_AutoHoch, getProfileInt( "TSG_BT_01", "BT_FH_S_AutoHoch", 0, profileFile ) );
    putValue( KCAN_BT_FH_S_AutoTief, getProfileInt( "TSG_BT_01", "BT_FH_S_AutoTief", 0, profileFile ) );
    putValue( KCAN_BT_FH_S_ManHoch, getProfileInt( "TSG_BT_01", "BT_FH_S_ManHoch", 0, profileFile ) );
    putValue( KCAN_BT_FH_S_ManTief, getProfileInt( "TSG_BT_01", "BT_FH_S_ManTief", 0, profileFile ) );
    putValue( KCAN_BT_FH_Thermo, getProfileInt( "TSG_BT_01", "BT_FH_Thermo", 0, profileFile ) );
    putValue( KCAN_BT_gesafet, getProfileInt( "TSG_BT_01", "BT_gesafet", 0, profileFile ) );
    putValue( KCAN_BT_Kisi_Fehler, getProfileInt( "TSG_BT_01", "BT_Kisi_Fehler", 0, profileFile ) );
    putValue( KCAN_BT_Lock_Taster, getProfileInt( "TSG_BT_01", "BT_Lock_Taster", 0, profileFile ) );
    putValue( KCAN_BT_Lock_Taster_inv, getProfileInt( "TSG_BT_01", "BT_Lock_Taster_inv", 0, profileFile ) );
    putValue( KCAN_BT_Lock_Unlock_Taster, getProfileInt( "TSG_BT_01", "BT_Lock_Unlock_Taster", 0, profileFile ) );
    putValue( KCAN_BT_Oben_Block_erw, getProfileInt( "TSG_BT_01", "BT_Oben_Block_erw", 0, profileFile ) );
    putValue( KCAN_BT_Schliesstaster, getProfileInt( "TSG_BT_01", "BT_Schliesstaster", 0, profileFile ) );
    putValue( KCAN_BT_Schluesselschalter_auf, getProfileInt( "TSG_BT_01", "BT_Schluesselschalter_auf", 0, profileFile ) );
    putValue( KCAN_BT_Schluesselschalter_zu, getProfileInt( "TSG_BT_01", "BT_Schluesselschalter_zu", 0, profileFile ) );
    putValue( KCAN_BT_Schluesselschalter_zu_inv, getProfileInt( "TSG_BT_01", "BT_Schluesselschalter_zu_inv", 0, profileFile ) );
    putValue( KCAN_BT_SP_ausgerastet, getProfileInt( "TSG_BT_01", "BT_SP_ausgerastet", 0, profileFile ) );
    putValue( KCAN_BT_Sp_Blk_def, getProfileInt( "TSG_BT_01", "BT_Sp_Blk_def", 0, profileFile ) );
    putValue( KCAN_BT_SP_Heizung_aktiv, getProfileInt( "TSG_BT_01", "BT_SP_Heizung_aktiv", 0, profileFile ) );
    putValue( KCAN_BT_Sp_Heizung_Anf, getProfileInt( "TSG_BT_01", "BT_Sp_Heizung_Anf", 0, profileFile ) );
    putValue( KCAN_BT_SP_Heizung_Status, getProfileInt( "TSG_BT_01", "BT_SP_Heizung_Status", 0, profileFile ) );
    putValue( KCAN_BT_SP_ht_aktiv, getProfileInt( "TSG_BT_01", "BT_SP_ht_aktiv", 0, profileFile ) );
    putValue( KCAN_BT_SP_lr_aktiv, getProfileInt( "TSG_BT_01", "BT_SP_lr_aktiv", 0, profileFile ) );
    putValue( KCAN_BT_Sperrklinke, getProfileInt( "TSG_BT_01", "BT_Sperrklinke", 0, profileFile ) );
    putValue( KCAN_BT_SWA_HMI_defekt, getProfileInt( "TSG_BT_01", "BT_SWA_HMI_defekt", 0, profileFile ) );
    putValue( KCAN_BT_TAG_betaetigt, getProfileInt( "TSG_BT_01", "BT_TAG_betaetigt", 0, profileFile ) );
    putValue( KCAN_BT_TCR_Mode_aktiv, getProfileInt( "TSG_BT_01", "BT_TCR_Mode_aktiv", 0, profileFile ) );
    putValue( KCAN_BT_TIG_betaetigt, getProfileInt( "TSG_BT_01", "BT_TIG_betaetigt", 0, profileFile ) );
    putValue( KCAN_BT_TSG_hinten_verbaut, getProfileInt( "TSG_BT_01", "BT_TSG_hinten_verbaut", 0, profileFile ) );
    putValue( KCAN_BT_Tuer_geoeffnet, getProfileInt( "TSG_BT_01", "BT_Tuer_geoeffnet", 0, profileFile ) );
    putValue( KCAN_BT_Tuer_Status, getProfileInt( "TSG_BT_01", "BT_Tuer_Status", 0, profileFile ) );
    putValue( KCAN_BT_Tuer_Status_QBit, getProfileInt( "TSG_BT_01", "BT_Tuer_Status_QBit", 0, profileFile ) );
    putValue( KCAN_BT_Tueroeffnen_Warnung, getProfileInt( "TSG_BT_01", "BT_Tueroeffnen_Warnung", 0, profileFile ) );
    putValue( KCAN_BT_Tuerschloss_defekt, getProfileInt( "TSG_BT_01", "BT_Tuerschloss_defekt", 0, profileFile ) );
    putValue( KCAN_BT_UEKB_aktiviert, getProfileInt( "TSG_BT_01", "BT_UEKB_aktiviert", 0, profileFile ) );
    putValue( KCAN_BT_Unlock_Taster, getProfileInt( "TSG_BT_01", "BT_Unlock_Taster", 0, profileFile ) );
    putValue( KCAN_BT_Unten_Block_erw, getProfileInt( "TSG_BT_01", "BT_Unten_Block_erw", 0, profileFile ) );
    putValue( KCAN_BT_verriegelt, getProfileInt( "TSG_BT_01", "BT_verriegelt", 0, profileFile ) );
    putValue( KCAN_BT_Zuziehhilfe_aktiv, getProfileInt( "TSG_BT_01", "BT_Zuziehhilfe_aktiv", 0, profileFile ) );

}


void loadSettings_TSG_FT_01( char profileFile[] )
{
    putValue( KCAN_ASW_HMI_defekt, getProfileInt( "TSG_FT_01", "ASW_HMI_defekt", 0, profileFile ) );
    putValue( KCAN_ASW_wakeup, getProfileInt( "TSG_FT_01", "ASW_wakeup", 0, profileFile ) );
    putValue( KCAN_ASW_Warnung_aktiv_FS, getProfileInt( "TSG_FT_01", "ASW_Warnung_aktiv_FS", 0, profileFile ) );
    putValue( KCAN_FS_Status_eTAG, getProfileInt( "TSG_FT_01", "FS_Status_eTAG", 0, profileFile ) );
    putValue( KCAN_FT_BFS_Fond_Freigabe, getProfileInt( "TSG_FT_01", "FT_BFS_Fond_Freigabe", 0, profileFile ) );
    putValue( KCAN_FT_Daemmglas, getProfileInt( "TSG_FT_01", "FT_Daemmglas", 0, profileFile ) );
    putValue( KCAN_FT_FH_Bew_hoch, getProfileInt( "TSG_FT_01", "FT_FH_Bew_hoch", 0, profileFile ) );
    putValue( KCAN_FT_FH_Bew_tief, getProfileInt( "TSG_FT_01", "FT_FH_Bew_tief", 0, profileFile ) );
    putValue( KCAN_FT_FH_Block, getProfileInt( "TSG_FT_01", "FT_FH_Block", 0, profileFile ) );
    putValue( KCAN_FT_FH_Fang, getProfileInt( "TSG_FT_01", "FT_FH_Fang", 0, profileFile ) );
    putValue( KCAN_FT_FH_normiert, getProfileInt( "TSG_FT_01", "FT_FH_normiert", 0, profileFile ) );
    putValue( KCAN_FT_FH_Oeffnung, getProfileFloat( "TSG_FT_01", "FT_FH_Oeffnung", 0, profileFile ) );
    putValue( KCAN_FT_FH_Pos_oben, getProfileInt( "TSG_FT_01", "FT_FH_Pos_oben", 0, profileFile ) );
    putValue( KCAN_FT_FH_S_AutoHoch, getProfileInt( "TSG_FT_01", "FT_FH_S_AutoHoch", 0, profileFile ) );
    putValue( KCAN_FT_FH_S_AutoTief, getProfileInt( "TSG_FT_01", "FT_FH_S_AutoTief", 0, profileFile ) );
    putValue( KCAN_FT_FH_S_ManHoch, getProfileInt( "TSG_FT_01", "FT_FH_S_ManHoch", 0, profileFile ) );
    putValue( KCAN_FT_FH_S_ManTief, getProfileInt( "TSG_FT_01", "FT_FH_S_ManTief", 0, profileFile ) );
    putValue( KCAN_FT_FH_Thermo, getProfileInt( "TSG_FT_01", "FT_FH_Thermo", 0, profileFile ) );
    putValue( KCAN_FT_gesafet, getProfileInt( "TSG_FT_01", "FT_gesafet", 0, profileFile ) );
    putValue( KCAN_FT_HD_Taste, getProfileInt( "TSG_FT_01", "FT_HD_Taste", 0, profileFile ) );
    putValue( KCAN_FT_HD_Taste_2, getProfileInt( "TSG_FT_01", "FT_HD_Taste_2", 0, profileFile ) );
    putValue( KCAN_FT_IRUE_Taste, getProfileInt( "TSG_FT_01", "FT_IRUE_Taste", 0, profileFile ) );
    putValue( KCAN_FT_Kisi_Fehler, getProfileInt( "TSG_FT_01", "FT_Kisi_Fehler", 0, profileFile ) );
    putValue( KCAN_FT_Kisi_li_aktiv, getProfileInt( "TSG_FT_01", "FT_Kisi_li_aktiv", 0, profileFile ) );
    putValue( KCAN_FT_Kisi_re_aktiv, getProfileInt( "TSG_FT_01", "FT_Kisi_re_aktiv", 0, profileFile ) );
    putValue( KCAN_FT_Kisi_Taster_li, getProfileInt( "TSG_FT_01", "FT_Kisi_Taster_li", 0, profileFile ) );
    putValue( KCAN_FT_Kisi_Taster_re, getProfileInt( "TSG_FT_01", "FT_Kisi_Taster_re", 0, profileFile ) );
    putValue( KCAN_FT_Lock_Taster, getProfileInt( "TSG_FT_01", "FT_Lock_Taster", 0, profileFile ) );
    putValue( KCAN_FT_Lock_Unlock_Taster, getProfileInt( "TSG_FT_01", "FT_Lock_Unlock_Taster", 0, profileFile ) );
    putValue( KCAN_FT_Oben_Block_erw, getProfileInt( "TSG_FT_01", "FT_Oben_Block_erw", 0, profileFile ) );
    putValue( KCAN_FT_Schliesstaster, getProfileInt( "TSG_FT_01", "FT_Schliesstaster", 0, profileFile ) );
    putValue( KCAN_FT_Schluesselschalter_auf, getProfileInt( "TSG_FT_01", "FT_Schluesselschalter_auf", 0, profileFile ) );
    putValue( KCAN_FT_Schluesselschalter_zu, getProfileInt( "TSG_FT_01", "FT_Schluesselschalter_zu", 0, profileFile ) );
    putValue( KCAN_FT_SP_ausgerastet, getProfileInt( "TSG_FT_01", "FT_SP_ausgerastet", 0, profileFile ) );
    putValue( KCAN_FT_Sp_Blk_def, getProfileInt( "TSG_FT_01", "FT_Sp_Blk_def", 0, profileFile ) );
    putValue( KCAN_FT_Sp_Heizung_Anf, getProfileInt( "TSG_FT_01", "FT_Sp_Heizung_Anf", 0, profileFile ) );
    putValue( KCAN_FT_SP_Heizung_Status, getProfileInt( "TSG_FT_01", "FT_SP_Heizung_Status", 0, profileFile ) );
    putValue( KCAN_FT_SP_ht_aktiv, getProfileInt( "TSG_FT_01", "FT_SP_ht_aktiv", 0, profileFile ) );
    putValue( KCAN_FT_SP_lr_aktiv, getProfileInt( "TSG_FT_01", "FT_SP_lr_aktiv", 0, profileFile ) );
    putValue( KCAN_FT_Sperrklinke, getProfileInt( "TSG_FT_01", "FT_Sperrklinke", 0, profileFile ) );
    putValue( KCAN_FT_SWA_Taster, getProfileInt( "TSG_FT_01", "FT_SWA_Taster", 0, profileFile ) );
    putValue( KCAN_FT_TAG_betaetigt, getProfileInt( "TSG_FT_01", "FT_TAG_betaetigt", 0, profileFile ) );
    putValue( KCAN_FT_TD_Taste, getProfileInt( "TSG_FT_01", "FT_TD_Taste", 0, profileFile ) );
    putValue( KCAN_FT_TD_Taste_Fehler, getProfileInt( "TSG_FT_01", "FT_TD_Taste_Fehler", 0, profileFile ) );
    putValue( KCAN_FT_TIG_betaetigt, getProfileInt( "TSG_FT_01", "FT_TIG_betaetigt", 0, profileFile ) );
    putValue( KCAN_FT_TSG_hinten_verbaut, getProfileInt( "TSG_FT_01", "FT_TSG_hinten_verbaut", 0, profileFile ) );
    putValue( KCAN_FT_Tuer_geoeffnet, getProfileInt( "TSG_FT_01", "FT_Tuer_geoeffnet", 0, profileFile ) );
    putValue( KCAN_FT_Tuerschloss_defekt, getProfileInt( "TSG_FT_01", "FT_Tuerschloss_defekt", 0, profileFile ) );
    putValue( KCAN_FT_UEKB_aktiviert, getProfileInt( "TSG_FT_01", "FT_UEKB_aktiviert", 0, profileFile ) );
    putValue( KCAN_FT_Unlock_Taster, getProfileInt( "TSG_FT_01", "FT_Unlock_Taster", 0, profileFile ) );
    putValue( KCAN_FT_Unten_Block_erw, getProfileInt( "TSG_FT_01", "FT_Unten_Block_erw", 0, profileFile ) );
    putValue( KCAN_FT_verriegelt, getProfileInt( "TSG_FT_01", "FT_verriegelt", 0, profileFile ) );
    putValue( KCAN_FT_Zuziehhilfe_aktiv, getProfileInt( "TSG_FT_01", "FT_Zuziehhilfe_aktiv", 0, profileFile ) );
    putValue( KCAN_SSR_Temp_Freigabe, getProfileInt( "TSG_FT_01", "SSR_Temp_Freigabe", 0, profileFile ) );
    putValue( KCAN_SWA_HMI_Diagnose, getProfileInt( "TSG_FT_01", "SWA_HMI_Diagnose", 0, profileFile ) );

}


void loadSettings_TSG_FT_02( char profileFile[] )
{
    putValue( KCAN_FT_BFS_Tuer_Status, getProfileInt( "TSG_FT_02", "FT_BFS_Tuer_Status", 0, profileFile ) );
    putValue( KCAN_FT_HBFS_Tuer_Status, getProfileInt( "TSG_FT_02", "FT_HBFS_Tuer_Status", 0, profileFile ) );
    putValue( KCAN_FT_HFS_Tuer_Status, getProfileInt( "TSG_FT_02", "FT_HFS_Tuer_Status", 0, profileFile ) );
    putValue( KCAN_FT_KiSi_Status_Soll_HBFS, getProfileInt( "TSG_FT_02", "FT_KiSi_Status_Soll_HBFS", 0, profileFile ) );
    putValue( KCAN_FT_KiSi_Status_Soll_HFS, getProfileInt( "TSG_FT_02", "FT_KiSi_Status_Soll_HFS", 0, profileFile ) );
    putValue( KCAN_FT_Kisi_Taster_li_02, getProfileInt( "TSG_FT_02", "FT_Kisi_Taster_li_02", 0, profileFile ) );
    putValue( KCAN_FT_Kisi_Taster_re_02, getProfileInt( "TSG_FT_02", "FT_Kisi_Taster_re_02", 0, profileFile ) );
    putValue( KCAN_FT_Lock_Taster_02, getProfileInt( "TSG_FT_02", "FT_Lock_Taster_02", 0, profileFile ) );
    putValue( KCAN_FT_Schluesselschalter_zu_02, getProfileInt( "TSG_FT_02", "FT_Schluesselschalter_zu_02", 0, profileFile ) );
    putValue( KCAN_FT_SP_Heizung_ein, getProfileInt( "TSG_FT_02", "FT_SP_Heizung_ein", 0, profileFile ) );
    putValue( KCAN_FT_TCR_Mode_aktiv, getProfileInt( "TSG_FT_02", "FT_TCR_Mode_aktiv", 0, profileFile ) );
    putValue( KCAN_FT_TD_Taste_Status, getProfileInt( "TSG_FT_02", "FT_TD_Taste_Status", 0, profileFile ) );
    putValue( KCAN_FT_Tuer_Status, getProfileInt( "TSG_FT_02", "FT_Tuer_Status", 0, profileFile ) );
    putValue( KCAN_FT_Tuer_Status_QBit, getProfileInt( "TSG_FT_02", "FT_Tuer_Status_QBit", 0, profileFile ) );
    putValue( KCAN_FT_Tueroeffnen_Warnung, getProfileInt( "TSG_FT_02", "FT_Tueroeffnen_Warnung", 0, profileFile ) );
    putValue( KCAN_TBF_FS_Touch_Event, getProfileInt( "TSG_FT_02", "TBF_FS_Touch_Event", 0, profileFile ) );

}


void loadSettings_TSG_HBFS_01( char profileFile[] )
{
    putValue( KCAN_ASW_Warnung_aktiv_HBFS, getProfileInt( "TSG_HBFS_01", "ASW_Warnung_aktiv_HBFS", 0, profileFile ) );
    putValue( KCAN_HBFS_FH_Bew_hoch, getProfileInt( "TSG_HBFS_01", "HBFS_FH_Bew_hoch", 0, profileFile ) );
    putValue( KCAN_HBFS_FH_Bew_tief, getProfileInt( "TSG_HBFS_01", "HBFS_FH_Bew_tief", 0, profileFile ) );
    putValue( KCAN_HBFS_FH_Block, getProfileInt( "TSG_HBFS_01", "HBFS_FH_Block", 0, profileFile ) );
    putValue( KCAN_HBFS_FH_Fang, getProfileInt( "TSG_HBFS_01", "HBFS_FH_Fang", 0, profileFile ) );
    putValue( KCAN_HBFS_FH_normiert, getProfileInt( "TSG_HBFS_01", "HBFS_FH_normiert", 0, profileFile ) );
    putValue( KCAN_HBFS_FH_Oeffnung, getProfileFloat( "TSG_HBFS_01", "HBFS_FH_Oeffnung", 0, profileFile ) );
    putValue( KCAN_HBFS_FH_S_AutoHoch, getProfileInt( "TSG_HBFS_01", "HBFS_FH_S_AutoHoch", 0, profileFile ) );
    putValue( KCAN_HBFS_FH_S_AutoTief, getProfileInt( "TSG_HBFS_01", "HBFS_FH_S_AutoTief", 0, profileFile ) );
    putValue( KCAN_HBFS_FH_S_HFS_AutoHoch, getProfileInt( "TSG_HBFS_01", "HBFS_FH_S_HFS_AutoHoch", 0, profileFile ) );
    putValue( KCAN_HBFS_FH_S_HFS_AutoTief, getProfileInt( "TSG_HBFS_01", "HBFS_FH_S_HFS_AutoTief", 0, profileFile ) );
    putValue( KCAN_HBFS_FH_S_HFS_ManHoch, getProfileInt( "TSG_HBFS_01", "HBFS_FH_S_HFS_ManHoch", 0, profileFile ) );
    putValue( KCAN_HBFS_FH_S_HFS_ManTief, getProfileInt( "TSG_HBFS_01", "HBFS_FH_S_HFS_ManTief", 0, profileFile ) );
    putValue( KCAN_HBFS_FH_S_ManHoch, getProfileInt( "TSG_HBFS_01", "HBFS_FH_S_ManHoch", 0, profileFile ) );
    putValue( KCAN_HBFS_FH_S_ManTief, getProfileInt( "TSG_HBFS_01", "HBFS_FH_S_ManTief", 0, profileFile ) );
    putValue( KCAN_HBFS_FH_Thermo, getProfileInt( "TSG_HBFS_01", "HBFS_FH_Thermo", 0, profileFile ) );
    putValue( KCAN_HBFS_gesafet, getProfileInt( "TSG_HBFS_01", "HBFS_gesafet", 0, profileFile ) );
    putValue( KCAN_HBFS_Heckrollotaster_betaetigt, getProfileInt( "TSG_HBFS_01", "HBFS_Heckrollotaster_betaetigt", 0, profileFile ) );
    putValue( KCAN_HBFS_Lock_Taster, getProfileInt( "TSG_HBFS_01", "HBFS_Lock_Taster", 0, profileFile ) );
    putValue( KCAN_HBFS_Lock_Taster_inv, getProfileInt( "TSG_HBFS_01", "HBFS_Lock_Taster_inv", 0, profileFile ) );
    putValue( KCAN_HBFS_MRollo_Schalter, getProfileInt( "TSG_HBFS_01", "HBFS_MRollo_Schalter", 0, profileFile ) );
    putValue( KCAN_HBFS_Oben_Block_erw, getProfileInt( "TSG_HBFS_01", "HBFS_Oben_Block_erw", 0, profileFile ) );
    putValue( KCAN_HBFS_SAD_Schalter, getProfileInt( "TSG_HBFS_01", "HBFS_SAD_Schalter", 0, profileFile ) );
    putValue( KCAN_HBFS_Seitenrollo_hoch, getProfileInt( "TSG_HBFS_01", "HBFS_Seitenrollo_hoch", 0, profileFile ) );
    putValue( KCAN_HBFS_Seitenrollo_tief, getProfileInt( "TSG_HBFS_01", "HBFS_Seitenrollo_tief", 0, profileFile ) );
    putValue( KCAN_HBFS_SK_betaetigt, getProfileInt( "TSG_HBFS_01", "HBFS_SK_betaetigt", 0, profileFile ) );
    putValue( KCAN_HBFS_Sperrklinke, getProfileInt( "TSG_HBFS_01", "HBFS_Sperrklinke", 0, profileFile ) );
    putValue( KCAN_HBFS_Status_eTAG, getProfileInt( "TSG_HBFS_01", "HBFS_Status_eTAG", 0, profileFile ) );
    putValue( KCAN_HBFS_Status_KiSi, getProfileInt( "TSG_HBFS_01", "HBFS_Status_KiSi", 0, profileFile ) );
    putValue( KCAN_HBFS_Status_KiSi_inv, getProfileInt( "TSG_HBFS_01", "HBFS_Status_KiSi_inv", 0, profileFile ) );
    putValue( KCAN_HBFS_TAG_betaetigt, getProfileInt( "TSG_HBFS_01", "HBFS_TAG_betaetigt", 0, profileFile ) );
    putValue( KCAN_HBFS_TIG_betaetigt, getProfileInt( "TSG_HBFS_01", "HBFS_TIG_betaetigt", 0, profileFile ) );
    putValue( KCAN_HBFS_TIG_betaetigt_oeffnen, getProfileInt( "TSG_HBFS_01", "HBFS_TIG_betaetigt_oeffnen", 0, profileFile ) );
    putValue( KCAN_HBFS_TIG_betaetigt_schliessen, getProfileInt( "TSG_HBFS_01", "HBFS_TIG_betaetigt_schliessen", 0, profileFile ) );
    putValue( KCAN_HBFS_Tuer_geoeffnet, getProfileInt( "TSG_HBFS_01", "HBFS_Tuer_geoeffnet", 0, profileFile ) );
    putValue( KCAN_HBFS_Tuer_Status, getProfileInt( "TSG_HBFS_01", "HBFS_Tuer_Status", 0, profileFile ) );
    putValue( KCAN_HBFS_Tuer_Status_QBit, getProfileInt( "TSG_HBFS_01", "HBFS_Tuer_Status_QBit", 0, profileFile ) );
    putValue( KCAN_HBFS_Tueroeffnen_Warnung, getProfileInt( "TSG_HBFS_01", "HBFS_Tueroeffnen_Warnung", 0, profileFile ) );
    putValue( KCAN_HBFS_Tuerschloss_defekt, getProfileInt( "TSG_HBFS_01", "HBFS_Tuerschloss_defekt", 0, profileFile ) );
    putValue( KCAN_HBFS_UEKB_aktiviert, getProfileInt( "TSG_HBFS_01", "HBFS_UEKB_aktiviert", 0, profileFile ) );
    putValue( KCAN_HBFS_Unlock_Taster, getProfileInt( "TSG_HBFS_01", "HBFS_Unlock_Taster", 0, profileFile ) );
    putValue( KCAN_HBFS_Unten_Block_erw, getProfileInt( "TSG_HBFS_01", "HBFS_Unten_Block_erw", 0, profileFile ) );
    putValue( KCAN_HBFS_verriegelt, getProfileInt( "TSG_HBFS_01", "HBFS_verriegelt", 0, profileFile ) );
    putValue( KCAN_HBFS_Vorraste_betaetigt, getProfileInt( "TSG_HBFS_01", "HBFS_Vorraste_betaetigt", 0, profileFile ) );
    putValue( KCAN_HBFS_Zuziehhilfe_aktiv, getProfileInt( "TSG_HBFS_01", "HBFS_Zuziehhilfe_aktiv", 0, profileFile ) );
    putValue( KCAN_MTHBFS_M_Taste, getProfileInt( "TSG_HBFS_01", "MTHBFS_M_Taste", 0, profileFile ) );
    putValue( KCAN_MTHBFS_Pos1, getProfileInt( "TSG_HBFS_01", "MTHBFS_Pos1", 0, profileFile ) );
    putValue( KCAN_MTHBFS_Pos2, getProfileInt( "TSG_HBFS_01", "MTHBFS_Pos2", 0, profileFile ) );
    putValue( KCAN_MTHBFS_Pos3, getProfileInt( "TSG_HBFS_01", "MTHBFS_Pos3", 0, profileFile ) );
    putValue( KCAN_SSR_HBFS_Pos_Unten, getProfileInt( "TSG_HBFS_01", "SSR_HBFS_Pos_Unten", 0, profileFile ) );

}


void loadSettings_TSG_HFS_01( char profileFile[] )
{
    putValue( KCAN_ASW_Warnung_aktiv_HFS, getProfileInt( "TSG_HFS_01", "ASW_Warnung_aktiv_HFS", 0, profileFile ) );
    putValue( KCAN_HFS_FH_Bew_hoch, getProfileInt( "TSG_HFS_01", "HFS_FH_Bew_hoch", 0, profileFile ) );
    putValue( KCAN_HFS_FH_Bew_tief, getProfileInt( "TSG_HFS_01", "HFS_FH_Bew_tief", 0, profileFile ) );
    putValue( KCAN_HFS_FH_Block, getProfileInt( "TSG_HFS_01", "HFS_FH_Block", 0, profileFile ) );
    putValue( KCAN_HFS_FH_Fang, getProfileInt( "TSG_HFS_01", "HFS_FH_Fang", 0, profileFile ) );
    putValue( KCAN_HFS_FH_normiert, getProfileInt( "TSG_HFS_01", "HFS_FH_normiert", 0, profileFile ) );
    putValue( KCAN_HFS_FH_Oeffnung, getProfileFloat( "TSG_HFS_01", "HFS_FH_Oeffnung", 0, profileFile ) );
    putValue( KCAN_HFS_FH_S_AutoHoch, getProfileInt( "TSG_HFS_01", "HFS_FH_S_AutoHoch", 0, profileFile ) );
    putValue( KCAN_HFS_FH_S_AutoTief, getProfileInt( "TSG_HFS_01", "HFS_FH_S_AutoTief", 0, profileFile ) );
    putValue( KCAN_HFS_FH_S_HBFS_AutoHoch, getProfileInt( "TSG_HFS_01", "HFS_FH_S_HBFS_AutoHoch", 0, profileFile ) );
    putValue( KCAN_HFS_FH_S_HBFS_AutoTief, getProfileInt( "TSG_HFS_01", "HFS_FH_S_HBFS_AutoTief", 0, profileFile ) );
    putValue( KCAN_HFS_FH_S_HBFS_ManHoch, getProfileInt( "TSG_HFS_01", "HFS_FH_S_HBFS_ManHoch", 0, profileFile ) );
    putValue( KCAN_HFS_FH_S_HBFS_ManTief, getProfileInt( "TSG_HFS_01", "HFS_FH_S_HBFS_ManTief", 0, profileFile ) );
    putValue( KCAN_HFS_FH_S_ManHoch, getProfileInt( "TSG_HFS_01", "HFS_FH_S_ManHoch", 0, profileFile ) );
    putValue( KCAN_HFS_FH_S_ManTief, getProfileInt( "TSG_HFS_01", "HFS_FH_S_ManTief", 0, profileFile ) );
    putValue( KCAN_HFS_FH_Thermo, getProfileInt( "TSG_HFS_01", "HFS_FH_Thermo", 0, profileFile ) );
    putValue( KCAN_HFS_gesafet, getProfileInt( "TSG_HFS_01", "HFS_gesafet", 0, profileFile ) );
    putValue( KCAN_HFS_Heckrollotaster_betaetigt, getProfileInt( "TSG_HFS_01", "HFS_Heckrollotaster_betaetigt", 0, profileFile ) );
    putValue( KCAN_HFS_Lock_Taster, getProfileInt( "TSG_HFS_01", "HFS_Lock_Taster", 0, profileFile ) );
    putValue( KCAN_HFS_Lock_Taster_inv, getProfileInt( "TSG_HFS_01", "HFS_Lock_Taster_inv", 0, profileFile ) );
    putValue( KCAN_HFS_MRollo_Schalter, getProfileInt( "TSG_HFS_01", "HFS_MRollo_Schalter", 0, profileFile ) );
    putValue( KCAN_HFS_Oben_Block_erw, getProfileInt( "TSG_HFS_01", "HFS_Oben_Block_erw", 0, profileFile ) );
    putValue( KCAN_HFS_SAD_Schalter, getProfileInt( "TSG_HFS_01", "HFS_SAD_Schalter", 0, profileFile ) );
    putValue( KCAN_HFS_Seitenrollo_hoch, getProfileInt( "TSG_HFS_01", "HFS_Seitenrollo_hoch", 0, profileFile ) );
    putValue( KCAN_HFS_Seitenrollo_tief, getProfileInt( "TSG_HFS_01", "HFS_Seitenrollo_tief", 0, profileFile ) );
    putValue( KCAN_HFS_SK_betaetigt, getProfileInt( "TSG_HFS_01", "HFS_SK_betaetigt", 0, profileFile ) );
    putValue( KCAN_HFS_Sperrklinke, getProfileInt( "TSG_HFS_01", "HFS_Sperrklinke", 0, profileFile ) );
    putValue( KCAN_HFS_Status_eTAG, getProfileInt( "TSG_HFS_01", "HFS_Status_eTAG", 0, profileFile ) );
    putValue( KCAN_HFS_Status_KiSi, getProfileInt( "TSG_HFS_01", "HFS_Status_KiSi", 0, profileFile ) );
    putValue( KCAN_HFS_TAG_betaetigt, getProfileInt( "TSG_HFS_01", "HFS_TAG_betaetigt", 0, profileFile ) );
    putValue( KCAN_HFS_TCR_Mode_aktiv, getProfileInt( "TSG_HFS_01", "HFS_TCR_Mode_aktiv", 0, profileFile ) );
    putValue( KCAN_HFS_TIG_betaetigt, getProfileInt( "TSG_HFS_01", "HFS_TIG_betaetigt", 0, profileFile ) );
    putValue( KCAN_HFS_TIG_betaetigt_oeffnen, getProfileInt( "TSG_HFS_01", "HFS_TIG_betaetigt_oeffnen", 0, profileFile ) );
    putValue( KCAN_HFS_TIG_betaetigt_schliessen, getProfileInt( "TSG_HFS_01", "HFS_TIG_betaetigt_schliessen", 0, profileFile ) );
    putValue( KCAN_HFS_Tuer_geoeffnet, getProfileInt( "TSG_HFS_01", "HFS_Tuer_geoeffnet", 0, profileFile ) );
    putValue( KCAN_HFS_Tuer_Status, getProfileInt( "TSG_HFS_01", "HFS_Tuer_Status", 0, profileFile ) );
    putValue( KCAN_HFS_Tuer_Status_QBit, getProfileInt( "TSG_HFS_01", "HFS_Tuer_Status_QBit", 0, profileFile ) );
    putValue( KCAN_HFS_Tueroeffnen_Warnung, getProfileInt( "TSG_HFS_01", "HFS_Tueroeffnen_Warnung", 0, profileFile ) );
    putValue( KCAN_HFS_Tuerschloss_defekt, getProfileInt( "TSG_HFS_01", "HFS_Tuerschloss_defekt", 0, profileFile ) );
    putValue( KCAN_HFS_UEKB_aktiviert, getProfileInt( "TSG_HFS_01", "HFS_UEKB_aktiviert", 0, profileFile ) );
    putValue( KCAN_HFS_Unlock_Taster, getProfileInt( "TSG_HFS_01", "HFS_Unlock_Taster", 0, profileFile ) );
    putValue( KCAN_HFS_Unten_Block_erw, getProfileInt( "TSG_HFS_01", "HFS_Unten_Block_erw", 0, profileFile ) );
    putValue( KCAN_HFS_verriegelt, getProfileInt( "TSG_HFS_01", "HFS_verriegelt", 0, profileFile ) );
    putValue( KCAN_HFS_Vorraste_betaetigt, getProfileInt( "TSG_HFS_01", "HFS_Vorraste_betaetigt", 0, profileFile ) );
    putValue( KCAN_HFS_Zuziehhilfe_aktiv, getProfileInt( "TSG_HFS_01", "HFS_Zuziehhilfe_aktiv", 0, profileFile ) );
    putValue( KCAN_MTHFS_M_Taste, getProfileInt( "TSG_HFS_01", "MTHFS_M_Taste", 0, profileFile ) );
    putValue( KCAN_MTHFS_Pos1, getProfileInt( "TSG_HFS_01", "MTHFS_Pos1", 0, profileFile ) );
    putValue( KCAN_MTHFS_Pos2, getProfileInt( "TSG_HFS_01", "MTHFS_Pos2", 0, profileFile ) );
    putValue( KCAN_MTHFS_Pos3, getProfileInt( "TSG_HFS_01", "MTHFS_Pos3", 0, profileFile ) );
    putValue( KCAN_SSR_HFS_Pos_Unten, getProfileInt( "TSG_HFS_01", "SSR_HFS_Pos_Unten", 0, profileFile ) );

}


void loadSettings_UserStateServer_01( char profileFile[] )
{
    putValue( KCAN_OPS_ComfortReadyStatus, getProfileInt( "UserStateServer_01", "OPS_ComfortReadyStatus", 0, profileFile ) );
    putValue( KCAN_OPS_DriverPresenceStatus, getProfileInt( "UserStateServer_01", "OPS_DriverPresenceStatus", 0, profileFile ) );
    putValue( KCAN_OPS_OccupantPresenceStatus, getProfileInt( "UserStateServer_01", "OPS_OccupantPresenceStatus", 0, profileFile ) );
    putValue( KCAN_OPS_QBit_DriverPresence, getProfileInt( "UserStateServer_01", "OPS_QBit_DriverPresence", 0, profileFile ) );

}


void loadSettings_VIN_01( char profileFile[] )
{
    putValue( KCAN_KS_Geheimnis_1, getProfileInt( "VIN_01", "KS_Geheimnis_1", 0, profileFile ) );
    putValue( KCAN_KS_Geheimnis_2, getProfileInt( "VIN_01", "KS_Geheimnis_2", 0, profileFile ) );
    putValue( KCAN_KS_Geheimnis_3, getProfileInt( "VIN_01", "KS_Geheimnis_3", 0, profileFile ) );
    putValue( KCAN_KS_Geheimnis_4, getProfileInt( "VIN_01", "KS_Geheimnis_4", 0, profileFile ) );
    putValue( KCAN_VIN_1, getProfileInt( "VIN_01", "VIN_1", 0, profileFile ) );
    putValue( KCAN_VIN_01_MUX, getProfileInt( "VIN_01", "VIN_01_MUX", 0, profileFile ) );
    putValue( KCAN_VIN_2, getProfileInt( "VIN_01", "VIN_2", 0, profileFile ) );
    putValue( KCAN_VIN_3, getProfileInt( "VIN_01", "VIN_3", 0, profileFile ) );
    putValue( KCAN_VIN_4, getProfileInt( "VIN_01", "VIN_4", 0, profileFile ) );
    putValue( KCAN_VIN_5, getProfileInt( "VIN_01", "VIN_5", 0, profileFile ) );
    putValue( KCAN_VIN_6, getProfileInt( "VIN_01", "VIN_6", 0, profileFile ) );
    putValue( KCAN_VIN_7, getProfileInt( "VIN_01", "VIN_7", 0, profileFile ) );
    putValue( KCAN_VIN_8, getProfileInt( "VIN_01", "VIN_8", 0, profileFile ) );
    putValue( KCAN_VIN_9, getProfileInt( "VIN_01", "VIN_9", 0, profileFile ) );
    putValue( KCAN_VIN_10, getProfileInt( "VIN_01", "VIN_10", 0, profileFile ) );
    putValue( KCAN_VIN_11, getProfileInt( "VIN_01", "VIN_11", 0, profileFile ) );
    putValue( KCAN_VIN_12, getProfileInt( "VIN_01", "VIN_12", 0, profileFile ) );
    putValue( KCAN_VIN_13, getProfileInt( "VIN_01", "VIN_13", 0, profileFile ) );
    putValue( KCAN_VIN_14, getProfileInt( "VIN_01", "VIN_14", 0, profileFile ) );
    putValue( KCAN_VIN_15, getProfileInt( "VIN_01", "VIN_15", 0, profileFile ) );
    putValue( KCAN_VIN_16, getProfileInt( "VIN_01", "VIN_16", 0, profileFile ) );
    putValue( KCAN_VIN_17, getProfileInt( "VIN_01", "VIN_17", 0, profileFile ) );

}


void loadSettings_VLK_01( char profileFile[] )
{
    putValue( KCAN_VLK_Anf_Antrieb, getProfileInt( "VLK_01", "VLK_Anf_Antrieb", 0, profileFile ) );
    putValue( KCAN_VLK_Anforderung_HMS, getProfileInt( "VLK_01", "VLK_Anforderung_HMS", 0, profileFile ) );
    putValue( KCAN_VLK_Anforderung_Rollfaehigkeit, getProfileInt( "VLK_01", "VLK_Anforderung_Rollfaehigkeit", 0, profileFile ) );
    putValue( KCAN_VLK_Antriebsdeaktivierung, getProfileInt( "VLK_01", "VLK_Antriebsdeaktivierung", 0, profileFile ) );
    putValue( KCAN_VLK_autom_Absch_Signalisierung, getProfileInt( "VLK_01", "VLK_autom_Absch_Signalisierung", 0, profileFile ) );
    putValue( KCAN_VLK_Hinweis_Rollfaehigkeit, getProfileInt( "VLK_01", "VLK_Hinweis_Rollfaehigkeit", 0, profileFile ) );
    putValue( KCAN_VLK_Parken_beibehalten_HMS, getProfileInt( "VLK_01", "VLK_Parken_beibehalten_HMS", 0, profileFile ) );
    putValue( KCAN_VLK_VLW_Anf, getProfileInt( "VLK_01", "VLK_VLW_Anf", 0, profileFile ) );

}


void loadSettings_VZE_04( char profileFile[] )
{
    putValue( KCAN_VZE_Anhaenger_Vmax, getProfileInt( "VZE_04", "VZE_Anhaenger_Vmax", 0, profileFile ) );
    putValue( KCAN_VZE_Anzeige_VZ_1, getProfileInt( "VZE_04", "VZE_Anzeige_VZ_1", 0, profileFile ) );
    putValue( KCAN_VZE_Anzeige_VZ_2, getProfileInt( "VZE_04", "VZE_Anzeige_VZ_2", 0, profileFile ) );
    putValue( KCAN_VZE_Anzeige_VZ_3, getProfileInt( "VZE_04", "VZE_Anzeige_VZ_3", 0, profileFile ) );
    putValue( KCAN_VZE_Anzeige_ZS_1, getProfileInt( "VZE_04", "VZE_Anzeige_ZS_1", 0, profileFile ) );
    putValue( KCAN_VZE_Anzeige_ZS_2, getProfileInt( "VZE_04", "VZE_Anzeige_ZS_2", 0, profileFile ) );
    putValue( KCAN_VZE_Anzeige_ZS_3, getProfileInt( "VZE_04", "VZE_Anzeige_ZS_3", 0, profileFile ) );
    putValue( KCAN_VZE_Anzeigemodus, getProfileInt( "VZE_04", "VZE_Anzeigemodus", 0, profileFile ) );
    putValue( KCAN_VZE_Anzeigeunterdrueck_Zeichen_1, getProfileInt( "VZE_04", "VZE_Anzeigeunterdrueck_Zeichen_1", 0, profileFile ) );
    putValue( KCAN_VZE_Anzeigeunterdrueck_Zeichen_2, getProfileInt( "VZE_04", "VZE_Anzeigeunterdrueck_Zeichen_2", 0, profileFile ) );
    putValue( KCAN_VZE_Anzeigeunterdrueck_Zeichen_3, getProfileInt( "VZE_04", "VZE_Anzeigeunterdrueck_Zeichen_3", 0, profileFile ) );
    putValue( KCAN_VZE_Anzeigeunterdrueck_Zeichen_4, getProfileInt( "VZE_04", "VZE_Anzeigeunterdrueck_Zeichen_4", 0, profileFile ) );
    putValue( KCAN_VZE_Anzeigeunterdrueck_Zeichen_5, getProfileInt( "VZE_04", "VZE_Anzeigeunterdrueck_Zeichen_5", 0, profileFile ) );
    putValue( KCAN_VZE_Baustelle, getProfileInt( "VZE_04", "VZE_Baustelle", 0, profileFile ) );
    putValue( KCAN_VZE_Erweiterte_Information, getProfileInt( "VZE_04", "VZE_Erweiterte_Information", 0, profileFile ) );
    putValue( KCAN_VZE_FoD_Status, getProfileInt( "VZE_04", "VZE_FoD_Status", 0, profileFile ) );
    putValue( KCAN_VZE_Gong, getProfileInt( "VZE_04", "VZE_Gong", 0, profileFile ) );
    putValue( KCAN_VZE_Hinweistext, getProfileInt( "VZE_04", "VZE_Hinweistext", 0, profileFile ) );
    putValue( KCAN_VZE_Hinweistext_03, getProfileInt( "VZE_04", "VZE_Hinweistext_03", 0, profileFile ) );
    putValue( KCAN_VZE_Land, getProfileInt( "VZE_04", "VZE_Land", 0, profileFile ) );
    putValue( KCAN_VZE_Tempowarnung_Einheit, getProfileInt( "VZE_04", "VZE_Tempowarnung_Einheit", 0, profileFile ) );
    putValue( KCAN_VZE_Tempowarnung_Offset, getProfileInt( "VZE_04", "VZE_Tempowarnung_Offset", 0, profileFile ) );
    putValue( KCAN_VZE_Tempowarnung_Status, getProfileInt( "VZE_04", "VZE_Tempowarnung_Status", 0, profileFile ) );
    putValue( KCAN_VZE_Umweltinfo_Anhaengerbetrieb, getProfileInt( "VZE_04", "VZE_Umweltinfo_Anhaengerbetrieb", 0, profileFile ) );
    putValue( KCAN_VZE_Umweltinfo_Naesse, getProfileInt( "VZE_04", "VZE_Umweltinfo_Naesse", 0, profileFile ) );
    putValue( KCAN_VZE_Umweltinfo_Nebel, getProfileInt( "VZE_04", "VZE_Umweltinfo_Nebel", 0, profileFile ) );
    putValue( KCAN_VZE_Verkehrszeichen_1, getProfileInt( "VZE_04", "VZE_Verkehrszeichen_1", 0, profileFile ) );
    putValue( KCAN_VZE_Verkehrszeichen_2, getProfileInt( "VZE_04", "VZE_Verkehrszeichen_2", 0, profileFile ) );
    putValue( KCAN_VZE_Verkehrszeichen_3, getProfileInt( "VZE_04", "VZE_Verkehrszeichen_3", 0, profileFile ) );
    putValue( KCAN_VZE_Verkehrszeichen_4, getProfileInt( "VZE_04", "VZE_Verkehrszeichen_4", 0, profileFile ) );
    putValue( KCAN_VZE_Verkehrszeichen_5, getProfileInt( "VZE_04", "VZE_Verkehrszeichen_5", 0, profileFile ) );
    putValue( KCAN_VZE_Verkehrszeichen_6, getProfileInt( "VZE_04", "VZE_Verkehrszeichen_6", 0, profileFile ) );
    putValue( KCAN_VZE_Verkehrszeichen_Einheit, getProfileInt( "VZE_04", "VZE_Verkehrszeichen_Einheit", 0, profileFile ) );
    putValue( KCAN_VZE_Warnung_Verkehrszeichen_1, getProfileInt( "VZE_04", "VZE_Warnung_Verkehrszeichen_1", 0, profileFile ) );
    putValue( KCAN_VZE_Warnung_Verkehrszeichen_2, getProfileInt( "VZE_04", "VZE_Warnung_Verkehrszeichen_2", 0, profileFile ) );
    putValue( KCAN_VZE_Warnung_Verkehrszeichen_3, getProfileInt( "VZE_04", "VZE_Warnung_Verkehrszeichen_3", 0, profileFile ) );
    putValue( KCAN_VZE_Warnung_Verkehrszeichen_4, getProfileInt( "VZE_04", "VZE_Warnung_Verkehrszeichen_4", 0, profileFile ) );
    putValue( KCAN_VZE_Warnung_Verkehrszeichen_5, getProfileInt( "VZE_04", "VZE_Warnung_Verkehrszeichen_5", 0, profileFile ) );
    putValue( KCAN_VZE_Warnung_VZ_1, getProfileInt( "VZE_04", "VZE_Warnung_VZ_1", 0, profileFile ) );
    putValue( KCAN_VZE_Warnung_VZ_2, getProfileInt( "VZE_04", "VZE_Warnung_VZ_2", 0, profileFile ) );
    putValue( KCAN_VZE_Warnung_VZ_3, getProfileInt( "VZE_04", "VZE_Warnung_VZ_3", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_01_Gesetz, getProfileInt( "VZE_04", "VZE_Zeichen_01_Gesetz", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_01_Kamera, getProfileInt( "VZE_04", "VZE_Zeichen_01_Kamera", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_01_KameraWied, getProfileInt( "VZE_04", "VZE_Zeichen_01_KameraWied", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_01_Karte, getProfileInt( "VZE_04", "VZE_Zeichen_01_Karte", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_02_Gesetz, getProfileInt( "VZE_04", "VZE_Zeichen_02_Gesetz", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_02_Kamera, getProfileInt( "VZE_04", "VZE_Zeichen_02_Kamera", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_02_KameraWied, getProfileInt( "VZE_04", "VZE_Zeichen_02_KameraWied", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_02_Karte, getProfileInt( "VZE_04", "VZE_Zeichen_02_Karte", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_03_Gesetz, getProfileInt( "VZE_04", "VZE_Zeichen_03_Gesetz", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_03_Kamera, getProfileInt( "VZE_04", "VZE_Zeichen_03_Kamera", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_03_KameraWied, getProfileInt( "VZE_04", "VZE_Zeichen_03_KameraWied", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_03_Karte, getProfileInt( "VZE_04", "VZE_Zeichen_03_Karte", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_04_Gesetz, getProfileInt( "VZE_04", "VZE_Zeichen_04_Gesetz", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_04_Kamera, getProfileInt( "VZE_04", "VZE_Zeichen_04_Kamera", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_04_KameraWied, getProfileInt( "VZE_04", "VZE_Zeichen_04_KameraWied", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_04_Karte, getProfileInt( "VZE_04", "VZE_Zeichen_04_Karte", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_05_Entfernung, getProfileInt( "VZE_04", "VZE_Zeichen_05_Entfernung", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_05_Entfernung_StdA, getProfileInt( "VZE_04", "VZE_Zeichen_05_Entfernung_StdA", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_05_Gesetz, getProfileInt( "VZE_04", "VZE_Zeichen_05_Gesetz", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_05_Kamera, getProfileInt( "VZE_04", "VZE_Zeichen_05_Kamera", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_05_KameraWied, getProfileInt( "VZE_04", "VZE_Zeichen_05_KameraWied", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_05_Karte, getProfileInt( "VZE_04", "VZE_Zeichen_05_Karte", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_06_Entfernung, getProfileInt( "VZE_04", "VZE_Zeichen_06_Entfernung", 0, profileFile ) );
    putValue( KCAN_VZE_Zeichen_06_Entfernung_StdA, getProfileInt( "VZE_04", "VZE_Zeichen_06_Entfernung_StdA", 0, profileFile ) );
    putValue( KCAN_VZE_Zusatzschild_1, getProfileInt( "VZE_04", "VZE_Zusatzschild_1", 0, profileFile ) );
    putValue( KCAN_VZE_Zusatzschild_2, getProfileInt( "VZE_04", "VZE_Zusatzschild_2", 0, profileFile ) );
    putValue( KCAN_VZE_Zusatzschild_3, getProfileInt( "VZE_04", "VZE_Zusatzschild_3", 0, profileFile ) );
    putValue( KCAN_VZE_Zusatzschild_4, getProfileInt( "VZE_04", "VZE_Zusatzschild_4", 0, profileFile ) );
    putValue( KCAN_VZE_Zusatzschild_5, getProfileInt( "VZE_04", "VZE_Zusatzschild_5", 0, profileFile ) );
    putValue( KCAN_VZE_Zusatzschild_6, getProfileInt( "VZE_04", "VZE_Zusatzschild_6", 0, profileFile ) );

}


void loadSettings_WBA_03( char profileFile[] )
{
    putValue( KCAN_GE_Sollgang, getProfileInt( "WBA_03", "GE_Sollgang", 0, profileFile ) );
    putValue( KCAN_GE_Stoppverbot_Anz_01, getProfileInt( "WBA_03", "GE_Stoppverbot_Anz_01", 0, profileFile ) );
    putValue( KCAN_GE_Stoppverbot_Anz_02, getProfileInt( "WBA_03", "GE_Stoppverbot_Anz_02", 0, profileFile ) );
    putValue( KCAN_GE_Stoppverbot_Anz_03, getProfileInt( "WBA_03", "GE_Stoppverbot_Anz_03", 0, profileFile ) );
    putValue( KCAN_GE_Stoppverbot_Anz_04, getProfileInt( "WBA_03", "GE_Stoppverbot_Anz_04", 0, profileFile ) );
    putValue( KCAN_GE_Stoppverbot_Anz_05, getProfileInt( "WBA_03", "GE_Stoppverbot_Anz_05", 0, profileFile ) );
    putValue( KCAN_GE_Stoppverbot_Anz_06, getProfileInt( "WBA_03", "GE_Stoppverbot_Anz_06", 0, profileFile ) );
    putValue( KCAN_GE_Stoppverbot_Anz_07, getProfileInt( "WBA_03", "GE_Stoppverbot_Anz_07", 0, profileFile ) );
    putValue( KCAN_GE_Stoppverbot_Anz_Std, getProfileInt( "WBA_03", "GE_Stoppverbot_Anz_Std", 0, profileFile ) );
    putValue( KCAN_GE_Tipschaltempf_verfuegbar, getProfileInt( "WBA_03", "GE_Tipschaltempf_verfuegbar", 0, profileFile ) );
    putValue( KCAN_GE_Wiederstart_Anz_Std, getProfileInt( "WBA_03", "GE_Wiederstart_Anz_Std", 0, profileFile ) );
    putValue( KCAN_WBA_Anforderung_Akustik, getProfileInt( "WBA_03", "WBA_Anforderung_Akustik", 0, profileFile ) );
    putValue( KCAN_WBA_Blinken, getProfileInt( "WBA_03", "WBA_Blinken", 0, profileFile ) );
    putValue( KCAN_WBA_eing_Gang_02, getProfileInt( "WBA_03", "WBA_eing_Gang_02", 0, profileFile ) );
    putValue( KCAN_WBA_Fahrstufe_02, getProfileInt( "WBA_03", "WBA_Fahrstufe_02", 0, profileFile ) );
    putValue( KCAN_WBA_GE_Texte, getProfileInt( "WBA_03", "WBA_GE_Texte", 0, profileFile ) );
    putValue( KCAN_WBA_GE_Texte_02, getProfileInt( "WBA_03", "WBA_GE_Texte_02", 0, profileFile ) );
    putValue( KCAN_WBA_GE_Warnung_02, getProfileInt( "WBA_03", "WBA_GE_Warnung_02", 0, profileFile ) );
    putValue( KCAN_WBA_GE_Zusatzwarnungen, getProfileInt( "WBA_03", "WBA_GE_Zusatzwarnungen", 0, profileFile ) );
    putValue( KCAN_WBA_Schaltschema_02, getProfileInt( "WBA_03", "WBA_Schaltschema_02", 0, profileFile ) );
    putValue( KCAN_WBA_Schaltschema_Fahreraktion, getProfileInt( "WBA_03", "WBA_Schaltschema_Fahreraktion", 0, profileFile ) );
    putValue( KCAN_WBA_Schaltschema_FS_inaktiv, getProfileInt( "WBA_03", "WBA_Schaltschema_FS_inaktiv", 0, profileFile ) );
    putValue( KCAN_WBA_Schaltschema_FS_vorwaerts, getProfileInt( "WBA_03", "WBA_Schaltschema_FS_vorwaerts", 0, profileFile ) );
    putValue( KCAN_WBA_Schaltschema_Tippgasse, getProfileInt( "WBA_03", "WBA_Schaltschema_Tippgasse", 0, profileFile ) );
    putValue( KCAN_WBA_Segeln_aktiv, getProfileInt( "WBA_03", "WBA_Segeln_aktiv", 0, profileFile ) );
    putValue( KCAN_WBA_Shiftlock_Lampe, getProfileInt( "WBA_03", "WBA_Shiftlock_Lampe", 0, profileFile ) );
    putValue( KCAN_WBA_ZielFahrstufe, getProfileInt( "WBA_03", "WBA_ZielFahrstufe", 0, profileFile ) );

}


void loadSettings_WFS_01( char profileFile[] )
{
    putValue( KCAN_WFS_Betrieb_Lesespule, getProfileInt( "WFS_01", "WFS_Betrieb_Lesespule", 0, profileFile ) );
    putValue( KCAN_WFS_ELV_authorisiert, getProfileInt( "WFS_01", "WFS_ELV_authorisiert", 0, profileFile ) );
    putValue( KCAN_WFS_Fahrerhinweise, getProfileInt( "WFS_01", "WFS_Fahrerhinweise", 0, profileFile ) );
    putValue( KCAN_WFS_ID_Geb_autorisiert, getProfileInt( "WFS_01", "WFS_ID_Geb_autorisiert", 0, profileFile ) );
    putValue( KCAN_WFS_ID_Geb_autorisiert_in_Kl15, getProfileInt( "WFS_01", "WFS_ID_Geb_autorisiert_in_Kl15", 0, profileFile ) );
    putValue( KCAN_WFS_ID_Geb_steckt, getProfileInt( "WFS_01", "WFS_ID_Geb_steckt", 0, profileFile ) );
    putValue( KCAN_WFS_Klemmenfreigabe, getProfileInt( "WFS_01", "WFS_Klemmenfreigabe", 0, profileFile ) );
    putValue( KCAN_WFS_Klemmenfreigabe_Signatur, getProfileInt( "WFS_01", "WFS_Klemmenfreigabe_Signatur", 0, profileFile ) );
    putValue( KCAN_WFS_LF_Aktiv, getProfileInt( "WFS_01", "WFS_LF_Aktiv", 0, profileFile ) );
    putValue( KCAN_WFS_LZ, getProfileInt( "WFS_01", "WFS_LZ", 0, profileFile ) );
    putValue( KCAN_WFS_LZ_02, getProfileInt( "WFS_01", "WFS_LZ_02", 0, profileFile ) );
    putValue( KCAN_WFS_Parken_Status, getProfileInt( "WFS_01", "WFS_Parken_Status", 0, profileFile ) );
    putValue( KCAN_WFS_Safe, getProfileInt( "WFS_01", "WFS_Safe", 0, profileFile ) );
    putValue( KCAN_WFS_Schluessel_Fahrberecht, getProfileInt( "WFS_01", "WFS_Schluessel_Fahrberecht", 0, profileFile ) );
    putValue( KCAN_WFS_Schluessel_Ist, getProfileInt( "WFS_01", "WFS_Schluessel_Ist", 0, profileFile ) );
    putValue( KCAN_WFS_Schluessel_Soll, getProfileInt( "WFS_01", "WFS_Schluessel_Soll", 0, profileFile ) );
    putValue( KCAN_WFS_Verbauinfo_ELV, getProfileInt( "WFS_01", "WFS_Verbauinfo_ELV", 0, profileFile ) );

}


void loadSettings_WFS_Transponder_Req_02( char profileFile[] )
{

}


void loadSettings_WFS_Transponder_Resp_02( char profileFile[] )
{

}


void loadSettings_WFS_Transponder_Status_02( char profileFile[] )
{
    putValue( KCAN_WFS_Diag_LF_Aktiv_02, getProfileInt( "WFS_Transponder_Status_02", "WFS_Diag_LF_Aktiv_02", 0, profileFile ) );
    putValue( KCAN_WFS_LF_aktiv_02, getProfileInt( "WFS_Transponder_Status_02", "WFS_LF_aktiv_02", 0, profileFile ) );
    putValue( KCAN_WFS_Transp_Mod_Unterbrechung_02, getProfileInt( "WFS_Transponder_Status_02", "WFS_Transp_Mod_Unterbrechung_02", 0, profileFile ) );
    putValue( KCAN_WFS_Verbau_Transp_Ant_02, getProfileInt( "WFS_Transponder_Status_02", "WFS_Verbau_Transp_Ant_02", 0, profileFile ) );

}


void loadSettings_Wischer_01( char profileFile[] )
{
    putValue( KCAN_BCM1_SRA_aktiv, getProfileInt( "Wischer_01", "BCM1_SRA_aktiv", 0, profileFile ) );
    putValue( KCAN_Waschen_vorne_aktiv, getProfileInt( "Wischer_01", "Waschen_vorne_aktiv", 0, profileFile ) );
    putValue( KCAN_Wischer1_Wischgeschwindigkeit, getProfileInt( "Wischer_01", "Wischer1_Wischgeschwindigkeit", 0, profileFile ) );
    putValue( KCAN_Wischer_Anzeigetext, getProfileInt( "Wischer_01", "Wischer_Anzeigetext", 0, profileFile ) );
    putValue( KCAN_Wischer_vorne_aktiv, getProfileInt( "Wischer_01", "Wischer_vorne_aktiv", 0, profileFile ) );
    putValue( KCAN_Wischer_vorne_blockiert, getProfileInt( "Wischer_01", "Wischer_vorne_blockiert", 0, profileFile ) );
    putValue( KCAN_Wischer_vorne_defekt, getProfileInt( "Wischer_01", "Wischer_vorne_defekt", 0, profileFile ) );
    putValue( KCAN_Wischer_vorne_Normal, getProfileInt( "Wischer_01", "Wischer_vorne_Normal", 0, profileFile ) );
    putValue( KCAN_Wischer_vorne_Parklage, getProfileInt( "Wischer_01", "Wischer_vorne_Parklage", 0, profileFile ) );
    putValue( KCAN_Wischer_vorne_Schnell, getProfileInt( "Wischer_01", "Wischer_vorne_Schnell", 0, profileFile ) );
    putValue( KCAN_WWSs_01_alt, getProfileInt( "Wischer_01", "WWSs_01_alt", 0, profileFile ) );

}


void loadSettings_WLC1_01( char profileFile[] )
{
    putValue( KCAN_WLC1_aktive_Spule, getProfileInt( "WLC1_01", "WLC1_aktive_Spule", 0, profileFile ) );
    putValue( KCAN_WLC1_Charger_Effizienz, getProfileInt( "WLC1_01", "WLC1_Charger_Effizienz", 0, profileFile ) );
    putValue( KCAN_WLC1_Charger_laedt, getProfileFloat( "WLC1_01", "WLC1_Charger_laedt", 0, profileFile ) );
    putValue( KCAN_WLC1_Fehler, getProfileInt( "WLC1_01", "WLC1_Fehler", 0, profileFile ) );
    putValue( KCAN_WLC1_Fremdobjekt_erkannt, getProfileInt( "WLC1_01", "WLC1_Fremdobjekt_erkannt", 0, profileFile ) );
    putValue( KCAN_WLC1_Leistungsklasse_Receiver, getProfileFloat( "WLC1_01", "WLC1_Leistungsklasse_Receiver", 0, profileFile ) );
    putValue( KCAN_WLC1_Objekt_erkannt, getProfileInt( "WLC1_01", "WLC1_Objekt_erkannt", 0, profileFile ) );
    putValue( KCAN_WLC1_Receiver_erkannt, getProfileInt( "WLC1_01", "WLC1_Receiver_erkannt", 0, profileFile ) );
    putValue( KCAN_WLC1_Receiver_voll_geladen, getProfileInt( "WLC1_01", "WLC1_Receiver_voll_geladen", 0, profileFile ) );
    putValue( KCAN_WLC1_Temp_Leistungsteil_Charger, getProfileInt( "WLC1_01", "WLC1_Temp_Leistungsteil_Charger", 0, profileFile ) );
    putValue( KCAN_WLC1_Temp_Oberfaeche_Charger, getProfileInt( "WLC1_01", "WLC1_Temp_Oberfaeche_Charger", 0, profileFile ) );
    putValue( KCAN_WLC1_Temp_Receiver, getProfileInt( "WLC1_01", "WLC1_Temp_Receiver", 0, profileFile ) );
    putValue( KCAN_WLC1_verwendeter_Ladestandard, getProfileInt( "WLC1_01", "WLC1_verwendeter_Ladestandard", 0, profileFile ) );

}


void loadSettings_XCP_SmaLi_CRO_01( char profileFile[] )
{

}


void loadSettings_XCP_SmaLi_DTO_01( char profileFile[] )
{

}


void loadSettings_Zeitmaster_02( char profileFile[] )
{
    putValue( KCAN_BasicUTC_Day, getProfileInt( "Zeitmaster_02", "BasicUTC_Day", 0, profileFile ) );
    putValue( KCAN_BasicUTC_Hour, getProfileInt( "Zeitmaster_02", "BasicUTC_Hour", 0, profileFile ) );
    putValue( KCAN_BasicUTC_Minute, getProfileInt( "Zeitmaster_02", "BasicUTC_Minute", 0, profileFile ) );
    putValue( KCAN_BasicUTC_Month, getProfileInt( "Zeitmaster_02", "BasicUTC_Month", 0, profileFile ) );
    putValue( KCAN_BasicUTC_Quality, getProfileInt( "Zeitmaster_02", "BasicUTC_Quality", 0, profileFile ) );
    putValue( KCAN_BasicUTC_Second, getProfileInt( "Zeitmaster_02", "BasicUTC_Second", 0, profileFile ) );
    putValue( KCAN_BasicUTC_Year, getProfileInt( "Zeitmaster_02", "BasicUTC_Year", 0, profileFile ) );

}


void loadSettings_Zentralrechner_01( char profileFile[] )
{
    putValue( KCAN_DI_Screendesign, getProfileInt( "Zentralrechner_01", "DI_Screendesign", 0, profileFile ) );
    putValue( KCAN_MMI_State_Zentralrechner_01, getProfileInt( "Zentralrechner_01", "MMI_State_Zentralrechner_01", 0, profileFile ) );
    putValue( KCAN_SI_ICAN, getProfileInt( "Zentralrechner_01", "SI_ICAN", 0, profileFile ) );
    putValue( KCAN_WLC1_Systemzustand, getProfileInt( "Zentralrechner_01", "WLC1_Systemzustand", 0, profileFile ) );
    putValue( KCAN_WLC2_Systemzustand, getProfileInt( "Zentralrechner_01", "WLC2_Systemzustand", 0, profileFile ) );
    putValue( KCAN_ZR_DimOffs_DU_1, getProfileInt( "Zentralrechner_01", "ZR_DimOffs_DU_1", 0, profileFile ) );
    putValue( KCAN_ZR_DimOffs_DU_2, getProfileInt( "Zentralrechner_01", "ZR_DimOffs_DU_2", 0, profileFile ) );
    putValue( KCAN_ZR_DimOffs_DU_3, getProfileInt( "Zentralrechner_01", "ZR_DimOffs_DU_3", 0, profileFile ) );
    putValue( KCAN_ZR_Lenkerposition, getProfileInt( "Zentralrechner_01", "ZR_Lenkerposition", 0, profileFile ) );
    putValue( KCAN_ZR_State_DU_1_Zentralrechner_01, getProfileInt( "Zentralrechner_01", "ZR_State_DU_1_Zentralrechner_01", 0, profileFile ) );
    putValue( KCAN_ZR_State_DU_2, getProfileInt( "Zentralrechner_01", "ZR_State_DU_2", 0, profileFile ) );
    putValue( KCAN_ZR_State_DU_3, getProfileInt( "Zentralrechner_01", "ZR_State_DU_3", 0, profileFile ) );
    putValue( KCAN_ZR_WecktGesp, getProfileInt( "Zentralrechner_01", "ZR_WecktGesp", 0, profileFile ) );

}


void loadSettings_ZV_02( char profileFile[] )
{
    putValue( KCAN_BCM_FH_Freigabe, getProfileInt( "ZV_02", "BCM_FH_Freigabe", 0, profileFile ) );
    putValue( KCAN_BCM_HSK_Freigabe, getProfileInt( "ZV_02", "BCM_HSK_Freigabe", 0, profileFile ) );
    putValue( KCAN_BCM_Komfortfkt_Freigabe, getProfileInt( "ZV_02", "BCM_Komfortfkt_Freigabe", 0, profileFile ) );
    putValue( KCAN_BCM_Verdeck_Freigabe, getProfileInt( "ZV_02", "BCM_Verdeck_Freigabe", 0, profileFile ) );
    putValue( KCAN_DWA_aktiv, getProfileInt( "ZV_02", "DWA_aktiv", 0, profileFile ) );
    putValue( KCAN_FBS_IDG_in_Reichweite, getProfileInt( "ZV_02", "FBS_IDG_in_Reichweite", 0, profileFile ) );
    putValue( KCAN_FBS_Warn_Schluessel_Batt, getProfileInt( "ZV_02", "FBS_Warn_Schluessel_Batt", 0, profileFile ) );
    putValue( KCAN_FFB_Auf_Taste, getProfileInt( "ZV_02", "FFB_Auf_Taste", 0, profileFile ) );
    putValue( KCAN_FFB_CarFinder, getProfileInt( "ZV_02", "FFB_CarFinder", 0, profileFile ) );
    putValue( KCAN_FFB_HDF_Taste, getProfileInt( "ZV_02", "FFB_HDF_Taste", 0, profileFile ) );
    putValue( KCAN_FFB_Komfortoeffnen, getProfileInt( "ZV_02", "FFB_Komfortoeffnen", 0, profileFile ) );
    putValue( KCAN_FFB_Komfortschliessen, getProfileInt( "ZV_02", "FFB_Komfortschliessen", 0, profileFile ) );
    putValue( KCAN_FFB_Panik_Taste, getProfileInt( "ZV_02", "FFB_Panik_Taste", 0, profileFile ) );
    putValue( KCAN_FFB_Zu_Taste, getProfileInt( "ZV_02", "FFB_Zu_Taste", 0, profileFile ) );
    putValue( KCAN_IRUE_aktiv, getProfileInt( "ZV_02", "IRUE_aktiv", 0, profileFile ) );
    putValue( KCAN_IRUE_Taster_Fkts_LED, getProfileInt( "ZV_02", "IRUE_Taster_Fkts_LED", 0, profileFile ) );
    putValue( KCAN_ZV_Anf_Challenge_Auth, getProfileInt( "ZV_02", "ZV_Anf_Challenge_Auth", 0, profileFile ) );
    putValue( KCAN_ZV_BT_offen, getProfileInt( "ZV_02", "ZV_BT_offen", 0, profileFile ) );
    putValue( KCAN_ZV_Einzeltuerentriegelung, getProfileInt( "ZV_02", "ZV_Einzeltuerentriegelung", 0, profileFile ) );
    putValue( KCAN_ZV_eRWK_Umfeld_Pruefung, getProfileInt( "ZV_02", "ZV_eRWK_Umfeld_Pruefung", 0, profileFile ) );
    putValue( KCAN_ZV_FT_offen, getProfileInt( "ZV_02", "ZV_FT_offen", 0, profileFile ) );
    putValue( KCAN_ZV_gesafet_extern_ist, getProfileInt( "ZV_02", "ZV_gesafet_extern_ist", 0, profileFile ) );
    putValue( KCAN_ZV_gesafet_extern_soll, getProfileInt( "ZV_02", "ZV_gesafet_extern_soll", 0, profileFile ) );
    putValue( KCAN_ZV_HBFS_offen, getProfileInt( "ZV_02", "ZV_HBFS_offen", 0, profileFile ) );
    putValue( KCAN_ZV_HD_offen, getProfileInt( "ZV_02", "ZV_HD_offen", 0, profileFile ) );
    putValue( KCAN_ZV_Heckeinzelentriegelung, getProfileInt( "ZV_02", "ZV_Heckeinzelentriegelung", 0, profileFile ) );
    putValue( KCAN_ZV_HFS_offen, getProfileInt( "ZV_02", "ZV_HFS_offen", 0, profileFile ) );
    putValue( KCAN_ZV_HS_offen, getProfileInt( "ZV_02", "ZV_HS_offen", 0, profileFile ) );
    putValue( KCAN_ZV_ist_Zustand_verfuegbar, getProfileInt( "ZV_02", "ZV_ist_Zustand_verfuegbar", 0, profileFile ) );
    putValue( KCAN_ZV_Oeffnungsmodus, getProfileInt( "ZV_02", "ZV_Oeffnungsmodus", 0, profileFile ) );
    putValue( KCAN_ZV_Rollo_auf, getProfileInt( "ZV_02", "ZV_Rollo_auf", 0, profileFile ) );
    putValue( KCAN_ZV_Rollo_zu, getProfileInt( "ZV_02", "ZV_Rollo_zu", 0, profileFile ) );
    putValue( KCAN_ZV_SAD_auf, getProfileInt( "ZV_02", "ZV_SAD_auf", 0, profileFile ) );
    putValue( KCAN_ZV_SAD_zu, getProfileInt( "ZV_02", "ZV_SAD_zu", 0, profileFile ) );
    putValue( KCAN_ZV_SafeFunktion_aktiv, getProfileInt( "ZV_02", "ZV_SafeFunktion_aktiv", 0, profileFile ) );
    putValue( KCAN_ZV_Schluessel_Zugang, getProfileInt( "ZV_02", "ZV_Schluessel_Zugang", 0, profileFile ) );
    putValue( KCAN_ZV_STSG_HBFS_Anf, getProfileInt( "ZV_02", "ZV_STSG_HBFS_Anf", 0, profileFile ) );
    putValue( KCAN_ZV_STSG_HFS_Anf, getProfileInt( "ZV_02", "ZV_STSG_HFS_Anf", 0, profileFile ) );
    putValue( KCAN_ZV_Tankklappe_offen, getProfileInt( "ZV_02", "ZV_Tankklappe_offen", 0, profileFile ) );
    putValue( KCAN_ZV_verriegeln_Anf, getProfileInt( "ZV_02", "ZV_verriegeln_Anf", 0, profileFile ) );
    putValue( KCAN_ZV_verriegelt_extern_ist, getProfileInt( "ZV_02", "ZV_verriegelt_extern_ist", 0, profileFile ) );
    putValue( KCAN_ZV_verriegelt_extern_soll, getProfileInt( "ZV_02", "ZV_verriegelt_extern_soll", 0, profileFile ) );
    putValue( KCAN_ZV_verriegelt_intern_ist, getProfileInt( "ZV_02", "ZV_verriegelt_intern_ist", 0, profileFile ) );
    putValue( KCAN_ZV_verriegelt_intern_soll, getProfileInt( "ZV_02", "ZV_verriegelt_intern_soll", 0, profileFile ) );
    putValue( KCAN_ZV_verriegelt_soll, getProfileInt( "ZV_02", "ZV_verriegelt_soll", 0, profileFile ) );

}


void loadSettings_ZV_04( char profileFile[] )
{
    putValue( KCAN_BCM_Waehlhebel_P_Hinweis, getProfileInt( "ZV_04", "BCM_Waehlhebel_P_Hinweis", 0, profileFile ) );
    putValue( KCAN_UHF_FFB_Funkschluesseltyp, getProfileInt( "ZV_04", "UHF_FFB_Funkschluesseltyp", 0, profileFile ) );
    putValue( KCAN_UHF_FFB_SKC_anlernen, getProfileInt( "ZV_04", "UHF_FFB_SKC_anlernen", 0, profileFile ) );
    putValue( KCAN_ZV_DWA_Einfachhorn_Anf, getProfileInt( "ZV_04", "ZV_DWA_Einfachhorn_Anf", 0, profileFile ) );
    putValue( KCAN_ZV_DWA_Einfachhorn_Takt, getProfileInt( "ZV_04", "ZV_DWA_Einfachhorn_Takt", 0, profileFile ) );
    putValue( KCAN_ZV_Einfachhorn_Anf, getProfileInt( "ZV_04", "ZV_Einfachhorn_Anf", 0, profileFile ) );
    putValue( KCAN_ZV_Einfachhorn_Takt, getProfileInt( "ZV_04", "ZV_Einfachhorn_Takt", 0, profileFile ) );
    putValue( KCAN_ZV_HD_Parkbremse_Hinweis, getProfileInt( "ZV_04", "ZV_HD_Parkbremse_Hinweis", 0, profileFile ) );
    putValue( KCAN_ZV_HW_Motor_Lock_HK, getProfileInt( "ZV_04", "ZV_HW_Motor_Lock_HK", 0, profileFile ) );
    putValue( KCAN_ZV_HW_Motor_Safe_Hinten, getProfileInt( "ZV_04", "ZV_HW_Motor_Safe_Hinten", 0, profileFile ) );
    putValue( KCAN_ZV_HW_TKL_mot_entr, getProfileInt( "ZV_04", "ZV_HW_TKL_mot_entr", 0, profileFile ) );
    putValue( KCAN_ZV_HW_TKL_mot_verr, getProfileInt( "ZV_04", "ZV_HW_TKL_mot_verr", 0, profileFile ) );
    putValue( KCAN_ZV_Laderaumabd_elektr_aktiviert, getProfileInt( "ZV_04", "ZV_Laderaumabd_elektr_aktiviert", 0, profileFile ) );

}


void loadENVars( char profileFile[] )
{
    putValue( eSendEnabled, getProfileInt( "Settings", "eSendEnabled", 0, profileFile ) );
    putValue( env_PIC_Status_StArtActive, getProfileInt( "Settings", "env_PIC_Status_StArtActive", 0, profileFile ) );
    putValue( env_PIC_Status_SendBtn, getProfileInt( "Settings", "env_PIC_Status_SendBtn", 0, profileFile ) );
    putValue( env_PIC_Status_GetIntAddrActive, getProfileInt( "Settings", "env_PIC_Status_GetIntAddrActive", 0, profileFile ) );
    putValue( env_PIC_Status_CoArtActive, getProfileInt( "Settings", "env_PIC_Status_CoArtActive", 0, profileFile ) );
    putValue( env_PIC_Status_AdContactActive, getProfileInt( "Settings", "env_PIC_Status_AdContactActive", 0, profileFile ) );
    putValue( env_PIC_Status_AcCallActive, getProfileInt( "Settings", "env_PIC_Status_AcCallActive", 0, profileFile ) );
    putValue( env_PIC_CoverArt_CovArtType, getProfileInt( "Settings", "env_PIC_CoverArt_CovArtType", 0, profileFile ) );
    putValue( env_PIC_CoverArt_SourceType, getProfileInt( "Settings", "env_PIC_CoverArt_SourceType", 0, profileFile ) );
    putValue( env_PIC_StationArt_StnArtType, getProfileInt( "Settings", "env_PIC_StationArt_StnArtType", 0, profileFile ) );
    putValue( env_PIC_StationArt_SourceType, getProfileInt( "Settings", "env_PIC_StationArt_SourceType", 0, profileFile ) );
    putValue( env_PIC_ActCallPic_PictureType, getProfileInt( "Settings", "env_PIC_ActCallPic_PictureType", 0, profileFile ) );
    putValue( env_PIC_ActCallPic_CallId, getProfileInt( "Settings", "env_PIC_ActCallPic_CallId", 0, profileFile ) );
    putValue( env_PIC_bapMOST_setImage_Cat, getProfileInt( "Settings", "env_PIC_bapMOST_setImage_Cat", 0, profileFile ) );
    putValue( env_PIC_bapMOST_setImage_POS, getProfileInt( "Settings", "env_PIC_bapMOST_setImage_POS", 0, profileFile ) );
    putValue( env_PIC_bapMOST_setImage_button, getProfileInt( "Settings", "env_PIC_bapMOST_setImage_button", 0, profileFile ) );
    putValue( env_PIC_CoverArt_Tx_Event, getProfileInt( "Settings", "env_PIC_CoverArt_Tx_Event", 0, profileFile ) );
    putValue( env_PIC_AdbCntctPic_Tx_Event, getProfileInt( "Settings", "env_PIC_AdbCntctPic_Tx_Event", 0, profileFile ) );
    putValue( env_PIC_ActCallPic_Tx_Event, getProfileInt( "Settings", "env_PIC_ActCallPic_Tx_Event", 0, profileFile ) );
    putValue( env_PIC_ActCallPic_Handle, getProfileInt( "Settings", "env_PIC_ActCallPic_Handle", 0, profileFile ) );
    putValue( env_PIC_AdbCntctPic_Handle, getProfileInt( "Settings", "env_PIC_AdbCntctPic_Handle", 0, profileFile ) );
    putValue( env_PIC_CoverArt_Handle, getProfileInt( "Settings", "env_PIC_CoverArt_Handle", 0, profileFile ) );
    putValue( env_PIC_StationArt_Tx_Event, getProfileInt( "Settings", "env_PIC_StationArt_Tx_Event", 0, profileFile ) );
    putValue( env_PIC_StationArt_Handle, getProfileInt( "Settings", "env_PIC_StationArt_Handle", 0, profileFile ) );
    putValue( env_PIC_bapMOST_active_flag, getProfileInt( "Settings", "env_PIC_bapMOST_active_flag", 0, profileFile ) );
    putValue( env_PIC_StressTest_Progress, getProfileInt( "Settings", "env_PIC_StressTest_Progress", 0, profileFile ) );
    putValue( env_PIC_StressTest_StressType, getProfileInt( "Settings", "env_PIC_StressTest_StressType", 0, profileFile ) );
    putValue( env_PIC_StressTest_AcCallActive, getProfileInt( "Settings", "env_PIC_StressTest_AcCallActive", 0, profileFile ) );
    putValue( env_PIC_StressTest_StArtActive, getProfileInt( "Settings", "env_PIC_StressTest_StArtActive", 0, profileFile ) );
    putValue( env_PIC_StressTest_AcCallDelay, getProfileInt( "Settings", "env_PIC_StressTest_AcCallDelay", 0, profileFile ) );
    putValue( env_PIC_StressTest_AcCallCount, getProfileInt( "Settings", "env_PIC_StressTest_AcCallCount", 0, profileFile ) );
    putValue( env_PIC_StressTest_StArtCount, getProfileInt( "Settings", "env_PIC_StressTest_StArtCount", 0, profileFile ) );
    putValue( env_PIC_StressTest_CoArtCount, getProfileInt( "Settings", "env_PIC_StressTest_CoArtCount", 0, profileFile ) );
    putValue( env_PIC_StressTest_StArtDelay, getProfileInt( "Settings", "env_PIC_StressTest_StArtDelay", 0, profileFile ) );
    putValue( env_PIC_StressTest_CoArtDelay, getProfileInt( "Settings", "env_PIC_StressTest_CoArtDelay", 0, profileFile ) );
    putValue( env_PIC_StressTest_Time, getProfileInt( "Settings", "env_PIC_StressTest_Time", 0, profileFile ) );
    putValue( env_PIC_StressTest_TestBtn, getProfileInt( "Settings", "env_PIC_StressTest_TestBtn", 0, profileFile ) );
    putValue( env_PIC_StressTest_CoArtActive, getProfileInt( "Settings", "env_PIC_StressTest_CoArtActive", 0, profileFile ) );
    putValue( env_ECL_RBDTestEvent, getProfileInt( "Settings", "env_ECL_RBDTestEvent", 0, profileFile ) );
    putValue( env_WakeupRequestInQueueFlag, getProfileInt( "Settings", "env_WakeupRequestInQueueFlag", 0, profileFile ) );
    putValue( env_ShutdownExecuteSendFlag, getProfileInt( "Settings", "env_ShutdownExecuteSendFlag", 0, profileFile ) );
    putValue( env_RadioButton_Shutdown_Wakeup, getProfileInt( "Settings", "env_RadioButton_Shutdown_Wakeup", 0, profileFile ) );
    putValue( env_RadioButton_MOSTLight_On_Off, getProfileInt( "Settings", "env_RadioButton_MOSTLight_On_Off", 0, profileFile ) );
    putValue( ENV_WRN_Time_DisplayTime, getProfileInt( "Settings", "ENV_WRN_Time_DisplayTime", 0, profileFile ) );
    putValue( ENV_WRN_Time_OnOff, getProfileInt( "Settings", "ENV_WRN_Time_OnOff", 0, profileFile ) );
    putValue( ENV_MO_Ges_calcConsumption_button, getProfileInt( "Settings", "ENV_MO_Ges_calcConsumption_button", 0, profileFile ) );
    putValue( ENV_MO_Recu_calcConsumption_button, getProfileInt( "Settings", "ENV_MO_Recu_calcConsumption_button", 0, profileFile ) );
    putValue( ENV_BMS_Verbrauch_calcConsumption_button, getProfileInt( "Settings", "ENV_BMS_Verbrauch_calcConsumption_button", 0, profileFile ) );
    putValue( ENV_BMS_Rekuperation_calcConsumption_button, getProfileInt( "Settings", "ENV_BMS_Rekuperation_calcConsumption_button", 0, profileFile ) );
    putValue( ENV_PlayReplayblock, getProfileInt( "Settings", "ENV_PlayReplayblock", 0, profileFile ) );
    putValue( ENV_KombiMQB_TxCycle_Check, getProfileInt( "Settings", "ENV_KombiMQB_TxCycle_Check", 0, profileFile ) );
    putValue( ENV_DEV_Kombi_54_TxC_stat, getProfileInt( "Settings", "ENV_DEV_Kombi_54_TxC_stat", 0, profileFile ) );
    putValue( ENV_DEV_Kombi_54_TxC_min, getProfileInt( "Settings", "ENV_DEV_Kombi_54_TxC_min", 0, profileFile ) );
    putValue( ENV_DEV_Kombi_54_TxC_max, getProfileInt( "Settings", "ENV_DEV_Kombi_54_TxC_max", 0, profileFile ) );
    putValue( ENV_DEV_Kombi_54_RedCtr, getProfileInt( "Settings", "ENV_DEV_Kombi_54_RedCtr", 0, profileFile ) );
    putValue( ENV_TxCycleCheck_ErrSummary, getProfileInt( "Settings", "ENV_TxCycleCheck_ErrSummary", 0, profileFile ) );
    putValue( ENV_DEV_Kombi_54_TxC_timeStamp, getProfileFloat( "Settings", "ENV_DEV_Kombi_54_TxC_timeStamp", 0, profileFile ) );
    putValue( ENV_SendMFL_Tasten_Kon_01, getProfileInt( "Settings", "ENV_SendMFL_Tasten_Kon_01", 0, profileFile ) );
    putValue( ENV_TESP_24, getProfileInt( "Settings", "ENV_TESP_24", 0, profileFile ) );
    putValue( ENV_KBI_PhototransistorD, getProfileInt( "Settings", "ENV_KBI_PhototransistorD", 0, profileFile ) );
    putValue( ENV_Phone_CombNum_list_short, getProfileInt( "Settings", "ENV_Phone_CombNum_list_short", 0, profileFile ) );
    putValue( ENV_FSG_CN_Flg, getProfileInt( "Settings", "ENV_FSG_CN_Flg", 0, profileFile ) );
    putValue( ENV_PIC_bapMOST_active_flag, getProfileInt( "Settings", "ENV_PIC_bapMOST_active_flag", 0, profileFile ) );
    putValue( ENV_SendEnabled, getProfileInt( "Settings", "ENV_SendEnabled", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_OFF, getProfileInt( "Settings", "ENV_INTEGR_TestCase_OFF", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ14, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ14", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ15, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ15", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ16, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ16", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ17, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ17", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ18, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ18", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ19, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ19", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ20, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ20", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ21, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ21", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ22, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ22", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ23, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ23", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ24, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ24", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ25, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ25", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ26, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ26", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ27, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ27", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ28, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ28", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ29, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ29", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ30, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ30", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ31, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ31", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ32, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ32", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ33, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ33", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ34, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ34", 0, profileFile ) );
    putValue( ENV_INTEGR_TestCase_BZ35, getProfileFloat( "Settings", "ENV_INTEGR_TestCase_BZ35", 0, profileFile ) );
    putValue( ENV_NaviSD_RG_Status, getProfileInt( "Settings", "ENV_NaviSD_RG_Status", 0, profileFile ) );
    putValue( ENV_NaviSD_RG_Status_update, getProfileInt( "Settings", "ENV_NaviSD_RG_Status_update", 0, profileFile ) );
    putValue( ENV_Navi_LaneGuidanceList_Long, getProfileInt( "Settings", "ENV_Navi_LaneGuidanceList_Long", 0, profileFile ) );
    putValue( ENV_NaviSD_MD_update, getProfileInt( "Settings", "ENV_NaviSD_MD_update", 0, profileFile ) );
    putValue( ENV_NaviSD_LG_LGOnOff, getProfileInt( "Settings", "ENV_NaviSD_LG_LGOnOff", 0, profileFile ) );
    putValue( ENV_NaviSD_MD_MainElement1, getProfileInt( "Settings", "ENV_NaviSD_MD_MainElement1", 0, profileFile ) );
    putValue( ENV_AudioSD_PowerOnOff, getProfileInt( "Settings", "ENV_AudioSD_PowerOnOff", 0, profileFile ) );
    putValue( ENV_MO_CNG_LPG, getProfileInt( "Settings", "ENV_MO_CNG_LPG", 0, profileFile ) );
    putValue( ENV_MO_akt_Betrieb, getProfileInt( "Settings", "ENV_MO_akt_Betrieb", 0, profileFile ) );
    putValue( ENV_MO_Fuellungsgrad_CNG, getProfileFloat( "Settings", "ENV_MO_Fuellungsgrad_CNG", 0, profileFile ) );
    putValue( ENV_MO_Verbrauch_LPG, getProfileInt( "Settings", "ENV_MO_Verbrauch_LPG", 0, profileFile ) );
    putValue( ENV_MO_Tankmasse_CNG, getProfileFloat( "Settings", "ENV_MO_Tankmasse_CNG", 0, profileFile ) );
    putValue( ENV_MO_Fuellungsgrad_LPG_m1, getProfileFloat( "Settings", "ENV_MO_Fuellungsgrad_LPG_m1", 0, profileFile ) );
    putValue( ENV_MO_Tankvolumen_LPG, getProfileFloat( "Settings", "ENV_MO_Tankvolumen_LPG", 0, profileFile ) );
    putValue( ENV_RadioButton_MOSTLight_On_Off, getProfileInt( "Settings", "ENV_RadioButton_MOSTLight_On_Off", 0, profileFile ) );
    putValue( ENV_RadioButton_Shutdown_Wakeup, getProfileInt( "Settings", "ENV_RadioButton_Shutdown_Wakeup", 0, profileFile ) );
    putValue( ENV_ShutdownExecuteSendFlag, getProfileInt( "Settings", "ENV_ShutdownExecuteSendFlag", 0, profileFile ) );
    putValue( ENV_WakeupRequestInQueueFlag, getProfileInt( "Settings", "ENV_WakeupRequestInQueueFlag", 0, profileFile ) );
    putValue( ENV_ECL_RBDTestEvent, getProfileInt( "Settings", "ENV_ECL_RBDTestEvent", 0, profileFile ) );
    putValue( ENV_AudioSD_MBList_Long, getProfileInt( "Settings", "ENV_AudioSD_MBList_Long", 0, profileFile ) );
    putValue( ENV_AudioSD_MBList_Short, getProfileInt( "Settings", "ENV_AudioSD_MBList_Short", 0, profileFile ) );
    putValue( ENV_AudioSD_SourceList_Long, getProfileInt( "Settings", "ENV_AudioSD_SourceList_Long", 0, profileFile ) );
    putValue( ENV_AudioSD_SourceList_Short, getProfileInt( "Settings", "ENV_AudioSD_SourceList_Short", 0, profileFile ) );
    putValue( ENV_NaviSD_BAP_Longlist, getProfileInt( "Settings", "ENV_NaviSD_BAP_Longlist", 0, profileFile ) );
    putValue( ENV_NaviSD_BAP_Shortlist, getProfileInt( "Settings", "ENV_NaviSD_BAP_Shortlist", 0, profileFile ) );
    putValue( ENV_Navi_LaneGuidanceList_Short, getProfileInt( "Settings", "ENV_Navi_LaneGuidanceList_Short", 0, profileFile ) );
    putValue( ENV_Phone_CombNum_list_long, getProfileInt( "Settings", "ENV_Phone_CombNum_list_long", 0, profileFile ) );
    putValue( ENV_Phone_Phonebook_list_short, getProfileInt( "Settings", "ENV_Phone_Phonebook_list_short", 0, profileFile ) );
    putValue( ENV_Phone_Phonebook_list_long, getProfileInt( "Settings", "ENV_Phone_Phonebook_list_long", 0, profileFile ) );
    putValue( ENV_NaviSD_PrefDeLis_Type, getProfileInt( "Settings", "ENV_NaviSD_PrefDeLis_Type", 0, profileFile ) );
    putValue( ENV_FSG_Schalter_OnOff, getProfileInt( "Settings", "ENV_FSG_Schalter_OnOff", 0, profileFile ) );
    putValue( ENV_NaviSD_LG_FRU, getProfileInt( "Settings", "ENV_NaviSD_LG_FRU", 0, profileFile ) );
    putValue( ENV_NaviSD_LDL_FRU, getProfileInt( "Settings", "ENV_NaviSD_LDL_FRU", 0, profileFile ) );
    putValue( ENV_AudioSD_MB_FRU, getProfileInt( "Settings", "ENV_AudioSD_MB_FRU", 0, profileFile ) );
    putValue( ENV_FSG_CN_FRU, getProfileInt( "Settings", "ENV_FSG_CN_FRU", 0, profileFile ) );
    putValue( ENV_FSG_IncomingCall, getProfileInt( "Settings", "ENV_FSG_IncomingCall", 0, profileFile ) );
    putValue( ENV_FSG_HangupCall, getProfileInt( "Settings", "ENV_FSG_HangupCall", 0, profileFile ) );
    putValue( ENV_Audio_StartResult_IND, getProfileInt( "Settings", "ENV_Audio_StartResult_IND", 0, profileFile ) );
    putValue( ENV_Telephone_DataGet_IND, getProfileInt( "Settings", "ENV_Telephone_DataGet_IND", 0, profileFile ) );
    putValue( ENV_NaviSD_FDL_FRU, getProfileInt( "Settings", "ENV_NaviSD_FDL_FRU", 0, profileFile ) );
    putValue( KCAN__STOP_All_MESSAGES_DEFAULT_STARTDELAY, getProfileInt( "Settings", "KCAN__STOP_All_MESSAGES_DEFAULT_STARTDELAY", 0, profileFile ) );
    putValue( KCAN__STOP_All_MESSAGES_SET_STARTDELAY, getProfileInt( "Settings", "KCAN__STOP_All_MESSAGES_SET_STARTDELAY", 0, profileFile ) );
    putValue( KCAN__SAVE_PANEL_CONFIG, getProfileInt( "Settings", "KCAN__SAVE_PANEL_CONFIG", 0, profileFile ) );
    putValue( KCAN__STOP_All_MESSAGES_ON, getProfileInt( "Settings", "KCAN__STOP_All_MESSAGES_ON", 0, profileFile ) );
    putValue( KCAN__STOP_All_MESSAGES_OFF, getProfileInt( "Settings", "KCAN__STOP_All_MESSAGES_OFF", 0, profileFile ) );
    putValue( KCAN__NMH_Fahrerdisplay_Kombi_ActualState, getProfileInt( "Settings", "KCAN__NMH_Fahrerdisplay_Kombi_ActualState", 0, profileFile ) );
    putValue( KCAN__HeavyBusload, getProfileInt( "Settings", "KCAN__HeavyBusload", 0, profileFile ) );
    putValue( KCAN__NMH_SmartLight_01_ActualState, getProfileInt( "Settings", "KCAN__NMH_SmartLight_01_ActualState", 0, profileFile ) );
    putValue( KCAN__NMH_ICAS3_Gateway_ActualState, getProfileInt( "Settings", "KCAN__NMH_ICAS3_Gateway_ActualState", 0, profileFile ) );
    putValue( KCAN__NMH_ICAS1_Gateway_ActualState, getProfileInt( "Settings", "KCAN__NMH_ICAS1_Gateway_ActualState", 0, profileFile ) );
    putValue( KCAN__NMH_HUD_ActualState, getProfileInt( "Settings", "KCAN__NMH_HUD_ActualState", 0, profileFile ) );
    putValue( KCAN__NMH_Kombi_ActualState, getProfileInt( "Settings", "KCAN__NMH_Kombi_ActualState", 0, profileFile ) );
    putValue( KCAN__MSGID_AAA_01, getProfileInt( "Settings", "KCAN__MSGID_AAA_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_AAA_01, getProfileInt( "Settings", "KCAN__MSGDLC_AAA_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_AAA_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_AAA_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_AAA_01, getProfileInt( "Settings", "KCAN__ALLDEF_AAA_01", 0, profileFile ) );
    putValue( KCAN__STMSG_AAA_01, getProfileInt( "Settings", "KCAN__STMSG_AAA_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_AAA_01, getProfileInt( "Settings", "KCAN__STMSGT_AAA_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_AAA_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_AAA_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_AAA_01, getProfileInt( "Settings", "KCAN__STMSGSD_AAA_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_AAA_01, getProfileInt( "Settings", "KCAN__STMSGCT_AAA_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_AAA_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_AAA_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_AAA_01, getProfileInt( "Settings", "KCAN__STMSG_PO_AAA_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_AAA_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_AAA_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_AAA_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_AAA_01", 0, profileFile ) );
    putValue( KCAN__MSGID_ACC_19, getProfileInt( "Settings", "KCAN__MSGID_ACC_19", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ACC_19, getProfileInt( "Settings", "KCAN__MSGDLC_ACC_19", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ACC_19_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ACC_19_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ACC_19, getProfileInt( "Settings", "KCAN__ALLDEF_ACC_19", 0, profileFile ) );
    putValue( KCAN__STMSG_ACC_19, getProfileInt( "Settings", "KCAN__STMSG_ACC_19", 0, profileFile ) );
    putValue( KCAN__STMSGT_ACC_19, getProfileInt( "Settings", "KCAN__STMSGT_ACC_19", 0, profileFile ) );
    putValue( KCAN__STMSGT_ACC_19_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ACC_19_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ACC_19, getProfileInt( "Settings", "KCAN__STMSGSD_ACC_19", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ACC_19, getProfileInt( "Settings", "KCAN__STMSGCT_ACC_19", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ACC_19_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ACC_19_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ACC_19, getProfileInt( "Settings", "KCAN__STMSG_PO_ACC_19", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ACC_19, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ACC_19", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ACC_19, getProfileInt( "Settings", "KCAN__MSG_SendNow_ACC_19", 0, profileFile ) );
    putValue( KCAN__MSGID_AGA_01, getProfileInt( "Settings", "KCAN__MSGID_AGA_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_AGA_01, getProfileInt( "Settings", "KCAN__MSGDLC_AGA_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_AGA_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_AGA_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_AGA_01, getProfileInt( "Settings", "KCAN__ALLDEF_AGA_01", 0, profileFile ) );
    putValue( KCAN__STMSG_AGA_01, getProfileInt( "Settings", "KCAN__STMSG_AGA_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_AGA_01, getProfileInt( "Settings", "KCAN__STMSGT_AGA_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_AGA_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_AGA_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_AGA_01, getProfileInt( "Settings", "KCAN__STMSGSD_AGA_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_AGA_01, getProfileInt( "Settings", "KCAN__STMSGCT_AGA_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_AGA_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_AGA_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_AGA_01, getProfileInt( "Settings", "KCAN__STMSG_PO_AGA_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_AGA_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_AGA_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_AGA_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_AGA_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Airbag_01, getProfileInt( "Settings", "KCAN__MSGID_Airbag_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Airbag_01, getProfileInt( "Settings", "KCAN__MSGDLC_Airbag_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Airbag_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Airbag_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Airbag_01, getProfileInt( "Settings", "KCAN__ALLDEF_Airbag_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Airbag_01, getProfileInt( "Settings", "KCAN__STMSG_Airbag_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Airbag_01, getProfileInt( "Settings", "KCAN__STMSGT_Airbag_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Airbag_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Airbag_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Airbag_01, getProfileInt( "Settings", "KCAN__STMSGSD_Airbag_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Airbag_01, getProfileInt( "Settings", "KCAN__STMSGCT_Airbag_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Airbag_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Airbag_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Airbag_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Airbag_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Airbag_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Airbag_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Airbag_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Airbag_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Airbag_02, getProfileInt( "Settings", "KCAN__MSGID_Airbag_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Airbag_02, getProfileInt( "Settings", "KCAN__MSGDLC_Airbag_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Airbag_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Airbag_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Airbag_02, getProfileInt( "Settings", "KCAN__ALLDEF_Airbag_02", 0, profileFile ) );
    putValue( KCAN__STMSG_Airbag_02, getProfileInt( "Settings", "KCAN__STMSG_Airbag_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_Airbag_02, getProfileInt( "Settings", "KCAN__STMSGT_Airbag_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_Airbag_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Airbag_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Airbag_02, getProfileInt( "Settings", "KCAN__STMSGSD_Airbag_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Airbag_02, getProfileInt( "Settings", "KCAN__STMSGCT_Airbag_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Airbag_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Airbag_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Airbag_02, getProfileInt( "Settings", "KCAN__STMSG_PO_Airbag_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Airbag_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Airbag_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Airbag_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_Airbag_02", 0, profileFile ) );
    putValue( KCAN__MSGID_Airbag_04, getProfileInt( "Settings", "KCAN__MSGID_Airbag_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Airbag_04, getProfileInt( "Settings", "KCAN__MSGDLC_Airbag_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Airbag_04_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Airbag_04_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Airbag_04, getProfileInt( "Settings", "KCAN__ALLDEF_Airbag_04", 0, profileFile ) );
    putValue( KCAN__STMSG_Airbag_04, getProfileInt( "Settings", "KCAN__STMSG_Airbag_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_Airbag_04, getProfileInt( "Settings", "KCAN__STMSGT_Airbag_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_Airbag_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Airbag_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Airbag_04, getProfileInt( "Settings", "KCAN__STMSGSD_Airbag_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Airbag_04, getProfileInt( "Settings", "KCAN__STMSGCT_Airbag_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Airbag_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Airbag_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Airbag_04, getProfileInt( "Settings", "KCAN__STMSG_PO_Airbag_04", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Airbag_04, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Airbag_04", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Airbag_04, getProfileInt( "Settings", "KCAN__MSG_SendNow_Airbag_04", 0, profileFile ) );
    putValue( KCAN__MSGID_Airbag_06, getProfileInt( "Settings", "KCAN__MSGID_Airbag_06", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Airbag_06, getProfileInt( "Settings", "KCAN__MSGDLC_Airbag_06", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Airbag_06_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Airbag_06_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Airbag_06, getProfileInt( "Settings", "KCAN__ALLDEF_Airbag_06", 0, profileFile ) );
    putValue( KCAN__STMSG_Airbag_06, getProfileInt( "Settings", "KCAN__STMSG_Airbag_06", 0, profileFile ) );
    putValue( KCAN__STMSGT_Airbag_06, getProfileInt( "Settings", "KCAN__STMSGT_Airbag_06", 0, profileFile ) );
    putValue( KCAN__STMSGT_Airbag_06_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Airbag_06_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Airbag_06, getProfileInt( "Settings", "KCAN__STMSGSD_Airbag_06", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Airbag_06, getProfileInt( "Settings", "KCAN__STMSGCT_Airbag_06", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Airbag_06_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Airbag_06_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Airbag_06, getProfileInt( "Settings", "KCAN__STMSG_PO_Airbag_06", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Airbag_06, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Airbag_06", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Airbag_06, getProfileInt( "Settings", "KCAN__MSG_SendNow_Airbag_06", 0, profileFile ) );
    putValue( KCAN__MSGID_Anhaenger_01, getProfileInt( "Settings", "KCAN__MSGID_Anhaenger_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Anhaenger_01, getProfileInt( "Settings", "KCAN__MSGDLC_Anhaenger_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Anhaenger_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Anhaenger_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Anhaenger_01, getProfileInt( "Settings", "KCAN__ALLDEF_Anhaenger_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Anhaenger_01, getProfileInt( "Settings", "KCAN__STMSG_Anhaenger_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Anhaenger_01, getProfileInt( "Settings", "KCAN__STMSGT_Anhaenger_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Anhaenger_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Anhaenger_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Anhaenger_01, getProfileInt( "Settings", "KCAN__STMSGSD_Anhaenger_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Anhaenger_01, getProfileInt( "Settings", "KCAN__STMSGCT_Anhaenger_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Anhaenger_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Anhaenger_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Anhaenger_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Anhaenger_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Anhaenger_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Anhaenger_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Anhaenger_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Anhaenger_01", 0, profileFile ) );
    putValue( KCAN__MSGID_ARA_Status_01, getProfileInt( "Settings", "KCAN__MSGID_ARA_Status_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ARA_Status_01, getProfileInt( "Settings", "KCAN__MSGDLC_ARA_Status_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ARA_Status_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ARA_Status_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ARA_Status_01, getProfileInt( "Settings", "KCAN__ALLDEF_ARA_Status_01", 0, profileFile ) );
    putValue( KCAN__STMSG_ARA_Status_01, getProfileInt( "Settings", "KCAN__STMSG_ARA_Status_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_ARA_Status_01, getProfileInt( "Settings", "KCAN__STMSGT_ARA_Status_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_ARA_Status_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ARA_Status_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ARA_Status_01, getProfileInt( "Settings", "KCAN__STMSGSD_ARA_Status_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ARA_Status_01, getProfileInt( "Settings", "KCAN__STMSGCT_ARA_Status_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ARA_Status_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ARA_Status_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ARA_Status_01, getProfileInt( "Settings", "KCAN__STMSG_PO_ARA_Status_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ARA_Status_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ARA_Status_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ARA_Status_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_ARA_Status_01", 0, profileFile ) );
    putValue( KCAN__MSGID_ARC_HUD_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_ARC_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ARC_HUD_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLC_ARC_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ARC_HUD_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ARC_HUD_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ARC_HUD_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_ARC_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_ARC_HUD_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_ARC_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ARC_HUD_Req_FD, getProfileInt( "Settings", "KCAN__STMSGT_ARC_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ARC_HUD_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ARC_HUD_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ARC_HUD_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_ARC_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ARC_HUD_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ARC_HUD_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ARC_HUD_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ARC_HUD_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ARC_HUD_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_ARC_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ARC_HUD_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ARC_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ARC_HUD_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_ARC_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_ARC_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_ARC_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ARC_HUD_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ARC_HUD_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ARC_HUD_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ARC_HUD_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ARC_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_ARC_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_ARC_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_ARC_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ARC_HUD_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ARC_HUD_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGT_ARC_HUD_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ARC_HUD_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ARC_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_ARC_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ARC_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_ARC_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ARC_HUD_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ARC_HUD_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ARC_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_ARC_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ARC_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ARC_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ARC_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_ARC_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_AWV_02, getProfileInt( "Settings", "KCAN__MSGID_AWV_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_AWV_02, getProfileInt( "Settings", "KCAN__MSGDLC_AWV_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_AWV_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_AWV_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_AWV_02, getProfileInt( "Settings", "KCAN__ALLDEF_AWV_02", 0, profileFile ) );
    putValue( KCAN__STMSG_AWV_02, getProfileInt( "Settings", "KCAN__STMSG_AWV_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_AWV_02, getProfileInt( "Settings", "KCAN__STMSGT_AWV_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_AWV_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_AWV_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_AWV_02, getProfileInt( "Settings", "KCAN__STMSGSD_AWV_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_AWV_02, getProfileInt( "Settings", "KCAN__STMSGCT_AWV_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_AWV_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_AWV_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_AWV_02, getProfileInt( "Settings", "KCAN__STMSG_PO_AWV_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_AWV_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_AWV_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_AWV_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_AWV_02", 0, profileFile ) );
    putValue( KCAN__MSGID_AZK_01, getProfileInt( "Settings", "KCAN__MSGID_AZK_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_AZK_01, getProfileInt( "Settings", "KCAN__MSGDLC_AZK_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_AZK_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_AZK_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_AZK_01, getProfileInt( "Settings", "KCAN__ALLDEF_AZK_01", 0, profileFile ) );
    putValue( KCAN__STMSG_AZK_01, getProfileInt( "Settings", "KCAN__STMSG_AZK_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_AZK_01, getProfileInt( "Settings", "KCAN__STMSGT_AZK_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_AZK_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_AZK_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_AZK_01, getProfileInt( "Settings", "KCAN__STMSGSD_AZK_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_AZK_01, getProfileInt( "Settings", "KCAN__STMSGCT_AZK_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_AZK_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_AZK_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_AZK_01, getProfileInt( "Settings", "KCAN__STMSG_PO_AZK_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_AZK_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_AZK_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_AZK_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_AZK_01", 0, profileFile ) );
    putValue( KCAN__MSGID_BCM_01, getProfileInt( "Settings", "KCAN__MSGID_BCM_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_BCM_01, getProfileInt( "Settings", "KCAN__MSGDLC_BCM_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_BCM_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_BCM_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_BCM_01, getProfileInt( "Settings", "KCAN__ALLDEF_BCM_01", 0, profileFile ) );
    putValue( KCAN__STMSG_BCM_01, getProfileInt( "Settings", "KCAN__STMSG_BCM_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_BCM_01, getProfileInt( "Settings", "KCAN__STMSGT_BCM_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_BCM_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_BCM_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_BCM_01, getProfileInt( "Settings", "KCAN__STMSGSD_BCM_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_BCM_01, getProfileInt( "Settings", "KCAN__STMSGCT_BCM_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_BCM_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_BCM_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_BCM_01, getProfileInt( "Settings", "KCAN__STMSG_PO_BCM_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_BCM_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_BCM_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_BCM_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_BCM_01", 0, profileFile ) );
    putValue( KCAN__MSGID_BCM_03, getProfileInt( "Settings", "KCAN__MSGID_BCM_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_BCM_03, getProfileInt( "Settings", "KCAN__MSGDLC_BCM_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_BCM_03_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_BCM_03_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_BCM_03, getProfileInt( "Settings", "KCAN__ALLDEF_BCM_03", 0, profileFile ) );
    putValue( KCAN__STMSG_BCM_03, getProfileInt( "Settings", "KCAN__STMSG_BCM_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_BCM_03, getProfileInt( "Settings", "KCAN__STMSGT_BCM_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_BCM_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_BCM_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_BCM_03, getProfileInt( "Settings", "KCAN__STMSGSD_BCM_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_BCM_03, getProfileInt( "Settings", "KCAN__STMSGCT_BCM_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_BCM_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_BCM_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_BCM_03, getProfileInt( "Settings", "KCAN__STMSG_PO_BCM_03", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_BCM_03, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_BCM_03", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_BCM_03, getProfileInt( "Settings", "KCAN__MSG_SendNow_BCM_03", 0, profileFile ) );
    putValue( KCAN__MSGID_BCM_04, getProfileInt( "Settings", "KCAN__MSGID_BCM_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_BCM_04, getProfileInt( "Settings", "KCAN__MSGDLC_BCM_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_BCM_04_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_BCM_04_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_BCM_04, getProfileInt( "Settings", "KCAN__ALLDEF_BCM_04", 0, profileFile ) );
    putValue( KCAN__STMSG_BCM_04, getProfileInt( "Settings", "KCAN__STMSG_BCM_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_BCM_04, getProfileInt( "Settings", "KCAN__STMSGT_BCM_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_BCM_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_BCM_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_BCM_04, getProfileInt( "Settings", "KCAN__STMSGSD_BCM_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_BCM_04, getProfileInt( "Settings", "KCAN__STMSGCT_BCM_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_BCM_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_BCM_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_BCM_04, getProfileInt( "Settings", "KCAN__STMSG_PO_BCM_04", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_BCM_04, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_BCM_04", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_BCM_04, getProfileInt( "Settings", "KCAN__MSG_SendNow_BCM_04", 0, profileFile ) );
    putValue( KCAN__MSGID_BCM_Taster_02, getProfileInt( "Settings", "KCAN__MSGID_BCM_Taster_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_BCM_Taster_02, getProfileInt( "Settings", "KCAN__MSGDLC_BCM_Taster_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_BCM_Taster_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_BCM_Taster_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_BCM_Taster_02, getProfileInt( "Settings", "KCAN__ALLDEF_BCM_Taster_02", 0, profileFile ) );
    putValue( KCAN__STMSG_BCM_Taster_02, getProfileInt( "Settings", "KCAN__STMSG_BCM_Taster_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_BCM_Taster_02, getProfileInt( "Settings", "KCAN__STMSGT_BCM_Taster_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_BCM_Taster_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_BCM_Taster_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_BCM_Taster_02, getProfileInt( "Settings", "KCAN__STMSGSD_BCM_Taster_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_BCM_Taster_02, getProfileInt( "Settings", "KCAN__STMSGCT_BCM_Taster_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_BCM_Taster_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_BCM_Taster_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_BCM_Taster_02, getProfileInt( "Settings", "KCAN__STMSG_PO_BCM_Taster_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_BCM_Taster_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_BCM_Taster_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_BCM_Taster_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_BCM_Taster_02", 0, profileFile ) );
    putValue( KCAN__MSGID_BCM_Taster_03, getProfileInt( "Settings", "KCAN__MSGID_BCM_Taster_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_BCM_Taster_03, getProfileInt( "Settings", "KCAN__MSGDLC_BCM_Taster_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_BCM_Taster_03_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_BCM_Taster_03_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_BCM_Taster_03, getProfileInt( "Settings", "KCAN__ALLDEF_BCM_Taster_03", 0, profileFile ) );
    putValue( KCAN__STMSG_BCM_Taster_03, getProfileInt( "Settings", "KCAN__STMSG_BCM_Taster_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_BCM_Taster_03, getProfileInt( "Settings", "KCAN__STMSGT_BCM_Taster_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_BCM_Taster_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_BCM_Taster_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_BCM_Taster_03, getProfileInt( "Settings", "KCAN__STMSGSD_BCM_Taster_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_BCM_Taster_03, getProfileInt( "Settings", "KCAN__STMSGCT_BCM_Taster_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_BCM_Taster_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_BCM_Taster_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_BCM_Taster_03, getProfileInt( "Settings", "KCAN__STMSG_PO_BCM_Taster_03", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_BCM_Taster_03, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_BCM_Taster_03", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_BCM_Taster_03, getProfileInt( "Settings", "KCAN__MSG_SendNow_BCM_Taster_03", 0, profileFile ) );
    putValue( KCAN__MSGID_BEM_02, getProfileInt( "Settings", "KCAN__MSGID_BEM_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_BEM_02, getProfileInt( "Settings", "KCAN__MSGDLC_BEM_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_BEM_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_BEM_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_BEM_02, getProfileInt( "Settings", "KCAN__ALLDEF_BEM_02", 0, profileFile ) );
    putValue( KCAN__STMSG_BEM_02, getProfileInt( "Settings", "KCAN__STMSG_BEM_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_BEM_02, getProfileInt( "Settings", "KCAN__STMSGT_BEM_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_BEM_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_BEM_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_BEM_02, getProfileInt( "Settings", "KCAN__STMSGSD_BEM_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_BEM_02, getProfileInt( "Settings", "KCAN__STMSGCT_BEM_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_BEM_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_BEM_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_BEM_02, getProfileInt( "Settings", "KCAN__STMSG_PO_BEM_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_BEM_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_BEM_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_BEM_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_BEM_02", 0, profileFile ) );
    putValue( KCAN__MSGID_BEM_06, getProfileInt( "Settings", "KCAN__MSGID_BEM_06", 0, profileFile ) );
    putValue( KCAN__MSGDLC_BEM_06, getProfileInt( "Settings", "KCAN__MSGDLC_BEM_06", 0, profileFile ) );
    putValue( KCAN__MSGDLC_BEM_06_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_BEM_06_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_BEM_06, getProfileInt( "Settings", "KCAN__ALLDEF_BEM_06", 0, profileFile ) );
    putValue( KCAN__STMSG_BEM_06, getProfileInt( "Settings", "KCAN__STMSG_BEM_06", 0, profileFile ) );
    putValue( KCAN__STMSGT_BEM_06, getProfileInt( "Settings", "KCAN__STMSGT_BEM_06", 0, profileFile ) );
    putValue( KCAN__STMSGT_BEM_06_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_BEM_06_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_BEM_06, getProfileInt( "Settings", "KCAN__STMSGSD_BEM_06", 0, profileFile ) );
    putValue( KCAN__STMSGCT_BEM_06, getProfileInt( "Settings", "KCAN__STMSGCT_BEM_06", 0, profileFile ) );
    putValue( KCAN__STMSGCT_BEM_06_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_BEM_06_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_BEM_06, getProfileInt( "Settings", "KCAN__STMSG_PO_BEM_06", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_BEM_06, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_BEM_06", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_BEM_06, getProfileInt( "Settings", "KCAN__MSG_SendNow_BEM_06", 0, profileFile ) );
    putValue( KCAN__MSGID_Blinkmodi_02, getProfileInt( "Settings", "KCAN__MSGID_Blinkmodi_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Blinkmodi_02, getProfileInt( "Settings", "KCAN__MSGDLC_Blinkmodi_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Blinkmodi_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Blinkmodi_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Blinkmodi_02, getProfileInt( "Settings", "KCAN__ALLDEF_Blinkmodi_02", 0, profileFile ) );
    putValue( KCAN__STMSG_Blinkmodi_02, getProfileInt( "Settings", "KCAN__STMSG_Blinkmodi_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_Blinkmodi_02, getProfileInt( "Settings", "KCAN__STMSGT_Blinkmodi_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_Blinkmodi_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Blinkmodi_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Blinkmodi_02, getProfileInt( "Settings", "KCAN__STMSGSD_Blinkmodi_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Blinkmodi_02, getProfileInt( "Settings", "KCAN__STMSGCT_Blinkmodi_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Blinkmodi_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Blinkmodi_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Blinkmodi_02, getProfileInt( "Settings", "KCAN__STMSG_PO_Blinkmodi_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Blinkmodi_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Blinkmodi_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Blinkmodi_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_Blinkmodi_02", 0, profileFile ) );
    putValue( KCAN__MSGID_BMS_05, getProfileInt( "Settings", "KCAN__MSGID_BMS_05", 0, profileFile ) );
    putValue( KCAN__MSGDLC_BMS_05, getProfileInt( "Settings", "KCAN__MSGDLC_BMS_05", 0, profileFile ) );
    putValue( KCAN__MSGDLC_BMS_05_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_BMS_05_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_BMS_05, getProfileInt( "Settings", "KCAN__ALLDEF_BMS_05", 0, profileFile ) );
    putValue( KCAN__STMSG_BMS_05, getProfileInt( "Settings", "KCAN__STMSG_BMS_05", 0, profileFile ) );
    putValue( KCAN__STMSGT_BMS_05, getProfileInt( "Settings", "KCAN__STMSGT_BMS_05", 0, profileFile ) );
    putValue( KCAN__STMSGT_BMS_05_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_BMS_05_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_BMS_05, getProfileInt( "Settings", "KCAN__STMSGSD_BMS_05", 0, profileFile ) );
    putValue( KCAN__STMSGCT_BMS_05, getProfileInt( "Settings", "KCAN__STMSGCT_BMS_05", 0, profileFile ) );
    putValue( KCAN__STMSGCT_BMS_05_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_BMS_05_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_BMS_05, getProfileInt( "Settings", "KCAN__STMSG_PO_BMS_05", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_BMS_05, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_BMS_05", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_BMS_05, getProfileInt( "Settings", "KCAN__MSG_SendNow_BMS_05", 0, profileFile ) );
    putValue( KCAN__MSGID_BMS_07, getProfileInt( "Settings", "KCAN__MSGID_BMS_07", 0, profileFile ) );
    putValue( KCAN__MSGDLC_BMS_07, getProfileInt( "Settings", "KCAN__MSGDLC_BMS_07", 0, profileFile ) );
    putValue( KCAN__MSGDLC_BMS_07_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_BMS_07_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_BMS_07, getProfileInt( "Settings", "KCAN__ALLDEF_BMS_07", 0, profileFile ) );
    putValue( KCAN__STMSG_BMS_07, getProfileInt( "Settings", "KCAN__STMSG_BMS_07", 0, profileFile ) );
    putValue( KCAN__STMSGT_BMS_07, getProfileInt( "Settings", "KCAN__STMSGT_BMS_07", 0, profileFile ) );
    putValue( KCAN__STMSGT_BMS_07_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_BMS_07_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_BMS_07, getProfileInt( "Settings", "KCAN__STMSGSD_BMS_07", 0, profileFile ) );
    putValue( KCAN__STMSGCT_BMS_07, getProfileInt( "Settings", "KCAN__STMSGCT_BMS_07", 0, profileFile ) );
    putValue( KCAN__STMSGCT_BMS_07_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_BMS_07_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_BMS_07, getProfileInt( "Settings", "KCAN__STMSG_PO_BMS_07", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_BMS_07, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_BMS_07", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_BMS_07, getProfileInt( "Settings", "KCAN__MSG_SendNow_BMS_07", 0, profileFile ) );
    putValue( KCAN__MSGID_Bremse_EV_02, getProfileInt( "Settings", "KCAN__MSGID_Bremse_EV_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Bremse_EV_02, getProfileInt( "Settings", "KCAN__MSGDLC_Bremse_EV_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Bremse_EV_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Bremse_EV_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Bremse_EV_02, getProfileInt( "Settings", "KCAN__ALLDEF_Bremse_EV_02", 0, profileFile ) );
    putValue( KCAN__STMSG_Bremse_EV_02, getProfileInt( "Settings", "KCAN__STMSG_Bremse_EV_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_Bremse_EV_02, getProfileInt( "Settings", "KCAN__STMSGT_Bremse_EV_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_Bremse_EV_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Bremse_EV_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Bremse_EV_02, getProfileInt( "Settings", "KCAN__STMSGSD_Bremse_EV_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Bremse_EV_02, getProfileInt( "Settings", "KCAN__STMSGCT_Bremse_EV_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Bremse_EV_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Bremse_EV_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Bremse_EV_02, getProfileInt( "Settings", "KCAN__STMSG_PO_Bremse_EV_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Bremse_EV_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Bremse_EV_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Bremse_EV_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_Bremse_EV_02", 0, profileFile ) );
    putValue( KCAN__MSGID_Charisma_03, getProfileInt( "Settings", "KCAN__MSGID_Charisma_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Charisma_03, getProfileInt( "Settings", "KCAN__MSGDLC_Charisma_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Charisma_03_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Charisma_03_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Charisma_03, getProfileInt( "Settings", "KCAN__ALLDEF_Charisma_03", 0, profileFile ) );
    putValue( KCAN__STMSG_Charisma_03, getProfileInt( "Settings", "KCAN__STMSG_Charisma_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_Charisma_03, getProfileInt( "Settings", "KCAN__STMSGT_Charisma_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_Charisma_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Charisma_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Charisma_03, getProfileInt( "Settings", "KCAN__STMSGSD_Charisma_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Charisma_03, getProfileInt( "Settings", "KCAN__STMSGCT_Charisma_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Charisma_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Charisma_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Charisma_03, getProfileInt( "Settings", "KCAN__STMSG_PO_Charisma_03", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Charisma_03, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Charisma_03", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Charisma_03, getProfileInt( "Settings", "KCAN__MSG_SendNow_Charisma_03", 0, profileFile ) );
    putValue( KCAN__MSGID_Daempfer_01, getProfileInt( "Settings", "KCAN__MSGID_Daempfer_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Daempfer_01, getProfileInt( "Settings", "KCAN__MSGDLC_Daempfer_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Daempfer_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Daempfer_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Daempfer_01, getProfileInt( "Settings", "KCAN__ALLDEF_Daempfer_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Daempfer_01, getProfileInt( "Settings", "KCAN__STMSG_Daempfer_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Daempfer_01, getProfileInt( "Settings", "KCAN__STMSGT_Daempfer_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Daempfer_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Daempfer_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Daempfer_01, getProfileInt( "Settings", "KCAN__STMSGSD_Daempfer_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Daempfer_01, getProfileInt( "Settings", "KCAN__STMSGCT_Daempfer_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Daempfer_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Daempfer_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Daempfer_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Daempfer_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Daempfer_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Daempfer_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Daempfer_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Daempfer_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Daempfer_05, getProfileInt( "Settings", "KCAN__MSGID_Daempfer_05", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Daempfer_05, getProfileInt( "Settings", "KCAN__MSGDLC_Daempfer_05", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Daempfer_05_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Daempfer_05_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Daempfer_05, getProfileInt( "Settings", "KCAN__ALLDEF_Daempfer_05", 0, profileFile ) );
    putValue( KCAN__STMSG_Daempfer_05, getProfileInt( "Settings", "KCAN__STMSG_Daempfer_05", 0, profileFile ) );
    putValue( KCAN__STMSGT_Daempfer_05, getProfileInt( "Settings", "KCAN__STMSGT_Daempfer_05", 0, profileFile ) );
    putValue( KCAN__STMSGT_Daempfer_05_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Daempfer_05_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Daempfer_05, getProfileInt( "Settings", "KCAN__STMSGSD_Daempfer_05", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Daempfer_05, getProfileInt( "Settings", "KCAN__STMSGCT_Daempfer_05", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Daempfer_05_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Daempfer_05_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Daempfer_05, getProfileInt( "Settings", "KCAN__STMSG_PO_Daempfer_05", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Daempfer_05, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Daempfer_05", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Daempfer_05, getProfileInt( "Settings", "KCAN__MSG_SendNow_Daempfer_05", 0, profileFile ) );
    putValue( KCAN__MSGID_DCDC_02, getProfileInt( "Settings", "KCAN__MSGID_DCDC_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DCDC_02, getProfileInt( "Settings", "KCAN__MSGDLC_DCDC_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DCDC_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_DCDC_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_DCDC_02, getProfileInt( "Settings", "KCAN__ALLDEF_DCDC_02", 0, profileFile ) );
    putValue( KCAN__STMSG_DCDC_02, getProfileInt( "Settings", "KCAN__STMSG_DCDC_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_DCDC_02, getProfileInt( "Settings", "KCAN__STMSGT_DCDC_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_DCDC_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_DCDC_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_DCDC_02, getProfileInt( "Settings", "KCAN__STMSGSD_DCDC_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DCDC_02, getProfileInt( "Settings", "KCAN__STMSGCT_DCDC_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DCDC_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DCDC_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_DCDC_02, getProfileInt( "Settings", "KCAN__STMSG_PO_DCDC_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_DCDC_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_DCDC_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_DCDC_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_DCDC_02", 0, profileFile ) );
    putValue( KCAN__MSGID_DEV_SmaLi_Tx_01, getProfileInt( "Settings", "KCAN__MSGID_DEV_SmaLi_Tx_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DEV_SmaLi_Tx_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_DEV_SmaLi_Tx_01_CTRL", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DEV_SmaLi_Tx_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_DEV_SmaLi_Tx_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_DEV_SmaLi_Tx_01, getProfileInt( "Settings", "KCAN__ALLDEF_DEV_SmaLi_Tx_01", 0, profileFile ) );
    putValue( KCAN__STMSG_DEV_SmaLi_Tx_01, getProfileInt( "Settings", "KCAN__STMSG_DEV_SmaLi_Tx_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_DEV_SmaLi_Tx_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_DEV_SmaLi_Tx_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGT_DEV_SmaLi_Tx_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_DEV_SmaLi_Tx_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_DEV_SmaLi_Tx_01, getProfileInt( "Settings", "KCAN__STMSGSD_DEV_SmaLi_Tx_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DEV_SmaLi_Tx_01, getProfileInt( "Settings", "KCAN__STMSGCT_DEV_SmaLi_Tx_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DEV_SmaLi_Tx_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DEV_SmaLi_Tx_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_DEV_SmaLi_Tx_01, getProfileInt( "Settings", "KCAN__STMSG_PO_DEV_SmaLi_Tx_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_DEV_SmaLi_Tx_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_DEV_SmaLi_Tx_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_DEV_SmaLi_Tx_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_DEV_SmaLi_Tx_01", 0, profileFile ) );
    putValue( KCAN__MSGID_DEV_ZR_Produktion_1_Rx_1D, getProfileInt( "Settings", "KCAN__MSGID_DEV_ZR_Produktion_1_Rx_1D", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DEV_ZR_Produktion_1_Rx_1D, getProfileInt( "Settings", "KCAN__MSGDLC_DEV_ZR_Produktion_1_Rx_1D", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DEV_ZR_Produktion_1_Rx_1D_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_DEV_ZR_Produktion_1_Rx_1D_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_DEV_ZR_Produktion_1_Rx_1D, getProfileInt( "Settings", "KCAN__ALLDEF_DEV_ZR_Produktion_1_Rx_1D", 0, profileFile ) );
    putValue( KCAN__STMSG_DEV_ZR_Produktion_1_Rx_1D, getProfileInt( "Settings", "KCAN__STMSG_DEV_ZR_Produktion_1_Rx_1D", 0, profileFile ) );
    putValue( KCAN__STMSGT_DEV_ZR_Produktion_1_Rx_1D, getProfileInt( "Settings", "KCAN__STMSGT_DEV_ZR_Produktion_1_Rx_1D", 0, profileFile ) );
    putValue( KCAN__STMSGT_DEV_ZR_Produktion_1_Rx_1D_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_DEV_ZR_Produktion_1_Rx_1D_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_DEV_ZR_Produktion_1_Rx_1D, getProfileInt( "Settings", "KCAN__STMSGSD_DEV_ZR_Produktion_1_Rx_1D", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DEV_ZR_Produktion_1_Rx_1D, getProfileInt( "Settings", "KCAN__STMSGCT_DEV_ZR_Produktion_1_Rx_1D", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DEV_ZR_Produktion_1_Rx_1D_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DEV_ZR_Produktion_1_Rx_1D_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_DEV_ZR_Produktion_1_Rx_1D, getProfileInt( "Settings", "KCAN__STMSG_PO_DEV_ZR_Produktion_1_Rx_1D", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_DEV_ZR_Produktion_1_Rx_1D, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_DEV_ZR_Produktion_1_Rx_1D", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_DEV_ZR_Produktion_1_Rx_1D, getProfileInt( "Settings", "KCAN__MSG_SendNow_DEV_ZR_Produktion_1_Rx_1D", 0, profileFile ) );
    putValue( KCAN__MSGID_DEV_ZR_Produktion_1_Tx_1C, getProfileInt( "Settings", "KCAN__MSGID_DEV_ZR_Produktion_1_Tx_1C", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DEV_ZR_Produktion_1_Tx_1C, getProfileInt( "Settings", "KCAN__MSGDLC_DEV_ZR_Produktion_1_Tx_1C", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DEV_ZR_Produktion_1_Tx_1C_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_DEV_ZR_Produktion_1_Tx_1C_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_DEV_ZR_Produktion_1_Tx_1C, getProfileInt( "Settings", "KCAN__ALLDEF_DEV_ZR_Produktion_1_Tx_1C", 0, profileFile ) );
    putValue( KCAN__STMSG_DEV_ZR_Produktion_1_Tx_1C, getProfileInt( "Settings", "KCAN__STMSG_DEV_ZR_Produktion_1_Tx_1C", 0, profileFile ) );
    putValue( KCAN__STMSGT_DEV_ZR_Produktion_1_Tx_1C, getProfileInt( "Settings", "KCAN__STMSGT_DEV_ZR_Produktion_1_Tx_1C", 0, profileFile ) );
    putValue( KCAN__STMSGT_DEV_ZR_Produktion_1_Tx_1C_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_DEV_ZR_Produktion_1_Tx_1C_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_DEV_ZR_Produktion_1_Tx_1C, getProfileInt( "Settings", "KCAN__STMSGSD_DEV_ZR_Produktion_1_Tx_1C", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DEV_ZR_Produktion_1_Tx_1C, getProfileInt( "Settings", "KCAN__STMSGCT_DEV_ZR_Produktion_1_Tx_1C", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DEV_ZR_Produktion_1_Tx_1C_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DEV_ZR_Produktion_1_Tx_1C_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_DEV_ZR_Produktion_1_Tx_1C, getProfileInt( "Settings", "KCAN__STMSG_PO_DEV_ZR_Produktion_1_Tx_1C", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_DEV_ZR_Produktion_1_Tx_1C, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_DEV_ZR_Produktion_1_Tx_1C", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_DEV_ZR_Produktion_1_Tx_1C, getProfileInt( "Settings", "KCAN__MSG_SendNow_DEV_ZR_Produktion_1_Tx_1C", 0, profileFile ) );
    putValue( KCAN__MSGID_DEV_ZR_Req_0D, getProfileInt( "Settings", "KCAN__MSGID_DEV_ZR_Req_0D", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DEV_ZR_Req_0D, getProfileInt( "Settings", "KCAN__MSGDLC_DEV_ZR_Req_0D", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DEV_ZR_Req_0D_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_DEV_ZR_Req_0D_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_DEV_ZR_Req_0D, getProfileInt( "Settings", "KCAN__ALLDEF_DEV_ZR_Req_0D", 0, profileFile ) );
    putValue( KCAN__STMSG_DEV_ZR_Req_0D, getProfileInt( "Settings", "KCAN__STMSG_DEV_ZR_Req_0D", 0, profileFile ) );
    putValue( KCAN__STMSGT_DEV_ZR_Req_0D, getProfileInt( "Settings", "KCAN__STMSGT_DEV_ZR_Req_0D", 0, profileFile ) );
    putValue( KCAN__STMSGT_DEV_ZR_Req_0D_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_DEV_ZR_Req_0D_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_DEV_ZR_Req_0D, getProfileInt( "Settings", "KCAN__STMSGSD_DEV_ZR_Req_0D", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DEV_ZR_Req_0D, getProfileInt( "Settings", "KCAN__STMSGCT_DEV_ZR_Req_0D", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DEV_ZR_Req_0D_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DEV_ZR_Req_0D_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_DEV_ZR_Req_0D, getProfileInt( "Settings", "KCAN__STMSG_PO_DEV_ZR_Req_0D", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_DEV_ZR_Req_0D, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_DEV_ZR_Req_0D", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_DEV_ZR_Req_0D, getProfileInt( "Settings", "KCAN__MSG_SendNow_DEV_ZR_Req_0D", 0, profileFile ) );
    putValue( KCAN__MSGID_DEV_ZR_Resp_00, getProfileInt( "Settings", "KCAN__MSGID_DEV_ZR_Resp_00", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DEV_ZR_Resp_00, getProfileInt( "Settings", "KCAN__MSGDLC_DEV_ZR_Resp_00", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DEV_ZR_Resp_00_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_DEV_ZR_Resp_00_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_DEV_ZR_Resp_00, getProfileInt( "Settings", "KCAN__ALLDEF_DEV_ZR_Resp_00", 0, profileFile ) );
    putValue( KCAN__STMSG_DEV_ZR_Resp_00, getProfileInt( "Settings", "KCAN__STMSG_DEV_ZR_Resp_00", 0, profileFile ) );
    putValue( KCAN__STMSGT_DEV_ZR_Resp_00, getProfileInt( "Settings", "KCAN__STMSGT_DEV_ZR_Resp_00", 0, profileFile ) );
    putValue( KCAN__STMSGT_DEV_ZR_Resp_00_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_DEV_ZR_Resp_00_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_DEV_ZR_Resp_00, getProfileInt( "Settings", "KCAN__STMSGSD_DEV_ZR_Resp_00", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DEV_ZR_Resp_00_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DEV_ZR_Resp_00_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DEV_ZR_Resp_00_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DEV_ZR_Resp_00_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_DEV_ZR_Resp_00, getProfileInt( "Settings", "KCAN__STMSG_PO_DEV_ZR_Resp_00", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_DEV_ZR_Resp_00, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_DEV_ZR_Resp_00", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_DEV_ZR_Resp_00, getProfileInt( "Settings", "KCAN__MSG_SendNow_DEV_ZR_Resp_00", 0, profileFile ) );
    putValue( KCAN__MSGID_DEV_ZR_SmaLi_01_Tx, getProfileInt( "Settings", "KCAN__MSGID_DEV_ZR_SmaLi_01_Tx", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DEV_ZR_SmaLi_01_Tx, getProfileInt( "Settings", "KCAN__MSGDLC_DEV_ZR_SmaLi_01_Tx", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DEV_ZR_SmaLi_01_Tx_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_DEV_ZR_SmaLi_01_Tx_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_DEV_ZR_SmaLi_01_Tx, getProfileInt( "Settings", "KCAN__ALLDEF_DEV_ZR_SmaLi_01_Tx", 0, profileFile ) );
    putValue( KCAN__STMSG_DEV_ZR_SmaLi_01_Tx, getProfileInt( "Settings", "KCAN__STMSG_DEV_ZR_SmaLi_01_Tx", 0, profileFile ) );
    putValue( KCAN__STMSGT_DEV_ZR_SmaLi_01_Tx, getProfileInt( "Settings", "KCAN__STMSGT_DEV_ZR_SmaLi_01_Tx", 0, profileFile ) );
    putValue( KCAN__STMSGT_DEV_ZR_SmaLi_01_Tx_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_DEV_ZR_SmaLi_01_Tx_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_DEV_ZR_SmaLi_01_Tx, getProfileInt( "Settings", "KCAN__STMSGSD_DEV_ZR_SmaLi_01_Tx", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DEV_ZR_SmaLi_01_Tx, getProfileInt( "Settings", "KCAN__STMSGCT_DEV_ZR_SmaLi_01_Tx", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DEV_ZR_SmaLi_01_Tx_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DEV_ZR_SmaLi_01_Tx_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_DEV_ZR_SmaLi_01_Tx, getProfileInt( "Settings", "KCAN__STMSG_PO_DEV_ZR_SmaLi_01_Tx", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_DEV_ZR_SmaLi_01_Tx, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_DEV_ZR_SmaLi_01_Tx", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_DEV_ZR_SmaLi_01_Tx, getProfileInt( "Settings", "KCAN__MSG_SendNow_DEV_ZR_SmaLi_01_Tx", 0, profileFile ) );
    putValue( KCAN__MSGID_DEV_ZR_Tx_14, getProfileInt( "Settings", "KCAN__MSGID_DEV_ZR_Tx_14", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DEV_ZR_Tx_14, getProfileInt( "Settings", "KCAN__MSGDLC_DEV_ZR_Tx_14", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DEV_ZR_Tx_14_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_DEV_ZR_Tx_14_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_DEV_ZR_Tx_14, getProfileInt( "Settings", "KCAN__ALLDEF_DEV_ZR_Tx_14", 0, profileFile ) );
    putValue( KCAN__STMSG_DEV_ZR_Tx_14, getProfileInt( "Settings", "KCAN__STMSG_DEV_ZR_Tx_14", 0, profileFile ) );
    putValue( KCAN__STMSGT_DEV_ZR_Tx_14, getProfileInt( "Settings", "KCAN__STMSGT_DEV_ZR_Tx_14", 0, profileFile ) );
    putValue( KCAN__STMSGT_DEV_ZR_Tx_14_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_DEV_ZR_Tx_14_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_DEV_ZR_Tx_14, getProfileInt( "Settings", "KCAN__STMSGSD_DEV_ZR_Tx_14", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DEV_ZR_Tx_14, getProfileInt( "Settings", "KCAN__STMSGCT_DEV_ZR_Tx_14", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DEV_ZR_Tx_14_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DEV_ZR_Tx_14_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_DEV_ZR_Tx_14, getProfileInt( "Settings", "KCAN__STMSG_PO_DEV_ZR_Tx_14", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_DEV_ZR_Tx_14, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_DEV_ZR_Tx_14", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_DEV_ZR_Tx_14, getProfileInt( "Settings", "KCAN__MSG_SendNow_DEV_ZR_Tx_14", 0, profileFile ) );
    putValue( KCAN__MSGID_DEV_ZR_Tx_15, getProfileInt( "Settings", "KCAN__MSGID_DEV_ZR_Tx_15", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DEV_ZR_Tx_15, getProfileInt( "Settings", "KCAN__MSGDLC_DEV_ZR_Tx_15", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DEV_ZR_Tx_15_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_DEV_ZR_Tx_15_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_DEV_ZR_Tx_15, getProfileInt( "Settings", "KCAN__ALLDEF_DEV_ZR_Tx_15", 0, profileFile ) );
    putValue( KCAN__STMSG_DEV_ZR_Tx_15, getProfileInt( "Settings", "KCAN__STMSG_DEV_ZR_Tx_15", 0, profileFile ) );
    putValue( KCAN__STMSGT_DEV_ZR_Tx_15, getProfileInt( "Settings", "KCAN__STMSGT_DEV_ZR_Tx_15", 0, profileFile ) );
    putValue( KCAN__STMSGT_DEV_ZR_Tx_15_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_DEV_ZR_Tx_15_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_DEV_ZR_Tx_15, getProfileInt( "Settings", "KCAN__STMSGSD_DEV_ZR_Tx_15", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DEV_ZR_Tx_15, getProfileInt( "Settings", "KCAN__STMSGCT_DEV_ZR_Tx_15", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DEV_ZR_Tx_15_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DEV_ZR_Tx_15_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_DEV_ZR_Tx_15, getProfileInt( "Settings", "KCAN__STMSG_PO_DEV_ZR_Tx_15", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_DEV_ZR_Tx_15, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_DEV_ZR_Tx_15", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_DEV_ZR_Tx_15, getProfileInt( "Settings", "KCAN__MSG_SendNow_DEV_ZR_Tx_15", 0, profileFile ) );
    putValue( KCAN__MSGID_DIA_ABT_1_Req, getProfileInt( "Settings", "KCAN__MSGID_DIA_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DIA_ABT_1_Req, getProfileInt( "Settings", "KCAN__MSGDLC_DIA_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DIA_ABT_1_Req_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_DIA_ABT_1_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_DIA_ABT_1_Req, getProfileInt( "Settings", "KCAN__ALLDEF_DIA_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__STMSG_DIA_ABT_1_Req, getProfileInt( "Settings", "KCAN__STMSG_DIA_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_DIA_ABT_1_Req, getProfileInt( "Settings", "KCAN__STMSGT_DIA_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_DIA_ABT_1_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_DIA_ABT_1_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_DIA_ABT_1_Req, getProfileInt( "Settings", "KCAN__STMSGSD_DIA_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DIA_ABT_1_Req, getProfileInt( "Settings", "KCAN__STMSGCT_DIA_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DIA_ABT_1_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DIA_ABT_1_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_DIA_ABT_1_Req, getProfileInt( "Settings", "KCAN__STMSG_PO_DIA_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_DIA_ABT_1_Req, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_DIA_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_DIA_ABT_1_Req, getProfileInt( "Settings", "KCAN__MSG_SendNow_DIA_ABT_1_Req", 0, profileFile ) );
    putValue( KCAN__MSGID_DIA_ABT_1_Resp, getProfileInt( "Settings", "KCAN__MSGID_DIA_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DIA_ABT_1_Resp, getProfileInt( "Settings", "KCAN__MSGDLC_DIA_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DIA_ABT_1_Resp_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_DIA_ABT_1_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_DIA_ABT_1_Resp, getProfileInt( "Settings", "KCAN__ALLDEF_DIA_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSG_DIA_ABT_1_Resp, getProfileInt( "Settings", "KCAN__STMSG_DIA_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_DIA_ABT_1_Resp, getProfileInt( "Settings", "KCAN__STMSGT_DIA_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_DIA_ABT_1_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_DIA_ABT_1_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_DIA_ABT_1_Resp, getProfileInt( "Settings", "KCAN__STMSGSD_DIA_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DIA_ABT_1_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DIA_ABT_1_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DIA_ABT_1_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DIA_ABT_1_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_DIA_ABT_1_Resp, getProfileInt( "Settings", "KCAN__STMSG_PO_DIA_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_DIA_ABT_1_Resp, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_DIA_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_DIA_ABT_1_Resp, getProfileInt( "Settings", "KCAN__MSG_SendNow_DIA_ABT_1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGID_Diagnose_01, getProfileInt( "Settings", "KCAN__MSGID_Diagnose_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Diagnose_01, getProfileInt( "Settings", "KCAN__MSGDLC_Diagnose_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Diagnose_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Diagnose_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Diagnose_01, getProfileInt( "Settings", "KCAN__ALLDEF_Diagnose_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Diagnose_01, getProfileInt( "Settings", "KCAN__STMSG_Diagnose_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Diagnose_01, getProfileInt( "Settings", "KCAN__STMSGT_Diagnose_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Diagnose_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Diagnose_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Diagnose_01, getProfileInt( "Settings", "KCAN__STMSGSD_Diagnose_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Diagnose_01, getProfileInt( "Settings", "KCAN__STMSGCT_Diagnose_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Diagnose_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Diagnose_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Diagnose_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Diagnose_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Diagnose_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Diagnose_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Diagnose_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Diagnose_01", 0, profileFile ) );
    putValue( KCAN__MSGID_DiETa_01, getProfileInt( "Settings", "KCAN__MSGID_DiETa_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DiETa_01, getProfileInt( "Settings", "KCAN__MSGDLC_DiETa_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DiETa_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_DiETa_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_DiETa_01, getProfileInt( "Settings", "KCAN__ALLDEF_DiETa_01", 0, profileFile ) );
    putValue( KCAN__STMSG_DiETa_01, getProfileInt( "Settings", "KCAN__STMSG_DiETa_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_DiETa_01, getProfileInt( "Settings", "KCAN__STMSGT_DiETa_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_DiETa_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_DiETa_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_DiETa_01, getProfileInt( "Settings", "KCAN__STMSGSD_DiETa_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DiETa_01, getProfileInt( "Settings", "KCAN__STMSGCT_DiETa_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DiETa_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DiETa_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_DiETa_01, getProfileInt( "Settings", "KCAN__STMSG_PO_DiETa_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_DiETa_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_DiETa_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_DiETa_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_DiETa_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Dimmung_01, getProfileInt( "Settings", "KCAN__MSGID_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Dimmung_01, getProfileInt( "Settings", "KCAN__MSGDLC_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Dimmung_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Dimmung_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Dimmung_01, getProfileInt( "Settings", "KCAN__ALLDEF_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Dimmung_01, getProfileInt( "Settings", "KCAN__STMSG_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Dimmung_01, getProfileInt( "Settings", "KCAN__STMSGT_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Dimmung_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Dimmung_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Dimmung_01, getProfileInt( "Settings", "KCAN__STMSGSD_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Dimmung_01, getProfileInt( "Settings", "KCAN__STMSGCT_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Dimmung_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Dimmung_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Dimmung_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Dimmung_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Dimmung_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Dimmung_01", 0, profileFile ) );
    putValue( KCAN__MSGID_DispKBI_FS_01, getProfileInt( "Settings", "KCAN__MSGID_DispKBI_FS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DispKBI_FS_01, getProfileInt( "Settings", "KCAN__MSGDLC_DispKBI_FS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DispKBI_FS_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_DispKBI_FS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_DispKBI_FS_01, getProfileInt( "Settings", "KCAN__ALLDEF_DispKBI_FS_01", 0, profileFile ) );
    putValue( KCAN__STMSG_DispKBI_FS_01, getProfileInt( "Settings", "KCAN__STMSG_DispKBI_FS_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_DispKBI_FS_01, getProfileInt( "Settings", "KCAN__STMSGT_DispKBI_FS_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_DispKBI_FS_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_DispKBI_FS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_DispKBI_FS_01, getProfileInt( "Settings", "KCAN__STMSGSD_DispKBI_FS_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DispKBI_FS_01, getProfileInt( "Settings", "KCAN__STMSGCT_DispKBI_FS_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DispKBI_FS_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DispKBI_FS_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_DispKBI_FS_01, getProfileInt( "Settings", "KCAN__STMSG_PO_DispKBI_FS_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_DispKBI_FS_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_DispKBI_FS_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_DispKBI_FS_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_DispKBI_FS_01", 0, profileFile ) );
    putValue( KCAN__MSGID_DispKBI_FS_DispPos_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_DispKBI_FS_DispPos_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DispKBI_FS_DispPos_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLC_DispKBI_FS_DispPos_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DispKBI_FS_DispPos_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_DispKBI_FS_DispPos_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_DispKBI_FS_DispPos_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_DispKBI_FS_DispPos_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_DispKBI_FS_DispPos_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_DispKBI_FS_DispPos_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_DispKBI_FS_DispPos_Req_FD, getProfileInt( "Settings", "KCAN__STMSGT_DispKBI_FS_DispPos_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_DispKBI_FS_DispPos_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_DispKBI_FS_DispPos_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_DispKBI_FS_DispPos_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_DispKBI_FS_DispPos_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DispKBI_FS_DispPos_Req_FD, getProfileInt( "Settings", "KCAN__STMSGCT_DispKBI_FS_DispPos_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DispKBI_FS_DispPos_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DispKBI_FS_DispPos_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_DispKBI_FS_DispPos_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_DispKBI_FS_DispPos_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_DispKBI_FS_DispPos_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_DispKBI_FS_DispPos_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_DispKBI_FS_DispPos_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_DispKBI_FS_DispPos_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_DispKBI_FS_DispPos_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_DispKBI_FS_DispPos_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DispKBI_FS_DispPos_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLC_DispKBI_FS_DispPos_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DispKBI_FS_DispPos_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_DispKBI_FS_DispPos_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_DispKBI_FS_DispPos_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_DispKBI_FS_DispPos_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_DispKBI_FS_DispPos_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_DispKBI_FS_DispPos_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_DispKBI_FS_DispPos_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGT_DispKBI_FS_DispPos_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_DispKBI_FS_DispPos_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_DispKBI_FS_DispPos_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_DispKBI_FS_DispPos_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_DispKBI_FS_DispPos_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DispKBI_FS_DispPos_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_DispKBI_FS_DispPos_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DispKBI_FS_DispPos_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DispKBI_FS_DispPos_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_DispKBI_FS_DispPos_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_DispKBI_FS_DispPos_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_DispKBI_FS_DispPos_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_DispKBI_FS_DispPos_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_DispKBI_FS_DispPos_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_DispKBI_FS_DispPos_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_Display_1_03, getProfileInt( "Settings", "KCAN__MSGID_Display_1_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Display_1_03, getProfileInt( "Settings", "KCAN__MSGDLC_Display_1_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Display_1_03_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Display_1_03_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Display_1_03, getProfileInt( "Settings", "KCAN__ALLDEF_Display_1_03", 0, profileFile ) );
    putValue( KCAN__STMSG_Display_1_03, getProfileInt( "Settings", "KCAN__STMSG_Display_1_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_Display_1_03, getProfileInt( "Settings", "KCAN__STMSGT_Display_1_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_Display_1_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Display_1_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Display_1_03, getProfileInt( "Settings", "KCAN__STMSGSD_Display_1_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Display_1_03, getProfileInt( "Settings", "KCAN__STMSGCT_Display_1_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Display_1_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Display_1_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Display_1_03, getProfileInt( "Settings", "KCAN__STMSG_PO_Display_1_03", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Display_1_03, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Display_1_03", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Display_1_03, getProfileInt( "Settings", "KCAN__MSG_SendNow_Display_1_03", 0, profileFile ) );
    putValue( KCAN__MSGID_DispPos_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_DispPos_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DispPos_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLC_DispPos_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DispPos_DispKBI_FS_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_DispPos_DispKBI_FS_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_DispPos_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_DispPos_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_DispPos_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_DispPos_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_DispPos_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSGT_DispPos_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_DispPos_DispKBI_FS_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_DispPos_DispKBI_FS_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_DispPos_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_DispPos_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DispPos_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSGCT_DispPos_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DispPos_DispKBI_FS_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DispPos_DispKBI_FS_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_DispPos_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_DispPos_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_DispPos_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_DispPos_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_DispPos_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_DispPos_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_DispPos_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_DispPos_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DispPos_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLC_DispPos_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_DispPos_DispKBI_FS_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_DispPos_DispKBI_FS_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_DispPos_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_DispPos_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_DispPos_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_DispPos_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_DispPos_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGT_DispPos_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_DispPos_DispKBI_FS_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_DispPos_DispKBI_FS_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_DispPos_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_DispPos_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DispPos_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_DispPos_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_DispPos_DispKBI_FS_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_DispPos_DispKBI_FS_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_DispPos_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_DispPos_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_DispPos_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_DispPos_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_DispPos_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_DispPos_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_EA_02, getProfileInt( "Settings", "KCAN__MSGID_EA_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_EA_02, getProfileInt( "Settings", "KCAN__MSGDLC_EA_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_EA_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_EA_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_EA_02, getProfileInt( "Settings", "KCAN__ALLDEF_EA_02", 0, profileFile ) );
    putValue( KCAN__STMSG_EA_02, getProfileInt( "Settings", "KCAN__STMSG_EA_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_EA_02, getProfileInt( "Settings", "KCAN__STMSGT_EA_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_EA_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_EA_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_EA_02, getProfileInt( "Settings", "KCAN__STMSGSD_EA_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_EA_02, getProfileInt( "Settings", "KCAN__STMSGCT_EA_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_EA_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_EA_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_EA_02, getProfileInt( "Settings", "KCAN__STMSG_PO_EA_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_EA_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_EA_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_EA_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_EA_02", 0, profileFile ) );
    putValue( KCAN__MSGID_ELV_01, getProfileInt( "Settings", "KCAN__MSGID_ELV_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ELV_01, getProfileInt( "Settings", "KCAN__MSGDLC_ELV_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ELV_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ELV_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ELV_01, getProfileInt( "Settings", "KCAN__ALLDEF_ELV_01", 0, profileFile ) );
    putValue( KCAN__STMSG_ELV_01, getProfileInt( "Settings", "KCAN__STMSG_ELV_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_ELV_01, getProfileInt( "Settings", "KCAN__STMSGT_ELV_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_ELV_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ELV_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ELV_01, getProfileInt( "Settings", "KCAN__STMSGSD_ELV_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ELV_01, getProfileInt( "Settings", "KCAN__STMSGCT_ELV_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ELV_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ELV_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ELV_01, getProfileInt( "Settings", "KCAN__STMSG_PO_ELV_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ELV_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ELV_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ELV_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_ELV_01", 0, profileFile ) );
    putValue( KCAN__MSGID_EML_06, getProfileInt( "Settings", "KCAN__MSGID_EML_06", 0, profileFile ) );
    putValue( KCAN__MSGDLC_EML_06, getProfileInt( "Settings", "KCAN__MSGDLC_EML_06", 0, profileFile ) );
    putValue( KCAN__MSGDLC_EML_06_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_EML_06_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_EML_06, getProfileInt( "Settings", "KCAN__ALLDEF_EML_06", 0, profileFile ) );
    putValue( KCAN__STMSG_EML_06, getProfileInt( "Settings", "KCAN__STMSG_EML_06", 0, profileFile ) );
    putValue( KCAN__STMSGT_EML_06, getProfileInt( "Settings", "KCAN__STMSGT_EML_06", 0, profileFile ) );
    putValue( KCAN__STMSGT_EML_06_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_EML_06_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_EML_06, getProfileInt( "Settings", "KCAN__STMSGSD_EML_06", 0, profileFile ) );
    putValue( KCAN__STMSGCT_EML_06, getProfileInt( "Settings", "KCAN__STMSGCT_EML_06", 0, profileFile ) );
    putValue( KCAN__STMSGCT_EML_06_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_EML_06_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_EML_06, getProfileInt( "Settings", "KCAN__STMSG_PO_EML_06", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_EML_06, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_EML_06", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_EML_06, getProfileInt( "Settings", "KCAN__MSG_SendNow_EML_06", 0, profileFile ) );
    putValue( KCAN__MSGID_EML_07, getProfileInt( "Settings", "KCAN__MSGID_EML_07", 0, profileFile ) );
    putValue( KCAN__MSGDLC_EML_07, getProfileInt( "Settings", "KCAN__MSGDLC_EML_07", 0, profileFile ) );
    putValue( KCAN__MSGDLC_EML_07_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_EML_07_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_EML_07, getProfileInt( "Settings", "KCAN__ALLDEF_EML_07", 0, profileFile ) );
    putValue( KCAN__STMSG_EML_07, getProfileInt( "Settings", "KCAN__STMSG_EML_07", 0, profileFile ) );
    putValue( KCAN__STMSGT_EML_07, getProfileInt( "Settings", "KCAN__STMSGT_EML_07", 0, profileFile ) );
    putValue( KCAN__STMSGT_EML_07_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_EML_07_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_EML_07, getProfileInt( "Settings", "KCAN__STMSGSD_EML_07", 0, profileFile ) );
    putValue( KCAN__STMSGCT_EML_07, getProfileInt( "Settings", "KCAN__STMSGCT_EML_07", 0, profileFile ) );
    putValue( KCAN__STMSGCT_EML_07_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_EML_07_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_EML_07, getProfileInt( "Settings", "KCAN__STMSG_PO_EML_07", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_EML_07, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_EML_07", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_EML_07, getProfileInt( "Settings", "KCAN__MSG_SendNow_EML_07", 0, profileFile ) );
    putValue( KCAN__MSGID_Entfernungen_01, getProfileInt( "Settings", "KCAN__MSGID_Entfernungen_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Entfernungen_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Entfernungen_01_CTRL", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Entfernungen_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Entfernungen_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Entfernungen_01, getProfileInt( "Settings", "KCAN__ALLDEF_Entfernungen_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Entfernungen_01, getProfileInt( "Settings", "KCAN__STMSG_Entfernungen_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Entfernungen_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Entfernungen_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGT_Entfernungen_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Entfernungen_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Entfernungen_01, getProfileInt( "Settings", "KCAN__STMSGSD_Entfernungen_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Entfernungen_01, getProfileInt( "Settings", "KCAN__STMSGCT_Entfernungen_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Entfernungen_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Entfernungen_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Entfernungen_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Entfernungen_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Entfernungen_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Entfernungen_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Entfernungen_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Entfernungen_01", 0, profileFile ) );
    putValue( KCAN__MSGID_EPB_03, getProfileInt( "Settings", "KCAN__MSGID_EPB_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_EPB_03, getProfileInt( "Settings", "KCAN__MSGDLC_EPB_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_EPB_03_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_EPB_03_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_EPB_03, getProfileInt( "Settings", "KCAN__ALLDEF_EPB_03", 0, profileFile ) );
    putValue( KCAN__STMSG_EPB_03, getProfileInt( "Settings", "KCAN__STMSG_EPB_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_EPB_03, getProfileInt( "Settings", "KCAN__STMSGT_EPB_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_EPB_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_EPB_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_EPB_03, getProfileInt( "Settings", "KCAN__STMSGSD_EPB_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_EPB_03, getProfileInt( "Settings", "KCAN__STMSGCT_EPB_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_EPB_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_EPB_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_EPB_03, getProfileInt( "Settings", "KCAN__STMSG_PO_EPB_03", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_EPB_03, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_EPB_03", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_EPB_03, getProfileInt( "Settings", "KCAN__MSG_SendNow_EPB_03", 0, profileFile ) );
    putValue( KCAN__MSGID_ESC_50, getProfileInt( "Settings", "KCAN__MSGID_ESC_50", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ESC_50, getProfileInt( "Settings", "KCAN__MSGDLC_ESC_50", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ESC_50_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ESC_50_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ESC_50, getProfileInt( "Settings", "KCAN__ALLDEF_ESC_50", 0, profileFile ) );
    putValue( KCAN__STMSG_ESC_50, getProfileInt( "Settings", "KCAN__STMSG_ESC_50", 0, profileFile ) );
    putValue( KCAN__STMSGT_ESC_50, getProfileInt( "Settings", "KCAN__STMSGT_ESC_50", 0, profileFile ) );
    putValue( KCAN__STMSGT_ESC_50_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ESC_50_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ESC_50, getProfileInt( "Settings", "KCAN__STMSGSD_ESC_50", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ESC_50, getProfileInt( "Settings", "KCAN__STMSGCT_ESC_50", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ESC_50_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ESC_50_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ESC_50, getProfileInt( "Settings", "KCAN__STMSG_PO_ESC_50", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ESC_50, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ESC_50", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ESC_50, getProfileInt( "Settings", "KCAN__MSG_SendNow_ESC_50", 0, profileFile ) );
    putValue( KCAN__MSGID_ESC_51, getProfileInt( "Settings", "KCAN__MSGID_ESC_51", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ESC_51, getProfileInt( "Settings", "KCAN__MSGDLC_ESC_51", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ESC_51_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ESC_51_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ESC_51, getProfileInt( "Settings", "KCAN__ALLDEF_ESC_51", 0, profileFile ) );
    putValue( KCAN__STMSG_ESC_51, getProfileInt( "Settings", "KCAN__STMSG_ESC_51", 0, profileFile ) );
    putValue( KCAN__STMSGT_ESC_51, getProfileInt( "Settings", "KCAN__STMSGT_ESC_51", 0, profileFile ) );
    putValue( KCAN__STMSGT_ESC_51_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ESC_51_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ESC_51, getProfileInt( "Settings", "KCAN__STMSGSD_ESC_51", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ESC_51, getProfileInt( "Settings", "KCAN__STMSGCT_ESC_51", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ESC_51_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ESC_51_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ESC_51, getProfileInt( "Settings", "KCAN__STMSG_PO_ESC_51", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ESC_51, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ESC_51", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ESC_51, getProfileInt( "Settings", "KCAN__MSG_SendNow_ESC_51", 0, profileFile ) );
    putValue( KCAN__MSGID_ESP_10, getProfileInt( "Settings", "KCAN__MSGID_ESP_10", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ESP_10, getProfileInt( "Settings", "KCAN__MSGDLC_ESP_10", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ESP_10_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ESP_10_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ESP_10, getProfileInt( "Settings", "KCAN__ALLDEF_ESP_10", 0, profileFile ) );
    putValue( KCAN__STMSG_ESP_10, getProfileInt( "Settings", "KCAN__STMSG_ESP_10", 0, profileFile ) );
    putValue( KCAN__STMSGT_ESP_10, getProfileInt( "Settings", "KCAN__STMSGT_ESP_10", 0, profileFile ) );
    putValue( KCAN__STMSGT_ESP_10_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ESP_10_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ESP_10, getProfileInt( "Settings", "KCAN__STMSGSD_ESP_10", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ESP_10, getProfileInt( "Settings", "KCAN__STMSGCT_ESP_10", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ESP_10_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ESP_10_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ESP_10, getProfileInt( "Settings", "KCAN__STMSG_PO_ESP_10", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ESP_10, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ESP_10", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ESP_10, getProfileInt( "Settings", "KCAN__MSG_SendNow_ESP_10", 0, profileFile ) );
    putValue( KCAN__MSGID_ESP_20, getProfileInt( "Settings", "KCAN__MSGID_ESP_20", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ESP_20, getProfileInt( "Settings", "KCAN__MSGDLC_ESP_20", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ESP_20_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ESP_20_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ESP_20, getProfileInt( "Settings", "KCAN__ALLDEF_ESP_20", 0, profileFile ) );
    putValue( KCAN__STMSG_ESP_20, getProfileInt( "Settings", "KCAN__STMSG_ESP_20", 0, profileFile ) );
    putValue( KCAN__STMSGT_ESP_20, getProfileInt( "Settings", "KCAN__STMSGT_ESP_20", 0, profileFile ) );
    putValue( KCAN__STMSGT_ESP_20_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ESP_20_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ESP_20, getProfileInt( "Settings", "KCAN__STMSGSD_ESP_20", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ESP_20, getProfileInt( "Settings", "KCAN__STMSGCT_ESP_20", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ESP_20_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ESP_20_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ESP_20, getProfileInt( "Settings", "KCAN__STMSG_PO_ESP_20", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ESP_20, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ESP_20", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ESP_20, getProfileInt( "Settings", "KCAN__MSG_SendNow_ESP_20", 0, profileFile ) );
    putValue( KCAN__MSGID_ESP_21, getProfileInt( "Settings", "KCAN__MSGID_ESP_21", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ESP_21, getProfileInt( "Settings", "KCAN__MSGDLC_ESP_21", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ESP_21_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ESP_21_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ESP_21, getProfileInt( "Settings", "KCAN__ALLDEF_ESP_21", 0, profileFile ) );
    putValue( KCAN__STMSG_ESP_21, getProfileInt( "Settings", "KCAN__STMSG_ESP_21", 0, profileFile ) );
    putValue( KCAN__STMSGT_ESP_21, getProfileInt( "Settings", "KCAN__STMSGT_ESP_21", 0, profileFile ) );
    putValue( KCAN__STMSGT_ESP_21_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ESP_21_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ESP_21, getProfileInt( "Settings", "KCAN__STMSGSD_ESP_21", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ESP_21, getProfileInt( "Settings", "KCAN__STMSGCT_ESP_21", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ESP_21_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ESP_21_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ESP_21, getProfileInt( "Settings", "KCAN__STMSG_PO_ESP_21", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ESP_21, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ESP_21", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ESP_21, getProfileInt( "Settings", "KCAN__MSG_SendNow_ESP_21", 0, profileFile ) );
    putValue( KCAN__MSGID_ESP_24, getProfileInt( "Settings", "KCAN__MSGID_ESP_24", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ESP_24, getProfileInt( "Settings", "KCAN__MSGDLC_ESP_24", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ESP_24_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ESP_24_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ESP_24, getProfileInt( "Settings", "KCAN__ALLDEF_ESP_24", 0, profileFile ) );
    putValue( KCAN__STMSG_ESP_24, getProfileInt( "Settings", "KCAN__STMSG_ESP_24", 0, profileFile ) );
    putValue( KCAN__STMSGT_ESP_24, getProfileInt( "Settings", "KCAN__STMSGT_ESP_24", 0, profileFile ) );
    putValue( KCAN__STMSGT_ESP_24_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ESP_24_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ESP_24, getProfileInt( "Settings", "KCAN__STMSGSD_ESP_24", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ESP_24, getProfileInt( "Settings", "KCAN__STMSGCT_ESP_24", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ESP_24_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ESP_24_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ESP_24, getProfileInt( "Settings", "KCAN__STMSG_PO_ESP_24", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ESP_24, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ESP_24", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ESP_24, getProfileInt( "Settings", "KCAN__MSG_SendNow_ESP_24", 0, profileFile ) );
    putValue( KCAN__MSGID_ESP_30, getProfileInt( "Settings", "KCAN__MSGID_ESP_30", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ESP_30, getProfileInt( "Settings", "KCAN__MSGDLC_ESP_30", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ESP_30_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ESP_30_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ESP_30, getProfileInt( "Settings", "KCAN__ALLDEF_ESP_30", 0, profileFile ) );
    putValue( KCAN__STMSG_ESP_30, getProfileInt( "Settings", "KCAN__STMSG_ESP_30", 0, profileFile ) );
    putValue( KCAN__STMSGT_ESP_30, getProfileInt( "Settings", "KCAN__STMSGT_ESP_30", 0, profileFile ) );
    putValue( KCAN__STMSGT_ESP_30_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ESP_30_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ESP_30, getProfileInt( "Settings", "KCAN__STMSGSD_ESP_30", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ESP_30, getProfileInt( "Settings", "KCAN__STMSGCT_ESP_30", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ESP_30_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ESP_30_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ESP_30, getProfileInt( "Settings", "KCAN__STMSG_PO_ESP_30", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ESP_30, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ESP_30", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ESP_30, getProfileInt( "Settings", "KCAN__MSG_SendNow_ESP_30", 0, profileFile ) );
    putValue( KCAN__MSGID_FAS_Anzeigen_01, getProfileInt( "Settings", "KCAN__MSGID_FAS_Anzeigen_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_FAS_Anzeigen_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_FAS_Anzeigen_01_CTRL", 0, profileFile ) );
    putValue( KCAN__MSGDLC_FAS_Anzeigen_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_FAS_Anzeigen_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_FAS_Anzeigen_01, getProfileInt( "Settings", "KCAN__ALLDEF_FAS_Anzeigen_01", 0, profileFile ) );
    putValue( KCAN__STMSG_FAS_Anzeigen_01, getProfileInt( "Settings", "KCAN__STMSG_FAS_Anzeigen_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_FAS_Anzeigen_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_FAS_Anzeigen_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGT_FAS_Anzeigen_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_FAS_Anzeigen_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_FAS_Anzeigen_01, getProfileInt( "Settings", "KCAN__STMSGSD_FAS_Anzeigen_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_FAS_Anzeigen_01, getProfileInt( "Settings", "KCAN__STMSGCT_FAS_Anzeigen_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_FAS_Anzeigen_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_FAS_Anzeigen_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_FAS_Anzeigen_01, getProfileInt( "Settings", "KCAN__STMSG_PO_FAS_Anzeigen_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_FAS_Anzeigen_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_FAS_Anzeigen_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_FAS_Anzeigen_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_FAS_Anzeigen_01", 0, profileFile ) );
    putValue( KCAN__MSGID_FoD_01, getProfileInt( "Settings", "KCAN__MSGID_FoD_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_FoD_01, getProfileInt( "Settings", "KCAN__MSGDLC_FoD_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_FoD_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_FoD_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_FoD_01, getProfileInt( "Settings", "KCAN__ALLDEF_FoD_01", 0, profileFile ) );
    putValue( KCAN__STMSG_FoD_01, getProfileInt( "Settings", "KCAN__STMSG_FoD_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_FoD_01, getProfileInt( "Settings", "KCAN__STMSGT_FoD_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_FoD_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_FoD_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_FoD_01, getProfileInt( "Settings", "KCAN__STMSGSD_FoD_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_FoD_01, getProfileInt( "Settings", "KCAN__STMSGCT_FoD_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_FoD_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_FoD_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_FoD_01, getProfileInt( "Settings", "KCAN__STMSG_PO_FoD_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_FoD_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_FoD_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_FoD_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_FoD_01", 0, profileFile ) );
    putValue( KCAN__MSGID_FoD_Kombi_Req, getProfileInt( "Settings", "KCAN__MSGID_FoD_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_FoD_Kombi_Req, getProfileInt( "Settings", "KCAN__MSGDLC_FoD_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_FoD_Kombi_Req_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_FoD_Kombi_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_FoD_Kombi_Req, getProfileInt( "Settings", "KCAN__ALLDEF_FoD_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__STMSG_FoD_Kombi_Req, getProfileInt( "Settings", "KCAN__STMSG_FoD_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_FoD_Kombi_Req, getProfileInt( "Settings", "KCAN__STMSGT_FoD_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_FoD_Kombi_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_FoD_Kombi_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_FoD_Kombi_Req, getProfileInt( "Settings", "KCAN__STMSGSD_FoD_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_FoD_Kombi_Req, getProfileInt( "Settings", "KCAN__STMSGCT_FoD_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_FoD_Kombi_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_FoD_Kombi_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_FoD_Kombi_Req, getProfileInt( "Settings", "KCAN__STMSG_PO_FoD_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_FoD_Kombi_Req, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_FoD_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_FoD_Kombi_Req, getProfileInt( "Settings", "KCAN__MSG_SendNow_FoD_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__MSGID_FoD_Kombi_Resp, getProfileInt( "Settings", "KCAN__MSGID_FoD_Kombi_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_FoD_Kombi_Resp, getProfileInt( "Settings", "KCAN__MSGDLC_FoD_Kombi_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_FoD_Kombi_Resp_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_FoD_Kombi_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_FoD_Kombi_Resp, getProfileInt( "Settings", "KCAN__ALLDEF_FoD_Kombi_Resp", 0, profileFile ) );
    putValue( KCAN__STMSG_FoD_Kombi_Resp, getProfileInt( "Settings", "KCAN__STMSG_FoD_Kombi_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_FoD_Kombi_Resp, getProfileInt( "Settings", "KCAN__STMSGT_FoD_Kombi_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_FoD_Kombi_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_FoD_Kombi_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_FoD_Kombi_Resp, getProfileInt( "Settings", "KCAN__STMSGSD_FoD_Kombi_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_FoD_Kombi_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_FoD_Kombi_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGCT_FoD_Kombi_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_FoD_Kombi_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_FoD_Kombi_Resp, getProfileInt( "Settings", "KCAN__STMSG_PO_FoD_Kombi_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_FoD_Kombi_Resp, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_FoD_Kombi_Resp", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_FoD_Kombi_Resp, getProfileInt( "Settings", "KCAN__MSG_SendNow_FoD_Kombi_Resp", 0, profileFile ) );
    putValue( KCAN__MSGID_FoD_ZR_Req, getProfileInt( "Settings", "KCAN__MSGID_FoD_ZR_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_FoD_ZR_Req, getProfileInt( "Settings", "KCAN__MSGDLC_FoD_ZR_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_FoD_ZR_Req_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_FoD_ZR_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_FoD_ZR_Req, getProfileInt( "Settings", "KCAN__ALLDEF_FoD_ZR_Req", 0, profileFile ) );
    putValue( KCAN__STMSG_FoD_ZR_Req, getProfileInt( "Settings", "KCAN__STMSG_FoD_ZR_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_FoD_ZR_Req, getProfileInt( "Settings", "KCAN__STMSGT_FoD_ZR_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_FoD_ZR_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_FoD_ZR_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_FoD_ZR_Req, getProfileInt( "Settings", "KCAN__STMSGSD_FoD_ZR_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_FoD_ZR_Req, getProfileInt( "Settings", "KCAN__STMSGCT_FoD_ZR_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_FoD_ZR_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_FoD_ZR_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_FoD_ZR_Req, getProfileInt( "Settings", "KCAN__STMSG_PO_FoD_ZR_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_FoD_ZR_Req, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_FoD_ZR_Req", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_FoD_ZR_Req, getProfileInt( "Settings", "KCAN__MSG_SendNow_FoD_ZR_Req", 0, profileFile ) );
    putValue( KCAN__MSGID_FoD_ZR_Resp, getProfileInt( "Settings", "KCAN__MSGID_FoD_ZR_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_FoD_ZR_Resp, getProfileInt( "Settings", "KCAN__MSGDLC_FoD_ZR_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_FoD_ZR_Resp_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_FoD_ZR_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_FoD_ZR_Resp, getProfileInt( "Settings", "KCAN__ALLDEF_FoD_ZR_Resp", 0, profileFile ) );
    putValue( KCAN__STMSG_FoD_ZR_Resp, getProfileInt( "Settings", "KCAN__STMSG_FoD_ZR_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_FoD_ZR_Resp, getProfileInt( "Settings", "KCAN__STMSGT_FoD_ZR_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_FoD_ZR_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_FoD_ZR_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_FoD_ZR_Resp, getProfileInt( "Settings", "KCAN__STMSGSD_FoD_ZR_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_FoD_ZR_Resp, getProfileInt( "Settings", "KCAN__STMSGCT_FoD_ZR_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_FoD_ZR_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_FoD_ZR_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_FoD_ZR_Resp, getProfileInt( "Settings", "KCAN__STMSG_PO_FoD_ZR_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_FoD_ZR_Resp, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_FoD_ZR_Resp", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_FoD_ZR_Resp, getProfileInt( "Settings", "KCAN__MSG_SendNow_FoD_ZR_Resp", 0, profileFile ) );
    putValue( KCAN__MSGID_Gateway_71, getProfileInt( "Settings", "KCAN__MSGID_Gateway_71", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Gateway_71, getProfileInt( "Settings", "KCAN__MSGDLC_Gateway_71", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Gateway_71_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Gateway_71_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Gateway_71, getProfileInt( "Settings", "KCAN__ALLDEF_Gateway_71", 0, profileFile ) );
    putValue( KCAN__STMSG_Gateway_71, getProfileInt( "Settings", "KCAN__STMSG_Gateway_71", 0, profileFile ) );
    putValue( KCAN__STMSGT_Gateway_71, getProfileInt( "Settings", "KCAN__STMSGT_Gateway_71", 0, profileFile ) );
    putValue( KCAN__STMSGT_Gateway_71_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Gateway_71_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Gateway_71, getProfileInt( "Settings", "KCAN__STMSGSD_Gateway_71", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Gateway_71, getProfileInt( "Settings", "KCAN__STMSGCT_Gateway_71", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Gateway_71_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Gateway_71_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Gateway_71, getProfileInt( "Settings", "KCAN__STMSG_PO_Gateway_71", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Gateway_71, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Gateway_71", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Gateway_71, getProfileInt( "Settings", "KCAN__MSG_SendNow_Gateway_71", 0, profileFile ) );
    putValue( KCAN__MSGID_Gateway_73, getProfileInt( "Settings", "KCAN__MSGID_Gateway_73", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Gateway_73, getProfileInt( "Settings", "KCAN__MSGDLC_Gateway_73", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Gateway_73_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Gateway_73_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Gateway_73, getProfileInt( "Settings", "KCAN__ALLDEF_Gateway_73", 0, profileFile ) );
    putValue( KCAN__STMSG_Gateway_73, getProfileInt( "Settings", "KCAN__STMSG_Gateway_73", 0, profileFile ) );
    putValue( KCAN__STMSGT_Gateway_73, getProfileInt( "Settings", "KCAN__STMSGT_Gateway_73", 0, profileFile ) );
    putValue( KCAN__STMSGT_Gateway_73_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Gateway_73_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Gateway_73, getProfileInt( "Settings", "KCAN__STMSGSD_Gateway_73", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Gateway_73, getProfileInt( "Settings", "KCAN__STMSGCT_Gateway_73", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Gateway_73_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Gateway_73_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Gateway_73, getProfileInt( "Settings", "KCAN__STMSG_PO_Gateway_73", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Gateway_73, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Gateway_73", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Gateway_73, getProfileInt( "Settings", "KCAN__MSG_SendNow_Gateway_73", 0, profileFile ) );
    putValue( KCAN__MSGID_Getriebe_16, getProfileInt( "Settings", "KCAN__MSGID_Getriebe_16", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Getriebe_16, getProfileInt( "Settings", "KCAN__MSGDLC_Getriebe_16", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Getriebe_16_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Getriebe_16_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Getriebe_16, getProfileInt( "Settings", "KCAN__ALLDEF_Getriebe_16", 0, profileFile ) );
    putValue( KCAN__STMSG_Getriebe_16, getProfileInt( "Settings", "KCAN__STMSG_Getriebe_16", 0, profileFile ) );
    putValue( KCAN__STMSGT_Getriebe_16, getProfileInt( "Settings", "KCAN__STMSGT_Getriebe_16", 0, profileFile ) );
    putValue( KCAN__STMSGT_Getriebe_16_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Getriebe_16_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Getriebe_16, getProfileInt( "Settings", "KCAN__STMSGSD_Getriebe_16", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Getriebe_16, getProfileInt( "Settings", "KCAN__STMSGCT_Getriebe_16", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Getriebe_16_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Getriebe_16_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Getriebe_16, getProfileInt( "Settings", "KCAN__STMSG_PO_Getriebe_16", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Getriebe_16, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Getriebe_16", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Getriebe_16, getProfileInt( "Settings", "KCAN__MSG_SendNow_Getriebe_16", 0, profileFile ) );
    putValue( KCAN__MSGID_Heckradar_01, getProfileInt( "Settings", "KCAN__MSGID_Heckradar_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Heckradar_01, getProfileInt( "Settings", "KCAN__MSGDLC_Heckradar_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Heckradar_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Heckradar_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Heckradar_01, getProfileInt( "Settings", "KCAN__ALLDEF_Heckradar_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Heckradar_01, getProfileInt( "Settings", "KCAN__STMSG_Heckradar_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Heckradar_01, getProfileInt( "Settings", "KCAN__STMSGT_Heckradar_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Heckradar_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Heckradar_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Heckradar_01, getProfileInt( "Settings", "KCAN__STMSGSD_Heckradar_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Heckradar_01, getProfileInt( "Settings", "KCAN__STMSGCT_Heckradar_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Heckradar_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Heckradar_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Heckradar_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Heckradar_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Heckradar_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Heckradar_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Heckradar_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Heckradar_01", 0, profileFile ) );
    putValue( KCAN__MSGID_HID_DispKBI_FS_ZR_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_HID_DispKBI_FS_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HID_DispKBI_FS_ZR_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLC_HID_DispKBI_FS_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HID_DispKBI_FS_ZR_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_HID_DispKBI_FS_ZR_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_HID_DispKBI_FS_ZR_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_HID_DispKBI_FS_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_HID_DispKBI_FS_ZR_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_HID_DispKBI_FS_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HID_DispKBI_FS_ZR_Req_FD, getProfileInt( "Settings", "KCAN__STMSGT_HID_DispKBI_FS_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HID_DispKBI_FS_ZR_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_HID_DispKBI_FS_ZR_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_HID_DispKBI_FS_ZR_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_HID_DispKBI_FS_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HID_DispKBI_FS_ZR_Req_FD, getProfileInt( "Settings", "KCAN__STMSGCT_HID_DispKBI_FS_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HID_DispKBI_FS_ZR_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_HID_DispKBI_FS_ZR_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_HID_DispKBI_FS_ZR_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_HID_DispKBI_FS_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_HID_DispKBI_FS_ZR_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_HID_DispKBI_FS_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_HID_DispKBI_FS_ZR_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_HID_DispKBI_FS_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_HID_DispKBI_FS_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_HID_DispKBI_FS_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HID_DispKBI_FS_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLC_HID_DispKBI_FS_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HID_DispKBI_FS_ZR_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_HID_DispKBI_FS_ZR_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_HID_DispKBI_FS_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_HID_DispKBI_FS_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_HID_DispKBI_FS_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_HID_DispKBI_FS_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HID_DispKBI_FS_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGT_HID_DispKBI_FS_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HID_DispKBI_FS_ZR_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_HID_DispKBI_FS_ZR_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_HID_DispKBI_FS_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_HID_DispKBI_FS_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HID_DispKBI_FS_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_HID_DispKBI_FS_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HID_DispKBI_FS_ZR_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_HID_DispKBI_FS_ZR_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_HID_DispKBI_FS_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_HID_DispKBI_FS_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_HID_DispKBI_FS_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_HID_DispKBI_FS_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_HID_DispKBI_FS_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_HID_DispKBI_FS_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_HID_HUD_ZR_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_HID_HUD_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HID_HUD_ZR_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLC_HID_HUD_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HID_HUD_ZR_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_HID_HUD_ZR_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_HID_HUD_ZR_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_HID_HUD_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_HID_HUD_ZR_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_HID_HUD_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HID_HUD_ZR_Req_FD, getProfileInt( "Settings", "KCAN__STMSGT_HID_HUD_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HID_HUD_ZR_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_HID_HUD_ZR_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_HID_HUD_ZR_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_HID_HUD_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HID_HUD_ZR_Req_FD, getProfileInt( "Settings", "KCAN__STMSGCT_HID_HUD_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HID_HUD_ZR_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_HID_HUD_ZR_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_HID_HUD_ZR_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_HID_HUD_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_HID_HUD_ZR_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_HID_HUD_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_HID_HUD_ZR_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_HID_HUD_ZR_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_HID_HUD_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_HID_HUD_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HID_HUD_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLC_HID_HUD_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HID_HUD_ZR_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_HID_HUD_ZR_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_HID_HUD_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_HID_HUD_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_HID_HUD_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_HID_HUD_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HID_HUD_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGT_HID_HUD_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HID_HUD_ZR_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_HID_HUD_ZR_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_HID_HUD_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_HID_HUD_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HID_HUD_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_HID_HUD_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HID_HUD_ZR_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_HID_HUD_ZR_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_HID_HUD_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_HID_HUD_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_HID_HUD_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_HID_HUD_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_HID_HUD_ZR_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_HID_HUD_ZR_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_HID_ZR_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_HID_ZR_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HID_ZR_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLC_HID_ZR_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HID_ZR_DispKBI_FS_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_HID_ZR_DispKBI_FS_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_HID_ZR_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_HID_ZR_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_HID_ZR_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_HID_ZR_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HID_ZR_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSGT_HID_ZR_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HID_ZR_DispKBI_FS_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_HID_ZR_DispKBI_FS_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_HID_ZR_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_HID_ZR_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HID_ZR_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSGCT_HID_ZR_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HID_ZR_DispKBI_FS_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_HID_ZR_DispKBI_FS_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_HID_ZR_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_HID_ZR_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_HID_ZR_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_HID_ZR_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_HID_ZR_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_HID_ZR_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_HID_ZR_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_HID_ZR_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HID_ZR_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLC_HID_ZR_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HID_ZR_DispKBI_FS_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_HID_ZR_DispKBI_FS_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_HID_ZR_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_HID_ZR_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_HID_ZR_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_HID_ZR_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HID_ZR_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGT_HID_ZR_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HID_ZR_DispKBI_FS_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_HID_ZR_DispKBI_FS_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_HID_ZR_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_HID_ZR_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HID_ZR_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_HID_ZR_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HID_ZR_DispKBI_FS_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_HID_ZR_DispKBI_FS_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_HID_ZR_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_HID_ZR_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_HID_ZR_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_HID_ZR_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_HID_ZR_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_HID_ZR_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_HID_ZR_HUD_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_HID_ZR_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HID_ZR_HUD_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLC_HID_ZR_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HID_ZR_HUD_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_HID_ZR_HUD_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_HID_ZR_HUD_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_HID_ZR_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_HID_ZR_HUD_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_HID_ZR_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HID_ZR_HUD_Req_FD, getProfileInt( "Settings", "KCAN__STMSGT_HID_ZR_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HID_ZR_HUD_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_HID_ZR_HUD_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_HID_ZR_HUD_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_HID_ZR_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HID_ZR_HUD_Req_FD, getProfileInt( "Settings", "KCAN__STMSGCT_HID_ZR_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HID_ZR_HUD_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_HID_ZR_HUD_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_HID_ZR_HUD_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_HID_ZR_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_HID_ZR_HUD_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_HID_ZR_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_HID_ZR_HUD_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_HID_ZR_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_HID_ZR_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_HID_ZR_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HID_ZR_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLC_HID_ZR_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HID_ZR_HUD_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_HID_ZR_HUD_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_HID_ZR_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_HID_ZR_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_HID_ZR_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_HID_ZR_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HID_ZR_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGT_HID_ZR_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HID_ZR_HUD_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_HID_ZR_HUD_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_HID_ZR_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_HID_ZR_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HID_ZR_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_HID_ZR_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HID_ZR_HUD_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_HID_ZR_HUD_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_HID_ZR_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_HID_ZR_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_HID_ZR_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_HID_ZR_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_HID_ZR_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_HID_ZR_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_HUD_ARC_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_HUD_ARC_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HUD_ARC_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLC_HUD_ARC_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HUD_ARC_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_HUD_ARC_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_HUD_ARC_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_HUD_ARC_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_HUD_ARC_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_HUD_ARC_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HUD_ARC_Req_FD, getProfileInt( "Settings", "KCAN__STMSGT_HUD_ARC_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HUD_ARC_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_HUD_ARC_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_HUD_ARC_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_HUD_ARC_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HUD_ARC_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_HUD_ARC_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HUD_ARC_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_HUD_ARC_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_HUD_ARC_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_HUD_ARC_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_HUD_ARC_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_HUD_ARC_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_HUD_ARC_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_HUD_ARC_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_HUD_ARC_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_HUD_ARC_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HUD_ARC_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_HUD_ARC_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HUD_ARC_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_HUD_ARC_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_HUD_ARC_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_HUD_ARC_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_HUD_ARC_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_HUD_ARC_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_HUD_ARC_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_HUD_ARC_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGT_HUD_ARC_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_HUD_ARC_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_HUD_ARC_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_HUD_ARC_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HUD_ARC_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_HUD_ARC_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HUD_ARC_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_HUD_ARC_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_HUD_ARC_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_HUD_ARC_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_HUD_ARC_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_HUD_ARC_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_HUD_ARC_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_HUD_ARC_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_HVK_01, getProfileInt( "Settings", "KCAN__MSGID_HVK_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HVK_01, getProfileInt( "Settings", "KCAN__MSGDLC_HVK_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_HVK_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_HVK_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_HVK_01, getProfileInt( "Settings", "KCAN__ALLDEF_HVK_01", 0, profileFile ) );
    putValue( KCAN__STMSG_HVK_01, getProfileInt( "Settings", "KCAN__STMSG_HVK_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_HVK_01, getProfileInt( "Settings", "KCAN__STMSGT_HVK_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_HVK_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_HVK_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_HVK_01, getProfileInt( "Settings", "KCAN__STMSGSD_HVK_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HVK_01, getProfileInt( "Settings", "KCAN__STMSGCT_HVK_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_HVK_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_HVK_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_HVK_01, getProfileInt( "Settings", "KCAN__STMSG_PO_HVK_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_HVK_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_HVK_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_HVK_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_HVK_01", 0, profileFile ) );
    putValue( KCAN__MSGID_IPA_02, getProfileInt( "Settings", "KCAN__MSGID_IPA_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_IPA_02, getProfileInt( "Settings", "KCAN__MSGDLC_IPA_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_IPA_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_IPA_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_IPA_02, getProfileInt( "Settings", "KCAN__ALLDEF_IPA_02", 0, profileFile ) );
    putValue( KCAN__STMSG_IPA_02, getProfileInt( "Settings", "KCAN__STMSG_IPA_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_IPA_02, getProfileInt( "Settings", "KCAN__STMSGT_IPA_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_IPA_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_IPA_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_IPA_02, getProfileInt( "Settings", "KCAN__STMSGSD_IPA_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_IPA_02, getProfileInt( "Settings", "KCAN__STMSGCT_IPA_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_IPA_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_IPA_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_IPA_02, getProfileInt( "Settings", "KCAN__STMSG_PO_IPA_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_IPA_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_IPA_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_IPA_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_IPA_02", 0, profileFile ) );
    putValue( KCAN__MSGID_ISO_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__MSGID_ISO_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISO_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__MSGDLC_ISO_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISO_Funktionaler_Req_All_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISO_Funktionaler_Req_All_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISO_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__ALLDEF_ISO_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__STMSG_ISO_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__STMSG_ISO_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISO_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__STMSGT_ISO_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISO_Funktionaler_Req_All_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISO_Funktionaler_Req_All_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISO_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__STMSGSD_ISO_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISO_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__STMSGCT_ISO_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISO_Funktionaler_Req_All_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISO_Funktionaler_Req_All_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISO_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__STMSG_PO_ISO_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISO_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISO_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISO_Funktionaler_Req_All, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISO_Funktionaler_Req_All", 0, profileFile ) );
    putValue( KCAN__MSGID_ISO_HUD_Req, getProfileInt( "Settings", "KCAN__MSGID_ISO_HUD_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISO_HUD_Req, getProfileInt( "Settings", "KCAN__MSGDLC_ISO_HUD_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISO_HUD_Req_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISO_HUD_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISO_HUD_Req, getProfileInt( "Settings", "KCAN__ALLDEF_ISO_HUD_Req", 0, profileFile ) );
    putValue( KCAN__STMSG_ISO_HUD_Req, getProfileInt( "Settings", "KCAN__STMSG_ISO_HUD_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISO_HUD_Req, getProfileInt( "Settings", "KCAN__STMSGT_ISO_HUD_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISO_HUD_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISO_HUD_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISO_HUD_Req, getProfileInt( "Settings", "KCAN__STMSGSD_ISO_HUD_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISO_HUD_Req, getProfileInt( "Settings", "KCAN__STMSGCT_ISO_HUD_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISO_HUD_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISO_HUD_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISO_HUD_Req, getProfileInt( "Settings", "KCAN__STMSG_PO_ISO_HUD_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISO_HUD_Req, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISO_HUD_Req", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISO_HUD_Req, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISO_HUD_Req", 0, profileFile ) );
    putValue( KCAN__MSGID_ISO_HUD_Resp, getProfileInt( "Settings", "KCAN__MSGID_ISO_HUD_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISO_HUD_Resp, getProfileInt( "Settings", "KCAN__MSGDLC_ISO_HUD_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISO_HUD_Resp_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISO_HUD_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISO_HUD_Resp, getProfileInt( "Settings", "KCAN__ALLDEF_ISO_HUD_Resp", 0, profileFile ) );
    putValue( KCAN__STMSG_ISO_HUD_Resp, getProfileInt( "Settings", "KCAN__STMSG_ISO_HUD_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISO_HUD_Resp, getProfileInt( "Settings", "KCAN__STMSGT_ISO_HUD_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISO_HUD_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISO_HUD_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISO_HUD_Resp, getProfileInt( "Settings", "KCAN__STMSGSD_ISO_HUD_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISO_HUD_Resp, getProfileInt( "Settings", "KCAN__STMSGCT_ISO_HUD_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISO_HUD_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISO_HUD_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISO_HUD_Resp, getProfileInt( "Settings", "KCAN__STMSG_PO_ISO_HUD_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISO_HUD_Resp, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISO_HUD_Resp", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISO_HUD_Resp, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISO_HUD_Resp", 0, profileFile ) );
    putValue( KCAN__MSGID_ISO_Kombi_Req, getProfileInt( "Settings", "KCAN__MSGID_ISO_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISO_Kombi_Req, getProfileInt( "Settings", "KCAN__MSGDLC_ISO_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISO_Kombi_Req_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISO_Kombi_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISO_Kombi_Req, getProfileInt( "Settings", "KCAN__ALLDEF_ISO_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__STMSG_ISO_Kombi_Req, getProfileInt( "Settings", "KCAN__STMSG_ISO_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISO_Kombi_Req, getProfileInt( "Settings", "KCAN__STMSGT_ISO_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISO_Kombi_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISO_Kombi_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISO_Kombi_Req, getProfileInt( "Settings", "KCAN__STMSGSD_ISO_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISO_Kombi_Req, getProfileInt( "Settings", "KCAN__STMSGCT_ISO_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISO_Kombi_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISO_Kombi_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISO_Kombi_Req, getProfileInt( "Settings", "KCAN__STMSG_PO_ISO_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISO_Kombi_Req, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISO_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISO_Kombi_Req, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISO_Kombi_Req", 0, profileFile ) );
    putValue( KCAN__MSGID_ISO_Kombi_Resp, getProfileInt( "Settings", "KCAN__MSGID_ISO_Kombi_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISO_Kombi_Resp, getProfileInt( "Settings", "KCAN__MSGDLC_ISO_Kombi_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISO_Kombi_Resp_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISO_Kombi_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISO_Kombi_Resp, getProfileInt( "Settings", "KCAN__ALLDEF_ISO_Kombi_Resp", 0, profileFile ) );
    putValue( KCAN__STMSG_ISO_Kombi_Resp, getProfileInt( "Settings", "KCAN__STMSG_ISO_Kombi_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISO_Kombi_Resp, getProfileInt( "Settings", "KCAN__STMSGT_ISO_Kombi_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISO_Kombi_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISO_Kombi_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISO_Kombi_Resp, getProfileInt( "Settings", "KCAN__STMSGSD_ISO_Kombi_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISO_Kombi_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISO_Kombi_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISO_Kombi_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISO_Kombi_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISO_Kombi_Resp, getProfileInt( "Settings", "KCAN__STMSG_PO_ISO_Kombi_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISO_Kombi_Resp, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISO_Kombi_Resp", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISO_Kombi_Resp, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISO_Kombi_Resp", 0, profileFile ) );
    putValue( KCAN__MSGID_ISO_NFCIApp_NFCIServ_Req, getProfileInt( "Settings", "KCAN__MSGID_ISO_NFCIApp_NFCIServ_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISO_NFCIApp_NFCIServ_Req, getProfileInt( "Settings", "KCAN__MSGDLC_ISO_NFCIApp_NFCIServ_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISO_NFCIApp_NFCIServ_Req_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISO_NFCIApp_NFCIServ_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISO_NFCIApp_NFCIServ_Req, getProfileInt( "Settings", "KCAN__ALLDEF_ISO_NFCIApp_NFCIServ_Req", 0, profileFile ) );
    putValue( KCAN__STMSG_ISO_NFCIApp_NFCIServ_Req, getProfileInt( "Settings", "KCAN__STMSG_ISO_NFCIApp_NFCIServ_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISO_NFCIApp_NFCIServ_Req, getProfileInt( "Settings", "KCAN__STMSGT_ISO_NFCIApp_NFCIServ_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISO_NFCIApp_NFCIServ_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISO_NFCIApp_NFCIServ_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISO_NFCIApp_NFCIServ_Req, getProfileInt( "Settings", "KCAN__STMSGSD_ISO_NFCIApp_NFCIServ_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISO_NFCIApp_NFCIServ_Req, getProfileInt( "Settings", "KCAN__STMSGCT_ISO_NFCIApp_NFCIServ_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISO_NFCIApp_NFCIServ_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISO_NFCIApp_NFCIServ_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISO_NFCIApp_NFCIServ_Req, getProfileInt( "Settings", "KCAN__STMSG_PO_ISO_NFCIApp_NFCIServ_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISO_NFCIApp_NFCIServ_Req, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISO_NFCIApp_NFCIServ_Req", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISO_NFCIApp_NFCIServ_Req, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISO_NFCIApp_NFCIServ_Req", 0, profileFile ) );
    putValue( KCAN__MSGID_ISO_NFCIApp_NFCIServ_Resp, getProfileInt( "Settings", "KCAN__MSGID_ISO_NFCIApp_NFCIServ_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISO_NFCIApp_NFCIServ_Resp, getProfileInt( "Settings", "KCAN__MSGDLC_ISO_NFCIApp_NFCIServ_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISO_NFCIApp_NFCIServ_Resp_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISO_NFCIApp_NFCIServ_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISO_NFCIApp_NFCIServ_Resp, getProfileInt( "Settings", "KCAN__ALLDEF_ISO_NFCIApp_NFCIServ_Resp", 0, profileFile ) );
    putValue( KCAN__STMSG_ISO_NFCIApp_NFCIServ_Resp, getProfileInt( "Settings", "KCAN__STMSG_ISO_NFCIApp_NFCIServ_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISO_NFCIApp_NFCIServ_Resp, getProfileInt( "Settings", "KCAN__STMSGT_ISO_NFCIApp_NFCIServ_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISO_NFCIApp_NFCIServ_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISO_NFCIApp_NFCIServ_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISO_NFCIApp_NFCIServ_Resp, getProfileInt( "Settings", "KCAN__STMSGSD_ISO_NFCIApp_NFCIServ_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISO_NFCIApp_NFCIServ_Resp, getProfileInt( "Settings", "KCAN__STMSGCT_ISO_NFCIApp_NFCIServ_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISO_NFCIApp_NFCIServ_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISO_NFCIApp_NFCIServ_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISO_NFCIApp_NFCIServ_Resp, getProfileInt( "Settings", "KCAN__STMSG_PO_ISO_NFCIApp_NFCIServ_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISO_NFCIApp_NFCIServ_Resp, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISO_NFCIApp_NFCIServ_Resp", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISO_NFCIApp_NFCIServ_Resp, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISO_NFCIApp_NFCIServ_Resp", 0, profileFile ) );
    putValue( KCAN__MSGID_ISO_NFCIServ_NFCIApp_Req, getProfileInt( "Settings", "KCAN__MSGID_ISO_NFCIServ_NFCIApp_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISO_NFCIServ_NFCIApp_Req, getProfileInt( "Settings", "KCAN__MSGDLC_ISO_NFCIServ_NFCIApp_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISO_NFCIServ_NFCIApp_Req_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISO_NFCIServ_NFCIApp_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISO_NFCIServ_NFCIApp_Req, getProfileInt( "Settings", "KCAN__ALLDEF_ISO_NFCIServ_NFCIApp_Req", 0, profileFile ) );
    putValue( KCAN__STMSG_ISO_NFCIServ_NFCIApp_Req, getProfileInt( "Settings", "KCAN__STMSG_ISO_NFCIServ_NFCIApp_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISO_NFCIServ_NFCIApp_Req, getProfileInt( "Settings", "KCAN__STMSGT_ISO_NFCIServ_NFCIApp_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISO_NFCIServ_NFCIApp_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISO_NFCIServ_NFCIApp_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISO_NFCIServ_NFCIApp_Req, getProfileInt( "Settings", "KCAN__STMSGSD_ISO_NFCIServ_NFCIApp_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISO_NFCIServ_NFCIApp_Req, getProfileInt( "Settings", "KCAN__STMSGCT_ISO_NFCIServ_NFCIApp_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISO_NFCIServ_NFCIApp_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISO_NFCIServ_NFCIApp_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISO_NFCIServ_NFCIApp_Req, getProfileInt( "Settings", "KCAN__STMSG_PO_ISO_NFCIServ_NFCIApp_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISO_NFCIServ_NFCIApp_Req, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISO_NFCIServ_NFCIApp_Req", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISO_NFCIServ_NFCIApp_Req, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISO_NFCIServ_NFCIApp_Req", 0, profileFile ) );
    putValue( KCAN__MSGID_ISO_NFCIServ_NFCIApp_Resp, getProfileInt( "Settings", "KCAN__MSGID_ISO_NFCIServ_NFCIApp_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISO_NFCIServ_NFCIApp_Resp, getProfileInt( "Settings", "KCAN__MSGDLC_ISO_NFCIServ_NFCIApp_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISO_NFCIServ_NFCIApp_Resp_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISO_NFCIServ_NFCIApp_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISO_NFCIServ_NFCIApp_Resp, getProfileInt( "Settings", "KCAN__ALLDEF_ISO_NFCIServ_NFCIApp_Resp", 0, profileFile ) );
    putValue( KCAN__STMSG_ISO_NFCIServ_NFCIApp_Resp, getProfileInt( "Settings", "KCAN__STMSG_ISO_NFCIServ_NFCIApp_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISO_NFCIServ_NFCIApp_Resp, getProfileInt( "Settings", "KCAN__STMSGT_ISO_NFCIServ_NFCIApp_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISO_NFCIServ_NFCIApp_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISO_NFCIServ_NFCIApp_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISO_NFCIServ_NFCIApp_Resp, getProfileInt( "Settings", "KCAN__STMSGSD_ISO_NFCIServ_NFCIApp_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISO_NFCIServ_NFCIApp_Resp, getProfileInt( "Settings", "KCAN__STMSGCT_ISO_NFCIServ_NFCIApp_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISO_NFCIServ_NFCIApp_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISO_NFCIServ_NFCIApp_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISO_NFCIServ_NFCIApp_Resp, getProfileInt( "Settings", "KCAN__STMSG_PO_ISO_NFCIServ_NFCIApp_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISO_NFCIServ_NFCIApp_Resp, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISO_NFCIServ_NFCIApp_Resp", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISO_NFCIServ_NFCIApp_Resp, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISO_NFCIServ_NFCIApp_Resp", 0, profileFile ) );
    putValue( KCAN__MSGID_ISOx_DispKBI_FS_Req, getProfileInt( "Settings", "KCAN__MSGID_ISOx_DispKBI_FS_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_DispKBI_FS_Req, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_DispKBI_FS_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_DispKBI_FS_Req_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_DispKBI_FS_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISOx_DispKBI_FS_Req, getProfileInt( "Settings", "KCAN__ALLDEF_ISOx_DispKBI_FS_Req", 0, profileFile ) );
    putValue( KCAN__STMSG_ISOx_DispKBI_FS_Req, getProfileInt( "Settings", "KCAN__STMSG_ISOx_DispKBI_FS_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_DispKBI_FS_Req, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_DispKBI_FS_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_DispKBI_FS_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_DispKBI_FS_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISOx_DispKBI_FS_Req, getProfileInt( "Settings", "KCAN__STMSGSD_ISOx_DispKBI_FS_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_DispKBI_FS_Req, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_DispKBI_FS_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_DispKBI_FS_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_DispKBI_FS_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISOx_DispKBI_FS_Req, getProfileInt( "Settings", "KCAN__STMSG_PO_ISOx_DispKBI_FS_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISOx_DispKBI_FS_Req, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISOx_DispKBI_FS_Req", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISOx_DispKBI_FS_Req, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISOx_DispKBI_FS_Req", 0, profileFile ) );
    putValue( KCAN__MSGID_ISOx_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_ISOx_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_DispKBI_FS_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_DispKBI_FS_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISOx_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_ISOx_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_ISOx_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_ISOx_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_DispKBI_FS_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_DispKBI_FS_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISOx_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_ISOx_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_DispKBI_FS_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_DispKBI_FS_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISOx_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_ISOx_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISOx_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISOx_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISOx_DispKBI_FS_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISOx_DispKBI_FS_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_ISOx_DispKBI_FS_Resp, getProfileInt( "Settings", "KCAN__MSGID_ISOx_DispKBI_FS_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_DispKBI_FS_Resp, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_DispKBI_FS_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_DispKBI_FS_Resp_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_DispKBI_FS_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISOx_DispKBI_FS_Resp, getProfileInt( "Settings", "KCAN__ALLDEF_ISOx_DispKBI_FS_Resp", 0, profileFile ) );
    putValue( KCAN__STMSG_ISOx_DispKBI_FS_Resp, getProfileInt( "Settings", "KCAN__STMSG_ISOx_DispKBI_FS_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_DispKBI_FS_Resp, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_DispKBI_FS_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_DispKBI_FS_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_DispKBI_FS_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISOx_DispKBI_FS_Resp, getProfileInt( "Settings", "KCAN__STMSGSD_ISOx_DispKBI_FS_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_DispKBI_FS_Resp, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_DispKBI_FS_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_DispKBI_FS_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_DispKBI_FS_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISOx_DispKBI_FS_Resp, getProfileInt( "Settings", "KCAN__STMSG_PO_ISOx_DispKBI_FS_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISOx_DispKBI_FS_Resp, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISOx_DispKBI_FS_Resp", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISOx_DispKBI_FS_Resp, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISOx_DispKBI_FS_Resp", 0, profileFile ) );
    putValue( KCAN__MSGID_ISOx_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_ISOx_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_DispKBI_FS_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_DispKBI_FS_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISOx_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_ISOx_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_ISOx_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_ISOx_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_DispKBI_FS_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_DispKBI_FS_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISOx_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_ISOx_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_DispKBI_FS_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_DispKBI_FS_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISOx_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_ISOx_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISOx_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISOx_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISOx_DispKBI_FS_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISOx_DispKBI_FS_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_ISOx_Funkt_Req_All_FD, getProfileInt( "Settings", "KCAN__MSGID_ISOx_Funkt_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_Funkt_Req_All_FD, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_Funkt_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_Funkt_Req_All_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_Funkt_Req_All_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISOx_Funkt_Req_All_FD, getProfileInt( "Settings", "KCAN__ALLDEF_ISOx_Funkt_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_ISOx_Funkt_Req_All_FD, getProfileInt( "Settings", "KCAN__STMSG_ISOx_Funkt_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_Funkt_Req_All_FD, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_Funkt_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_Funkt_Req_All_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_Funkt_Req_All_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISOx_Funkt_Req_All_FD, getProfileInt( "Settings", "KCAN__STMSGSD_ISOx_Funkt_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_Funkt_Req_All_FD, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_Funkt_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_Funkt_Req_All_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_Funkt_Req_All_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISOx_Funkt_Req_All_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_ISOx_Funkt_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISOx_Funkt_Req_All_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISOx_Funkt_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISOx_Funkt_Req_All_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISOx_Funkt_Req_All_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_ISOx_HUD_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_ISOx_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_HUD_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_HUD_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_HUD_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_HUD_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISOx_HUD_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_ISOx_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_ISOx_HUD_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_ISOx_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_HUD_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_HUD_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_HUD_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_HUD_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISOx_HUD_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_ISOx_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_HUD_Req_FD, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_HUD_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_HUD_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISOx_HUD_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_ISOx_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISOx_HUD_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISOx_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISOx_HUD_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISOx_HUD_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_ISOx_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_ISOx_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_HUD_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_HUD_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISOx_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_ISOx_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_ISOx_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_ISOx_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_HUD_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_HUD_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISOx_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_ISOx_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_HUD_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_HUD_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISOx_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_ISOx_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISOx_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISOx_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISOx_HUD_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISOx_HUD_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_ISOx_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_ISOx_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_Kombi_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_Kombi_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISOx_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_ISOx_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_ISOx_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_ISOx_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_Kombi_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_Kombi_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISOx_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_ISOx_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_Kombi_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_Kombi_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISOx_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_ISOx_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISOx_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISOx_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISOx_Kombi_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISOx_Kombi_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_ISOx_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_ISOx_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_Kombi_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_Kombi_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISOx_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_ISOx_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_ISOx_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_ISOx_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_Kombi_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_Kombi_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISOx_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_ISOx_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_Kombi_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_Kombi_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISOx_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_ISOx_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISOx_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISOx_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISOx_Kombi_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISOx_Kombi_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_ISOx_SmLi_01_Req, getProfileInt( "Settings", "KCAN__MSGID_ISOx_SmLi_01_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_SmLi_01_Req, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_SmLi_01_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_SmLi_01_Req_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_SmLi_01_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISOx_SmLi_01_Req, getProfileInt( "Settings", "KCAN__ALLDEF_ISOx_SmLi_01_Req", 0, profileFile ) );
    putValue( KCAN__STMSG_ISOx_SmLi_01_Req, getProfileInt( "Settings", "KCAN__STMSG_ISOx_SmLi_01_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_SmLi_01_Req, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_SmLi_01_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_SmLi_01_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_SmLi_01_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISOx_SmLi_01_Req, getProfileInt( "Settings", "KCAN__STMSGSD_ISOx_SmLi_01_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_SmLi_01_Req, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_SmLi_01_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_SmLi_01_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_SmLi_01_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISOx_SmLi_01_Req, getProfileInt( "Settings", "KCAN__STMSG_PO_ISOx_SmLi_01_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISOx_SmLi_01_Req, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISOx_SmLi_01_Req", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISOx_SmLi_01_Req, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISOx_SmLi_01_Req", 0, profileFile ) );
    putValue( KCAN__MSGID_ISOx_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__MSGID_ISOx_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_SmLi_01_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_SmLi_01_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISOx_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__ALLDEF_ISOx_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_ISOx_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_ISOx_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_SmLi_01_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_SmLi_01_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISOx_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__STMSGSD_ISOx_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_SmLi_01_Req_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_SmLi_01_Req_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISOx_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_ISOx_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISOx_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISOx_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISOx_SmLi_01_Req_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISOx_SmLi_01_Req_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_ISOx_SmLi_01_Resp, getProfileInt( "Settings", "KCAN__MSGID_ISOx_SmLi_01_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_SmLi_01_Resp, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_SmLi_01_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_SmLi_01_Resp_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_SmLi_01_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISOx_SmLi_01_Resp, getProfileInt( "Settings", "KCAN__ALLDEF_ISOx_SmLi_01_Resp", 0, profileFile ) );
    putValue( KCAN__STMSG_ISOx_SmLi_01_Resp, getProfileInt( "Settings", "KCAN__STMSG_ISOx_SmLi_01_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_SmLi_01_Resp, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_SmLi_01_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_SmLi_01_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_SmLi_01_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISOx_SmLi_01_Resp, getProfileInt( "Settings", "KCAN__STMSGSD_ISOx_SmLi_01_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_SmLi_01_Resp, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_SmLi_01_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_SmLi_01_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_SmLi_01_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISOx_SmLi_01_Resp, getProfileInt( "Settings", "KCAN__STMSG_PO_ISOx_SmLi_01_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISOx_SmLi_01_Resp, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISOx_SmLi_01_Resp", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISOx_SmLi_01_Resp, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISOx_SmLi_01_Resp", 0, profileFile ) );
    putValue( KCAN__MSGID_ISOx_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__MSGID_ISOx_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_SmLi_01_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_SmLi_01_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISOx_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__ALLDEF_ISOx_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSG_ISOx_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_ISOx_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_SmLi_01_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_SmLi_01_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISOx_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGSD_ISOx_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_SmLi_01_Resp_FD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_SmLi_01_Resp_FD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISOx_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__STMSG_PO_ISOx_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISOx_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISOx_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISOx_SmLi_01_Resp_FD, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISOx_SmLi_01_Resp_FD", 0, profileFile ) );
    putValue( KCAN__MSGID_ISOx_WLC1_Req, getProfileInt( "Settings", "KCAN__MSGID_ISOx_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_WLC1_Req, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_WLC1_Req_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_WLC1_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISOx_WLC1_Req, getProfileInt( "Settings", "KCAN__ALLDEF_ISOx_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__STMSG_ISOx_WLC1_Req, getProfileInt( "Settings", "KCAN__STMSG_ISOx_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_WLC1_Req, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_WLC1_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_WLC1_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISOx_WLC1_Req, getProfileInt( "Settings", "KCAN__STMSGSD_ISOx_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_WLC1_Req, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_WLC1_Req_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_WLC1_Req_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISOx_WLC1_Req, getProfileInt( "Settings", "KCAN__STMSG_PO_ISOx_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISOx_WLC1_Req, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISOx_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISOx_WLC1_Req, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISOx_WLC1_Req", 0, profileFile ) );
    putValue( KCAN__MSGID_ISOx_WLC1_Resp, getProfileInt( "Settings", "KCAN__MSGID_ISOx_WLC1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_WLC1_Resp, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_WLC1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLC_ISOx_WLC1_Resp_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_ISOx_WLC1_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_ISOx_WLC1_Resp, getProfileInt( "Settings", "KCAN__ALLDEF_ISOx_WLC1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSG_ISOx_WLC1_Resp, getProfileInt( "Settings", "KCAN__STMSG_ISOx_WLC1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_WLC1_Resp, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_WLC1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGT_ISOx_WLC1_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_ISOx_WLC1_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_ISOx_WLC1_Resp, getProfileInt( "Settings", "KCAN__STMSGSD_ISOx_WLC1_Resp", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_WLC1_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_WLC1_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGCT_ISOx_WLC1_Resp_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_ISOx_WLC1_Resp_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_ISOx_WLC1_Resp, getProfileInt( "Settings", "KCAN__STMSG_PO_ISOx_WLC1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_ISOx_WLC1_Resp, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_ISOx_WLC1_Resp", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_ISOx_WLC1_Resp, getProfileInt( "Settings", "KCAN__MSG_SendNow_ISOx_WLC1_Resp", 0, profileFile ) );
    putValue( KCAN__MSGID_Kessy_04, getProfileInt( "Settings", "KCAN__MSGID_Kessy_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Kessy_04, getProfileInt( "Settings", "KCAN__MSGDLC_Kessy_04", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Kessy_04_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Kessy_04_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Kessy_04, getProfileInt( "Settings", "KCAN__ALLDEF_Kessy_04", 0, profileFile ) );
    putValue( KCAN__STMSG_Kessy_04, getProfileInt( "Settings", "KCAN__STMSG_Kessy_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_Kessy_04, getProfileInt( "Settings", "KCAN__STMSGT_Kessy_04", 0, profileFile ) );
    putValue( KCAN__STMSGT_Kessy_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Kessy_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Kessy_04, getProfileInt( "Settings", "KCAN__STMSGSD_Kessy_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Kessy_04, getProfileInt( "Settings", "KCAN__STMSGCT_Kessy_04", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Kessy_04_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Kessy_04_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Kessy_04, getProfileInt( "Settings", "KCAN__STMSG_PO_Kessy_04", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Kessy_04, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Kessy_04", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Kessy_04, getProfileInt( "Settings", "KCAN__MSG_SendNow_Kessy_04", 0, profileFile ) );
    putValue( KCAN__MSGID_Klemmen_Status_01, getProfileInt( "Settings", "KCAN__MSGID_Klemmen_Status_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Klemmen_Status_01, getProfileInt( "Settings", "KCAN__MSGDLC_Klemmen_Status_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Klemmen_Status_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Klemmen_Status_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Klemmen_Status_01, getProfileInt( "Settings", "KCAN__ALLDEF_Klemmen_Status_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Klemmen_Status_01, getProfileInt( "Settings", "KCAN__STMSG_Klemmen_Status_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Klemmen_Status_01, getProfileInt( "Settings", "KCAN__STMSGT_Klemmen_Status_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Klemmen_Status_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Klemmen_Status_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Klemmen_Status_01, getProfileInt( "Settings", "KCAN__STMSGSD_Klemmen_Status_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Klemmen_Status_01, getProfileInt( "Settings", "KCAN__STMSGCT_Klemmen_Status_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Klemmen_Status_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Klemmen_Status_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Klemmen_Status_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Klemmen_Status_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Klemmen_Status_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Klemmen_Status_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Klemmen_Status_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Klemmen_Status_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Klemmen_Status_02, getProfileInt( "Settings", "KCAN__MSGID_Klemmen_Status_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Klemmen_Status_02, getProfileInt( "Settings", "KCAN__MSGDLC_Klemmen_Status_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Klemmen_Status_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Klemmen_Status_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Klemmen_Status_02, getProfileInt( "Settings", "KCAN__ALLDEF_Klemmen_Status_02", 0, profileFile ) );
    putValue( KCAN__STMSG_Klemmen_Status_02, getProfileInt( "Settings", "KCAN__STMSG_Klemmen_Status_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_Klemmen_Status_02, getProfileInt( "Settings", "KCAN__STMSGT_Klemmen_Status_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_Klemmen_Status_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Klemmen_Status_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Klemmen_Status_02, getProfileInt( "Settings", "KCAN__STMSGSD_Klemmen_Status_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Klemmen_Status_02, getProfileInt( "Settings", "KCAN__STMSGCT_Klemmen_Status_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Klemmen_Status_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Klemmen_Status_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Klemmen_Status_02, getProfileInt( "Settings", "KCAN__STMSG_PO_Klemmen_Status_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Klemmen_Status_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Klemmen_Status_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Klemmen_Status_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_Klemmen_Status_02", 0, profileFile ) );
    putValue( KCAN__MSGID_Klemmen_Steuerung_01, getProfileInt( "Settings", "KCAN__MSGID_Klemmen_Steuerung_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Klemmen_Steuerung_01, getProfileInt( "Settings", "KCAN__MSGDLC_Klemmen_Steuerung_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Klemmen_Steuerung_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Klemmen_Steuerung_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Klemmen_Steuerung_01, getProfileInt( "Settings", "KCAN__ALLDEF_Klemmen_Steuerung_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Klemmen_Steuerung_01, getProfileInt( "Settings", "KCAN__STMSG_Klemmen_Steuerung_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Klemmen_Steuerung_01, getProfileInt( "Settings", "KCAN__STMSGT_Klemmen_Steuerung_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Klemmen_Steuerung_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Klemmen_Steuerung_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Klemmen_Steuerung_01, getProfileInt( "Settings", "KCAN__STMSGSD_Klemmen_Steuerung_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Klemmen_Steuerung_01, getProfileInt( "Settings", "KCAN__STMSGCT_Klemmen_Steuerung_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Klemmen_Steuerung_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Klemmen_Steuerung_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Klemmen_Steuerung_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Klemmen_Steuerung_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Klemmen_Steuerung_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Klemmen_Steuerung_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Klemmen_Steuerung_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Klemmen_Steuerung_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Klima_03, getProfileInt( "Settings", "KCAN__MSGID_Klima_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Klima_03, getProfileInt( "Settings", "KCAN__MSGDLC_Klima_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Klima_03_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Klima_03_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Klima_03, getProfileInt( "Settings", "KCAN__ALLDEF_Klima_03", 0, profileFile ) );
    putValue( KCAN__STMSG_Klima_03, getProfileInt( "Settings", "KCAN__STMSG_Klima_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_Klima_03, getProfileInt( "Settings", "KCAN__STMSGT_Klima_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_Klima_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Klima_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Klima_03, getProfileInt( "Settings", "KCAN__STMSGSD_Klima_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Klima_03, getProfileInt( "Settings", "KCAN__STMSGCT_Klima_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Klima_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Klima_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Klima_03, getProfileInt( "Settings", "KCAN__STMSG_PO_Klima_03", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Klima_03, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Klima_03", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Klima_03, getProfileInt( "Settings", "KCAN__MSG_SendNow_Klima_03", 0, profileFile ) );
    putValue( KCAN__MSGID_Klima_06, getProfileInt( "Settings", "KCAN__MSGID_Klima_06", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Klima_06, getProfileInt( "Settings", "KCAN__MSGDLC_Klima_06", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Klima_06_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Klima_06_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Klima_06, getProfileInt( "Settings", "KCAN__ALLDEF_Klima_06", 0, profileFile ) );
    putValue( KCAN__STMSG_Klima_06, getProfileInt( "Settings", "KCAN__STMSG_Klima_06", 0, profileFile ) );
    putValue( KCAN__STMSGT_Klima_06, getProfileInt( "Settings", "KCAN__STMSGT_Klima_06", 0, profileFile ) );
    putValue( KCAN__STMSGT_Klima_06_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Klima_06_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Klima_06, getProfileInt( "Settings", "KCAN__STMSGSD_Klima_06", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Klima_06, getProfileInt( "Settings", "KCAN__STMSGCT_Klima_06", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Klima_06_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Klima_06_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Klima_06, getProfileInt( "Settings", "KCAN__STMSG_PO_Klima_06", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Klima_06, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Klima_06", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Klima_06, getProfileInt( "Settings", "KCAN__MSG_SendNow_Klima_06", 0, profileFile ) );
    putValue( KCAN__MSGID_Klima_12, getProfileInt( "Settings", "KCAN__MSGID_Klima_12", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Klima_12, getProfileInt( "Settings", "KCAN__MSGDLC_Klima_12", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Klima_12_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Klima_12_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Klima_12, getProfileInt( "Settings", "KCAN__ALLDEF_Klima_12", 0, profileFile ) );
    putValue( KCAN__STMSG_Klima_12, getProfileInt( "Settings", "KCAN__STMSG_Klima_12", 0, profileFile ) );
    putValue( KCAN__STMSGT_Klima_12, getProfileInt( "Settings", "KCAN__STMSGT_Klima_12", 0, profileFile ) );
    putValue( KCAN__STMSGT_Klima_12_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Klima_12_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Klima_12, getProfileInt( "Settings", "KCAN__STMSGSD_Klima_12", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Klima_12, getProfileInt( "Settings", "KCAN__STMSGCT_Klima_12", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Klima_12_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Klima_12_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Klima_12, getProfileInt( "Settings", "KCAN__STMSG_PO_Klima_12", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Klima_12, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Klima_12", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Klima_12, getProfileInt( "Settings", "KCAN__MSG_SendNow_Klima_12", 0, profileFile ) );
    putValue( KCAN__MSGID_Klima_16, getProfileInt( "Settings", "KCAN__MSGID_Klima_16", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Klima_16, getProfileInt( "Settings", "KCAN__MSGDLC_Klima_16", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Klima_16_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Klima_16_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Klima_16, getProfileInt( "Settings", "KCAN__ALLDEF_Klima_16", 0, profileFile ) );
    putValue( KCAN__STMSG_Klima_16, getProfileInt( "Settings", "KCAN__STMSG_Klima_16", 0, profileFile ) );
    putValue( KCAN__STMSGT_Klima_16, getProfileInt( "Settings", "KCAN__STMSGT_Klima_16", 0, profileFile ) );
    putValue( KCAN__STMSGT_Klima_16_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Klima_16_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Klima_16, getProfileInt( "Settings", "KCAN__STMSGSD_Klima_16", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Klima_16, getProfileInt( "Settings", "KCAN__STMSGCT_Klima_16", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Klima_16_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Klima_16_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Klima_16, getProfileInt( "Settings", "KCAN__STMSG_PO_Klima_16", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Klima_16, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Klima_16", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Klima_16, getProfileInt( "Settings", "KCAN__MSG_SendNow_Klima_16", 0, profileFile ) );
    putValue( KCAN__MSGID_Klima_Sensor_02, getProfileInt( "Settings", "KCAN__MSGID_Klima_Sensor_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Klima_Sensor_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Klima_Sensor_02_CTRL", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Klima_Sensor_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Klima_Sensor_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Klima_Sensor_02, getProfileInt( "Settings", "KCAN__ALLDEF_Klima_Sensor_02", 0, profileFile ) );
    putValue( KCAN__STMSG_Klima_Sensor_02, getProfileInt( "Settings", "KCAN__STMSG_Klima_Sensor_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_Klima_Sensor_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Klima_Sensor_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGT_Klima_Sensor_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Klima_Sensor_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Klima_Sensor_02, getProfileInt( "Settings", "KCAN__STMSGSD_Klima_Sensor_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Klima_Sensor_02, getProfileInt( "Settings", "KCAN__STMSGCT_Klima_Sensor_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Klima_Sensor_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Klima_Sensor_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Klima_Sensor_02, getProfileInt( "Settings", "KCAN__STMSG_PO_Klima_Sensor_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Klima_Sensor_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Klima_Sensor_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Klima_Sensor_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_Klima_Sensor_02", 0, profileFile ) );
    putValue( KCAN__MSGID_KN_DispKBI_FS, getProfileInt( "Settings", "KCAN__MSGID_KN_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KN_DispKBI_FS, getProfileInt( "Settings", "KCAN__MSGDLC_KN_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KN_DispKBI_FS_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_KN_DispKBI_FS_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_KN_DispKBI_FS, getProfileInt( "Settings", "KCAN__ALLDEF_KN_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__STMSG_KN_DispKBI_FS, getProfileInt( "Settings", "KCAN__STMSG_KN_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__STMSGT_KN_DispKBI_FS, getProfileInt( "Settings", "KCAN__STMSGT_KN_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__STMSGT_KN_DispKBI_FS_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_KN_DispKBI_FS_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_KN_DispKBI_FS, getProfileInt( "Settings", "KCAN__STMSGSD_KN_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KN_DispKBI_FS, getProfileInt( "Settings", "KCAN__STMSGCT_KN_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KN_DispKBI_FS_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_KN_DispKBI_FS_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_KN_DispKBI_FS, getProfileInt( "Settings", "KCAN__STMSG_PO_KN_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_KN_DispKBI_FS, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_KN_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_KN_DispKBI_FS, getProfileInt( "Settings", "KCAN__MSG_SendNow_KN_DispKBI_FS", 0, profileFile ) );
    putValue( KCAN__MSGID_KN_Gateway, getProfileInt( "Settings", "KCAN__MSGID_KN_Gateway", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KN_Gateway, getProfileInt( "Settings", "KCAN__MSGDLC_KN_Gateway", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KN_Gateway_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_KN_Gateway_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_KN_Gateway, getProfileInt( "Settings", "KCAN__ALLDEF_KN_Gateway", 0, profileFile ) );
    putValue( KCAN__STMSG_KN_Gateway, getProfileInt( "Settings", "KCAN__STMSG_KN_Gateway", 0, profileFile ) );
    putValue( KCAN__STMSGT_KN_Gateway, getProfileInt( "Settings", "KCAN__STMSGT_KN_Gateway", 0, profileFile ) );
    putValue( KCAN__STMSGT_KN_Gateway_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_KN_Gateway_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_KN_Gateway, getProfileInt( "Settings", "KCAN__STMSGSD_KN_Gateway", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KN_Gateway, getProfileInt( "Settings", "KCAN__STMSGCT_KN_Gateway", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KN_Gateway_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_KN_Gateway_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_KN_Gateway, getProfileInt( "Settings", "KCAN__STMSG_PO_KN_Gateway", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_KN_Gateway, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_KN_Gateway", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_KN_Gateway, getProfileInt( "Settings", "KCAN__MSG_SendNow_KN_Gateway", 0, profileFile ) );
    putValue( KCAN__MSGID_KN_HUD, getProfileInt( "Settings", "KCAN__MSGID_KN_HUD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KN_HUD, getProfileInt( "Settings", "KCAN__MSGDLC_KN_HUD", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KN_HUD_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_KN_HUD_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_KN_HUD, getProfileInt( "Settings", "KCAN__ALLDEF_KN_HUD", 0, profileFile ) );
    putValue( KCAN__STMSG_KN_HUD, getProfileInt( "Settings", "KCAN__STMSG_KN_HUD", 0, profileFile ) );
    putValue( KCAN__STMSGT_KN_HUD, getProfileInt( "Settings", "KCAN__STMSGT_KN_HUD", 0, profileFile ) );
    putValue( KCAN__STMSGT_KN_HUD_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_KN_HUD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_KN_HUD, getProfileInt( "Settings", "KCAN__STMSGSD_KN_HUD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KN_HUD, getProfileInt( "Settings", "KCAN__STMSGCT_KN_HUD", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KN_HUD_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_KN_HUD_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_KN_HUD, getProfileInt( "Settings", "KCAN__STMSG_PO_KN_HUD", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_KN_HUD, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_KN_HUD", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_KN_HUD, getProfileInt( "Settings", "KCAN__MSG_SendNow_KN_HUD", 0, profileFile ) );
    putValue( KCAN__MSGID_KN_Info_El, getProfileInt( "Settings", "KCAN__MSGID_KN_Info_El", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KN_Info_El, getProfileInt( "Settings", "KCAN__MSGDLC_KN_Info_El", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KN_Info_El_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_KN_Info_El_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_KN_Info_El, getProfileInt( "Settings", "KCAN__ALLDEF_KN_Info_El", 0, profileFile ) );
    putValue( KCAN__STMSG_KN_Info_El, getProfileInt( "Settings", "KCAN__STMSG_KN_Info_El", 0, profileFile ) );
    putValue( KCAN__STMSGT_KN_Info_El, getProfileInt( "Settings", "KCAN__STMSGT_KN_Info_El", 0, profileFile ) );
    putValue( KCAN__STMSGT_KN_Info_El_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_KN_Info_El_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_KN_Info_El, getProfileInt( "Settings", "KCAN__STMSGSD_KN_Info_El", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KN_Info_El, getProfileInt( "Settings", "KCAN__STMSGCT_KN_Info_El", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KN_Info_El_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_KN_Info_El_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_KN_Info_El, getProfileInt( "Settings", "KCAN__STMSG_PO_KN_Info_El", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_KN_Info_El, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_KN_Info_El", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_KN_Info_El, getProfileInt( "Settings", "KCAN__MSG_SendNow_KN_Info_El", 0, profileFile ) );
    putValue( KCAN__MSGID_KN_Kombi, getProfileInt( "Settings", "KCAN__MSGID_KN_Kombi", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KN_Kombi, getProfileInt( "Settings", "KCAN__MSGDLC_KN_Kombi", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KN_Kombi_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_KN_Kombi_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_KN_Kombi, getProfileInt( "Settings", "KCAN__ALLDEF_KN_Kombi", 0, profileFile ) );
    putValue( KCAN__STMSG_KN_Kombi, getProfileInt( "Settings", "KCAN__STMSG_KN_Kombi", 0, profileFile ) );
    putValue( KCAN__STMSGT_KN_Kombi, getProfileInt( "Settings", "KCAN__STMSGT_KN_Kombi", 0, profileFile ) );
    putValue( KCAN__STMSGT_KN_Kombi_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_KN_Kombi_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_KN_Kombi, getProfileInt( "Settings", "KCAN__STMSGSD_KN_Kombi", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KN_Kombi, getProfileInt( "Settings", "KCAN__STMSGCT_KN_Kombi", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KN_Kombi_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_KN_Kombi_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_KN_Kombi, getProfileInt( "Settings", "KCAN__STMSG_PO_KN_Kombi", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_KN_Kombi, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_KN_Kombi", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_KN_Kombi, getProfileInt( "Settings", "KCAN__MSG_SendNow_KN_Kombi", 0, profileFile ) );
    putValue( KCAN__MSGID_KN_SmLi_1, getProfileInt( "Settings", "KCAN__MSGID_KN_SmLi_1", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KN_SmLi_1, getProfileInt( "Settings", "KCAN__MSGDLC_KN_SmLi_1", 0, profileFile ) );
    putValue( KCAN__MSGDLC_KN_SmLi_1_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_KN_SmLi_1_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_KN_SmLi_1, getProfileInt( "Settings", "KCAN__ALLDEF_KN_SmLi_1", 0, profileFile ) );
    putValue( KCAN__STMSG_KN_SmLi_1, getProfileInt( "Settings", "KCAN__STMSG_KN_SmLi_1", 0, profileFile ) );
    putValue( KCAN__STMSGT_KN_SmLi_1, getProfileInt( "Settings", "KCAN__STMSGT_KN_SmLi_1", 0, profileFile ) );
    putValue( KCAN__STMSGT_KN_SmLi_1_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_KN_SmLi_1_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_KN_SmLi_1, getProfileInt( "Settings", "KCAN__STMSGSD_KN_SmLi_1", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KN_SmLi_1, getProfileInt( "Settings", "KCAN__STMSGCT_KN_SmLi_1", 0, profileFile ) );
    putValue( KCAN__STMSGCT_KN_SmLi_1_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_KN_SmLi_1_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_KN_SmLi_1, getProfileInt( "Settings", "KCAN__STMSG_PO_KN_SmLi_1", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_KN_SmLi_1, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_KN_SmLi_1", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_KN_SmLi_1, getProfileInt( "Settings", "KCAN__MSG_SendNow_KN_SmLi_1", 0, profileFile ) );
    putValue( KCAN__MSGID_Kombi_01, getProfileInt( "Settings", "KCAN__MSGID_Kombi_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Kombi_01, getProfileInt( "Settings", "KCAN__MSGDLC_Kombi_01", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Kombi_01_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Kombi_01_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Kombi_01, getProfileInt( "Settings", "KCAN__ALLDEF_Kombi_01", 0, profileFile ) );
    putValue( KCAN__STMSG_Kombi_01, getProfileInt( "Settings", "KCAN__STMSG_Kombi_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Kombi_01, getProfileInt( "Settings", "KCAN__STMSGT_Kombi_01", 0, profileFile ) );
    putValue( KCAN__STMSGT_Kombi_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Kombi_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Kombi_01, getProfileInt( "Settings", "KCAN__STMSGSD_Kombi_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Kombi_01, getProfileInt( "Settings", "KCAN__STMSGCT_Kombi_01", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Kombi_01_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Kombi_01_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Kombi_01, getProfileInt( "Settings", "KCAN__STMSG_PO_Kombi_01", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Kombi_01, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Kombi_01", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Kombi_01, getProfileInt( "Settings", "KCAN__MSG_SendNow_Kombi_01", 0, profileFile ) );
    putValue( KCAN__MSGID_Kombi_02, getProfileInt( "Settings", "KCAN__MSGID_Kombi_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Kombi_02, getProfileInt( "Settings", "KCAN__MSGDLC_Kombi_02", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Kombi_02_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Kombi_02_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Kombi_02, getProfileInt( "Settings", "KCAN__ALLDEF_Kombi_02", 0, profileFile ) );
    putValue( KCAN__STMSG_Kombi_02, getProfileInt( "Settings", "KCAN__STMSG_Kombi_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_Kombi_02, getProfileInt( "Settings", "KCAN__STMSGT_Kombi_02", 0, profileFile ) );
    putValue( KCAN__STMSGT_Kombi_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Kombi_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Kombi_02, getProfileInt( "Settings", "KCAN__STMSGSD_Kombi_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Kombi_02, getProfileInt( "Settings", "KCAN__STMSGCT_Kombi_02", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Kombi_02_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Kombi_02_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Kombi_02, getProfileInt( "Settings", "KCAN__STMSG_PO_Kombi_02", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Kombi_02, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Kombi_02", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Kombi_02, getProfileInt( "Settings", "KCAN__MSG_SendNow_Kombi_02", 0, profileFile ) );
    putValue( KCAN__MSGID_Kombi_03, getProfileInt( "Settings", "KCAN__MSGID_Kombi_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Kombi_03, getProfileInt( "Settings", "KCAN__MSGDLC_Kombi_03", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Kombi_03_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Kombi_03_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Kombi_03, getProfileInt( "Settings", "KCAN__ALLDEF_Kombi_03", 0, profileFile ) );
    putValue( KCAN__STMSG_Kombi_03, getProfileInt( "Settings", "KCAN__STMSG_Kombi_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_Kombi_03, getProfileInt( "Settings", "KCAN__STMSGT_Kombi_03", 0, profileFile ) );
    putValue( KCAN__STMSGT_Kombi_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Kombi_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Kombi_03, getProfileInt( "Settings", "KCAN__STMSGSD_Kombi_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Kombi_03, getProfileInt( "Settings", "KCAN__STMSGCT_Kombi_03", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Kombi_03_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Kombi_03_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Kombi_03, getProfileInt( "Settings", "KCAN__STMSG_PO_Kombi_03", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Kombi_03, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Kombi_03", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Kombi_03, getProfileInt( "Settings", "KCAN__MSG_SendNow_Kombi_03", 0, profileFile ) );
    putValue( KCAN__MSGID_Kombi_08, getProfileInt( "Settings", "KCAN__MSGID_Kombi_08", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Kombi_08, getProfileInt( "Settings", "KCAN__MSGDLC_Kombi_08", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Kombi_08_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Kombi_08_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Kombi_08, getProfileInt( "Settings", "KCAN__ALLDEF_Kombi_08", 0, profileFile ) );
    putValue( KCAN__STMSG_Kombi_08, getProfileInt( "Settings", "KCAN__STMSG_Kombi_08", 0, profileFile ) );
    putValue( KCAN__STMSGT_Kombi_08, getProfileInt( "Settings", "KCAN__STMSGT_Kombi_08", 0, profileFile ) );
    putValue( KCAN__STMSGT_Kombi_08_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Kombi_08_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Kombi_08, getProfileInt( "Settings", "KCAN__STMSGSD_Kombi_08", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Kombi_08, getProfileInt( "Settings", "KCAN__STMSGCT_Kombi_08", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Kombi_08_CTRL, getProfileInt( "Settings", "KCAN__STMSGCT_Kombi_08_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSG_PO_Kombi_08, getProfileInt( "Settings", "KCAN__STMSG_PO_Kombi_08", 0, profileFile ) );
    putValue( KCAN__MSGDLoadDefault_Kombi_08, getProfileInt( "Settings", "KCAN__MSGDLoadDefault_Kombi_08", 0, profileFile ) );
    putValue( KCAN__MSG_SendNow_Kombi_08, getProfileInt( "Settings", "KCAN__MSG_SendNow_Kombi_08", 0, profileFile ) );
    putValue( KCAN__MSGID_Kombi_21, getProfileInt( "Settings", "KCAN__MSGID_Kombi_21", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Kombi_21, getProfileInt( "Settings", "KCAN__MSGDLC_Kombi_21", 0, profileFile ) );
    putValue( KCAN__MSGDLC_Kombi_21_CTRL, getProfileInt( "Settings", "KCAN__MSGDLC_Kombi_21_CTRL", 0, profileFile ) );
    putValue( KCAN__ALLDEF_Kombi_21, getProfileInt( "Settings", "KCAN__ALLDEF_Kombi_21", 0, profileFile ) );
    putValue( KCAN__STMSG_Kombi_21, getProfileInt( "Settings", "KCAN__STMSG_Kombi_21", 0, profileFile ) );
    putValue( KCAN__STMSGT_Kombi_21, getProfileInt( "Settings", "KCAN__STMSGT_Kombi_21", 0, profileFile ) );
    putValue( KCAN__STMSGT_Kombi_21_CTRL, getProfileInt( "Settings", "KCAN__STMSGT_Kombi_21_CTRL", 0, profileFile ) );
    putValue( KCAN__STMSGSD_Kombi_21, getProfileInt( "Settings", "KCAN__STMSGSD_Kombi_21", 0, profileFile ) );
    putValue( KCAN__STMSGCT_Kombi_21, getProfileInt( "Settings", "KCAN__STMSGCT_Kombi_21", 0, profileFile ) );
