    writeProfileInt("BAP" ,"env_NaviSD_ETC_Status_Extension1_hex" ,getValue(env_NaviSD_ETC_Status_Extension1_hex), profileFile);
    writeProfileInt("BAP" ,"env_NaviSD_ManeuverState_update" ,getValue(env_NaviSD_ManeuverState_update), profileFile);
    writeProfileInt("BAP" ,"env_NaviSD_ETC_Status_Status" ,getValue(env_NaviSD_ETC_Status_Status), profileFile);
    writeProfileInt("BAP" ,"env_NaviSD_FctList_0x37" ,getValue(env_NaviSD_FctList_0x37), profileFile);
    writeProfileInt("BAP" ,"env_NaviSD_FctList_0x38" ,getValue(env_NaviSD_FctList_0x38), profileFile);
    writeProfileInt("BAP" ,"env_NaviSD_DTD_DTDType" ,getValue(env_NaviSD_DTD_DTDType), profileFile);
    writeProfileInt("BAP" ,"env_NaviSD_RGActDeact_Result" ,getValue(env_NaviSD_RGActDeact_Result), profileFile);
    writeProfileInt("BAP" ,"env_NaviSD_NB_ASGID_error" ,getValue(env_NaviSD_NB_ASGID_error), profileFile);
    writeProfileInt("BAP" ,"env_NaviSD_NB_TAID_error" ,getValue(env_NaviSD_NB_TAID_error), profileFile);
    writeProfileInt("BAP" ,"env_NaviSD_POI_List_ErrorCode" ,getValue(env_NaviSD_POI_List_ErrorCode), profileFile);
    writeProfileInt("BAP" ,"env_NaviSD_POI_List_TimeOut" ,getValue(env_NaviSD_POI_List_TimeOut), profileFile);
    writeProfileInt("BAP" ,"env_NaviSD_POI_List_TAID_error" ,getValue(env_NaviSD_POI_List_TAID_error), profileFile);
    writeProfileInt("BAP" ,"env_NaviSD_POI_List_ASGID_error" ,getValue(env_NaviSD_POI_List_ASGID_error), profileFile);

}

void loadBAPSettings( char profileFile[] )
{
    putValue( ERRORLIST_ASG15_1_VT, getProfileInt( "BAP", "ERRORLIST_ASG15_1_VT", 0, profileFile ) );
    putValue( BusType_ASG15_1, getProfileInt( "BAP", "BusType_ASG15_1", 0, profileFile ) );
    putValue( ON_OFF_ASG15_1, getProfileInt( "BAP", "ON_OFF_ASG15_1", 0, profileFile ) );
    putValue( BAPCFG_ASG_15_1_0_DFMajor, getProfileInt( "BAP", "BAPCFG_ASG_15_1_0_DFMajor", 0, profileFile ) );
    putValue( BAPCFG_ASG_15_1_0_DFMinor, getProfileInt( "BAP", "BAPCFG_ASG_15_1_0_DFMinor", 0, profileFile ) );
    putValue( BAPCFG_ASG_15_1_0_LsgClassMajor, getProfileInt( "BAP", "BAPCFG_ASG_15_1_0_LsgClassMajor", 0, profileFile ) );
    putValue( BAPCFG_ASG_15_1_0_LsgClassMinor, getProfileInt( "BAP", "BAPCFG_ASG_15_1_0_LsgClassMinor", 0, profileFile ) );
    putValue( BAPCFG_ASG_15_1_0_ProtocolMajor, getProfileInt( "BAP", "BAPCFG_ASG_15_1_0_ProtocolMajor", 0, profileFile ) );
    putValue( BAPCFG_ASG_15_1_0_ProtocolMinor, getProfileInt( "BAP", "BAPCFG_ASG_15_1_0_ProtocolMinor", 0, profileFile ) );
    putValue( C_ASG_15_1_0_1GetAll_BTN, getProfileInt( "BAP", "C_ASG_15_1_0_1GetAll_BTN", 0, profileFile ) );
    putValue( C_ASG_15_1_0_1_FctLstItemEn, getProfileInt( "BAP", "C_ASG_15_1_0_1_FctLstItemEn", 0, profileFile ) );
    putValue( C_ASG_15_1_0_1_ErrCode, getProfileInt( "BAP", "C_ASG_15_1_0_1_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_2Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_2Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_2_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_2_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_2_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_2_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_2, getProfileFloat( "BAP", "P_ASG_15_1_0_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_2_range, getProfileFloat( "BAP", "P_ASG_15_1_0_2_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_3Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_3Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_3_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_3_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_3_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_3_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_4Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_4Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_4_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_4_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_4_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_4_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_4, getProfileInt( "BAP", "P_ASG_15_1_0_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_13Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_13Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_13SetGet_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_13SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_13_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_13_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_13_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_13_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_13, getProfileInt( "BAP", "P_ASG_15_1_0_13", 0, profileFile ) );
    putValue( P_ASG_15_1_0_13_1, getProfileInt( "BAP", "P_ASG_15_1_0_13_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_13_1_0, getProfileInt( "BAP", "P_ASG_15_1_0_13_1_0", 0, profileFile ) );
    putValue( P_ASG_15_1_0_13_1_4, getProfileInt( "BAP", "P_ASG_15_1_0_13_1_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_14Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_14_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_14_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_6, getProfileFloat( "BAP", "P_ASG_15_1_0_14_6", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_6_range, getProfileFloat( "BAP", "P_ASG_15_1_0_14_6_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_2, getProfileInt( "BAP", "P_ASG_15_1_0_14_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_2_0, getProfileInt( "BAP", "P_ASG_15_1_0_14_2_0", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_2_1, getProfileInt( "BAP", "P_ASG_15_1_0_14_2_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_2_2, getProfileInt( "BAP", "P_ASG_15_1_0_14_2_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_1, getProfileInt( "BAP", "P_ASG_15_1_0_14_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_1_0, getProfileInt( "BAP", "P_ASG_15_1_0_14_1_0", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_1_1, getProfileInt( "BAP", "P_ASG_15_1_0_14_1_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_1_2, getProfileInt( "BAP", "P_ASG_15_1_0_14_1_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_1_3, getProfileInt( "BAP", "P_ASG_15_1_0_14_1_3", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_1_4, getProfileInt( "BAP", "P_ASG_15_1_0_14_1_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_1_5, getProfileInt( "BAP", "P_ASG_15_1_0_14_1_5", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_1_6, getProfileInt( "BAP", "P_ASG_15_1_0_14_1_6", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_1_7, getProfileInt( "BAP", "P_ASG_15_1_0_14_1_7", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_1_8, getProfileInt( "BAP", "P_ASG_15_1_0_14_1_8", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_1_9, getProfileInt( "BAP", "P_ASG_15_1_0_14_1_9", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_1_10, getProfileInt( "BAP", "P_ASG_15_1_0_14_1_10", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_1_11, getProfileInt( "BAP", "P_ASG_15_1_0_14_1_11", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_1_12, getProfileInt( "BAP", "P_ASG_15_1_0_14_1_12", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_1_13, getProfileInt( "BAP", "P_ASG_15_1_0_14_1_13", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_1_14, getProfileInt( "BAP", "P_ASG_15_1_0_14_1_14", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_1_15, getProfileInt( "BAP", "P_ASG_15_1_0_14_1_15", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_4, getProfileInt( "BAP", "P_ASG_15_1_0_14_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_5, getProfileInt( "BAP", "P_ASG_15_1_0_14_5", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_5_0, getProfileInt( "BAP", "P_ASG_15_1_0_14_5_0", 0, profileFile ) );
    putValue( P_ASG_15_1_0_14_3, getProfileInt( "BAP", "P_ASG_15_1_0_14_3", 0, profileFile ) );
    putValue( P_ASG_15_1_0_15Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_15Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_15_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_15_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_15_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_15_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_15, getProfileInt( "BAP", "P_ASG_15_1_0_15", 0, profileFile ) );
    putValue( P_ASG_15_1_0_15_1, getProfileInt( "BAP", "P_ASG_15_1_0_15_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_16Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16SetGet_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_16SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_16_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_IntTlgEn, getProfileInt( "BAP", "P_ASG_15_1_0_16_IntTlgEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_SegmEn, getProfileInt( "BAP", "P_ASG_15_1_0_16_SegmEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_16_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_6, getProfileFloat( "BAP", "P_ASG_15_1_0_16_6", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_6_range, getProfileFloat( "BAP", "P_ASG_15_1_0_16_6_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_4, getProfileInt( "BAP", "P_ASG_15_1_0_16_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_4_0, getProfileInt( "BAP", "P_ASG_15_1_0_16_4_0", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_4_1, getProfileInt( "BAP", "P_ASG_15_1_0_16_4_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_4_2, getProfileInt( "BAP", "P_ASG_15_1_0_16_4_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_4_3, getProfileInt( "BAP", "P_ASG_15_1_0_16_4_3", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_4_4, getProfileInt( "BAP", "P_ASG_15_1_0_16_4_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_4_5, getProfileInt( "BAP", "P_ASG_15_1_0_16_4_5", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_4_6, getProfileInt( "BAP", "P_ASG_15_1_0_16_4_6", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_4_7, getProfileInt( "BAP", "P_ASG_15_1_0_16_4_7", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_1, getProfileInt( "BAP", "P_ASG_15_1_0_16_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_1_0, getProfileInt( "BAP", "P_ASG_15_1_0_16_1_0", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_1_1, getProfileInt( "BAP", "P_ASG_15_1_0_16_1_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_1_2, getProfileInt( "BAP", "P_ASG_15_1_0_16_1_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_1_3, getProfileInt( "BAP", "P_ASG_15_1_0_16_1_3", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_1_4, getProfileInt( "BAP", "P_ASG_15_1_0_16_1_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_1_5, getProfileInt( "BAP", "P_ASG_15_1_0_16_1_5", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_1_6, getProfileInt( "BAP", "P_ASG_15_1_0_16_1_6", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_1_7, getProfileInt( "BAP", "P_ASG_15_1_0_16_1_7", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_1_8, getProfileInt( "BAP", "P_ASG_15_1_0_16_1_8", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_1_9, getProfileInt( "BAP", "P_ASG_15_1_0_16_1_9", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_1_10, getProfileInt( "BAP", "P_ASG_15_1_0_16_1_10", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_1_11, getProfileInt( "BAP", "P_ASG_15_1_0_16_1_11", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_1_12, getProfileInt( "BAP", "P_ASG_15_1_0_16_1_12", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_1_13, getProfileInt( "BAP", "P_ASG_15_1_0_16_1_13", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_1_14, getProfileInt( "BAP", "P_ASG_15_1_0_16_1_14", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_5, getProfileFloat( "BAP", "P_ASG_15_1_0_16_5", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_5_range, getProfileFloat( "BAP", "P_ASG_15_1_0_16_5_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_3, getProfileInt( "BAP", "P_ASG_15_1_0_16_3", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_3_0, getProfileInt( "BAP", "P_ASG_15_1_0_16_3_0", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_3_1, getProfileInt( "BAP", "P_ASG_15_1_0_16_3_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_3_2, getProfileInt( "BAP", "P_ASG_15_1_0_16_3_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_3_3, getProfileInt( "BAP", "P_ASG_15_1_0_16_3_3", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_3_4, getProfileInt( "BAP", "P_ASG_15_1_0_16_3_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_3_5, getProfileInt( "BAP", "P_ASG_15_1_0_16_3_5", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_3_6, getProfileInt( "BAP", "P_ASG_15_1_0_16_3_6", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_3_7, getProfileInt( "BAP", "P_ASG_15_1_0_16_3_7", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_3_8, getProfileInt( "BAP", "P_ASG_15_1_0_16_3_8", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_3_9, getProfileInt( "BAP", "P_ASG_15_1_0_16_3_9", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_3_10, getProfileInt( "BAP", "P_ASG_15_1_0_16_3_10", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_3_11, getProfileInt( "BAP", "P_ASG_15_1_0_16_3_11", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_3_12, getProfileInt( "BAP", "P_ASG_15_1_0_16_3_12", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_3_13, getProfileInt( "BAP", "P_ASG_15_1_0_16_3_13", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_3_14, getProfileInt( "BAP", "P_ASG_15_1_0_16_3_14", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_2, getProfileInt( "BAP", "P_ASG_15_1_0_16_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_2_0, getProfileInt( "BAP", "P_ASG_15_1_0_16_2_0", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_2_1, getProfileInt( "BAP", "P_ASG_15_1_0_16_2_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_2_2, getProfileInt( "BAP", "P_ASG_15_1_0_16_2_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_2_3, getProfileInt( "BAP", "P_ASG_15_1_0_16_2_3", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_2_4, getProfileInt( "BAP", "P_ASG_15_1_0_16_2_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_2_5, getProfileInt( "BAP", "P_ASG_15_1_0_16_2_5", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_2_6, getProfileInt( "BAP", "P_ASG_15_1_0_16_2_6", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_2_7, getProfileInt( "BAP", "P_ASG_15_1_0_16_2_7", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_2_8, getProfileInt( "BAP", "P_ASG_15_1_0_16_2_8", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_2_9, getProfileInt( "BAP", "P_ASG_15_1_0_16_2_9", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_2_10, getProfileInt( "BAP", "P_ASG_15_1_0_16_2_10", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_2_11, getProfileInt( "BAP", "P_ASG_15_1_0_16_2_11", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_2_12, getProfileInt( "BAP", "P_ASG_15_1_0_16_2_12", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_2_13, getProfileInt( "BAP", "P_ASG_15_1_0_16_2_13", 0, profileFile ) );
    putValue( P_ASG_15_1_0_16_2_14, getProfileInt( "BAP", "P_ASG_15_1_0_16_2_14", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17StartResult_BTN, getProfileInt( "BAP", "M_ASG_15_1_0_17StartResult_BTN", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_FctLstItemEn, getProfileInt( "BAP", "M_ASG_15_1_0_17_FctLstItemEn", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_ErrCode, getProfileInt( "BAP", "M_ASG_15_1_0_17_ErrCode", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Result, getProfileInt( "BAP", "M_ASG_15_1_0_17_Result", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Result_1, getProfileInt( "BAP", "M_ASG_15_1_0_17_Result_1", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Result_1_0, getProfileInt( "BAP", "M_ASG_15_1_0_17_Result_1_0", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Processing, getProfileInt( "BAP", "M_ASG_15_1_0_17_Processing", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Processing_1, getProfileInt( "BAP", "M_ASG_15_1_0_17_Processing_1", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Processing_1_1, getProfileInt( "BAP", "M_ASG_15_1_0_17_Processing_1_1", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Processing_1_2, getProfileInt( "BAP", "M_ASG_15_1_0_17_Processing_1_2", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Processing_1_3, getProfileInt( "BAP", "M_ASG_15_1_0_17_Processing_1_3", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Processing_1_4, getProfileInt( "BAP", "M_ASG_15_1_0_17_Processing_1_4", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Processing_1_5, getProfileInt( "BAP", "M_ASG_15_1_0_17_Processing_1_5", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Processing_1_6, getProfileInt( "BAP", "M_ASG_15_1_0_17_Processing_1_6", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Processing_1_7, getProfileInt( "BAP", "M_ASG_15_1_0_17_Processing_1_7", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Start, getProfileInt( "BAP", "M_ASG_15_1_0_17_Start", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Start_1, getProfileInt( "BAP", "M_ASG_15_1_0_17_Start_1", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Start_1_1, getProfileInt( "BAP", "M_ASG_15_1_0_17_Start_1_1", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Start_1_2, getProfileInt( "BAP", "M_ASG_15_1_0_17_Start_1_2", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Start_1_3, getProfileInt( "BAP", "M_ASG_15_1_0_17_Start_1_3", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Start_1_4, getProfileInt( "BAP", "M_ASG_15_1_0_17_Start_1_4", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Start_1_5, getProfileInt( "BAP", "M_ASG_15_1_0_17_Start_1_5", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Start_1_6, getProfileInt( "BAP", "M_ASG_15_1_0_17_Start_1_6", 0, profileFile ) );
    putValue( M_ASG_15_1_0_17_Start_1_7, getProfileInt( "BAP", "M_ASG_15_1_0_17_Start_1_7", 0, profileFile ) );
    putValue( P_ASG_15_1_0_18Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_18Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_18SetGet_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_18SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_18_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_18_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_18_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_18_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_18_2, getProfileFloat( "BAP", "P_ASG_15_1_0_18_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_18_2_range, getProfileFloat( "BAP", "P_ASG_15_1_0_18_2_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_18_4, getProfileFloat( "BAP", "P_ASG_15_1_0_18_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_18_4_range, getProfileFloat( "BAP", "P_ASG_15_1_0_18_4_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_18_1, getProfileInt( "BAP", "P_ASG_15_1_0_18_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_18_1_0, getProfileInt( "BAP", "P_ASG_15_1_0_18_1_0", 0, profileFile ) );
    putValue( P_ASG_15_1_0_18_3, getProfileInt( "BAP", "P_ASG_15_1_0_18_3", 0, profileFile ) );
    putValue( P_ASG_15_1_0_19Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_19Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_19_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_19_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_19_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_19_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_19_4, getProfileInt( "BAP", "P_ASG_15_1_0_19_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_19_2, getProfileInt( "BAP", "P_ASG_15_1_0_19_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_19_1, getProfileFloat( "BAP", "P_ASG_15_1_0_19_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_19_1_range, getProfileFloat( "BAP", "P_ASG_15_1_0_19_1_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_19_3, getProfileFloat( "BAP", "P_ASG_15_1_0_19_3", 0, profileFile ) );
    putValue( P_ASG_15_1_0_19_3_range, getProfileFloat( "BAP", "P_ASG_15_1_0_19_3_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_20Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_20Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_20_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_20_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_20_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_20_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_20_3, getProfileFloat( "BAP", "P_ASG_15_1_0_20_3", 0, profileFile ) );
    putValue( P_ASG_15_1_0_20_3_range, getProfileFloat( "BAP", "P_ASG_15_1_0_20_3_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_20_1, getProfileFloat( "BAP", "P_ASG_15_1_0_20_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_20_1_range, getProfileFloat( "BAP", "P_ASG_15_1_0_20_1_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_20_2, getProfileFloat( "BAP", "P_ASG_15_1_0_20_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_20_2_range, getProfileFloat( "BAP", "P_ASG_15_1_0_20_2_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_20_4, getProfileInt( "BAP", "P_ASG_15_1_0_20_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_21Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_21Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_21_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_21_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_21_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_21_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_21_2, getProfileInt( "BAP", "P_ASG_15_1_0_21_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_21_1, getProfileFloat( "BAP", "P_ASG_15_1_0_21_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_21_1_range, getProfileFloat( "BAP", "P_ASG_15_1_0_21_1_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_22Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_22Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_22_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_22_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_22_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_22_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_22_7, getProfileFloat( "BAP", "P_ASG_15_1_0_22_7", 0, profileFile ) );
    putValue( P_ASG_15_1_0_22_7_range, getProfileFloat( "BAP", "P_ASG_15_1_0_22_7_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_22_5, getProfileFloat( "BAP", "P_ASG_15_1_0_22_5", 0, profileFile ) );
    putValue( P_ASG_15_1_0_22_5_range, getProfileFloat( "BAP", "P_ASG_15_1_0_22_5_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_22_1, getProfileFloat( "BAP", "P_ASG_15_1_0_22_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_22_1_range, getProfileFloat( "BAP", "P_ASG_15_1_0_22_1_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_22_8, getProfileInt( "BAP", "P_ASG_15_1_0_22_8", 0, profileFile ) );
    putValue( P_ASG_15_1_0_22_2, getProfileInt( "BAP", "P_ASG_15_1_0_22_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_22_6, getProfileInt( "BAP", "P_ASG_15_1_0_22_6", 0, profileFile ) );
    putValue( P_ASG_15_1_0_22_9, getProfileFloat( "BAP", "P_ASG_15_1_0_22_9", 0, profileFile ) );
    putValue( P_ASG_15_1_0_22_9_range, getProfileFloat( "BAP", "P_ASG_15_1_0_22_9_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_22_3, getProfileFloat( "BAP", "P_ASG_15_1_0_22_3", 0, profileFile ) );
    putValue( P_ASG_15_1_0_22_3_range, getProfileFloat( "BAP", "P_ASG_15_1_0_22_3_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_22_4, getProfileInt( "BAP", "P_ASG_15_1_0_22_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_23Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_23_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_23_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_11, getProfileFloat( "BAP", "P_ASG_15_1_0_23_11", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_11_range, getProfileFloat( "BAP", "P_ASG_15_1_0_23_11_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_10, getProfileFloat( "BAP", "P_ASG_15_1_0_23_10", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_10_range, getProfileFloat( "BAP", "P_ASG_15_1_0_23_10_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_9, getProfileFloat( "BAP", "P_ASG_15_1_0_23_9", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_9_range, getProfileFloat( "BAP", "P_ASG_15_1_0_23_9_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_8, getProfileFloat( "BAP", "P_ASG_15_1_0_23_8", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_8_range, getProfileFloat( "BAP", "P_ASG_15_1_0_23_8_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_7, getProfileFloat( "BAP", "P_ASG_15_1_0_23_7", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_7_range, getProfileFloat( "BAP", "P_ASG_15_1_0_23_7_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_6, getProfileFloat( "BAP", "P_ASG_15_1_0_23_6", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_6_range, getProfileFloat( "BAP", "P_ASG_15_1_0_23_6_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_5, getProfileFloat( "BAP", "P_ASG_15_1_0_23_5", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_5_range, getProfileFloat( "BAP", "P_ASG_15_1_0_23_5_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_1, getProfileFloat( "BAP", "P_ASG_15_1_0_23_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_1_range, getProfileFloat( "BAP", "P_ASG_15_1_0_23_1_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_4, getProfileInt( "BAP", "P_ASG_15_1_0_23_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_2, getProfileInt( "BAP", "P_ASG_15_1_0_23_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_3, getProfileFloat( "BAP", "P_ASG_15_1_0_23_3", 0, profileFile ) );
    putValue( P_ASG_15_1_0_23_3_range, getProfileFloat( "BAP", "P_ASG_15_1_0_23_3_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_24Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_24Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_24_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_24_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_24_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_24_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_24_7, getProfileFloat( "BAP", "P_ASG_15_1_0_24_7", 0, profileFile ) );
    putValue( P_ASG_15_1_0_24_7_range, getProfileFloat( "BAP", "P_ASG_15_1_0_24_7_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_24_5, getProfileFloat( "BAP", "P_ASG_15_1_0_24_5", 0, profileFile ) );
    putValue( P_ASG_15_1_0_24_5_range, getProfileFloat( "BAP", "P_ASG_15_1_0_24_5_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_24_1, getProfileFloat( "BAP", "P_ASG_15_1_0_24_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_24_1_range, getProfileFloat( "BAP", "P_ASG_15_1_0_24_1_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_24_8, getProfileInt( "BAP", "P_ASG_15_1_0_24_8", 0, profileFile ) );
    putValue( P_ASG_15_1_0_24_2, getProfileInt( "BAP", "P_ASG_15_1_0_24_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_24_6, getProfileInt( "BAP", "P_ASG_15_1_0_24_6", 0, profileFile ) );
    putValue( P_ASG_15_1_0_24_9, getProfileFloat( "BAP", "P_ASG_15_1_0_24_9", 0, profileFile ) );
    putValue( P_ASG_15_1_0_24_9_range, getProfileFloat( "BAP", "P_ASG_15_1_0_24_9_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_24_3, getProfileFloat( "BAP", "P_ASG_15_1_0_24_3", 0, profileFile ) );
    putValue( P_ASG_15_1_0_24_3_range, getProfileFloat( "BAP", "P_ASG_15_1_0_24_3_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_24_4, getProfileInt( "BAP", "P_ASG_15_1_0_24_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_25Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_25_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_25_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_11, getProfileFloat( "BAP", "P_ASG_15_1_0_25_11", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_11_range, getProfileFloat( "BAP", "P_ASG_15_1_0_25_11_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_10, getProfileFloat( "BAP", "P_ASG_15_1_0_25_10", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_10_range, getProfileFloat( "BAP", "P_ASG_15_1_0_25_10_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_9, getProfileFloat( "BAP", "P_ASG_15_1_0_25_9", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_9_range, getProfileFloat( "BAP", "P_ASG_15_1_0_25_9_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_8, getProfileFloat( "BAP", "P_ASG_15_1_0_25_8", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_8_range, getProfileFloat( "BAP", "P_ASG_15_1_0_25_8_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_7, getProfileFloat( "BAP", "P_ASG_15_1_0_25_7", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_7_range, getProfileFloat( "BAP", "P_ASG_15_1_0_25_7_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_6, getProfileFloat( "BAP", "P_ASG_15_1_0_25_6", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_6_range, getProfileFloat( "BAP", "P_ASG_15_1_0_25_6_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_5, getProfileFloat( "BAP", "P_ASG_15_1_0_25_5", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_5_range, getProfileFloat( "BAP", "P_ASG_15_1_0_25_5_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_1, getProfileFloat( "BAP", "P_ASG_15_1_0_25_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_1_range, getProfileFloat( "BAP", "P_ASG_15_1_0_25_1_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_4, getProfileInt( "BAP", "P_ASG_15_1_0_25_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_2, getProfileInt( "BAP", "P_ASG_15_1_0_25_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_3, getProfileFloat( "BAP", "P_ASG_15_1_0_25_3", 0, profileFile ) );
    putValue( P_ASG_15_1_0_25_3_range, getProfileFloat( "BAP", "P_ASG_15_1_0_25_3_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_26Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_26Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_26_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_26_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_26_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_26_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_26_7, getProfileFloat( "BAP", "P_ASG_15_1_0_26_7", 0, profileFile ) );
    putValue( P_ASG_15_1_0_26_7_range, getProfileFloat( "BAP", "P_ASG_15_1_0_26_7_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_26_5, getProfileFloat( "BAP", "P_ASG_15_1_0_26_5", 0, profileFile ) );
    putValue( P_ASG_15_1_0_26_5_range, getProfileFloat( "BAP", "P_ASG_15_1_0_26_5_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_26_1, getProfileFloat( "BAP", "P_ASG_15_1_0_26_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_26_1_range, getProfileFloat( "BAP", "P_ASG_15_1_0_26_1_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_26_8, getProfileInt( "BAP", "P_ASG_15_1_0_26_8", 0, profileFile ) );
    putValue( P_ASG_15_1_0_26_2, getProfileInt( "BAP", "P_ASG_15_1_0_26_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_26_6, getProfileInt( "BAP", "P_ASG_15_1_0_26_6", 0, profileFile ) );
    putValue( P_ASG_15_1_0_26_9, getProfileFloat( "BAP", "P_ASG_15_1_0_26_9", 0, profileFile ) );
    putValue( P_ASG_15_1_0_26_9_range, getProfileFloat( "BAP", "P_ASG_15_1_0_26_9_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_26_3, getProfileFloat( "BAP", "P_ASG_15_1_0_26_3", 0, profileFile ) );
    putValue( P_ASG_15_1_0_26_3_range, getProfileFloat( "BAP", "P_ASG_15_1_0_26_3_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_26_4, getProfileInt( "BAP", "P_ASG_15_1_0_26_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_27Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_27_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_27_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_11, getProfileFloat( "BAP", "P_ASG_15_1_0_27_11", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_11_range, getProfileFloat( "BAP", "P_ASG_15_1_0_27_11_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_10, getProfileFloat( "BAP", "P_ASG_15_1_0_27_10", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_10_range, getProfileFloat( "BAP", "P_ASG_15_1_0_27_10_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_9, getProfileFloat( "BAP", "P_ASG_15_1_0_27_9", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_9_range, getProfileFloat( "BAP", "P_ASG_15_1_0_27_9_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_8, getProfileFloat( "BAP", "P_ASG_15_1_0_27_8", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_8_range, getProfileFloat( "BAP", "P_ASG_15_1_0_27_8_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_7, getProfileFloat( "BAP", "P_ASG_15_1_0_27_7", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_7_range, getProfileFloat( "BAP", "P_ASG_15_1_0_27_7_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_6, getProfileFloat( "BAP", "P_ASG_15_1_0_27_6", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_6_range, getProfileFloat( "BAP", "P_ASG_15_1_0_27_6_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_5, getProfileFloat( "BAP", "P_ASG_15_1_0_27_5", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_5_range, getProfileFloat( "BAP", "P_ASG_15_1_0_27_5_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_1, getProfileFloat( "BAP", "P_ASG_15_1_0_27_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_1_range, getProfileFloat( "BAP", "P_ASG_15_1_0_27_1_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_4, getProfileInt( "BAP", "P_ASG_15_1_0_27_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_2, getProfileInt( "BAP", "P_ASG_15_1_0_27_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_3, getProfileFloat( "BAP", "P_ASG_15_1_0_27_3", 0, profileFile ) );
    putValue( P_ASG_15_1_0_27_3_range, getProfileFloat( "BAP", "P_ASG_15_1_0_27_3_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_28Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_28_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_28_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_2_Year, getProfileFloat( "BAP", "P_ASG_15_1_0_28_2_Year", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_2_Year_range, getProfileFloat( "BAP", "P_ASG_15_1_0_28_2_Year_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_2_Month, getProfileFloat( "BAP", "P_ASG_15_1_0_28_2_Month", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_2_Month_range, getProfileFloat( "BAP", "P_ASG_15_1_0_28_2_Month_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_2_Day, getProfileFloat( "BAP", "P_ASG_15_1_0_28_2_Day", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_2_Day_range, getProfileFloat( "BAP", "P_ASG_15_1_0_28_2_Day_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_2_Hour, getProfileFloat( "BAP", "P_ASG_15_1_0_28_2_Hour", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_2_Hour_range, getProfileFloat( "BAP", "P_ASG_15_1_0_28_2_Hour_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_2_Minute, getProfileFloat( "BAP", "P_ASG_15_1_0_28_2_Minute", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_2_Minute_range, getProfileFloat( "BAP", "P_ASG_15_1_0_28_2_Minute_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_1_Year, getProfileFloat( "BAP", "P_ASG_15_1_0_28_1_Year", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_1_Year_range, getProfileFloat( "BAP", "P_ASG_15_1_0_28_1_Year_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_1_Month, getProfileFloat( "BAP", "P_ASG_15_1_0_28_1_Month", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_1_Month_range, getProfileFloat( "BAP", "P_ASG_15_1_0_28_1_Month_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_1_Day, getProfileFloat( "BAP", "P_ASG_15_1_0_28_1_Day", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_1_Day_range, getProfileFloat( "BAP", "P_ASG_15_1_0_28_1_Day_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_1_Hour, getProfileFloat( "BAP", "P_ASG_15_1_0_28_1_Hour", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_1_Hour_range, getProfileFloat( "BAP", "P_ASG_15_1_0_28_1_Hour_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_1_Minute, getProfileFloat( "BAP", "P_ASG_15_1_0_28_1_Minute", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_1_Minute_range, getProfileFloat( "BAP", "P_ASG_15_1_0_28_1_Minute_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_3_Year, getProfileFloat( "BAP", "P_ASG_15_1_0_28_3_Year", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_3_Year_range, getProfileFloat( "BAP", "P_ASG_15_1_0_28_3_Year_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_3_Month, getProfileFloat( "BAP", "P_ASG_15_1_0_28_3_Month", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_3_Month_range, getProfileFloat( "BAP", "P_ASG_15_1_0_28_3_Month_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_3_Day, getProfileFloat( "BAP", "P_ASG_15_1_0_28_3_Day", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_3_Day_range, getProfileFloat( "BAP", "P_ASG_15_1_0_28_3_Day_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_3_Hour, getProfileFloat( "BAP", "P_ASG_15_1_0_28_3_Hour", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_3_Hour_range, getProfileFloat( "BAP", "P_ASG_15_1_0_28_3_Hour_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_3_Minute, getProfileFloat( "BAP", "P_ASG_15_1_0_28_3_Minute", 0, profileFile ) );
    putValue( P_ASG_15_1_0_28_3_Minute_range, getProfileFloat( "BAP", "P_ASG_15_1_0_28_3_Minute_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_29Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_29Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_29_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_29_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_29_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_29_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_29_2, getProfileFloat( "BAP", "P_ASG_15_1_0_29_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_29_2_range, getProfileFloat( "BAP", "P_ASG_15_1_0_29_2_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_29_1, getProfileFloat( "BAP", "P_ASG_15_1_0_29_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_29_1_range, getProfileFloat( "BAP", "P_ASG_15_1_0_29_1_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_30Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_30Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_30_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_30_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_30_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_30_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_30_4, getProfileInt( "BAP", "P_ASG_15_1_0_30_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_30_2, getProfileInt( "BAP", "P_ASG_15_1_0_30_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_30_3, getProfileFloat( "BAP", "P_ASG_15_1_0_30_3", 0, profileFile ) );
    putValue( P_ASG_15_1_0_30_3_range, getProfileFloat( "BAP", "P_ASG_15_1_0_30_3_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_30_1, getProfileFloat( "BAP", "P_ASG_15_1_0_30_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_30_1_range, getProfileFloat( "BAP", "P_ASG_15_1_0_30_1_range", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31Get_BTN, getProfileInt( "BAP", "A_ASG_15_1_0_31Get_BTN", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_FctLstItemEn, getProfileInt( "BAP", "A_ASG_15_1_0_31_FctLstItemEn", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_IntTlgEn, getProfileInt( "BAP", "A_ASG_15_1_0_31_IntTlgEn", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_SegmEn, getProfileInt( "BAP", "A_ASG_15_1_0_31_SegmEn", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_AT, getProfileInt( "BAP", "A_ASG_15_1_0_31_AT", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_ErrCode, getProfileInt( "BAP", "A_ASG_15_1_0_31_ErrCode", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_DataIndex, getProfileInt( "BAP", "A_ASG_15_1_0_31_DataIndex", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_DataIndex_Incr, getProfileInt( "BAP", "A_ASG_15_1_0_31_DataIndex_Incr", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_DataIndex_Decr, getProfileInt( "BAP", "A_ASG_15_1_0_31_DataIndex_Decr", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_loadArray_Btn, getProfileInt( "BAP", "A_ASG_15_1_0_31_loadArray_Btn", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_generateData_Btn, getProfileInt( "BAP", "A_ASG_15_1_0_31_generateData_Btn", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_Data_4_len, getProfileInt( "BAP", "A_ASG_15_1_0_31_Data_4_len", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_Data_4_cnt, getProfileInt( "BAP", "A_ASG_15_1_0_31_Data_4_cnt", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_2, getProfileFloat( "BAP", "A_ASG_15_1_0_31_2", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_2_range, getProfileFloat( "BAP", "A_ASG_15_1_0_31_2_range", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_1, getProfileInt( "BAP", "A_ASG_15_1_0_31_1", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_Data_1, getProfileFloat( "BAP", "A_ASG_15_1_0_31_Data_1", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_Data_1_range, getProfileFloat( "BAP", "A_ASG_15_1_0_31_Data_1_range", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_3, getProfileFloat( "BAP", "A_ASG_15_1_0_31_3", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_3_range, getProfileFloat( "BAP", "A_ASG_15_1_0_31_3_range", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_Data_2, getProfileInt( "BAP", "A_ASG_15_1_0_31_Data_2", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_Data_3_len, getProfileInt( "BAP", "A_ASG_15_1_0_31_Data_3_len", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_Data_3_cnt, getProfileInt( "BAP", "A_ASG_15_1_0_31_Data_3_cnt", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_RecAdr, getProfileInt( "BAP", "A_ASG_15_1_0_31_RecAdr", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_Direction, getProfileInt( "BAP", "A_ASG_15_1_0_31_Direction", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_Shift, getProfileInt( "BAP", "A_ASG_15_1_0_31_Shift", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_TransPos, getProfileInt( "BAP", "A_ASG_15_1_0_31_TransPos", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_IndexSize, getProfileInt( "BAP", "A_ASG_15_1_0_31_IndexSize", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_Start, getProfileInt( "BAP", "A_ASG_15_1_0_31_Start", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_Elements, getProfileInt( "BAP", "A_ASG_15_1_0_31_Elements", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_Changed_RecAdr, getProfileInt( "BAP", "A_ASG_15_1_0_31_Changed_RecAdr", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_Changed_Direction, getProfileInt( "BAP", "A_ASG_15_1_0_31_Changed_Direction", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_Changed_Shift, getProfileInt( "BAP", "A_ASG_15_1_0_31_Changed_Shift", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_Changed_TransPos, getProfileInt( "BAP", "A_ASG_15_1_0_31_Changed_TransPos", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_Changed_IndexSize, getProfileInt( "BAP", "A_ASG_15_1_0_31_Changed_IndexSize", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_Changed_Start, getProfileInt( "BAP", "A_ASG_15_1_0_31_Changed_Start", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_Changed_Elements, getProfileInt( "BAP", "A_ASG_15_1_0_31_Changed_Elements", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_2_SetGet, getProfileFloat( "BAP", "A_ASG_15_1_0_31_2_SetGet", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_2_SetGet_range, getProfileFloat( "BAP", "A_ASG_15_1_0_31_2_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_1_SetGet, getProfileInt( "BAP", "A_ASG_15_1_0_31_1_SetGet", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_SetGet_RecAdr, getProfileInt( "BAP", "A_ASG_15_1_0_31_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_SetGet_Direction, getProfileInt( "BAP", "A_ASG_15_1_0_31_SetGet_Direction", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_SetGet_Shift, getProfileInt( "BAP", "A_ASG_15_1_0_31_SetGet_Shift", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_SetGet_IndexSize, getProfileInt( "BAP", "A_ASG_15_1_0_31_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_SetGet_Start, getProfileInt( "BAP", "A_ASG_15_1_0_31_SetGet_Start", 0, profileFile ) );
    putValue( A_ASG_15_1_0_31_SetGet_Elements, getProfileInt( "BAP", "A_ASG_15_1_0_31_SetGet_Elements", 0, profileFile ) );
    putValue( P_ASG_15_1_0_32Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_32Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_32_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_32_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_32_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_32_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_32_2, getProfileInt( "BAP", "P_ASG_15_1_0_32_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_32_1, getProfileFloat( "BAP", "P_ASG_15_1_0_32_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_32_1_range, getProfileFloat( "BAP", "P_ASG_15_1_0_32_1_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_33Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_33Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_33_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_33_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_33_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_33_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_33_2, getProfileInt( "BAP", "P_ASG_15_1_0_33_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_33_1, getProfileFloat( "BAP", "P_ASG_15_1_0_33_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_33_1_range, getProfileFloat( "BAP", "P_ASG_15_1_0_33_1_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_34Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_34Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_34_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_34_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_34_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_34_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_34_2, getProfileInt( "BAP", "P_ASG_15_1_0_34_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_34_1, getProfileFloat( "BAP", "P_ASG_15_1_0_34_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_34_1_range, getProfileFloat( "BAP", "P_ASG_15_1_0_34_1_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_35Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_35Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_35_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_35_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_35_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_35_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_35_7, getProfileFloat( "BAP", "P_ASG_15_1_0_35_7", 0, profileFile ) );
    putValue( P_ASG_15_1_0_35_7_range, getProfileFloat( "BAP", "P_ASG_15_1_0_35_7_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_35_2, getProfileFloat( "BAP", "P_ASG_15_1_0_35_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_35_2_range, getProfileFloat( "BAP", "P_ASG_15_1_0_35_2_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_35_5, getProfileFloat( "BAP", "P_ASG_15_1_0_35_5", 0, profileFile ) );
    putValue( P_ASG_15_1_0_35_5_range, getProfileFloat( "BAP", "P_ASG_15_1_0_35_5_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_35_1, getProfileFloat( "BAP", "P_ASG_15_1_0_35_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_35_1_range, getProfileFloat( "BAP", "P_ASG_15_1_0_35_1_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_35_4, getProfileFloat( "BAP", "P_ASG_15_1_0_35_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_35_4_range, getProfileFloat( "BAP", "P_ASG_15_1_0_35_4_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_35_3, getProfileInt( "BAP", "P_ASG_15_1_0_35_3", 0, profileFile ) );
    putValue( P_ASG_15_1_0_35_8, getProfileInt( "BAP", "P_ASG_15_1_0_35_8", 0, profileFile ) );
    putValue( P_ASG_15_1_0_35_6, getProfileInt( "BAP", "P_ASG_15_1_0_35_6", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36Get_BTN, getProfileInt( "BAP", "A_ASG_15_1_0_36Get_BTN", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36SetGet_BTN, getProfileInt( "BAP", "A_ASG_15_1_0_36SetGet_BTN", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_FctLstItemEn, getProfileInt( "BAP", "A_ASG_15_1_0_36_FctLstItemEn", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_IntTlgEn, getProfileInt( "BAP", "A_ASG_15_1_0_36_IntTlgEn", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_SegmEn, getProfileInt( "BAP", "A_ASG_15_1_0_36_SegmEn", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_AT, getProfileInt( "BAP", "A_ASG_15_1_0_36_AT", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_ErrCode, getProfileInt( "BAP", "A_ASG_15_1_0_36_ErrCode", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_DataIndex, getProfileInt( "BAP", "A_ASG_15_1_0_36_DataIndex", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_DataIndex_Incr, getProfileInt( "BAP", "A_ASG_15_1_0_36_DataIndex_Incr", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_DataIndex_Decr, getProfileInt( "BAP", "A_ASG_15_1_0_36_DataIndex_Decr", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_loadArray_Btn, getProfileInt( "BAP", "A_ASG_15_1_0_36_loadArray_Btn", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_generateData_Btn, getProfileInt( "BAP", "A_ASG_15_1_0_36_generateData_Btn", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_4, getProfileFloat( "BAP", "A_ASG_15_1_0_36_Data_4", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_4_range, getProfileFloat( "BAP", "A_ASG_15_1_0_36_Data_4_range", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_2, getProfileInt( "BAP", "A_ASG_15_1_0_36_2", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_3, getProfileFloat( "BAP", "A_ASG_15_1_0_36_3", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_3_range, getProfileFloat( "BAP", "A_ASG_15_1_0_36_3_range", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_7, getProfileFloat( "BAP", "A_ASG_15_1_0_36_7", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_7_range, getProfileFloat( "BAP", "A_ASG_15_1_0_36_7_range", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_3, getProfileInt( "BAP", "A_ASG_15_1_0_36_Data_3", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_3_0, getProfileInt( "BAP", "A_ASG_15_1_0_36_Data_3_0", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_3_4, getProfileInt( "BAP", "A_ASG_15_1_0_36_Data_3_4", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_3_5, getProfileInt( "BAP", "A_ASG_15_1_0_36_Data_3_5", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_3_6, getProfileInt( "BAP", "A_ASG_15_1_0_36_Data_3_6", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_3_7, getProfileInt( "BAP", "A_ASG_15_1_0_36_Data_3_7", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_5, getProfileInt( "BAP", "A_ASG_15_1_0_36_5", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_2, getProfileFloat( "BAP", "A_ASG_15_1_0_36_Data_2", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_2_range, getProfileFloat( "BAP", "A_ASG_15_1_0_36_Data_2_range", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_1, getProfileInt( "BAP", "A_ASG_15_1_0_36_1", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_5_len, getProfileInt( "BAP", "A_ASG_15_1_0_36_Data_5_len", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_5_cnt, getProfileInt( "BAP", "A_ASG_15_1_0_36_Data_5_cnt", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_6, getProfileFloat( "BAP", "A_ASG_15_1_0_36_6", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_6_range, getProfileFloat( "BAP", "A_ASG_15_1_0_36_6_range", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_4, getProfileInt( "BAP", "A_ASG_15_1_0_36_4", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_4_0, getProfileInt( "BAP", "A_ASG_15_1_0_36_4_0", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_4_1, getProfileInt( "BAP", "A_ASG_15_1_0_36_4_1", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_4_2, getProfileInt( "BAP", "A_ASG_15_1_0_36_4_2", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_1, getProfileFloat( "BAP", "A_ASG_15_1_0_36_Data_1", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_1_range, getProfileFloat( "BAP", "A_ASG_15_1_0_36_Data_1_range", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_RecAdr, getProfileInt( "BAP", "A_ASG_15_1_0_36_RecAdr", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Direction, getProfileInt( "BAP", "A_ASG_15_1_0_36_Direction", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Shift, getProfileInt( "BAP", "A_ASG_15_1_0_36_Shift", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_TransPos, getProfileInt( "BAP", "A_ASG_15_1_0_36_TransPos", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_IndexSize, getProfileInt( "BAP", "A_ASG_15_1_0_36_IndexSize", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Start, getProfileInt( "BAP", "A_ASG_15_1_0_36_Start", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Elements, getProfileInt( "BAP", "A_ASG_15_1_0_36_Elements", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_2_Changed, getProfileInt( "BAP", "A_ASG_15_1_0_36_2_Changed", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_1_Changed, getProfileInt( "BAP", "A_ASG_15_1_0_36_1_Changed", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_3_Changed, getProfileFloat( "BAP", "A_ASG_15_1_0_36_3_Changed", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_3_Changed_range, getProfileFloat( "BAP", "A_ASG_15_1_0_36_3_Changed_range", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Changed_RecAdr, getProfileInt( "BAP", "A_ASG_15_1_0_36_Changed_RecAdr", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Changed_Direction, getProfileInt( "BAP", "A_ASG_15_1_0_36_Changed_Direction", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Changed_Shift, getProfileInt( "BAP", "A_ASG_15_1_0_36_Changed_Shift", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Changed_TransPos, getProfileInt( "BAP", "A_ASG_15_1_0_36_Changed_TransPos", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Changed_IndexSize, getProfileInt( "BAP", "A_ASG_15_1_0_36_Changed_IndexSize", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Changed_Start, getProfileInt( "BAP", "A_ASG_15_1_0_36_Changed_Start", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Changed_Elements, getProfileInt( "BAP", "A_ASG_15_1_0_36_Changed_Elements", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_DataIndex_SetGet, getProfileInt( "BAP", "A_ASG_15_1_0_36_DataIndex_SetGet", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_DataIndex_SetGet_Incr, getProfileInt( "BAP", "A_ASG_15_1_0_36_DataIndex_SetGet_Incr", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_DataIndex_SetGet_Decr, getProfileInt( "BAP", "A_ASG_15_1_0_36_DataIndex_SetGet_Decr", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_4_SetGet, getProfileFloat( "BAP", "A_ASG_15_1_0_36_Data_4_SetGet", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_4_SetGet_range, getProfileFloat( "BAP", "A_ASG_15_1_0_36_Data_4_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_2_SetGet, getProfileInt( "BAP", "A_ASG_15_1_0_36_2_SetGet", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_3_SetGet, getProfileFloat( "BAP", "A_ASG_15_1_0_36_3_SetGet", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_3_SetGet_range, getProfileFloat( "BAP", "A_ASG_15_1_0_36_3_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_3_SetGet, getProfileInt( "BAP", "A_ASG_15_1_0_36_Data_3_SetGet", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_3_SetGet_0, getProfileInt( "BAP", "A_ASG_15_1_0_36_Data_3_SetGet_0", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_3_SetGet_4, getProfileInt( "BAP", "A_ASG_15_1_0_36_Data_3_SetGet_4", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_3_SetGet_5, getProfileInt( "BAP", "A_ASG_15_1_0_36_Data_3_SetGet_5", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_3_SetGet_6, getProfileInt( "BAP", "A_ASG_15_1_0_36_Data_3_SetGet_6", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_3_SetGet_7, getProfileInt( "BAP", "A_ASG_15_1_0_36_Data_3_SetGet_7", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_4_SetGet, getProfileInt( "BAP", "A_ASG_15_1_0_36_4_SetGet", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_2_SetGet, getProfileFloat( "BAP", "A_ASG_15_1_0_36_Data_2_SetGet", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_2_SetGet_range, getProfileFloat( "BAP", "A_ASG_15_1_0_36_Data_2_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_1_SetGet, getProfileInt( "BAP", "A_ASG_15_1_0_36_1_SetGet", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_5_SetGet_len, getProfileInt( "BAP", "A_ASG_15_1_0_36_Data_5_SetGet_len", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_5_SetGet_cnt, getProfileInt( "BAP", "A_ASG_15_1_0_36_Data_5_SetGet_cnt", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_5_SetGet, getProfileFloat( "BAP", "A_ASG_15_1_0_36_5_SetGet", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_5_SetGet_range, getProfileFloat( "BAP", "A_ASG_15_1_0_36_5_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_1_SetGet, getProfileFloat( "BAP", "A_ASG_15_1_0_36_Data_1_SetGet", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_Data_1_SetGet_range, getProfileFloat( "BAP", "A_ASG_15_1_0_36_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_SetGet_RecAdr, getProfileInt( "BAP", "A_ASG_15_1_0_36_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_SetGet_Direction, getProfileInt( "BAP", "A_ASG_15_1_0_36_SetGet_Direction", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_SetGet_Shift, getProfileInt( "BAP", "A_ASG_15_1_0_36_SetGet_Shift", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_SetGet_IndexSize, getProfileInt( "BAP", "A_ASG_15_1_0_36_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_SetGet_Start, getProfileInt( "BAP", "A_ASG_15_1_0_36_SetGet_Start", 0, profileFile ) );
    putValue( A_ASG_15_1_0_36_SetGet_Elements, getProfileInt( "BAP", "A_ASG_15_1_0_36_SetGet_Elements", 0, profileFile ) );
    putValue( P_ASG_15_1_0_37Get_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_37Get_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_37SetGet_BTN, getProfileInt( "BAP", "P_ASG_15_1_0_37SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_15_1_0_37_FctLstItemEn, getProfileInt( "BAP", "P_ASG_15_1_0_37_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_15_1_0_37_ErrCode, getProfileInt( "BAP", "P_ASG_15_1_0_37_ErrCode", 0, profileFile ) );
    putValue( P_ASG_15_1_0_37_2, getProfileFloat( "BAP", "P_ASG_15_1_0_37_2", 0, profileFile ) );
    putValue( P_ASG_15_1_0_37_2_range, getProfileFloat( "BAP", "P_ASG_15_1_0_37_2_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_37_4, getProfileFloat( "BAP", "P_ASG_15_1_0_37_4", 0, profileFile ) );
    putValue( P_ASG_15_1_0_37_4_range, getProfileFloat( "BAP", "P_ASG_15_1_0_37_4_range", 0, profileFile ) );
    putValue( P_ASG_15_1_0_37_1, getProfileInt( "BAP", "P_ASG_15_1_0_37_1", 0, profileFile ) );
    putValue( P_ASG_15_1_0_37_1_0, getProfileInt( "BAP", "P_ASG_15_1_0_37_1_0", 0, profileFile ) );
    putValue( P_ASG_15_1_0_37_3, getProfileInt( "BAP", "P_ASG_15_1_0_37_3", 0, profileFile ) );
    putValue( ERRORLIST_ASG69_0_VT, getProfileInt( "BAP", "ERRORLIST_ASG69_0_VT", 0, profileFile ) );
    putValue( BusType_ASG69_0, getProfileInt( "BAP", "BusType_ASG69_0", 0, profileFile ) );
    putValue( ON_OFF_ASG69_0, getProfileInt( "BAP", "ON_OFF_ASG69_0", 0, profileFile ) );
    putValue( BAPCFG_ASG_69_0_0_DFMajor, getProfileInt( "BAP", "BAPCFG_ASG_69_0_0_DFMajor", 0, profileFile ) );
    putValue( BAPCFG_ASG_69_0_0_DFMinor, getProfileInt( "BAP", "BAPCFG_ASG_69_0_0_DFMinor", 0, profileFile ) );
    putValue( BAPCFG_ASG_69_0_0_LsgClassMajor, getProfileInt( "BAP", "BAPCFG_ASG_69_0_0_LsgClassMajor", 0, profileFile ) );
    putValue( BAPCFG_ASG_69_0_0_LsgClassMinor, getProfileInt( "BAP", "BAPCFG_ASG_69_0_0_LsgClassMinor", 0, profileFile ) );
    putValue( BAPCFG_ASG_69_0_0_ProtocolMajor, getProfileInt( "BAP", "BAPCFG_ASG_69_0_0_ProtocolMajor", 0, profileFile ) );
    putValue( BAPCFG_ASG_69_0_0_ProtocolMinor, getProfileInt( "BAP", "BAPCFG_ASG_69_0_0_ProtocolMinor", 0, profileFile ) );
    putValue( C_ASG_69_0_0_1GetAll_BTN, getProfileInt( "BAP", "C_ASG_69_0_0_1GetAll_BTN", 0, profileFile ) );
    putValue( C_ASG_69_0_0_1_FctLstItemEn, getProfileInt( "BAP", "C_ASG_69_0_0_1_FctLstItemEn", 0, profileFile ) );
    putValue( C_ASG_69_0_0_1_ErrCode, getProfileInt( "BAP", "C_ASG_69_0_0_1_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_2Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_2Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_2_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_2_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_2_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_2_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_2, getProfileFloat( "BAP", "P_ASG_69_0_0_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_2_range, getProfileFloat( "BAP", "P_ASG_69_0_0_2_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_3Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_3Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_3_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_3_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_3_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_3_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_4Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_4Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_4_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_4_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_4_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_4_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_4, getProfileInt( "BAP", "P_ASG_69_0_0_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_13Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_13Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_13SetGet_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_13SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_13_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_13_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_13_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_13_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_13, getProfileInt( "BAP", "P_ASG_69_0_0_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_13_1, getProfileInt( "BAP", "P_ASG_69_0_0_13_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_13_1_0, getProfileInt( "BAP", "P_ASG_69_0_0_13_1_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_14Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_14_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_14_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_6, getProfileFloat( "BAP", "P_ASG_69_0_0_14_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_6_range, getProfileFloat( "BAP", "P_ASG_69_0_0_14_6_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_1, getProfileFloat( "BAP", "P_ASG_69_0_0_14_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_1_range, getProfileFloat( "BAP", "P_ASG_69_0_0_14_1_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_5, getProfileInt( "BAP", "P_ASG_69_0_0_14_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_5_0, getProfileInt( "BAP", "P_ASG_69_0_0_14_5_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_5_1, getProfileInt( "BAP", "P_ASG_69_0_0_14_5_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_5_2, getProfileInt( "BAP", "P_ASG_69_0_0_14_5_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_5_3, getProfileInt( "BAP", "P_ASG_69_0_0_14_5_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_5_4, getProfileInt( "BAP", "P_ASG_69_0_0_14_5_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_5_5, getProfileInt( "BAP", "P_ASG_69_0_0_14_5_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_3, getProfileInt( "BAP", "P_ASG_69_0_0_14_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_3_0, getProfileInt( "BAP", "P_ASG_69_0_0_14_3_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_3_1, getProfileInt( "BAP", "P_ASG_69_0_0_14_3_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_3_2, getProfileInt( "BAP", "P_ASG_69_0_0_14_3_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_2, getProfileInt( "BAP", "P_ASG_69_0_0_14_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_2_0, getProfileInt( "BAP", "P_ASG_69_0_0_14_2_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_4, getProfileInt( "BAP", "P_ASG_69_0_0_14_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_4_0, getProfileInt( "BAP", "P_ASG_69_0_0_14_4_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_4_1, getProfileInt( "BAP", "P_ASG_69_0_0_14_4_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_4_2, getProfileInt( "BAP", "P_ASG_69_0_0_14_4_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_4_3, getProfileInt( "BAP", "P_ASG_69_0_0_14_4_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_14_4_4, getProfileInt( "BAP", "P_ASG_69_0_0_14_4_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_15Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_15Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_15_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_15_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_15_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_15_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_15, getProfileInt( "BAP", "P_ASG_69_0_0_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_15_1, getProfileInt( "BAP", "P_ASG_69_0_0_15_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_16Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_16Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_16SetGet_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_16SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_16_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_16_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_16_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_16_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_16_1, getProfileFloat( "BAP", "P_ASG_69_0_0_16_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_16_1_range, getProfileFloat( "BAP", "P_ASG_69_0_0_16_1_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_16_2, getProfileInt( "BAP", "P_ASG_69_0_0_16_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_16_3, getProfileInt( "BAP", "P_ASG_69_0_0_16_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_16_3_0, getProfileInt( "BAP", "P_ASG_69_0_0_16_3_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_17Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_17Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_17SetGet_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_17SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_17_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_17_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_17_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_17_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_17_1, getProfileFloat( "BAP", "P_ASG_69_0_0_17_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_17_1_range, getProfileFloat( "BAP", "P_ASG_69_0_0_17_1_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_17_2, getProfileInt( "BAP", "P_ASG_69_0_0_17_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_17_3, getProfileInt( "BAP", "P_ASG_69_0_0_17_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_17_3_0, getProfileInt( "BAP", "P_ASG_69_0_0_17_3_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18Get_BTN, getProfileInt( "BAP", "A_ASG_69_0_0_18Get_BTN", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18SetGet_BTN, getProfileInt( "BAP", "A_ASG_69_0_0_18SetGet_BTN", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_FctLstItemEn, getProfileInt( "BAP", "A_ASG_69_0_0_18_FctLstItemEn", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_IntTlgEn, getProfileInt( "BAP", "A_ASG_69_0_0_18_IntTlgEn", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_SegmEn, getProfileInt( "BAP", "A_ASG_69_0_0_18_SegmEn", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_AT, getProfileInt( "BAP", "A_ASG_69_0_0_18_AT", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_ErrCode, getProfileInt( "BAP", "A_ASG_69_0_0_18_ErrCode", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_DataIndex, getProfileInt( "BAP", "A_ASG_69_0_0_18_DataIndex", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_DataIndex_Incr, getProfileInt( "BAP", "A_ASG_69_0_0_18_DataIndex_Incr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_DataIndex_Decr, getProfileInt( "BAP", "A_ASG_69_0_0_18_DataIndex_Decr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_loadArray_Btn, getProfileInt( "BAP", "A_ASG_69_0_0_18_loadArray_Btn", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_generateData_Btn, getProfileInt( "BAP", "A_ASG_69_0_0_18_generateData_Btn", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_6_len, getProfileInt( "BAP", "A_ASG_69_0_0_18_Data_6_len", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_6_cnt, getProfileInt( "BAP", "A_ASG_69_0_0_18_Data_6_cnt", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_3, getProfileFloat( "BAP", "A_ASG_69_0_0_18_Data_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_3_range, getProfileFloat( "BAP", "A_ASG_69_0_0_18_Data_3_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_4, getProfileFloat( "BAP", "A_ASG_69_0_0_18_Data_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_4_range, getProfileFloat( "BAP", "A_ASG_69_0_0_18_Data_4_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_3, getProfileFloat( "BAP", "A_ASG_69_0_0_18_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_3_range, getProfileFloat( "BAP", "A_ASG_69_0_0_18_3_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_2, getProfileFloat( "BAP", "A_ASG_69_0_0_18_Data_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_2_range, getProfileFloat( "BAP", "A_ASG_69_0_0_18_Data_2_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_1, getProfileInt( "BAP", "A_ASG_69_0_0_18_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_1, getProfileFloat( "BAP", "A_ASG_69_0_0_18_Data_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_1_range, getProfileFloat( "BAP", "A_ASG_69_0_0_18_Data_1_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_2, getProfileFloat( "BAP", "A_ASG_69_0_0_18_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_2_range, getProfileFloat( "BAP", "A_ASG_69_0_0_18_2_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_5, getProfileInt( "BAP", "A_ASG_69_0_0_18_Data_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_RecAdr, getProfileInt( "BAP", "A_ASG_69_0_0_18_RecAdr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Direction, getProfileInt( "BAP", "A_ASG_69_0_0_18_Direction", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Shift, getProfileInt( "BAP", "A_ASG_69_0_0_18_Shift", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_TransPos, getProfileInt( "BAP", "A_ASG_69_0_0_18_TransPos", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_IndexSize, getProfileInt( "BAP", "A_ASG_69_0_0_18_IndexSize", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Start, getProfileInt( "BAP", "A_ASG_69_0_0_18_Start", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Elements, getProfileInt( "BAP", "A_ASG_69_0_0_18_Elements", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Changed_RecAdr, getProfileInt( "BAP", "A_ASG_69_0_0_18_Changed_RecAdr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Changed_Direction, getProfileInt( "BAP", "A_ASG_69_0_0_18_Changed_Direction", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Changed_Shift, getProfileInt( "BAP", "A_ASG_69_0_0_18_Changed_Shift", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Changed_TransPos, getProfileInt( "BAP", "A_ASG_69_0_0_18_Changed_TransPos", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Changed_IndexSize, getProfileInt( "BAP", "A_ASG_69_0_0_18_Changed_IndexSize", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Changed_Start, getProfileInt( "BAP", "A_ASG_69_0_0_18_Changed_Start", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Changed_Elements, getProfileInt( "BAP", "A_ASG_69_0_0_18_Changed_Elements", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_DataIndex_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_18_DataIndex_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_DataIndex_SetGet_Incr, getProfileInt( "BAP", "A_ASG_69_0_0_18_DataIndex_SetGet_Incr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_DataIndex_SetGet_Decr, getProfileInt( "BAP", "A_ASG_69_0_0_18_DataIndex_SetGet_Decr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_4_SetGet, getProfileFloat( "BAP", "A_ASG_69_0_0_18_Data_4_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_4_SetGet_range, getProfileFloat( "BAP", "A_ASG_69_0_0_18_Data_4_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_2_SetGet, getProfileFloat( "BAP", "A_ASG_69_0_0_18_2_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_2_SetGet_range, getProfileFloat( "BAP", "A_ASG_69_0_0_18_2_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_1_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_18_1_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_2_SetGet, getProfileFloat( "BAP", "A_ASG_69_0_0_18_Data_2_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_2_SetGet_range, getProfileFloat( "BAP", "A_ASG_69_0_0_18_Data_2_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_1_SetGet, getProfileFloat( "BAP", "A_ASG_69_0_0_18_Data_1_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_1_SetGet_range, getProfileFloat( "BAP", "A_ASG_69_0_0_18_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_6_SetGet_len, getProfileInt( "BAP", "A_ASG_69_0_0_18_Data_6_SetGet_len", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_6_SetGet_cnt, getProfileInt( "BAP", "A_ASG_69_0_0_18_Data_6_SetGet_cnt", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_5_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_18_Data_5_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_3_SetGet, getProfileFloat( "BAP", "A_ASG_69_0_0_18_Data_3_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_Data_3_SetGet_range, getProfileFloat( "BAP", "A_ASG_69_0_0_18_Data_3_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_SetGet_RecAdr, getProfileInt( "BAP", "A_ASG_69_0_0_18_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_SetGet_Direction, getProfileInt( "BAP", "A_ASG_69_0_0_18_SetGet_Direction", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_SetGet_Shift, getProfileInt( "BAP", "A_ASG_69_0_0_18_SetGet_Shift", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_SetGet_IndexSize, getProfileInt( "BAP", "A_ASG_69_0_0_18_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_SetGet_Start, getProfileInt( "BAP", "A_ASG_69_0_0_18_SetGet_Start", 0, profileFile ) );
    putValue( A_ASG_69_0_0_18_SetGet_Elements, getProfileInt( "BAP", "A_ASG_69_0_0_18_SetGet_Elements", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_19Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_19_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_19_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6, getProfileInt( "BAP", "P_ASG_69_0_0_19_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_0, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_1, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_2, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_3, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_4, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_5, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_6, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_7, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_8, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_8", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_9, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_9", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_10, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_10", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_11, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_11", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_12, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_12", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_13, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_14, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_14", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_15, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_16, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_16", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_17, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_17", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_18, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_18", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_19, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_19", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_20, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_20", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_21, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_21", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_22, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_22", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_23, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_23", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_24, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_24", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_25, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_25", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_26, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_27, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_27", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_28, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_28", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_6_29, getProfileInt( "BAP", "P_ASG_69_0_0_19_6_29", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5, getProfileInt( "BAP", "P_ASG_69_0_0_19_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_0, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_1, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_2, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_3, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_4, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_5, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_6, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_7, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_8, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_8", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_9, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_9", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_10, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_10", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_11, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_11", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_12, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_12", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_13, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_14, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_14", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_15, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_16, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_16", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_17, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_17", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_18, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_18", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_19, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_19", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_20, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_20", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_21, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_21", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_22, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_22", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_23, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_23", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_24, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_24", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_25, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_25", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_26, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_27, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_27", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_28, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_28", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_29, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_29", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_30, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_30", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_5_31, getProfileInt( "BAP", "P_ASG_69_0_0_19_5_31", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_2, getProfileInt( "BAP", "P_ASG_69_0_0_19_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_2_0, getProfileInt( "BAP", "P_ASG_69_0_0_19_2_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_2_1, getProfileInt( "BAP", "P_ASG_69_0_0_19_2_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4, getProfileInt( "BAP", "P_ASG_69_0_0_19_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_0, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_1, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_2, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_3, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_4, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_5, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_6, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_7, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_8, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_8", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_9, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_9", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_10, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_10", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_11, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_11", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_12, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_12", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_13, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_14, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_14", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_15, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_16, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_16", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_17, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_17", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_18, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_18", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_19, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_19", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_20, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_20", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_21, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_21", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_22, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_22", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_23, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_23", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_24, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_24", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_25, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_25", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_26, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_27, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_27", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_28, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_28", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_4_29, getProfileInt( "BAP", "P_ASG_69_0_0_19_4_29", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3, getProfileInt( "BAP", "P_ASG_69_0_0_19_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_0, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_1, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_2, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_3, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_4, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_5, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_6, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_7, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_8, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_8", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_9, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_9", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_10, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_10", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_11, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_11", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_12, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_12", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_13, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_14, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_14", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_15, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_16, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_16", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_17, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_17", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_18, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_18", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_19, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_19", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_20, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_20", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_21, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_21", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_22, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_22", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_23, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_23", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_24, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_24", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_25, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_25", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_26, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_27, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_27", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_28, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_28", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_29, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_29", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_30, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_30", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_3_31, getProfileInt( "BAP", "P_ASG_69_0_0_19_3_31", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1, getProfileInt( "BAP", "P_ASG_69_0_0_19_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_0, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_1, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_2, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_3, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_4, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_5, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_6, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_7, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_8, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_8", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_9, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_9", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_10, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_10", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_11, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_11", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_12, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_12", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_13, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_14, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_14", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_15, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_16, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_16", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_17, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_17", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_18, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_18", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_19, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_19", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_20, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_20", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_21, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_21", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_22, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_22", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_23, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_23", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_24, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_24", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_25, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_25", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_26, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_27, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_27", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_28, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_28", 0, profileFile ) );
    putValue( P_ASG_69_0_0_19_1_29, getProfileInt( "BAP", "P_ASG_69_0_0_19_1_29", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_20Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20SetGet_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_20SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_20_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_20_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_3, getProfileFloat( "BAP", "P_ASG_69_0_0_20_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_3_range, getProfileFloat( "BAP", "P_ASG_69_0_0_20_3_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_2, getProfileFloat( "BAP", "P_ASG_69_0_0_20_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_2_range, getProfileFloat( "BAP", "P_ASG_69_0_0_20_2_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1, getProfileInt( "BAP", "P_ASG_69_0_0_20_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_0, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_1, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_2, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_3, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_4, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_5, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_6, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_7, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_8, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_8", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_9, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_9", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_10, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_10", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_11, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_11", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_12, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_12", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_13, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_14, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_14", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_15, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_16, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_16", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_17, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_17", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_18, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_18", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_19, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_19", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_20, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_20", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_21, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_21", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_22, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_22", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_23, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_23", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_24, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_24", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_25, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_25", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_26, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_27, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_27", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_28, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_28", 0, profileFile ) );
    putValue( P_ASG_69_0_0_20_1_29, getProfileInt( "BAP", "P_ASG_69_0_0_20_1_29", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_21Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_21_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_21_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6, getProfileInt( "BAP", "P_ASG_69_0_0_21_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_0, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_1, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_2, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_3, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_4, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_5, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_6, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_7, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_8, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_8", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_9, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_9", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_10, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_10", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_11, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_11", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_12, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_12", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_13, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_14, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_14", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_15, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_16, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_16", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_17, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_17", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_18, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_18", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_19, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_19", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_20, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_20", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_21, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_21", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_22, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_22", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_23, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_23", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_24, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_24", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_25, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_25", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_26, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_27, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_27", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_28, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_28", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_6_29, getProfileInt( "BAP", "P_ASG_69_0_0_21_6_29", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5, getProfileInt( "BAP", "P_ASG_69_0_0_21_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_0, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_1, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_2, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_3, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_4, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_5, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_6, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_7, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_8, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_8", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_9, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_9", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_10, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_10", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_11, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_11", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_12, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_12", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_13, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_14, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_14", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_15, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_16, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_16", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_17, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_17", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_18, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_18", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_19, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_19", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_20, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_20", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_21, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_21", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_22, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_22", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_23, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_23", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_24, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_24", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_25, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_25", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_26, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_27, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_27", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_28, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_28", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_29, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_29", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_30, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_30", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_5_31, getProfileInt( "BAP", "P_ASG_69_0_0_21_5_31", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_2, getProfileInt( "BAP", "P_ASG_69_0_0_21_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_2_0, getProfileInt( "BAP", "P_ASG_69_0_0_21_2_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_2_1, getProfileInt( "BAP", "P_ASG_69_0_0_21_2_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4, getProfileInt( "BAP", "P_ASG_69_0_0_21_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_0, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_1, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_2, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_3, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_4, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_5, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_6, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_7, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_8, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_8", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_9, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_9", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_10, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_10", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_11, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_11", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_12, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_12", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_13, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_14, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_14", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_15, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_16, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_16", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_17, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_17", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_18, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_18", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_19, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_19", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_20, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_20", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_21, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_21", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_22, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_22", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_23, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_23", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_24, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_24", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_25, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_25", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_26, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_27, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_27", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_28, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_28", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_4_29, getProfileInt( "BAP", "P_ASG_69_0_0_21_4_29", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3, getProfileInt( "BAP", "P_ASG_69_0_0_21_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_0, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_1, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_2, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_3, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_4, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_5, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_6, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_7, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_8, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_8", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_9, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_9", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_10, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_10", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_11, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_11", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_12, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_12", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_13, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_14, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_14", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_15, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_16, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_16", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_17, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_17", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_18, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_18", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_19, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_19", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_20, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_20", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_21, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_21", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_22, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_22", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_23, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_23", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_24, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_24", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_25, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_25", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_26, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_27, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_27", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_28, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_28", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_29, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_29", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_30, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_30", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_3_31, getProfileInt( "BAP", "P_ASG_69_0_0_21_3_31", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1, getProfileInt( "BAP", "P_ASG_69_0_0_21_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_0, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_1, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_2, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_3, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_4, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_5, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_6, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_7, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_8, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_8", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_9, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_9", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_10, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_10", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_11, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_11", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_12, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_12", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_13, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_14, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_14", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_15, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_16, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_16", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_17, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_17", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_18, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_18", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_19, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_19", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_20, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_20", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_21, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_21", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_22, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_22", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_23, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_23", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_24, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_24", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_25, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_25", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_26, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_27, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_27", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_28, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_28", 0, profileFile ) );
    putValue( P_ASG_69_0_0_21_1_29, getProfileInt( "BAP", "P_ASG_69_0_0_21_1_29", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_22Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22SetGet_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_22SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_22_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_22_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_3, getProfileFloat( "BAP", "P_ASG_69_0_0_22_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_3_range, getProfileFloat( "BAP", "P_ASG_69_0_0_22_3_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_2, getProfileFloat( "BAP", "P_ASG_69_0_0_22_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_2_range, getProfileFloat( "BAP", "P_ASG_69_0_0_22_2_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1, getProfileInt( "BAP", "P_ASG_69_0_0_22_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_0, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_1, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_2, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_3, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_4, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_5, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_6, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_7, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_8, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_8", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_9, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_9", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_10, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_10", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_11, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_11", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_12, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_12", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_13, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_14, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_14", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_15, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_16, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_16", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_17, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_17", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_18, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_18", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_19, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_19", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_20, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_20", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_21, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_21", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_22, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_22", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_23, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_23", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_24, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_24", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_25, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_25", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_26, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_27, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_27", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_28, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_28", 0, profileFile ) );
    putValue( P_ASG_69_0_0_22_1_29, getProfileInt( "BAP", "P_ASG_69_0_0_22_1_29", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_23Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_23_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_23_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6, getProfileInt( "BAP", "P_ASG_69_0_0_23_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_0, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_1, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_2, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_3, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_4, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_5, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_6, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_7, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_8, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_8", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_9, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_9", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_10, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_10", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_11, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_11", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_12, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_12", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_13, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_14, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_14", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_15, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_16, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_16", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_17, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_17", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_18, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_18", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_19, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_19", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_20, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_20", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_21, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_21", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_22, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_22", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_23, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_23", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_24, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_24", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_25, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_25", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_26, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_27, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_27", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_28, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_28", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_6_29, getProfileInt( "BAP", "P_ASG_69_0_0_23_6_29", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5, getProfileInt( "BAP", "P_ASG_69_0_0_23_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_0, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_1, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_2, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_3, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_4, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_5, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_6, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_7, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_8, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_8", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_9, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_9", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_10, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_10", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_11, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_11", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_12, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_12", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_13, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_14, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_14", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_15, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_16, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_16", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_17, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_17", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_18, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_18", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_19, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_19", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_20, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_20", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_21, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_21", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_22, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_22", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_23, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_23", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_24, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_24", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_25, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_25", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_26, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_27, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_27", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_28, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_28", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_29, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_29", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_30, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_30", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_5_31, getProfileInt( "BAP", "P_ASG_69_0_0_23_5_31", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_2, getProfileInt( "BAP", "P_ASG_69_0_0_23_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_2_0, getProfileInt( "BAP", "P_ASG_69_0_0_23_2_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_2_1, getProfileInt( "BAP", "P_ASG_69_0_0_23_2_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4, getProfileInt( "BAP", "P_ASG_69_0_0_23_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_0, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_1, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_2, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_3, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_4, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_5, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_6, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_7, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_8, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_8", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_9, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_9", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_10, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_10", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_11, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_11", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_12, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_12", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_13, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_14, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_14", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_15, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_16, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_16", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_17, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_17", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_18, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_18", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_19, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_19", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_20, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_20", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_21, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_21", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_22, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_22", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_23, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_23", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_24, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_24", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_25, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_25", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_26, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_27, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_27", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_28, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_28", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_4_29, getProfileInt( "BAP", "P_ASG_69_0_0_23_4_29", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3, getProfileInt( "BAP", "P_ASG_69_0_0_23_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_0, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_1, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_2, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_3, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_4, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_5, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_6, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_7, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_8, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_8", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_9, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_9", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_10, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_10", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_11, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_11", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_12, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_12", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_13, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_14, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_14", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_15, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_16, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_16", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_17, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_17", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_18, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_18", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_19, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_19", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_20, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_20", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_21, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_21", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_22, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_22", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_23, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_23", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_24, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_24", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_25, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_25", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_26, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_27, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_27", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_28, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_28", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_29, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_29", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_30, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_30", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_3_31, getProfileInt( "BAP", "P_ASG_69_0_0_23_3_31", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1, getProfileInt( "BAP", "P_ASG_69_0_0_23_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_0, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_1, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_2, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_3, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_4, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_5, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_6, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_7, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_8, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_8", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_9, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_9", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_10, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_10", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_11, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_11", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_12, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_12", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_13, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_14, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_14", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_15, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_16, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_16", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_17, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_17", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_18, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_18", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_19, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_19", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_20, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_20", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_21, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_21", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_22, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_22", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_23, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_23", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_24, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_24", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_25, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_25", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_26, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_27, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_27", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_28, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_28", 0, profileFile ) );
    putValue( P_ASG_69_0_0_23_1_29, getProfileInt( "BAP", "P_ASG_69_0_0_23_1_29", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_24Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24SetGet_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_24SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_24_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_24_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_3, getProfileFloat( "BAP", "P_ASG_69_0_0_24_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_3_range, getProfileFloat( "BAP", "P_ASG_69_0_0_24_3_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_2, getProfileFloat( "BAP", "P_ASG_69_0_0_24_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_2_range, getProfileFloat( "BAP", "P_ASG_69_0_0_24_2_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1, getProfileInt( "BAP", "P_ASG_69_0_0_24_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_0, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_1, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_2, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_3, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_4, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_5, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_6, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_7, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_8, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_8", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_9, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_9", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_10, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_10", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_11, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_11", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_12, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_12", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_13, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_13", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_14, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_14", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_15, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_15", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_16, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_16", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_17, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_17", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_18, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_18", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_19, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_19", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_20, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_20", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_21, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_21", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_22, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_22", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_23, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_23", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_24, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_24", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_25, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_25", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_26, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_27, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_27", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_28, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_28", 0, profileFile ) );
    putValue( P_ASG_69_0_0_24_1_29, getProfileInt( "BAP", "P_ASG_69_0_0_24_1_29", 0, profileFile ) );
    putValue( P_ASG_69_0_0_25Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_25Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_25SetGet_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_25SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_25_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_25_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_25_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_25_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_25_2, getProfileFloat( "BAP", "P_ASG_69_0_0_25_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_25_2_range, getProfileFloat( "BAP", "P_ASG_69_0_0_25_2_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_25_1, getProfileInt( "BAP", "P_ASG_69_0_0_25_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_25_1_0, getProfileInt( "BAP", "P_ASG_69_0_0_25_1_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_25_1_1, getProfileInt( "BAP", "P_ASG_69_0_0_25_1_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_25_1_2, getProfileInt( "BAP", "P_ASG_69_0_0_25_1_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_25_3, getProfileInt( "BAP", "P_ASG_69_0_0_25_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_25_4, getProfileInt( "BAP", "P_ASG_69_0_0_25_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_25_4_0, getProfileInt( "BAP", "P_ASG_69_0_0_25_4_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_26Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_26Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_26SetGet_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_26SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_26_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_26_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_26_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_26_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_26, getProfileInt( "BAP", "P_ASG_69_0_0_26", 0, profileFile ) );
    putValue( P_ASG_69_0_0_26_1, getProfileInt( "BAP", "P_ASG_69_0_0_26_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_26_1_0, getProfileInt( "BAP", "P_ASG_69_0_0_26_1_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_26_1_1, getProfileInt( "BAP", "P_ASG_69_0_0_26_1_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_26_1_2, getProfileInt( "BAP", "P_ASG_69_0_0_26_1_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_26_1_3, getProfileInt( "BAP", "P_ASG_69_0_0_26_1_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_26_1_4, getProfileInt( "BAP", "P_ASG_69_0_0_26_1_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_26_1_5, getProfileInt( "BAP", "P_ASG_69_0_0_26_1_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27Get_BTN, getProfileInt( "BAP", "A_ASG_69_0_0_27Get_BTN", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27SetGet_BTN, getProfileInt( "BAP", "A_ASG_69_0_0_27SetGet_BTN", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_FctLstItemEn, getProfileInt( "BAP", "A_ASG_69_0_0_27_FctLstItemEn", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_IntTlgEn, getProfileInt( "BAP", "A_ASG_69_0_0_27_IntTlgEn", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_SegmEn, getProfileInt( "BAP", "A_ASG_69_0_0_27_SegmEn", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_AT, getProfileInt( "BAP", "A_ASG_69_0_0_27_AT", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_ErrCode, getProfileInt( "BAP", "A_ASG_69_0_0_27_ErrCode", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_DataIndex, getProfileInt( "BAP", "A_ASG_69_0_0_27_DataIndex", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_DataIndex_Incr, getProfileInt( "BAP", "A_ASG_69_0_0_27_DataIndex_Incr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_DataIndex_Decr, getProfileInt( "BAP", "A_ASG_69_0_0_27_DataIndex_Decr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_loadArray_Btn, getProfileInt( "BAP", "A_ASG_69_0_0_27_loadArray_Btn", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_generateData_Btn, getProfileInt( "BAP", "A_ASG_69_0_0_27_generateData_Btn", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_30, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_30", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_31, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_31", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_30, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_30", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_31, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_31", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_30, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_30", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_31, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_31", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_3, getProfileFloat( "BAP", "A_ASG_69_0_0_27_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_3_range, getProfileFloat( "BAP", "A_ASG_69_0_0_27_3_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_20_len, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_20_len", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_20_cnt, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_20_cnt", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_4, getProfileFloat( "BAP", "A_ASG_69_0_0_27_Data_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_4_range, getProfileFloat( "BAP", "A_ASG_69_0_0_27_Data_4_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_1, getProfileFloat( "BAP", "A_ASG_69_0_0_27_Data_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_1_range, getProfileFloat( "BAP", "A_ASG_69_0_0_27_Data_1_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_30, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_30", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_31, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_31", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_30, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_30", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_31, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_31", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_30, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_30", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_31, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_31", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_2, getProfileFloat( "BAP", "A_ASG_69_0_0_27_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_2_range, getProfileFloat( "BAP", "A_ASG_69_0_0_27_2_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_RecAdr, getProfileInt( "BAP", "A_ASG_69_0_0_27_RecAdr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Direction, getProfileInt( "BAP", "A_ASG_69_0_0_27_Direction", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Shift, getProfileInt( "BAP", "A_ASG_69_0_0_27_Shift", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_TransPos, getProfileInt( "BAP", "A_ASG_69_0_0_27_TransPos", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_IndexSize, getProfileInt( "BAP", "A_ASG_69_0_0_27_IndexSize", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Start, getProfileInt( "BAP", "A_ASG_69_0_0_27_Start", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Elements, getProfileInt( "BAP", "A_ASG_69_0_0_27_Elements", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Changed_RecAdr, getProfileInt( "BAP", "A_ASG_69_0_0_27_Changed_RecAdr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Changed_Direction, getProfileInt( "BAP", "A_ASG_69_0_0_27_Changed_Direction", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Changed_Shift, getProfileInt( "BAP", "A_ASG_69_0_0_27_Changed_Shift", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Changed_TransPos, getProfileInt( "BAP", "A_ASG_69_0_0_27_Changed_TransPos", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Changed_IndexSize, getProfileInt( "BAP", "A_ASG_69_0_0_27_Changed_IndexSize", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Changed_Start, getProfileInt( "BAP", "A_ASG_69_0_0_27_Changed_Start", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Changed_Elements, getProfileInt( "BAP", "A_ASG_69_0_0_27_Changed_Elements", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_DataIndex_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_DataIndex_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_DataIndex_SetGet_Incr, getProfileInt( "BAP", "A_ASG_69_0_0_27_DataIndex_SetGet_Incr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_DataIndex_SetGet_Decr, getProfileInt( "BAP", "A_ASG_69_0_0_27_DataIndex_SetGet_Decr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_3_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_3_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_1_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_1_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_10_SetGet_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_10_SetGet_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_17_SetGet_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_17_SetGet_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_30, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_30", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_16_SetGet_31, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_16_SetGet_31", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_15_SetGet_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_15_SetGet_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_14_SetGet_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_14_SetGet_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_30, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_30", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_13_SetGet_31, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_13_SetGet_31", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_9_SetGet_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_9_SetGet_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_30, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_30", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_8_SetGet_31, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_8_SetGet_31", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_2_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_2_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_20_SetGet_len, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_20_SetGet_len", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_20_SetGet_cnt, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_20_SetGet_cnt", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_5_SetGet_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_5_SetGet_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_4_SetGet, getProfileFloat( "BAP", "A_ASG_69_0_0_27_Data_4_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_4_SetGet_range, getProfileFloat( "BAP", "A_ASG_69_0_0_27_Data_4_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_1_SetGet, getProfileFloat( "BAP", "A_ASG_69_0_0_27_Data_1_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_1_SetGet_range, getProfileFloat( "BAP", "A_ASG_69_0_0_27_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_19_SetGet_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_19_SetGet_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_30, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_30", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_18_SetGet_31, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_18_SetGet_31", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_12_SetGet_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_12_SetGet_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_30, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_30", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_11_SetGet_31, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_11_SetGet_31", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_7_SetGet_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_7_SetGet_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_0, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_1, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_2, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_3, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_4, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_5, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_6, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_7, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_8, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_8", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_9, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_9", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_10, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_10", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_11, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_11", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_12, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_12", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_13, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_13", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_14, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_14", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_15, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_15", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_16, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_16", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_17, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_17", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_18, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_18", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_19, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_19", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_20, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_20", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_21, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_21", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_22, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_22", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_23, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_23", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_24, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_24", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_25, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_25", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_26, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_26", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_27, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_27", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_28, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_28", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_29, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_29", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_30, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_30", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_Data_6_SetGet_31, getProfileInt( "BAP", "A_ASG_69_0_0_27_Data_6_SetGet_31", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_2_SetGet, getProfileFloat( "BAP", "A_ASG_69_0_0_27_2_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_2_SetGet_range, getProfileFloat( "BAP", "A_ASG_69_0_0_27_2_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_SetGet_RecAdr, getProfileInt( "BAP", "A_ASG_69_0_0_27_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_SetGet_Direction, getProfileInt( "BAP", "A_ASG_69_0_0_27_SetGet_Direction", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_SetGet_Shift, getProfileInt( "BAP", "A_ASG_69_0_0_27_SetGet_Shift", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_SetGet_IndexSize, getProfileInt( "BAP", "A_ASG_69_0_0_27_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_SetGet_Start, getProfileInt( "BAP", "A_ASG_69_0_0_27_SetGet_Start", 0, profileFile ) );
    putValue( A_ASG_69_0_0_27_SetGet_Elements, getProfileInt( "BAP", "A_ASG_69_0_0_27_SetGet_Elements", 0, profileFile ) );
    putValue( P_ASG_69_0_0_28Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_28Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_28SetGet_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_28SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_28_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_28_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_28_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_28_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_28_3, getProfileFloat( "BAP", "P_ASG_69_0_0_28_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_28_3_range, getProfileFloat( "BAP", "P_ASG_69_0_0_28_3_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_28_2, getProfileFloat( "BAP", "P_ASG_69_0_0_28_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_28_2_range, getProfileFloat( "BAP", "P_ASG_69_0_0_28_2_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_28_1, getProfileInt( "BAP", "P_ASG_69_0_0_28_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_28_1_0, getProfileInt( "BAP", "P_ASG_69_0_0_28_1_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_28_4, getProfileInt( "BAP", "P_ASG_69_0_0_28_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_28_5, getProfileInt( "BAP", "P_ASG_69_0_0_28_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_28_5_0, getProfileInt( "BAP", "P_ASG_69_0_0_28_5_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_29Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_29Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_29SetGet_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_29SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_29_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_29_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_29_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_29_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_29_1, getProfileFloat( "BAP", "P_ASG_69_0_0_29_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_29_1_range, getProfileFloat( "BAP", "P_ASG_69_0_0_29_1_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_29_2, getProfileInt( "BAP", "P_ASG_69_0_0_29_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_29_3, getProfileInt( "BAP", "P_ASG_69_0_0_29_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_29_3_0, getProfileInt( "BAP", "P_ASG_69_0_0_29_3_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_30Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_30Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_30SetGet_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_30SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_30_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_30_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_30_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_30_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_30_3, getProfileFloat( "BAP", "P_ASG_69_0_0_30_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_30_3_range, getProfileFloat( "BAP", "P_ASG_69_0_0_30_3_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_30_2, getProfileFloat( "BAP", "P_ASG_69_0_0_30_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_30_2_range, getProfileFloat( "BAP", "P_ASG_69_0_0_30_2_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_30_1, getProfileInt( "BAP", "P_ASG_69_0_0_30_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_30_4, getProfileInt( "BAP", "P_ASG_69_0_0_30_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_30_5, getProfileInt( "BAP", "P_ASG_69_0_0_30_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_30_5_0, getProfileInt( "BAP", "P_ASG_69_0_0_30_5_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_31Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_31Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_31SetGet_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_31SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_31_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_31_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_31_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_31_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_31_5, getProfileFloat( "BAP", "P_ASG_69_0_0_31_5", 0, profileFile ) );
    putValue( P_ASG_69_0_0_31_5_range, getProfileFloat( "BAP", "P_ASG_69_0_0_31_5_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_31_4, getProfileFloat( "BAP", "P_ASG_69_0_0_31_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_31_4_range, getProfileFloat( "BAP", "P_ASG_69_0_0_31_4_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_31_1, getProfileInt( "BAP", "P_ASG_69_0_0_31_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_31_1_0, getProfileInt( "BAP", "P_ASG_69_0_0_31_1_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_31_2, getProfileInt( "BAP", "P_ASG_69_0_0_31_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_31_3, getProfileInt( "BAP", "P_ASG_69_0_0_31_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_31_3_0, getProfileInt( "BAP", "P_ASG_69_0_0_31_3_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_31_7, getProfileFloat( "BAP", "P_ASG_69_0_0_31_7", 0, profileFile ) );
    putValue( P_ASG_69_0_0_31_7_range, getProfileFloat( "BAP", "P_ASG_69_0_0_31_7_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_31_6, getProfileFloat( "BAP", "P_ASG_69_0_0_31_6", 0, profileFile ) );
    putValue( P_ASG_69_0_0_31_6_range, getProfileFloat( "BAP", "P_ASG_69_0_0_31_6_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_32Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_32Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_32SetGet_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_32SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_32_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_32_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_32_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_32_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_32_2, getProfileFloat( "BAP", "P_ASG_69_0_0_32_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_32_2_range, getProfileFloat( "BAP", "P_ASG_69_0_0_32_2_range", 0, profileFile ) );
    putValue( P_ASG_69_0_0_32_1, getProfileInt( "BAP", "P_ASG_69_0_0_32_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_32_1_0, getProfileInt( "BAP", "P_ASG_69_0_0_32_1_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_32_1_1, getProfileInt( "BAP", "P_ASG_69_0_0_32_1_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_32_1_2, getProfileInt( "BAP", "P_ASG_69_0_0_32_1_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_32_1_3, getProfileInt( "BAP", "P_ASG_69_0_0_32_1_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_32_1_4, getProfileInt( "BAP", "P_ASG_69_0_0_32_1_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_32_3, getProfileInt( "BAP", "P_ASG_69_0_0_32_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_32_4, getProfileInt( "BAP", "P_ASG_69_0_0_32_4", 0, profileFile ) );
    putValue( P_ASG_69_0_0_32_4_0, getProfileInt( "BAP", "P_ASG_69_0_0_32_4_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_33Get_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_33Get_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_33SetGet_BTN, getProfileInt( "BAP", "P_ASG_69_0_0_33SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_69_0_0_33_FctLstItemEn, getProfileInt( "BAP", "P_ASG_69_0_0_33_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_69_0_0_33_ErrCode, getProfileInt( "BAP", "P_ASG_69_0_0_33_ErrCode", 0, profileFile ) );
    putValue( P_ASG_69_0_0_33_1, getProfileInt( "BAP", "P_ASG_69_0_0_33_1", 0, profileFile ) );
    putValue( P_ASG_69_0_0_33_1_0, getProfileInt( "BAP", "P_ASG_69_0_0_33_1_0", 0, profileFile ) );
    putValue( P_ASG_69_0_0_33_2, getProfileInt( "BAP", "P_ASG_69_0_0_33_2", 0, profileFile ) );
    putValue( P_ASG_69_0_0_33_3, getProfileInt( "BAP", "P_ASG_69_0_0_33_3", 0, profileFile ) );
    putValue( P_ASG_69_0_0_33_3_0, getProfileInt( "BAP", "P_ASG_69_0_0_33_3_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34Get_BTN, getProfileInt( "BAP", "A_ASG_69_0_0_34Get_BTN", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34SetGet_BTN, getProfileInt( "BAP", "A_ASG_69_0_0_34SetGet_BTN", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_FctLstItemEn, getProfileInt( "BAP", "A_ASG_69_0_0_34_FctLstItemEn", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_IntTlgEn, getProfileInt( "BAP", "A_ASG_69_0_0_34_IntTlgEn", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_SegmEn, getProfileInt( "BAP", "A_ASG_69_0_0_34_SegmEn", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_AT, getProfileInt( "BAP", "A_ASG_69_0_0_34_AT", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_ErrCode, getProfileInt( "BAP", "A_ASG_69_0_0_34_ErrCode", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_DataIndex, getProfileInt( "BAP", "A_ASG_69_0_0_34_DataIndex", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_DataIndex_Incr, getProfileInt( "BAP", "A_ASG_69_0_0_34_DataIndex_Incr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_DataIndex_Decr, getProfileInt( "BAP", "A_ASG_69_0_0_34_DataIndex_Decr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_loadArray_Btn, getProfileInt( "BAP", "A_ASG_69_0_0_34_loadArray_Btn", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_generateData_Btn, getProfileInt( "BAP", "A_ASG_69_0_0_34_generateData_Btn", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_4, getProfileFloat( "BAP", "A_ASG_69_0_0_34_Data_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_4_range, getProfileFloat( "BAP", "A_ASG_69_0_0_34_Data_4_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_2, getProfileInt( "BAP", "A_ASG_69_0_0_34_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_3, getProfileFloat( "BAP", "A_ASG_69_0_0_34_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_3_range, getProfileFloat( "BAP", "A_ASG_69_0_0_34_3_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_7, getProfileFloat( "BAP", "A_ASG_69_0_0_34_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_7_range, getProfileFloat( "BAP", "A_ASG_69_0_0_34_7_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_3, getProfileInt( "BAP", "A_ASG_69_0_0_34_Data_3", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_3_0, getProfileInt( "BAP", "A_ASG_69_0_0_34_Data_3_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_3_4, getProfileInt( "BAP", "A_ASG_69_0_0_34_Data_3_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_3_5, getProfileInt( "BAP", "A_ASG_69_0_0_34_Data_3_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_3_6, getProfileInt( "BAP", "A_ASG_69_0_0_34_Data_3_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_3_7, getProfileInt( "BAP", "A_ASG_69_0_0_34_Data_3_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_5, getProfileInt( "BAP", "A_ASG_69_0_0_34_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_2, getProfileFloat( "BAP", "A_ASG_69_0_0_34_Data_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_2_range, getProfileFloat( "BAP", "A_ASG_69_0_0_34_Data_2_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_1, getProfileInt( "BAP", "A_ASG_69_0_0_34_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_5_len, getProfileInt( "BAP", "A_ASG_69_0_0_34_Data_5_len", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_5_cnt, getProfileInt( "BAP", "A_ASG_69_0_0_34_Data_5_cnt", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_6, getProfileFloat( "BAP", "A_ASG_69_0_0_34_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_6_range, getProfileFloat( "BAP", "A_ASG_69_0_0_34_6_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_4, getProfileInt( "BAP", "A_ASG_69_0_0_34_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_4_0, getProfileInt( "BAP", "A_ASG_69_0_0_34_4_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_4_1, getProfileInt( "BAP", "A_ASG_69_0_0_34_4_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_4_2, getProfileInt( "BAP", "A_ASG_69_0_0_34_4_2", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_1, getProfileFloat( "BAP", "A_ASG_69_0_0_34_Data_1", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_1_range, getProfileFloat( "BAP", "A_ASG_69_0_0_34_Data_1_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_RecAdr, getProfileInt( "BAP", "A_ASG_69_0_0_34_RecAdr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Direction, getProfileInt( "BAP", "A_ASG_69_0_0_34_Direction", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Shift, getProfileInt( "BAP", "A_ASG_69_0_0_34_Shift", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_TransPos, getProfileInt( "BAP", "A_ASG_69_0_0_34_TransPos", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_IndexSize, getProfileInt( "BAP", "A_ASG_69_0_0_34_IndexSize", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Start, getProfileInt( "BAP", "A_ASG_69_0_0_34_Start", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Elements, getProfileInt( "BAP", "A_ASG_69_0_0_34_Elements", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_2_Changed, getProfileInt( "BAP", "A_ASG_69_0_0_34_2_Changed", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_1_Changed, getProfileInt( "BAP", "A_ASG_69_0_0_34_1_Changed", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_3_Changed, getProfileFloat( "BAP", "A_ASG_69_0_0_34_3_Changed", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_3_Changed_range, getProfileFloat( "BAP", "A_ASG_69_0_0_34_3_Changed_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Changed_RecAdr, getProfileInt( "BAP", "A_ASG_69_0_0_34_Changed_RecAdr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Changed_Direction, getProfileInt( "BAP", "A_ASG_69_0_0_34_Changed_Direction", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Changed_Shift, getProfileInt( "BAP", "A_ASG_69_0_0_34_Changed_Shift", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Changed_TransPos, getProfileInt( "BAP", "A_ASG_69_0_0_34_Changed_TransPos", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Changed_IndexSize, getProfileInt( "BAP", "A_ASG_69_0_0_34_Changed_IndexSize", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Changed_Start, getProfileInt( "BAP", "A_ASG_69_0_0_34_Changed_Start", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Changed_Elements, getProfileInt( "BAP", "A_ASG_69_0_0_34_Changed_Elements", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_DataIndex_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_34_DataIndex_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_DataIndex_SetGet_Incr, getProfileInt( "BAP", "A_ASG_69_0_0_34_DataIndex_SetGet_Incr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_DataIndex_SetGet_Decr, getProfileInt( "BAP", "A_ASG_69_0_0_34_DataIndex_SetGet_Decr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_4_SetGet, getProfileFloat( "BAP", "A_ASG_69_0_0_34_Data_4_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_4_SetGet_range, getProfileFloat( "BAP", "A_ASG_69_0_0_34_Data_4_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_2_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_34_2_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_3_SetGet, getProfileFloat( "BAP", "A_ASG_69_0_0_34_3_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_3_SetGet_range, getProfileFloat( "BAP", "A_ASG_69_0_0_34_3_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_3_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_34_Data_3_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_3_SetGet_0, getProfileInt( "BAP", "A_ASG_69_0_0_34_Data_3_SetGet_0", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_3_SetGet_4, getProfileInt( "BAP", "A_ASG_69_0_0_34_Data_3_SetGet_4", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_3_SetGet_5, getProfileInt( "BAP", "A_ASG_69_0_0_34_Data_3_SetGet_5", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_3_SetGet_6, getProfileInt( "BAP", "A_ASG_69_0_0_34_Data_3_SetGet_6", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_3_SetGet_7, getProfileInt( "BAP", "A_ASG_69_0_0_34_Data_3_SetGet_7", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_4_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_34_4_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_2_SetGet, getProfileFloat( "BAP", "A_ASG_69_0_0_34_Data_2_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_2_SetGet_range, getProfileFloat( "BAP", "A_ASG_69_0_0_34_Data_2_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_1_SetGet, getProfileInt( "BAP", "A_ASG_69_0_0_34_1_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_5_SetGet_len, getProfileInt( "BAP", "A_ASG_69_0_0_34_Data_5_SetGet_len", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_5_SetGet_cnt, getProfileInt( "BAP", "A_ASG_69_0_0_34_Data_5_SetGet_cnt", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_5_SetGet, getProfileFloat( "BAP", "A_ASG_69_0_0_34_5_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_5_SetGet_range, getProfileFloat( "BAP", "A_ASG_69_0_0_34_5_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_1_SetGet, getProfileFloat( "BAP", "A_ASG_69_0_0_34_Data_1_SetGet", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_Data_1_SetGet_range, getProfileFloat( "BAP", "A_ASG_69_0_0_34_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_SetGet_RecAdr, getProfileInt( "BAP", "A_ASG_69_0_0_34_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_SetGet_Direction, getProfileInt( "BAP", "A_ASG_69_0_0_34_SetGet_Direction", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_SetGet_Shift, getProfileInt( "BAP", "A_ASG_69_0_0_34_SetGet_Shift", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_SetGet_IndexSize, getProfileInt( "BAP", "A_ASG_69_0_0_34_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_SetGet_Start, getProfileInt( "BAP", "A_ASG_69_0_0_34_SetGet_Start", 0, profileFile ) );
    putValue( A_ASG_69_0_0_34_SetGet_Elements, getProfileInt( "BAP", "A_ASG_69_0_0_34_SetGet_Elements", 0, profileFile ) );
    putValue( C_FSG_40_0_0_0_1_FctLstItemEn, getProfileInt( "BAP", "C_FSG_40_0_0_0_1_FctLstItemEn", 0, profileFile ) );
    putValue( C_FSG_40_0_0_0_1_FctEn, getProfileInt( "BAP", "C_FSG_40_0_0_0_1_FctEn", 0, profileFile ) );
    putValue( C_FSG_40_0_0_0_1_ErrEn, getProfileInt( "BAP", "C_FSG_40_0_0_0_1_ErrEn", 0, profileFile ) );
    putValue( C_FSG_40_0_0_0_1_IntTlgEn, getProfileInt( "BAP", "C_FSG_40_0_0_0_1_IntTlgEn", 0, profileFile ) );
    putValue( C_FSG_40_0_0_0_1_SegmEn, getProfileInt( "BAP", "C_FSG_40_0_0_0_1_SegmEn", 0, profileFile ) );
    putValue( C_FSG_40_0_0_0_1_ErrCode, getProfileInt( "BAP", "C_FSG_40_0_0_0_1_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_0_2Reset_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_0_2Reset_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_0_2_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_0_2_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_0_2_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_0_2_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_0_2_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_0_2_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_0_2_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_0_2_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_0_3_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_0_3_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_0_3_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_0_3_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_0_3_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_0_3_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_0_3_IntTlgEn, getProfileInt( "BAP", "P_FSG_40_0_0_0_3_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_0_3_SegmEn, getProfileInt( "BAP", "P_FSG_40_0_0_0_3_SegmEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_0_3_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_0_3_ErrCode", 0, profileFile ) );
    putValue( ERRORLIST_FSG40_0_VT, getProfileInt( "BAP", "ERRORLIST_FSG40_0_VT", 0, profileFile ) );
    putValue( ON_OFF_FSG40_0, getProfileInt( "BAP", "ON_OFF_FSG40_0", 0, profileFile ) );
    putValue( BAPCFG_FSG_40_0_0_DFMajor, getProfileInt( "BAP", "BAPCFG_FSG_40_0_0_DFMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_40_0_0_DFMinor, getProfileInt( "BAP", "BAPCFG_FSG_40_0_0_DFMinor", 0, profileFile ) );
    putValue( BAPCFG_FSG_40_0_0_LsgClassMajor, getProfileInt( "BAP", "BAPCFG_FSG_40_0_0_LsgClassMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_40_0_0_LsgClassMinor, getProfileInt( "BAP", "BAPCFG_FSG_40_0_0_LsgClassMinor", 0, profileFile ) );
    putValue( BAPCFG_FSG_40_0_0_ProtocolMajor, getProfileInt( "BAP", "BAPCFG_FSG_40_0_0_ProtocolMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_40_0_0_ProtocolMinor, getProfileInt( "BAP", "BAPCFG_FSG_40_0_0_ProtocolMinor", 0, profileFile ) );
    putValue( C_FSG_40_0_0_1_FctLstItemEn, getProfileInt( "BAP", "C_FSG_40_0_0_1_FctLstItemEn", 0, profileFile ) );
    putValue( C_FSG_40_0_0_1_FctEn, getProfileInt( "BAP", "C_FSG_40_0_0_1_FctEn", 0, profileFile ) );
    putValue( C_FSG_40_0_0_1_ErrEn, getProfileInt( "BAP", "C_FSG_40_0_0_1_ErrEn", 0, profileFile ) );
    putValue( C_FSG_40_0_0_1_IntTlgEn, getProfileInt( "BAP", "C_FSG_40_0_0_1_IntTlgEn", 0, profileFile ) );
    putValue( C_FSG_40_0_0_1_SegmEn, getProfileInt( "BAP", "C_FSG_40_0_0_1_SegmEn", 0, profileFile ) );
    putValue( C_FSG_40_0_0_1_ErrCode, getProfileInt( "BAP", "C_FSG_40_0_0_1_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_2Reset_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_2Reset_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_2_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_2_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_2_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_2_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_2_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_2_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_2_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_2_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_2, getProfileFloat( "BAP", "P_FSG_40_0_0_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_2_range, getProfileFloat( "BAP", "P_FSG_40_0_0_2_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_3Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_3Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_3_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_3_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_3_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_3_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_3_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_3_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_3_IntTlgEn, getProfileInt( "BAP", "P_FSG_40_0_0_3_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_3_SegmEn, getProfileInt( "BAP", "P_FSG_40_0_0_3_SegmEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_3_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_3_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_4Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_4Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_4_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_4_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_4_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_4_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_4_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_4_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_4_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_4_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_4, getProfileInt( "BAP", "P_FSG_40_0_0_4", 0, profileFile ) );
    putValue( P_FSG_40_0_0_14Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_14Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_14_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_14_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_14_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_14_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_14_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_14_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_14_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_14_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_14_2, getProfileInt( "BAP", "P_FSG_40_0_0_14_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_14_1, getProfileInt( "BAP", "P_FSG_40_0_0_14_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_14_1_0, getProfileInt( "BAP", "P_FSG_40_0_0_14_1_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_14_1_1, getProfileInt( "BAP", "P_FSG_40_0_0_14_1_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_14_1_2, getProfileInt( "BAP", "P_FSG_40_0_0_14_1_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_14_1_3, getProfileInt( "BAP", "P_FSG_40_0_0_14_1_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_14_1_4, getProfileInt( "BAP", "P_FSG_40_0_0_14_1_4", 0, profileFile ) );
    putValue( P_FSG_40_0_0_14_1_5, getProfileInt( "BAP", "P_FSG_40_0_0_14_1_5", 0, profileFile ) );
    putValue( P_FSG_40_0_0_14_1_6, getProfileInt( "BAP", "P_FSG_40_0_0_14_1_6", 0, profileFile ) );
    putValue( P_FSG_40_0_0_15Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_15Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_15_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_15_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_15_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_15_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_15_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_15_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_15_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_15_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_15_1, getProfileInt( "BAP", "P_FSG_40_0_0_15_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_15_3, getProfileInt( "BAP", "P_FSG_40_0_0_15_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_15_3_0, getProfileInt( "BAP", "P_FSG_40_0_0_15_3_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_15_3_1, getProfileInt( "BAP", "P_FSG_40_0_0_15_3_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_15_3_2, getProfileInt( "BAP", "P_FSG_40_0_0_15_3_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_15_3_3, getProfileInt( "BAP", "P_FSG_40_0_0_15_3_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_15_2, getProfileInt( "BAP", "P_FSG_40_0_0_15_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_16Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_16_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_16_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_16_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_IntTlgEn, getProfileInt( "BAP", "P_FSG_40_0_0_16_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_SegmEn, getProfileInt( "BAP", "P_FSG_40_0_0_16_SegmEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_16_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_17, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_17", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_18, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_18", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_19, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_19", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_20, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_20", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_21, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_21", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_22, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_22", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_23, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_23", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_24, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_24", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_25, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_25", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_26, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_26", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_27, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_27", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_28, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_28", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_29, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_29", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_30, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_30", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_31, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_31", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_32, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_32", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_33, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_33", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_34, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_34", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_35, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_35", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_36, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_36", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_37, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_37", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_38, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_38", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_39, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_39", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_40, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_40", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_41, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_41", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_42, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_42", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_43, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_43", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_44, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_44", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_45, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_45", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_46, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_46", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_47, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_47", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_48, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_48", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_49, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_49", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_50, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_50", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_51, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_51", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_52, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_52", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_53, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_53", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_54, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_54", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_55, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_55", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_56, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_56", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_57, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_57", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_58, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_58", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_59, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_59", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_60, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_60", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_61, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_61", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_62, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_62", 0, profileFile ) );
    putValue( P_FSG_40_0_0_16_1_63, getProfileInt( "BAP", "P_FSG_40_0_0_16_1_63", 0, profileFile ) );
    putValue( P_FSG_40_0_0_17Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_17Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_17_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_17_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_17_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_17_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_17_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_17_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_17_IntTlgEn, getProfileInt( "BAP", "P_FSG_40_0_0_17_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_17_SegmEn, getProfileInt( "BAP", "P_FSG_40_0_0_17_SegmEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_17_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_17_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_17_1_len, getProfileInt( "BAP", "P_FSG_40_0_0_17_1_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_17_1_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_17_1_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_18Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_18Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_18_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_18_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_18_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_18_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_18_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_18_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_18_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_18_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_18_3, getProfileInt( "BAP", "P_FSG_40_0_0_18_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_18_2, getProfileInt( "BAP", "P_FSG_40_0_0_18_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_18_1, getProfileInt( "BAP", "P_FSG_40_0_0_18_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_19Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_19Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_19_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_19_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_19_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_19_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_19_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_19_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_19_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_19_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_19, getProfileInt( "BAP", "P_FSG_40_0_0_19", 0, profileFile ) );
    putValue( P_FSG_40_0_0_19_1, getProfileInt( "BAP", "P_FSG_40_0_0_19_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_20Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_20Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_20_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_20_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_20_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_20_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_20_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_20_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_20_IntTlgEn, getProfileInt( "BAP", "P_FSG_40_0_0_20_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_20_SegmEn, getProfileInt( "BAP", "P_FSG_40_0_0_20_SegmEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_20_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_20_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_20_4_len, getProfileInt( "BAP", "P_FSG_40_0_0_20_4_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_20_4_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_20_4_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_20_3, getProfileInt( "BAP", "P_FSG_40_0_0_20_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_20_1, getProfileInt( "BAP", "P_FSG_40_0_0_20_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_20_2_len, getProfileInt( "BAP", "P_FSG_40_0_0_20_2_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_20_2_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_20_2_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_21Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_21Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_21_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_21_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_21_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_21_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_21_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_21_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_21_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_21_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_21, getProfileInt( "BAP", "P_FSG_40_0_0_21", 0, profileFile ) );
    putValue( P_FSG_40_0_0_21_1, getProfileFloat( "BAP", "P_FSG_40_0_0_21_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_21_1_range, getProfileFloat( "BAP", "P_FSG_40_0_0_21_1_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_22Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_22_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_22_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_22_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_IntTlgEn, getProfileInt( "BAP", "P_FSG_40_0_0_22_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_SegmEn, getProfileInt( "BAP", "P_FSG_40_0_0_22_SegmEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_22_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_19, getProfileInt( "BAP", "P_FSG_40_0_0_22_19", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_16, getProfileInt( "BAP", "P_FSG_40_0_0_22_16", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_13, getProfileInt( "BAP", "P_FSG_40_0_0_22_13", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_10, getProfileInt( "BAP", "P_FSG_40_0_0_22_10", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_7, getProfileInt( "BAP", "P_FSG_40_0_0_22_7", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_4, getProfileInt( "BAP", "P_FSG_40_0_0_22_4", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_1, getProfileInt( "BAP", "P_FSG_40_0_0_22_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_21, getProfileInt( "BAP", "P_FSG_40_0_0_22_21", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_21_0, getProfileInt( "BAP", "P_FSG_40_0_0_22_21_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_21_1, getProfileInt( "BAP", "P_FSG_40_0_0_22_21_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_21_2, getProfileInt( "BAP", "P_FSG_40_0_0_22_21_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_21_3, getProfileInt( "BAP", "P_FSG_40_0_0_22_21_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_21_4, getProfileInt( "BAP", "P_FSG_40_0_0_22_21_4", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_21_5, getProfileInt( "BAP", "P_FSG_40_0_0_22_21_5", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_21_6, getProfileInt( "BAP", "P_FSG_40_0_0_22_21_6", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_21_7, getProfileInt( "BAP", "P_FSG_40_0_0_22_21_7", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_18, getProfileInt( "BAP", "P_FSG_40_0_0_22_18", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_18_0, getProfileInt( "BAP", "P_FSG_40_0_0_22_18_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_18_1, getProfileInt( "BAP", "P_FSG_40_0_0_22_18_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_18_2, getProfileInt( "BAP", "P_FSG_40_0_0_22_18_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_18_3, getProfileInt( "BAP", "P_FSG_40_0_0_22_18_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_18_4, getProfileInt( "BAP", "P_FSG_40_0_0_22_18_4", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_18_5, getProfileInt( "BAP", "P_FSG_40_0_0_22_18_5", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_18_6, getProfileInt( "BAP", "P_FSG_40_0_0_22_18_6", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_18_7, getProfileInt( "BAP", "P_FSG_40_0_0_22_18_7", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_15, getProfileInt( "BAP", "P_FSG_40_0_0_22_15", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_15_0, getProfileInt( "BAP", "P_FSG_40_0_0_22_15_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_15_1, getProfileInt( "BAP", "P_FSG_40_0_0_22_15_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_15_2, getProfileInt( "BAP", "P_FSG_40_0_0_22_15_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_15_3, getProfileInt( "BAP", "P_FSG_40_0_0_22_15_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_15_4, getProfileInt( "BAP", "P_FSG_40_0_0_22_15_4", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_15_5, getProfileInt( "BAP", "P_FSG_40_0_0_22_15_5", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_15_6, getProfileInt( "BAP", "P_FSG_40_0_0_22_15_6", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_15_7, getProfileInt( "BAP", "P_FSG_40_0_0_22_15_7", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_12, getProfileInt( "BAP", "P_FSG_40_0_0_22_12", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_12_0, getProfileInt( "BAP", "P_FSG_40_0_0_22_12_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_12_1, getProfileInt( "BAP", "P_FSG_40_0_0_22_12_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_12_2, getProfileInt( "BAP", "P_FSG_40_0_0_22_12_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_12_3, getProfileInt( "BAP", "P_FSG_40_0_0_22_12_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_12_4, getProfileInt( "BAP", "P_FSG_40_0_0_22_12_4", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_12_5, getProfileInt( "BAP", "P_FSG_40_0_0_22_12_5", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_12_6, getProfileInt( "BAP", "P_FSG_40_0_0_22_12_6", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_12_7, getProfileInt( "BAP", "P_FSG_40_0_0_22_12_7", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_9, getProfileInt( "BAP", "P_FSG_40_0_0_22_9", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_9_0, getProfileInt( "BAP", "P_FSG_40_0_0_22_9_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_9_1, getProfileInt( "BAP", "P_FSG_40_0_0_22_9_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_9_2, getProfileInt( "BAP", "P_FSG_40_0_0_22_9_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_9_3, getProfileInt( "BAP", "P_FSG_40_0_0_22_9_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_9_4, getProfileInt( "BAP", "P_FSG_40_0_0_22_9_4", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_9_5, getProfileInt( "BAP", "P_FSG_40_0_0_22_9_5", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_9_6, getProfileInt( "BAP", "P_FSG_40_0_0_22_9_6", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_9_7, getProfileInt( "BAP", "P_FSG_40_0_0_22_9_7", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_6, getProfileInt( "BAP", "P_FSG_40_0_0_22_6", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_6_0, getProfileInt( "BAP", "P_FSG_40_0_0_22_6_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_6_1, getProfileInt( "BAP", "P_FSG_40_0_0_22_6_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_6_2, getProfileInt( "BAP", "P_FSG_40_0_0_22_6_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_6_3, getProfileInt( "BAP", "P_FSG_40_0_0_22_6_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_6_4, getProfileInt( "BAP", "P_FSG_40_0_0_22_6_4", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_6_5, getProfileInt( "BAP", "P_FSG_40_0_0_22_6_5", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_6_6, getProfileInt( "BAP", "P_FSG_40_0_0_22_6_6", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_6_7, getProfileInt( "BAP", "P_FSG_40_0_0_22_6_7", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_3, getProfileInt( "BAP", "P_FSG_40_0_0_22_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_3_0, getProfileInt( "BAP", "P_FSG_40_0_0_22_3_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_3_1, getProfileInt( "BAP", "P_FSG_40_0_0_22_3_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_3_2, getProfileInt( "BAP", "P_FSG_40_0_0_22_3_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_3_3, getProfileInt( "BAP", "P_FSG_40_0_0_22_3_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_3_4, getProfileInt( "BAP", "P_FSG_40_0_0_22_3_4", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_3_5, getProfileInt( "BAP", "P_FSG_40_0_0_22_3_5", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_3_6, getProfileInt( "BAP", "P_FSG_40_0_0_22_3_6", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_3_7, getProfileInt( "BAP", "P_FSG_40_0_0_22_3_7", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_20, getProfileInt( "BAP", "P_FSG_40_0_0_22_20", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_17, getProfileInt( "BAP", "P_FSG_40_0_0_22_17", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_14, getProfileInt( "BAP", "P_FSG_40_0_0_22_14", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_11, getProfileInt( "BAP", "P_FSG_40_0_0_22_11", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_8, getProfileInt( "BAP", "P_FSG_40_0_0_22_8", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_5, getProfileInt( "BAP", "P_FSG_40_0_0_22_5", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_2, getProfileInt( "BAP", "P_FSG_40_0_0_22_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_23, getProfileInt( "BAP", "P_FSG_40_0_0_22_23", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_23_0, getProfileInt( "BAP", "P_FSG_40_0_0_22_23_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_23_1, getProfileInt( "BAP", "P_FSG_40_0_0_22_23_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_23_2, getProfileInt( "BAP", "P_FSG_40_0_0_22_23_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_23_3, getProfileInt( "BAP", "P_FSG_40_0_0_22_23_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_23_4, getProfileInt( "BAP", "P_FSG_40_0_0_22_23_4", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_23_5, getProfileInt( "BAP", "P_FSG_40_0_0_22_23_5", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_23_6, getProfileInt( "BAP", "P_FSG_40_0_0_22_23_6", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_23_7, getProfileInt( "BAP", "P_FSG_40_0_0_22_23_7", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_22, getProfileInt( "BAP", "P_FSG_40_0_0_22_22", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_22_0, getProfileInt( "BAP", "P_FSG_40_0_0_22_22_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_22_1, getProfileInt( "BAP", "P_FSG_40_0_0_22_22_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_22_2, getProfileInt( "BAP", "P_FSG_40_0_0_22_22_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_22_3, getProfileInt( "BAP", "P_FSG_40_0_0_22_22_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_22_4, getProfileInt( "BAP", "P_FSG_40_0_0_22_22_4", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_22_5, getProfileInt( "BAP", "P_FSG_40_0_0_22_22_5", 0, profileFile ) );
    putValue( P_FSG_40_0_0_22_22_6, getProfileInt( "BAP", "P_FSG_40_0_0_22_22_6", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_23Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_23_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_23_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_23_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_IntTlgEn, getProfileInt( "BAP", "P_FSG_40_0_0_23_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_SegmEn, getProfileInt( "BAP", "P_FSG_40_0_0_23_SegmEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_23_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_19_len, getProfileInt( "BAP", "P_FSG_40_0_0_23_19_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_19_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_23_19_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_16_len, getProfileInt( "BAP", "P_FSG_40_0_0_23_16_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_16_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_23_16_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_13_len, getProfileInt( "BAP", "P_FSG_40_0_0_23_13_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_13_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_23_13_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_10_len, getProfileInt( "BAP", "P_FSG_40_0_0_23_10_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_10_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_23_10_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_7_len, getProfileInt( "BAP", "P_FSG_40_0_0_23_7_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_7_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_23_7_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_4_len, getProfileInt( "BAP", "P_FSG_40_0_0_23_4_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_4_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_23_4_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_1_len, getProfileInt( "BAP", "P_FSG_40_0_0_23_1_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_1_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_23_1_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_20_len, getProfileInt( "BAP", "P_FSG_40_0_0_23_20_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_20_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_23_20_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_17_len, getProfileInt( "BAP", "P_FSG_40_0_0_23_17_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_17_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_23_17_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_14_len, getProfileInt( "BAP", "P_FSG_40_0_0_23_14_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_14_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_23_14_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_11_len, getProfileInt( "BAP", "P_FSG_40_0_0_23_11_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_11_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_23_11_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_8_len, getProfileInt( "BAP", "P_FSG_40_0_0_23_8_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_8_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_23_8_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_21, getProfileInt( "BAP", "P_FSG_40_0_0_23_21", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_5_len, getProfileInt( "BAP", "P_FSG_40_0_0_23_5_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_5_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_23_5_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_18, getProfileInt( "BAP", "P_FSG_40_0_0_23_18", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_2_len, getProfileInt( "BAP", "P_FSG_40_0_0_23_2_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_2_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_23_2_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_15, getProfileInt( "BAP", "P_FSG_40_0_0_23_15", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_12, getProfileInt( "BAP", "P_FSG_40_0_0_23_12", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_9, getProfileInt( "BAP", "P_FSG_40_0_0_23_9", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_6, getProfileInt( "BAP", "P_FSG_40_0_0_23_6", 0, profileFile ) );
    putValue( P_FSG_40_0_0_23_3, getProfileInt( "BAP", "P_FSG_40_0_0_23_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_24Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_24_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_24_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_24_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_IntTlgEn, getProfileInt( "BAP", "P_FSG_40_0_0_24_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_SegmEn, getProfileInt( "BAP", "P_FSG_40_0_0_24_SegmEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_24_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_7, getProfileFloat( "BAP", "P_FSG_40_0_0_24_7", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_7_range, getProfileFloat( "BAP", "P_FSG_40_0_0_24_7_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_6, getProfileFloat( "BAP", "P_FSG_40_0_0_24_6", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_6_range, getProfileFloat( "BAP", "P_FSG_40_0_0_24_6_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_5, getProfileFloat( "BAP", "P_FSG_40_0_0_24_5", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_5_range, getProfileFloat( "BAP", "P_FSG_40_0_0_24_5_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_4, getProfileFloat( "BAP", "P_FSG_40_0_0_24_4", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_4_range, getProfileFloat( "BAP", "P_FSG_40_0_0_24_4_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_3, getProfileFloat( "BAP", "P_FSG_40_0_0_24_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_3_range, getProfileFloat( "BAP", "P_FSG_40_0_0_24_3_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_2, getProfileFloat( "BAP", "P_FSG_40_0_0_24_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_2_range, getProfileFloat( "BAP", "P_FSG_40_0_0_24_2_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_1, getProfileFloat( "BAP", "P_FSG_40_0_0_24_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_24_1_range, getProfileFloat( "BAP", "P_FSG_40_0_0_24_1_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_25Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_25Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_25_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_25_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_25_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_25_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_25_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_25_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_25_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_25_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_25, getProfileInt( "BAP", "P_FSG_40_0_0_25", 0, profileFile ) );
    putValue( P_FSG_40_0_0_25_1, getProfileInt( "BAP", "P_FSG_40_0_0_25_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_26Result_BTN, getProfileInt( "BAP", "M_FSG_40_0_0_26Result_BTN", 0, profileFile ) );
    putValue( M_FSG_40_0_0_26_FctLstItemEn, getProfileInt( "BAP", "M_FSG_40_0_0_26_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_26_FctEn, getProfileInt( "BAP", "M_FSG_40_0_0_26_FctEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_26_ErrEn, getProfileInt( "BAP", "M_FSG_40_0_0_26_ErrEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_26_ErrCode, getProfileInt( "BAP", "M_FSG_40_0_0_26_ErrCode", 0, profileFile ) );
    putValue( M_FSG_40_0_0_26_Result, getProfileInt( "BAP", "M_FSG_40_0_0_26_Result", 0, profileFile ) );
    putValue( M_FSG_40_0_0_26_Result_1, getProfileInt( "BAP", "M_FSG_40_0_0_26_Result_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_26_Processing_1_range, getProfileInt( "BAP", "M_FSG_40_0_0_26_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_26_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_26_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_26_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_26_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_26_Start_1_len, getProfileInt( "BAP", "M_FSG_40_0_0_26_Start_1_len", 0, profileFile ) );
    putValue( M_FSG_40_0_0_26_Start_1_cnt, getProfileInt( "BAP", "M_FSG_40_0_0_26_Start_1_cnt", 0, profileFile ) );
    putValue( M_FSG_40_0_0_26_Start_2_len, getProfileInt( "BAP", "M_FSG_40_0_0_26_Start_2_len", 0, profileFile ) );
    putValue( M_FSG_40_0_0_26_Start_2_cnt, getProfileInt( "BAP", "M_FSG_40_0_0_26_Start_2_cnt", 0, profileFile ) );
    putValue( M_FSG_40_0_0_27Result_BTN, getProfileInt( "BAP", "M_FSG_40_0_0_27Result_BTN", 0, profileFile ) );
    putValue( M_FSG_40_0_0_27_FctLstItemEn, getProfileInt( "BAP", "M_FSG_40_0_0_27_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_27_FctEn, getProfileInt( "BAP", "M_FSG_40_0_0_27_FctEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_27_ErrEn, getProfileInt( "BAP", "M_FSG_40_0_0_27_ErrEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_27_ErrCode, getProfileInt( "BAP", "M_FSG_40_0_0_27_ErrCode", 0, profileFile ) );
    putValue( M_FSG_40_0_0_27_Result, getProfileInt( "BAP", "M_FSG_40_0_0_27_Result", 0, profileFile ) );
    putValue( M_FSG_40_0_0_27_Result_1, getProfileInt( "BAP", "M_FSG_40_0_0_27_Result_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_27_Processing_1_range, getProfileInt( "BAP", "M_FSG_40_0_0_27_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_27_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_27_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_27_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_27_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_27_Start, getProfileInt( "BAP", "M_FSG_40_0_0_27_Start", 0, profileFile ) );
    putValue( M_FSG_40_0_0_27_Start_1, getProfileInt( "BAP", "M_FSG_40_0_0_27_Start_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_28Result_BTN, getProfileInt( "BAP", "M_FSG_40_0_0_28Result_BTN", 0, profileFile ) );
    putValue( M_FSG_40_0_0_28_FctLstItemEn, getProfileInt( "BAP", "M_FSG_40_0_0_28_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_28_FctEn, getProfileInt( "BAP", "M_FSG_40_0_0_28_FctEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_28_ErrEn, getProfileInt( "BAP", "M_FSG_40_0_0_28_ErrEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_28_ErrCode, getProfileInt( "BAP", "M_FSG_40_0_0_28_ErrCode", 0, profileFile ) );
    putValue( M_FSG_40_0_0_28_Result, getProfileInt( "BAP", "M_FSG_40_0_0_28_Result", 0, profileFile ) );
    putValue( M_FSG_40_0_0_28_Result_1, getProfileInt( "BAP", "M_FSG_40_0_0_28_Result_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_28_Processing_1_range, getProfileInt( "BAP", "M_FSG_40_0_0_28_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_28_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_28_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_28_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_28_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_28_Start, getProfileInt( "BAP", "M_FSG_40_0_0_28_Start", 0, profileFile ) );
    putValue( M_FSG_40_0_0_28_Start_1, getProfileInt( "BAP", "M_FSG_40_0_0_28_Start_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_29Result_BTN, getProfileInt( "BAP", "M_FSG_40_0_0_29Result_BTN", 0, profileFile ) );
    putValue( M_FSG_40_0_0_29_FctLstItemEn, getProfileInt( "BAP", "M_FSG_40_0_0_29_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_29_FctEn, getProfileInt( "BAP", "M_FSG_40_0_0_29_FctEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_29_ErrEn, getProfileInt( "BAP", "M_FSG_40_0_0_29_ErrEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_29_ErrCode, getProfileInt( "BAP", "M_FSG_40_0_0_29_ErrCode", 0, profileFile ) );
    putValue( M_FSG_40_0_0_29_Result, getProfileInt( "BAP", "M_FSG_40_0_0_29_Result", 0, profileFile ) );
    putValue( M_FSG_40_0_0_29_Result_1, getProfileInt( "BAP", "M_FSG_40_0_0_29_Result_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_29_Processing_1_range, getProfileInt( "BAP", "M_FSG_40_0_0_29_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_29_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_29_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_29_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_29_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_29_Start, getProfileInt( "BAP", "M_FSG_40_0_0_29_Start", 0, profileFile ) );
    putValue( M_FSG_40_0_0_29_Start_1, getProfileInt( "BAP", "M_FSG_40_0_0_29_Start_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_30Result_BTN, getProfileInt( "BAP", "M_FSG_40_0_0_30Result_BTN", 0, profileFile ) );
    putValue( M_FSG_40_0_0_30_FctLstItemEn, getProfileInt( "BAP", "M_FSG_40_0_0_30_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_30_FctEn, getProfileInt( "BAP", "M_FSG_40_0_0_30_FctEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_30_ErrEn, getProfileInt( "BAP", "M_FSG_40_0_0_30_ErrEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_30_ErrCode, getProfileInt( "BAP", "M_FSG_40_0_0_30_ErrCode", 0, profileFile ) );
    putValue( M_FSG_40_0_0_30_Result, getProfileInt( "BAP", "M_FSG_40_0_0_30_Result", 0, profileFile ) );
    putValue( M_FSG_40_0_0_30_Result_1, getProfileInt( "BAP", "M_FSG_40_0_0_30_Result_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_30_Processing_1_range, getProfileInt( "BAP", "M_FSG_40_0_0_30_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_30_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_30_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_30_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_30_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_30_Start, getProfileInt( "BAP", "M_FSG_40_0_0_30_Start", 0, profileFile ) );
    putValue( M_FSG_40_0_0_30_Start_0, getProfileInt( "BAP", "M_FSG_40_0_0_30_Start_0", 0, profileFile ) );
    putValue( M_FSG_40_0_0_31Result_BTN, getProfileInt( "BAP", "M_FSG_40_0_0_31Result_BTN", 0, profileFile ) );
    putValue( M_FSG_40_0_0_31_FctLstItemEn, getProfileInt( "BAP", "M_FSG_40_0_0_31_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_31_FctEn, getProfileInt( "BAP", "M_FSG_40_0_0_31_FctEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_31_ErrEn, getProfileInt( "BAP", "M_FSG_40_0_0_31_ErrEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_31_ErrCode, getProfileInt( "BAP", "M_FSG_40_0_0_31_ErrCode", 0, profileFile ) );
    putValue( M_FSG_40_0_0_31_Result, getProfileInt( "BAP", "M_FSG_40_0_0_31_Result", 0, profileFile ) );
    putValue( M_FSG_40_0_0_31_Result_1, getProfileInt( "BAP", "M_FSG_40_0_0_31_Result_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_31_Processing_1_range, getProfileInt( "BAP", "M_FSG_40_0_0_31_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_31_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_31_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_31_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_31_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_31_Start, getProfileInt( "BAP", "M_FSG_40_0_0_31_Start", 0, profileFile ) );
    putValue( M_FSG_40_0_0_31_Start_0, getProfileInt( "BAP", "M_FSG_40_0_0_31_Start_0", 0, profileFile ) );
    putValue( M_FSG_40_0_0_32Result_BTN, getProfileInt( "BAP", "M_FSG_40_0_0_32Result_BTN", 0, profileFile ) );
    putValue( M_FSG_40_0_0_32_FctLstItemEn, getProfileInt( "BAP", "M_FSG_40_0_0_32_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_32_FctEn, getProfileInt( "BAP", "M_FSG_40_0_0_32_FctEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_32_ErrEn, getProfileInt( "BAP", "M_FSG_40_0_0_32_ErrEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_32_ErrCode, getProfileInt( "BAP", "M_FSG_40_0_0_32_ErrCode", 0, profileFile ) );
    putValue( M_FSG_40_0_0_32_Result, getProfileInt( "BAP", "M_FSG_40_0_0_32_Result", 0, profileFile ) );
    putValue( M_FSG_40_0_0_32_Result_1, getProfileInt( "BAP", "M_FSG_40_0_0_32_Result_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_32_Processing_1_range, getProfileInt( "BAP", "M_FSG_40_0_0_32_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_32_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_32_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_32_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_32_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_32_Start, getProfileInt( "BAP", "M_FSG_40_0_0_32_Start", 0, profileFile ) );
    putValue( M_FSG_40_0_0_32_Start_0, getProfileInt( "BAP", "M_FSG_40_0_0_32_Start_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_33Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_33Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_33_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_33_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_33_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_33_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_33_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_33_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_33_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_33_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_33, getProfileInt( "BAP", "P_FSG_40_0_0_33", 0, profileFile ) );
    putValue( P_FSG_40_0_0_33_1, getProfileInt( "BAP", "P_FSG_40_0_0_33_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_33_1_0, getProfileInt( "BAP", "P_FSG_40_0_0_33_1_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_34Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_34Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_34_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_34_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_34_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_34_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_34_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_34_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_34_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_34_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_34, getProfileInt( "BAP", "P_FSG_40_0_0_34", 0, profileFile ) );
    putValue( P_FSG_40_0_0_34_1, getProfileInt( "BAP", "P_FSG_40_0_0_34_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_34_1_0, getProfileInt( "BAP", "P_FSG_40_0_0_34_1_0", 0, profileFile ) );
    putValue( M_FSG_40_0_0_35Result_BTN, getProfileInt( "BAP", "M_FSG_40_0_0_35Result_BTN", 0, profileFile ) );
    putValue( M_FSG_40_0_0_35_FctLstItemEn, getProfileInt( "BAP", "M_FSG_40_0_0_35_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_35_FctEn, getProfileInt( "BAP", "M_FSG_40_0_0_35_FctEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_35_ErrEn, getProfileInt( "BAP", "M_FSG_40_0_0_35_ErrEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_35_ErrCode, getProfileInt( "BAP", "M_FSG_40_0_0_35_ErrCode", 0, profileFile ) );
    putValue( M_FSG_40_0_0_35_Result, getProfileInt( "BAP", "M_FSG_40_0_0_35_Result", 0, profileFile ) );
    putValue( M_FSG_40_0_0_35_Result_1, getProfileInt( "BAP", "M_FSG_40_0_0_35_Result_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_35_Processing_1_range, getProfileInt( "BAP", "M_FSG_40_0_0_35_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_35_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_35_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_35_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_35_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_35_Start, getProfileInt( "BAP", "M_FSG_40_0_0_35_Start", 0, profileFile ) );
    putValue( M_FSG_40_0_0_35_Start_0, getProfileInt( "BAP", "M_FSG_40_0_0_35_Start_0", 0, profileFile ) );
    putValue( M_FSG_40_0_0_36Result_BTN, getProfileInt( "BAP", "M_FSG_40_0_0_36Result_BTN", 0, profileFile ) );
    putValue( M_FSG_40_0_0_36_FctLstItemEn, getProfileInt( "BAP", "M_FSG_40_0_0_36_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_36_FctEn, getProfileInt( "BAP", "M_FSG_40_0_0_36_FctEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_36_ErrEn, getProfileInt( "BAP", "M_FSG_40_0_0_36_ErrEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_36_ErrCode, getProfileInt( "BAP", "M_FSG_40_0_0_36_ErrCode", 0, profileFile ) );
    putValue( M_FSG_40_0_0_36_Result, getProfileInt( "BAP", "M_FSG_40_0_0_36_Result", 0, profileFile ) );
    putValue( M_FSG_40_0_0_36_Result_1, getProfileInt( "BAP", "M_FSG_40_0_0_36_Result_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_36_Processing_1_range, getProfileInt( "BAP", "M_FSG_40_0_0_36_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_36_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_36_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_36_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_36_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_36_Start, getProfileInt( "BAP", "M_FSG_40_0_0_36_Start", 0, profileFile ) );
    putValue( M_FSG_40_0_0_36_Start_0, getProfileInt( "BAP", "M_FSG_40_0_0_36_Start_0", 0, profileFile ) );
    putValue( M_FSG_40_0_0_37Result_BTN, getProfileInt( "BAP", "M_FSG_40_0_0_37Result_BTN", 0, profileFile ) );
    putValue( M_FSG_40_0_0_37_FctLstItemEn, getProfileInt( "BAP", "M_FSG_40_0_0_37_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_37_FctEn, getProfileInt( "BAP", "M_FSG_40_0_0_37_FctEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_37_ErrEn, getProfileInt( "BAP", "M_FSG_40_0_0_37_ErrEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_37_ErrCode, getProfileInt( "BAP", "M_FSG_40_0_0_37_ErrCode", 0, profileFile ) );
    putValue( M_FSG_40_0_0_37_Result, getProfileInt( "BAP", "M_FSG_40_0_0_37_Result", 0, profileFile ) );
    putValue( M_FSG_40_0_0_37_Result_1, getProfileInt( "BAP", "M_FSG_40_0_0_37_Result_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_37_Processing_1_range, getProfileInt( "BAP", "M_FSG_40_0_0_37_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_37_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_37_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_37_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_37_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_37_Start, getProfileInt( "BAP", "M_FSG_40_0_0_37_Start", 0, profileFile ) );
    putValue( M_FSG_40_0_0_37_Start_0, getProfileInt( "BAP", "M_FSG_40_0_0_37_Start_0", 0, profileFile ) );
    putValue( M_FSG_40_0_0_38Result_BTN, getProfileInt( "BAP", "M_FSG_40_0_0_38Result_BTN", 0, profileFile ) );
    putValue( M_FSG_40_0_0_38_FctLstItemEn, getProfileInt( "BAP", "M_FSG_40_0_0_38_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_38_FctEn, getProfileInt( "BAP", "M_FSG_40_0_0_38_FctEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_38_ErrEn, getProfileInt( "BAP", "M_FSG_40_0_0_38_ErrEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_38_ErrCode, getProfileInt( "BAP", "M_FSG_40_0_0_38_ErrCode", 0, profileFile ) );
    putValue( M_FSG_40_0_0_38_Result, getProfileInt( "BAP", "M_FSG_40_0_0_38_Result", 0, profileFile ) );
    putValue( M_FSG_40_0_0_38_Result_1, getProfileInt( "BAP", "M_FSG_40_0_0_38_Result_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_38_Processing_1_range, getProfileInt( "BAP", "M_FSG_40_0_0_38_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_38_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_38_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_38_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_38_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_38_Start, getProfileInt( "BAP", "M_FSG_40_0_0_38_Start", 0, profileFile ) );
    putValue( M_FSG_40_0_0_38_Start_0, getProfileInt( "BAP", "M_FSG_40_0_0_38_Start_0", 0, profileFile ) );
    putValue( M_FSG_40_0_0_39Result_BTN, getProfileInt( "BAP", "M_FSG_40_0_0_39Result_BTN", 0, profileFile ) );
    putValue( M_FSG_40_0_0_39_FctLstItemEn, getProfileInt( "BAP", "M_FSG_40_0_0_39_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_39_FctEn, getProfileInt( "BAP", "M_FSG_40_0_0_39_FctEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_39_ErrEn, getProfileInt( "BAP", "M_FSG_40_0_0_39_ErrEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_39_ErrCode, getProfileInt( "BAP", "M_FSG_40_0_0_39_ErrCode", 0, profileFile ) );
    putValue( M_FSG_40_0_0_39_Result, getProfileInt( "BAP", "M_FSG_40_0_0_39_Result", 0, profileFile ) );
    putValue( M_FSG_40_0_0_39_Result_1, getProfileInt( "BAP", "M_FSG_40_0_0_39_Result_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_39_Processing_1_range, getProfileInt( "BAP", "M_FSG_40_0_0_39_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_39_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_39_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_39_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_39_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_39_Start, getProfileInt( "BAP", "M_FSG_40_0_0_39_Start", 0, profileFile ) );
    putValue( M_FSG_40_0_0_39_Start_0, getProfileInt( "BAP", "M_FSG_40_0_0_39_Start_0", 0, profileFile ) );
    putValue( M_FSG_40_0_0_40Result_BTN, getProfileInt( "BAP", "M_FSG_40_0_0_40Result_BTN", 0, profileFile ) );
    putValue( M_FSG_40_0_0_40_FctLstItemEn, getProfileInt( "BAP", "M_FSG_40_0_0_40_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_40_FctEn, getProfileInt( "BAP", "M_FSG_40_0_0_40_FctEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_40_ErrEn, getProfileInt( "BAP", "M_FSG_40_0_0_40_ErrEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_40_ErrCode, getProfileInt( "BAP", "M_FSG_40_0_0_40_ErrCode", 0, profileFile ) );
    putValue( M_FSG_40_0_0_40_Result, getProfileInt( "BAP", "M_FSG_40_0_0_40_Result", 0, profileFile ) );
    putValue( M_FSG_40_0_0_40_Result_1, getProfileInt( "BAP", "M_FSG_40_0_0_40_Result_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_40_Processing_1_range, getProfileInt( "BAP", "M_FSG_40_0_0_40_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_40_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_40_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_40_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_40_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_40_Start, getProfileInt( "BAP", "M_FSG_40_0_0_40_Start", 0, profileFile ) );
    putValue( M_FSG_40_0_0_40_Start_0, getProfileInt( "BAP", "M_FSG_40_0_0_40_Start_0", 0, profileFile ) );
    putValue( M_FSG_40_0_0_41Result_BTN, getProfileInt( "BAP", "M_FSG_40_0_0_41Result_BTN", 0, profileFile ) );
    putValue( M_FSG_40_0_0_41_FctLstItemEn, getProfileInt( "BAP", "M_FSG_40_0_0_41_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_41_FctEn, getProfileInt( "BAP", "M_FSG_40_0_0_41_FctEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_41_ErrEn, getProfileInt( "BAP", "M_FSG_40_0_0_41_ErrEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_41_ErrCode, getProfileInt( "BAP", "M_FSG_40_0_0_41_ErrCode", 0, profileFile ) );
    putValue( M_FSG_40_0_0_41_Result, getProfileInt( "BAP", "M_FSG_40_0_0_41_Result", 0, profileFile ) );
    putValue( M_FSG_40_0_0_41_Result_1, getProfileInt( "BAP", "M_FSG_40_0_0_41_Result_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_41_Processing_1_range, getProfileInt( "BAP", "M_FSG_40_0_0_41_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_41_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_41_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_41_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_41_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_41_Start, getProfileInt( "BAP", "M_FSG_40_0_0_41_Start", 0, profileFile ) );
    putValue( M_FSG_40_0_0_41_Start_1, getProfileInt( "BAP", "M_FSG_40_0_0_41_Start_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_42Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_42Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_42_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_42_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_42_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_42_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_42_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_42_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_42_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_42_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_42, getProfileInt( "BAP", "P_FSG_40_0_0_42", 0, profileFile ) );
    putValue( P_FSG_40_0_0_42_1, getProfileInt( "BAP", "P_FSG_40_0_0_42_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_43Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_43Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_43_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_43_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_43_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_43_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_43_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_43_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_43_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_43_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_43_5, getProfileInt( "BAP", "P_FSG_40_0_0_43_5", 0, profileFile ) );
    putValue( P_FSG_40_0_0_43_5_0, getProfileInt( "BAP", "P_FSG_40_0_0_43_5_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_43_5_1, getProfileInt( "BAP", "P_FSG_40_0_0_43_5_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_43_5_2, getProfileInt( "BAP", "P_FSG_40_0_0_43_5_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_43_5_3, getProfileInt( "BAP", "P_FSG_40_0_0_43_5_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_43_2, getProfileFloat( "BAP", "P_FSG_40_0_0_43_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_43_2_range, getProfileFloat( "BAP", "P_FSG_40_0_0_43_2_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_43_1, getProfileFloat( "BAP", "P_FSG_40_0_0_43_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_43_1_range, getProfileFloat( "BAP", "P_FSG_40_0_0_43_1_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_43_4, getProfileFloat( "BAP", "P_FSG_40_0_0_43_4", 0, profileFile ) );
    putValue( P_FSG_40_0_0_43_4_range, getProfileFloat( "BAP", "P_FSG_40_0_0_43_4_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_43_3, getProfileFloat( "BAP", "P_FSG_40_0_0_43_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_43_3_range, getProfileFloat( "BAP", "P_FSG_40_0_0_43_3_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_44Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_44Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_44_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_44_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_44_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_44_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_44_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_44_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_44_IntTlgEn, getProfileInt( "BAP", "P_FSG_40_0_0_44_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_44_SegmEn, getProfileInt( "BAP", "P_FSG_40_0_0_44_SegmEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_44_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_44_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_44_2, getProfileFloat( "BAP", "P_FSG_40_0_0_44_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_44_2_range, getProfileFloat( "BAP", "P_FSG_40_0_0_44_2_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_44_1, getProfileInt( "BAP", "P_FSG_40_0_0_44_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_44_3, getProfileFloat( "BAP", "P_FSG_40_0_0_44_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_44_3_range, getProfileFloat( "BAP", "P_FSG_40_0_0_44_3_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_45Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_45Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_45_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_45_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_45_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_45_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_45_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_45_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_45_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_45_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_45_2, getProfileFloat( "BAP", "P_FSG_40_0_0_45_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_45_2_range, getProfileFloat( "BAP", "P_FSG_40_0_0_45_2_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_45_1, getProfileFloat( "BAP", "P_FSG_40_0_0_45_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_45_1_range, getProfileFloat( "BAP", "P_FSG_40_0_0_45_1_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46Changed_BTN, getProfileInt( "BAP", "A_FSG_40_0_0_46Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46Status_BTN, getProfileInt( "BAP", "A_FSG_40_0_0_46Status_BTN", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_FctLstItemEn, getProfileInt( "BAP", "A_FSG_40_0_0_46_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_FctEn, getProfileInt( "BAP", "A_FSG_40_0_0_46_FctEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_ErrEn, getProfileInt( "BAP", "A_FSG_40_0_0_46_ErrEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_IntTlgEn, getProfileInt( "BAP", "A_FSG_40_0_0_46_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_SegmEn, getProfileInt( "BAP", "A_FSG_40_0_0_46_SegmEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_AT, getProfileInt( "BAP", "A_FSG_40_0_0_46_AT", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_ErrCode, getProfileInt( "BAP", "A_FSG_40_0_0_46_ErrCode", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_DataIndex_SetGet_Incr, getProfileInt( "BAP", "A_FSG_40_0_0_46_DataIndex_SetGet_Incr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_40_0_0_46_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_40_0_0_46_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_loadArray_Btn, getProfileInt( "BAP", "A_FSG_40_0_0_46_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_generateData_Btn, getProfileInt( "BAP", "A_FSG_40_0_0_46_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_7_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_7_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_7_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_7_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_4_len, getProfileInt( "BAP", "A_FSG_40_0_0_46_Data_4_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_4_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_46_Data_4_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_3, getProfileFloat( "BAP", "A_FSG_40_0_0_46_3", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_3_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_3_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_3, getProfileInt( "BAP", "A_FSG_40_0_0_46_Data_3", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_1, getProfileInt( "BAP", "A_FSG_40_0_0_46_1", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_6_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_6_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_6_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_6_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_10_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_10_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_10_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_10_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_2_len, getProfileInt( "BAP", "A_FSG_40_0_0_46_Data_2_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_2_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_46_Data_2_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_9_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_9_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_9_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_9_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_8_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_8_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_8_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_8_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_5_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_5_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_5_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_5_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_10_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_10_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_1_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_2, getProfileFloat( "BAP", "A_FSG_40_0_0_46_2", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_2_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_2_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_RecAdr, getProfileInt( "BAP", "A_FSG_40_0_0_46_RecAdr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Direction, getProfileInt( "BAP", "A_FSG_40_0_0_46_Direction", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Shift, getProfileInt( "BAP", "A_FSG_40_0_0_46_Shift", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_TransPos, getProfileInt( "BAP", "A_FSG_40_0_0_46_TransPos", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_IndexSize, getProfileInt( "BAP", "A_FSG_40_0_0_46_IndexSize", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Start, getProfileInt( "BAP", "A_FSG_40_0_0_46_Start", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Elements, getProfileInt( "BAP", "A_FSG_40_0_0_46_Elements", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_40_0_0_46_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Changed_Direction, getProfileInt( "BAP", "A_FSG_40_0_0_46_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Changed_Shift, getProfileInt( "BAP", "A_FSG_40_0_0_46_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Changed_TransPos, getProfileInt( "BAP", "A_FSG_40_0_0_46_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_40_0_0_46_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Changed_Start, getProfileInt( "BAP", "A_FSG_40_0_0_46_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Changed_Elements, getProfileInt( "BAP", "A_FSG_40_0_0_46_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_DataIndex_SetGet, getProfileInt( "BAP", "A_FSG_40_0_0_46_DataIndex_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_DataIndex_SetGet_Incr, getProfileInt( "BAP", "A_FSG_40_0_0_46_DataIndex_SetGet_Incr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_DataIndex_SetGet_Decr, getProfileInt( "BAP", "A_FSG_40_0_0_46_DataIndex_SetGet_Decr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_7_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_7_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_7_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_7_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_4_SetGet_len, getProfileInt( "BAP", "A_FSG_40_0_0_46_Data_4_SetGet_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_4_SetGet_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_46_Data_4_SetGet_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_3_SetGet, getProfileInt( "BAP", "A_FSG_40_0_0_46_Data_3_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_1_SetGet, getProfileInt( "BAP", "A_FSG_40_0_0_46_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_6_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_6_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_6_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_6_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_10_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_10_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_10_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_10_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_2_SetGet_len, getProfileInt( "BAP", "A_FSG_40_0_0_46_Data_2_SetGet_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_2_SetGet_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_46_Data_2_SetGet_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_9_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_9_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_9_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_9_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_8_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_8_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_8_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_8_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_5_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_5_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_5_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_5_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_1_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_Data_1_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_2_SetGet, getProfileFloat( "BAP", "A_FSG_40_0_0_46_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_46_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_40_0_0_46_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_SetGet_Direction, getProfileInt( "BAP", "A_FSG_40_0_0_46_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_SetGet_Shift, getProfileInt( "BAP", "A_FSG_40_0_0_46_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_40_0_0_46_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_SetGet_Start, getProfileInt( "BAP", "A_FSG_40_0_0_46_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_40_0_0_46_SetGet_Elements, getProfileInt( "BAP", "A_FSG_40_0_0_46_SetGet_Elements", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47Changed_BTN, getProfileInt( "BAP", "A_FSG_40_0_0_47Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47Status_BTN, getProfileInt( "BAP", "A_FSG_40_0_0_47Status_BTN", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_FctLstItemEn, getProfileInt( "BAP", "A_FSG_40_0_0_47_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_FctEn, getProfileInt( "BAP", "A_FSG_40_0_0_47_FctEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_ErrEn, getProfileInt( "BAP", "A_FSG_40_0_0_47_ErrEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_IntTlgEn, getProfileInt( "BAP", "A_FSG_40_0_0_47_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_SegmEn, getProfileInt( "BAP", "A_FSG_40_0_0_47_SegmEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_AT, getProfileInt( "BAP", "A_FSG_40_0_0_47_AT", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_ErrCode, getProfileInt( "BAP", "A_FSG_40_0_0_47_ErrCode", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_DataIndex_SetGet_Incr, getProfileInt( "BAP", "A_FSG_40_0_0_47_DataIndex_SetGet_Incr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_40_0_0_47_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_40_0_0_47_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_loadArray_Btn, getProfileInt( "BAP", "A_FSG_40_0_0_47_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_generateData_Btn, getProfileInt( "BAP", "A_FSG_40_0_0_47_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_7_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_7_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_7_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_7_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_4_len, getProfileInt( "BAP", "A_FSG_40_0_0_47_Data_4_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_4_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_47_Data_4_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_3, getProfileFloat( "BAP", "A_FSG_40_0_0_47_3", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_3_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_3_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_3, getProfileInt( "BAP", "A_FSG_40_0_0_47_Data_3", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_1, getProfileInt( "BAP", "A_FSG_40_0_0_47_1", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_6_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_6_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_6_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_6_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_10_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_10_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_10_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_10_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_2_len, getProfileInt( "BAP", "A_FSG_40_0_0_47_Data_2_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_2_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_47_Data_2_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_9_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_9_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_9_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_9_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_8_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_8_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_8_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_8_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_5_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_5_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_5_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_5_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_10_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_10_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_1_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_2, getProfileFloat( "BAP", "A_FSG_40_0_0_47_2", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_2_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_2_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_RecAdr, getProfileInt( "BAP", "A_FSG_40_0_0_47_RecAdr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Direction, getProfileInt( "BAP", "A_FSG_40_0_0_47_Direction", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Shift, getProfileInt( "BAP", "A_FSG_40_0_0_47_Shift", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_TransPos, getProfileInt( "BAP", "A_FSG_40_0_0_47_TransPos", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_IndexSize, getProfileInt( "BAP", "A_FSG_40_0_0_47_IndexSize", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Start, getProfileInt( "BAP", "A_FSG_40_0_0_47_Start", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Elements, getProfileInt( "BAP", "A_FSG_40_0_0_47_Elements", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_40_0_0_47_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Changed_Direction, getProfileInt( "BAP", "A_FSG_40_0_0_47_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Changed_Shift, getProfileInt( "BAP", "A_FSG_40_0_0_47_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Changed_TransPos, getProfileInt( "BAP", "A_FSG_40_0_0_47_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_40_0_0_47_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Changed_Start, getProfileInt( "BAP", "A_FSG_40_0_0_47_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Changed_Elements, getProfileInt( "BAP", "A_FSG_40_0_0_47_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_DataIndex_SetGet, getProfileInt( "BAP", "A_FSG_40_0_0_47_DataIndex_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_DataIndex_SetGet_Incr, getProfileInt( "BAP", "A_FSG_40_0_0_47_DataIndex_SetGet_Incr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_DataIndex_SetGet_Decr, getProfileInt( "BAP", "A_FSG_40_0_0_47_DataIndex_SetGet_Decr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_7_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_7_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_7_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_7_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_4_SetGet_len, getProfileInt( "BAP", "A_FSG_40_0_0_47_Data_4_SetGet_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_4_SetGet_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_47_Data_4_SetGet_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_3_SetGet, getProfileInt( "BAP", "A_FSG_40_0_0_47_Data_3_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_1_SetGet, getProfileInt( "BAP", "A_FSG_40_0_0_47_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_6_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_6_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_6_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_6_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_10_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_10_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_10_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_10_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_2_SetGet_len, getProfileInt( "BAP", "A_FSG_40_0_0_47_Data_2_SetGet_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_2_SetGet_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_47_Data_2_SetGet_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_9_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_9_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_9_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_9_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_8_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_8_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_8_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_8_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_5_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_5_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_5_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_5_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_1_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_Data_1_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_2_SetGet, getProfileFloat( "BAP", "A_FSG_40_0_0_47_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_47_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_40_0_0_47_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_SetGet_Direction, getProfileInt( "BAP", "A_FSG_40_0_0_47_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_SetGet_Shift, getProfileInt( "BAP", "A_FSG_40_0_0_47_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_40_0_0_47_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_SetGet_Start, getProfileInt( "BAP", "A_FSG_40_0_0_47_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_40_0_0_47_SetGet_Elements, getProfileInt( "BAP", "A_FSG_40_0_0_47_SetGet_Elements", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48Changed_BTN, getProfileInt( "BAP", "A_FSG_40_0_0_48Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48Status_BTN, getProfileInt( "BAP", "A_FSG_40_0_0_48Status_BTN", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_FctLstItemEn, getProfileInt( "BAP", "A_FSG_40_0_0_48_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_FctEn, getProfileInt( "BAP", "A_FSG_40_0_0_48_FctEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_ErrEn, getProfileInt( "BAP", "A_FSG_40_0_0_48_ErrEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_IntTlgEn, getProfileInt( "BAP", "A_FSG_40_0_0_48_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_SegmEn, getProfileInt( "BAP", "A_FSG_40_0_0_48_SegmEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_AT, getProfileInt( "BAP", "A_FSG_40_0_0_48_AT", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_ErrCode, getProfileInt( "BAP", "A_FSG_40_0_0_48_ErrCode", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_DataIndex_SetGet_Incr, getProfileInt( "BAP", "A_FSG_40_0_0_48_DataIndex_SetGet_Incr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_40_0_0_48_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_40_0_0_48_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_loadArray_Btn, getProfileInt( "BAP", "A_FSG_40_0_0_48_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_generateData_Btn, getProfileInt( "BAP", "A_FSG_40_0_0_48_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_7_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_7_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_7_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_7_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_4_len, getProfileInt( "BAP", "A_FSG_40_0_0_48_Data_4_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_4_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_48_Data_4_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_3, getProfileFloat( "BAP", "A_FSG_40_0_0_48_3", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_3_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_3_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_3, getProfileInt( "BAP", "A_FSG_40_0_0_48_Data_3", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_1, getProfileInt( "BAP", "A_FSG_40_0_0_48_1", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_6_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_6_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_6_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_6_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_10_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_10_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_10_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_10_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_2_len, getProfileInt( "BAP", "A_FSG_40_0_0_48_Data_2_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_2_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_48_Data_2_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_9_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_9_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_9_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_9_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_8_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_8_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_8_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_8_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_5_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_5_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_5_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_5_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_10_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_10_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_1_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_2, getProfileFloat( "BAP", "A_FSG_40_0_0_48_2", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_2_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_2_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_RecAdr, getProfileInt( "BAP", "A_FSG_40_0_0_48_RecAdr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Direction, getProfileInt( "BAP", "A_FSG_40_0_0_48_Direction", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Shift, getProfileInt( "BAP", "A_FSG_40_0_0_48_Shift", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_TransPos, getProfileInt( "BAP", "A_FSG_40_0_0_48_TransPos", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_IndexSize, getProfileInt( "BAP", "A_FSG_40_0_0_48_IndexSize", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Start, getProfileInt( "BAP", "A_FSG_40_0_0_48_Start", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Elements, getProfileInt( "BAP", "A_FSG_40_0_0_48_Elements", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_40_0_0_48_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Changed_Direction, getProfileInt( "BAP", "A_FSG_40_0_0_48_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Changed_Shift, getProfileInt( "BAP", "A_FSG_40_0_0_48_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Changed_TransPos, getProfileInt( "BAP", "A_FSG_40_0_0_48_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_40_0_0_48_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Changed_Start, getProfileInt( "BAP", "A_FSG_40_0_0_48_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Changed_Elements, getProfileInt( "BAP", "A_FSG_40_0_0_48_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_DataIndex_SetGet, getProfileInt( "BAP", "A_FSG_40_0_0_48_DataIndex_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_DataIndex_SetGet_Incr, getProfileInt( "BAP", "A_FSG_40_0_0_48_DataIndex_SetGet_Incr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_DataIndex_SetGet_Decr, getProfileInt( "BAP", "A_FSG_40_0_0_48_DataIndex_SetGet_Decr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_7_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_7_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_7_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_7_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_4_SetGet_len, getProfileInt( "BAP", "A_FSG_40_0_0_48_Data_4_SetGet_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_4_SetGet_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_48_Data_4_SetGet_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_3_SetGet, getProfileInt( "BAP", "A_FSG_40_0_0_48_Data_3_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_1_SetGet, getProfileInt( "BAP", "A_FSG_40_0_0_48_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_6_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_6_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_6_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_6_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_10_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_10_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_10_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_10_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_2_SetGet_len, getProfileInt( "BAP", "A_FSG_40_0_0_48_Data_2_SetGet_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_2_SetGet_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_48_Data_2_SetGet_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_9_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_9_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_9_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_9_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_8_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_8_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_8_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_8_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_5_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_5_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_5_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_5_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_1_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_Data_1_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_2_SetGet, getProfileFloat( "BAP", "A_FSG_40_0_0_48_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_48_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_40_0_0_48_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_SetGet_Direction, getProfileInt( "BAP", "A_FSG_40_0_0_48_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_SetGet_Shift, getProfileInt( "BAP", "A_FSG_40_0_0_48_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_40_0_0_48_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_SetGet_Start, getProfileInt( "BAP", "A_FSG_40_0_0_48_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_40_0_0_48_SetGet_Elements, getProfileInt( "BAP", "A_FSG_40_0_0_48_SetGet_Elements", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49Changed_BTN, getProfileInt( "BAP", "A_FSG_40_0_0_49Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49Status_BTN, getProfileInt( "BAP", "A_FSG_40_0_0_49Status_BTN", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_FctLstItemEn, getProfileInt( "BAP", "A_FSG_40_0_0_49_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_FctEn, getProfileInt( "BAP", "A_FSG_40_0_0_49_FctEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_ErrEn, getProfileInt( "BAP", "A_FSG_40_0_0_49_ErrEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_IntTlgEn, getProfileInt( "BAP", "A_FSG_40_0_0_49_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_SegmEn, getProfileInt( "BAP", "A_FSG_40_0_0_49_SegmEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_AT, getProfileInt( "BAP", "A_FSG_40_0_0_49_AT", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_ErrCode, getProfileInt( "BAP", "A_FSG_40_0_0_49_ErrCode", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_DataIndex_SetGet_Incr, getProfileInt( "BAP", "A_FSG_40_0_0_49_DataIndex_SetGet_Incr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_40_0_0_49_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_40_0_0_49_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_loadArray_Btn, getProfileInt( "BAP", "A_FSG_40_0_0_49_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_generateData_Btn, getProfileInt( "BAP", "A_FSG_40_0_0_49_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_8_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_8_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_8_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_8_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_4, getProfileInt( "BAP", "A_FSG_40_0_0_49_Data_4", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_5_len, getProfileInt( "BAP", "A_FSG_40_0_0_49_Data_5_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_5_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_49_Data_5_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_3, getProfileFloat( "BAP", "A_FSG_40_0_0_49_3", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_3_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_3_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_3, getProfileInt( "BAP", "A_FSG_40_0_0_49_Data_3", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_1, getProfileInt( "BAP", "A_FSG_40_0_0_49_1", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_7_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_7_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_7_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_7_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_11_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_11_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_11_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_11_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_2_len, getProfileInt( "BAP", "A_FSG_40_0_0_49_Data_2_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_2_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_49_Data_2_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_10_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_10_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_10_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_10_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_9_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_9_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_9_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_9_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_6_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_6_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_6_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_6_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_11_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_11_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_1_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_2, getProfileFloat( "BAP", "A_FSG_40_0_0_49_2", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_2_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_2_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_RecAdr, getProfileInt( "BAP", "A_FSG_40_0_0_49_RecAdr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Direction, getProfileInt( "BAP", "A_FSG_40_0_0_49_Direction", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Shift, getProfileInt( "BAP", "A_FSG_40_0_0_49_Shift", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_TransPos, getProfileInt( "BAP", "A_FSG_40_0_0_49_TransPos", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_IndexSize, getProfileInt( "BAP", "A_FSG_40_0_0_49_IndexSize", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Start, getProfileInt( "BAP", "A_FSG_40_0_0_49_Start", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Elements, getProfileInt( "BAP", "A_FSG_40_0_0_49_Elements", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_40_0_0_49_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Changed_Direction, getProfileInt( "BAP", "A_FSG_40_0_0_49_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Changed_Shift, getProfileInt( "BAP", "A_FSG_40_0_0_49_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Changed_TransPos, getProfileInt( "BAP", "A_FSG_40_0_0_49_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_40_0_0_49_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Changed_Start, getProfileInt( "BAP", "A_FSG_40_0_0_49_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Changed_Elements, getProfileInt( "BAP", "A_FSG_40_0_0_49_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_DataIndex_SetGet, getProfileInt( "BAP", "A_FSG_40_0_0_49_DataIndex_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_DataIndex_SetGet_Incr, getProfileInt( "BAP", "A_FSG_40_0_0_49_DataIndex_SetGet_Incr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_DataIndex_SetGet_Decr, getProfileInt( "BAP", "A_FSG_40_0_0_49_DataIndex_SetGet_Decr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_8_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_8_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_8_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_8_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_4_SetGet, getProfileInt( "BAP", "A_FSG_40_0_0_49_Data_4_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_5_SetGet_len, getProfileInt( "BAP", "A_FSG_40_0_0_49_Data_5_SetGet_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_5_SetGet_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_49_Data_5_SetGet_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_3_SetGet, getProfileInt( "BAP", "A_FSG_40_0_0_49_Data_3_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_1_SetGet, getProfileInt( "BAP", "A_FSG_40_0_0_49_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_7_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_7_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_7_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_7_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_11_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_11_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_11_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_11_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_2_SetGet_len, getProfileInt( "BAP", "A_FSG_40_0_0_49_Data_2_SetGet_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_2_SetGet_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_49_Data_2_SetGet_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_10_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_10_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_10_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_10_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_9_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_9_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_9_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_9_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_6_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_6_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_6_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_6_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_1_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_Data_1_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_2_SetGet, getProfileFloat( "BAP", "A_FSG_40_0_0_49_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_49_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_40_0_0_49_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_SetGet_Direction, getProfileInt( "BAP", "A_FSG_40_0_0_49_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_SetGet_Shift, getProfileInt( "BAP", "A_FSG_40_0_0_49_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_40_0_0_49_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_SetGet_Start, getProfileInt( "BAP", "A_FSG_40_0_0_49_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_40_0_0_49_SetGet_Elements, getProfileInt( "BAP", "A_FSG_40_0_0_49_SetGet_Elements", 0, profileFile ) );
    putValue( M_FSG_40_0_0_50Result_BTN, getProfileInt( "BAP", "M_FSG_40_0_0_50Result_BTN", 0, profileFile ) );
    putValue( M_FSG_40_0_0_50_FctLstItemEn, getProfileInt( "BAP", "M_FSG_40_0_0_50_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_50_FctEn, getProfileInt( "BAP", "M_FSG_40_0_0_50_FctEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_50_ErrEn, getProfileInt( "BAP", "M_FSG_40_0_0_50_ErrEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_50_ErrCode, getProfileInt( "BAP", "M_FSG_40_0_0_50_ErrCode", 0, profileFile ) );
    putValue( M_FSG_40_0_0_50_Result, getProfileInt( "BAP", "M_FSG_40_0_0_50_Result", 0, profileFile ) );
    putValue( M_FSG_40_0_0_50_Result_1, getProfileInt( "BAP", "M_FSG_40_0_0_50_Result_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_50_Processing_1_range, getProfileInt( "BAP", "M_FSG_40_0_0_50_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_50_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_50_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_50_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_50_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_50_Start, getProfileInt( "BAP", "M_FSG_40_0_0_50_Start", 0, profileFile ) );
    putValue( M_FSG_40_0_0_50_Start_1, getProfileInt( "BAP", "M_FSG_40_0_0_50_Start_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_50_Start_1_0, getProfileInt( "BAP", "M_FSG_40_0_0_50_Start_1_0", 0, profileFile ) );
    putValue( M_FSG_40_0_0_50_Start_1_1, getProfileInt( "BAP", "M_FSG_40_0_0_50_Start_1_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_50_Start_1_2, getProfileInt( "BAP", "M_FSG_40_0_0_50_Start_1_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_51Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_51Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_51_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_51_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_51_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_51_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_51_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_51_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_51_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_51_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_51_1, getProfileInt( "BAP", "P_FSG_40_0_0_51_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_51_2, getProfileFloat( "BAP", "P_FSG_40_0_0_51_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_51_2_range, getProfileFloat( "BAP", "P_FSG_40_0_0_51_2_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52Changed_BTN, getProfileInt( "BAP", "A_FSG_40_0_0_52Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52Status_BTN, getProfileInt( "BAP", "A_FSG_40_0_0_52Status_BTN", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_FctLstItemEn, getProfileInt( "BAP", "A_FSG_40_0_0_52_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_FctEn, getProfileInt( "BAP", "A_FSG_40_0_0_52_FctEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_ErrEn, getProfileInt( "BAP", "A_FSG_40_0_0_52_ErrEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_IntTlgEn, getProfileInt( "BAP", "A_FSG_40_0_0_52_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_SegmEn, getProfileInt( "BAP", "A_FSG_40_0_0_52_SegmEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_AT, getProfileInt( "BAP", "A_FSG_40_0_0_52_AT", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_ErrCode, getProfileInt( "BAP", "A_FSG_40_0_0_52_ErrCode", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_DataIndex, getProfileInt( "BAP", "A_FSG_40_0_0_52_DataIndex", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_40_0_0_52_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_40_0_0_52_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_loadArray_Btn, getProfileInt( "BAP", "A_FSG_40_0_0_52_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_generateData_Btn, getProfileInt( "BAP", "A_FSG_40_0_0_52_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_3, getProfileFloat( "BAP", "A_FSG_40_0_0_52_3", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_3_range, getProfileFloat( "BAP", "A_FSG_40_0_0_52_3_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_1, getProfileInt( "BAP", "A_FSG_40_0_0_52_1", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_6_len, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_6_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_6_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_6_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_9, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_9", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_10, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_10", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_10_0, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_10_0", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_10_1, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_10_1", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_10_2, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_10_2", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_10_3, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_10_3", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_10_4, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_10_4", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_10_5, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_10_5", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_5, getProfileFloat( "BAP", "A_FSG_40_0_0_52_Data_5", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_5_range, getProfileFloat( "BAP", "A_FSG_40_0_0_52_Data_5_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_4, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_4", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_4_0, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_4_0", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_4_1, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_4_1", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_2_len, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_2_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_2_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_2_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_7, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_7", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_7_0, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_7_0", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_8, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_8", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_1, getProfileFloat( "BAP", "A_FSG_40_0_0_52_Data_1", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_1_range, getProfileFloat( "BAP", "A_FSG_40_0_0_52_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_2, getProfileFloat( "BAP", "A_FSG_40_0_0_52_2", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_2_range, getProfileFloat( "BAP", "A_FSG_40_0_0_52_2_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Data_3, getProfileInt( "BAP", "A_FSG_40_0_0_52_Data_3", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_RecAdr, getProfileInt( "BAP", "A_FSG_40_0_0_52_RecAdr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Direction, getProfileInt( "BAP", "A_FSG_40_0_0_52_Direction", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Shift, getProfileInt( "BAP", "A_FSG_40_0_0_52_Shift", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_TransPos, getProfileInt( "BAP", "A_FSG_40_0_0_52_TransPos", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_IndexSize, getProfileInt( "BAP", "A_FSG_40_0_0_52_IndexSize", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Start, getProfileInt( "BAP", "A_FSG_40_0_0_52_Start", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Elements, getProfileInt( "BAP", "A_FSG_40_0_0_52_Elements", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_40_0_0_52_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Changed_Direction, getProfileInt( "BAP", "A_FSG_40_0_0_52_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Changed_Shift, getProfileInt( "BAP", "A_FSG_40_0_0_52_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Changed_TransPos, getProfileInt( "BAP", "A_FSG_40_0_0_52_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_40_0_0_52_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Changed_Start, getProfileInt( "BAP", "A_FSG_40_0_0_52_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_Changed_Elements, getProfileInt( "BAP", "A_FSG_40_0_0_52_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_2_SetGet, getProfileFloat( "BAP", "A_FSG_40_0_0_52_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_52_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_1_SetGet, getProfileInt( "BAP", "A_FSG_40_0_0_52_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_40_0_0_52_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_SetGet_Direction, getProfileInt( "BAP", "A_FSG_40_0_0_52_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_SetGet_Shift, getProfileInt( "BAP", "A_FSG_40_0_0_52_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_40_0_0_52_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_SetGet_Start, getProfileInt( "BAP", "A_FSG_40_0_0_52_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_40_0_0_52_SetGet_Elements, getProfileInt( "BAP", "A_FSG_40_0_0_52_SetGet_Elements", 0, profileFile ) );
    putValue( M_FSG_40_0_0_53Result_BTN, getProfileInt( "BAP", "M_FSG_40_0_0_53Result_BTN", 0, profileFile ) );
    putValue( M_FSG_40_0_0_53_FctLstItemEn, getProfileInt( "BAP", "M_FSG_40_0_0_53_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_53_FctEn, getProfileInt( "BAP", "M_FSG_40_0_0_53_FctEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_53_ErrEn, getProfileInt( "BAP", "M_FSG_40_0_0_53_ErrEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_53_ErrCode, getProfileInt( "BAP", "M_FSG_40_0_0_53_ErrCode", 0, profileFile ) );
    putValue( M_FSG_40_0_0_53_Result_1, getProfileInt( "BAP", "M_FSG_40_0_0_53_Result_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_53_Result_2, getProfileFloat( "BAP", "M_FSG_40_0_0_53_Result_2", 0, profileFile ) );
    putValue( M_FSG_40_0_0_53_Result_2_range, getProfileFloat( "BAP", "M_FSG_40_0_0_53_Result_2_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_53_Result_3, getProfileFloat( "BAP", "M_FSG_40_0_0_53_Result_3", 0, profileFile ) );
    putValue( M_FSG_40_0_0_53_Result_3_range, getProfileFloat( "BAP", "M_FSG_40_0_0_53_Result_3_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_53_Processing_1_len, getProfileInt( "BAP", "M_FSG_40_0_0_53_Processing_1_len", 0, profileFile ) );
    putValue( M_FSG_40_0_0_53_Processing_1_cnt, getProfileInt( "BAP", "M_FSG_40_0_0_53_Processing_1_cnt", 0, profileFile ) );
    putValue( M_FSG_40_0_0_53_Start_1, getProfileInt( "BAP", "M_FSG_40_0_0_53_Start_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_53_Start_2_len, getProfileInt( "BAP", "M_FSG_40_0_0_53_Start_2_len", 0, profileFile ) );
    putValue( M_FSG_40_0_0_53_Start_2_cnt, getProfileInt( "BAP", "M_FSG_40_0_0_53_Start_2_cnt", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54Result_BTN, getProfileInt( "BAP", "M_FSG_40_0_0_54Result_BTN", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_FctLstItemEn, getProfileInt( "BAP", "M_FSG_40_0_0_54_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_FctEn, getProfileInt( "BAP", "M_FSG_40_0_0_54_FctEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_ErrEn, getProfileInt( "BAP", "M_FSG_40_0_0_54_ErrEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_IntTlgEn, getProfileInt( "BAP", "M_FSG_40_0_0_54_IntTlgEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_SegmEn, getProfileInt( "BAP", "M_FSG_40_0_0_54_SegmEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_ErrCode, getProfileInt( "BAP", "M_FSG_40_0_0_54_ErrCode", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_Result_1, getProfileInt( "BAP", "M_FSG_40_0_0_54_Result_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_Result_2, getProfileFloat( "BAP", "M_FSG_40_0_0_54_Result_2", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_Result_2_range, getProfileFloat( "BAP", "M_FSG_40_0_0_54_Result_2_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_Result_3, getProfileFloat( "BAP", "M_FSG_40_0_0_54_Result_3", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_Result_3_range, getProfileFloat( "BAP", "M_FSG_40_0_0_54_Result_3_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_Result_4, getProfileFloat( "BAP", "M_FSG_40_0_0_54_Result_4", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_Result_4_range, getProfileFloat( "BAP", "M_FSG_40_0_0_54_Result_4_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_54_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_Processing_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_54_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_Start_1, getProfileFloat( "BAP", "M_FSG_40_0_0_54_Start_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_Start_1_range, getProfileFloat( "BAP", "M_FSG_40_0_0_54_Start_1_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_Start_2, getProfileFloat( "BAP", "M_FSG_40_0_0_54_Start_2", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_Start_2_range, getProfileFloat( "BAP", "M_FSG_40_0_0_54_Start_2_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_54_Start_3, getProfileInt( "BAP", "M_FSG_40_0_0_54_Start_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_55Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_55Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_55_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_55_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_55_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_55_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_55_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_55_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_55_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_55_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_55_1, getProfileInt( "BAP", "P_FSG_40_0_0_55_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_55_3, getProfileFloat( "BAP", "P_FSG_40_0_0_55_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_55_3_range, getProfileFloat( "BAP", "P_FSG_40_0_0_55_3_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_55_2, getProfileInt( "BAP", "P_FSG_40_0_0_55_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_56Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_56Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_56_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_56_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_56_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_56_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_56_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_56_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_56_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_56_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_56, getProfileInt( "BAP", "P_FSG_40_0_0_56", 0, profileFile ) );
    putValue( P_FSG_40_0_0_56_1, getProfileInt( "BAP", "P_FSG_40_0_0_56_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_56_1_0, getProfileInt( "BAP", "P_FSG_40_0_0_56_1_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_57Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_57Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_57_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_57_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_57_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_57_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_57_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_57_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_57_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_57_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_57, getProfileInt( "BAP", "P_FSG_40_0_0_57", 0, profileFile ) );
    putValue( P_FSG_40_0_0_57_1, getProfileInt( "BAP", "P_FSG_40_0_0_57_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_57_1_0, getProfileInt( "BAP", "P_FSG_40_0_0_57_1_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_58Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_58Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_58_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_58_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_58_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_58_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_58_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_58_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_58_IntTlgEn, getProfileInt( "BAP", "P_FSG_40_0_0_58_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_58_SegmEn, getProfileInt( "BAP", "P_FSG_40_0_0_58_SegmEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_58_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_58_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_58_1, getProfileFloat( "BAP", "P_FSG_40_0_0_58_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_58_1_range, getProfileFloat( "BAP", "P_FSG_40_0_0_58_1_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_58_3_len, getProfileInt( "BAP", "P_FSG_40_0_0_58_3_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_58_3_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_58_3_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_58_2_len, getProfileInt( "BAP", "P_FSG_40_0_0_58_2_len", 0, profileFile ) );
    putValue( P_FSG_40_0_0_58_2_cnt, getProfileInt( "BAP", "P_FSG_40_0_0_58_2_cnt", 0, profileFile ) );
    putValue( P_FSG_40_0_0_58_4, getProfileInt( "BAP", "P_FSG_40_0_0_58_4", 0, profileFile ) );
    putValue( P_FSG_40_0_0_59Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_59Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_59_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_59_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_59_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_59_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_59_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_59_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_59_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_59_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_59_1, getProfileInt( "BAP", "P_FSG_40_0_0_59_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_59_1_0, getProfileInt( "BAP", "P_FSG_40_0_0_59_1_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_59_1_1, getProfileInt( "BAP", "P_FSG_40_0_0_59_1_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_59_1_2, getProfileInt( "BAP", "P_FSG_40_0_0_59_1_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_59_1_3, getProfileInt( "BAP", "P_FSG_40_0_0_59_1_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_59_3, getProfileFloat( "BAP", "P_FSG_40_0_0_59_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_59_3_range, getProfileFloat( "BAP", "P_FSG_40_0_0_59_3_range", 0, profileFile ) );
    putValue( P_FSG_40_0_0_59_2, getProfileFloat( "BAP", "P_FSG_40_0_0_59_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_59_2_range, getProfileFloat( "BAP", "P_FSG_40_0_0_59_2_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60Changed_BTN, getProfileInt( "BAP", "A_FSG_40_0_0_60Changed_BTN", 0, profileFile ) );
