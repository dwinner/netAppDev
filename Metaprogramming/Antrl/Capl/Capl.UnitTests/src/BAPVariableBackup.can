    writeProfileInt("BAP" ,"P_FSG_42_0_0_2_ErrEn" ,getValue(P_FSG_42_0_0_2_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_2_ErrCode" ,getValue(P_FSG_42_0_0_2_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_2" ,getValue(P_FSG_42_0_0_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_2_range" ,getValue(P_FSG_42_0_0_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_3Status_BTN" ,getValue(P_FSG_42_0_0_3Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_3_FctLstItemEn" ,getValue(P_FSG_42_0_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_3_FctEn" ,getValue(P_FSG_42_0_0_3_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_3_ErrEn" ,getValue(P_FSG_42_0_0_3_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_3_IntTlgEn" ,getValue(P_FSG_42_0_0_3_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_3_SegmEn" ,getValue(P_FSG_42_0_0_3_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_3_ErrCode" ,getValue(P_FSG_42_0_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_4Status_BTN" ,getValue(P_FSG_42_0_0_4Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_4_FctLstItemEn" ,getValue(P_FSG_42_0_0_4_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_4_FctEn" ,getValue(P_FSG_42_0_0_4_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_4_ErrEn" ,getValue(P_FSG_42_0_0_4_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_4_ErrCode" ,getValue(P_FSG_42_0_0_4_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_4" ,getValue(P_FSG_42_0_0_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_13Status_BTN" ,getValue(P_FSG_42_0_0_13Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_13_FctLstItemEn" ,getValue(P_FSG_42_0_0_13_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_13_FctEn" ,getValue(P_FSG_42_0_0_13_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_13_ErrEn" ,getValue(P_FSG_42_0_0_13_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_13_ErrCode" ,getValue(P_FSG_42_0_0_13_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_13_2" ,getValue(P_FSG_42_0_0_13_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_13_2_range" ,getValue(P_FSG_42_0_0_13_2_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_13_1" ,getValue(P_FSG_42_0_0_13_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_13_1_range" ,getValue(P_FSG_42_0_0_13_1_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_14Status_BTN" ,getValue(P_FSG_42_0_0_14Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_14_FctLstItemEn" ,getValue(P_FSG_42_0_0_14_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_14_FctEn" ,getValue(P_FSG_42_0_0_14_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_14_ErrEn" ,getValue(P_FSG_42_0_0_14_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_14_ErrCode" ,getValue(P_FSG_42_0_0_14_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_14_2" ,getValue(P_FSG_42_0_0_14_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_14_2_range" ,getValue(P_FSG_42_0_0_14_2_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_14_1" ,getValue(P_FSG_42_0_0_14_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_14_1_range" ,getValue(P_FSG_42_0_0_14_1_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_15Status_BTN" ,getValue(P_FSG_42_0_0_15Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_15_FctLstItemEn" ,getValue(P_FSG_42_0_0_15_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_15_FctEn" ,getValue(P_FSG_42_0_0_15_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_15_ErrEn" ,getValue(P_FSG_42_0_0_15_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_15_ErrCode" ,getValue(P_FSG_42_0_0_15_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_15_2" ,getValue(P_FSG_42_0_0_15_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_15_2_range" ,getValue(P_FSG_42_0_0_15_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_15_1" ,getValue(P_FSG_42_0_0_15_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16Status_BTN" ,getValue(P_FSG_42_0_0_16Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_FctLstItemEn" ,getValue(P_FSG_42_0_0_16_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_FctEn" ,getValue(P_FSG_42_0_0_16_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_ErrEn" ,getValue(P_FSG_42_0_0_16_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_IntTlgEn" ,getValue(P_FSG_42_0_0_16_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_SegmEn" ,getValue(P_FSG_42_0_0_16_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_ErrCode" ,getValue(P_FSG_42_0_0_16_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_16_2" ,getValue(P_FSG_42_0_0_16_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_16_2_range" ,getValue(P_FSG_42_0_0_16_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_1" ,getValue(P_FSG_42_0_0_16_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_4" ,getValue(P_FSG_42_0_0_16_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_4_0" ,getValue(P_FSG_42_0_0_16_4_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_4_1" ,getValue(P_FSG_42_0_0_16_4_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_5" ,getValue(P_FSG_42_0_0_16_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_3_len" ,getValue(P_FSG_42_0_0_16_3_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_3_cnt" ,getValue(P_FSG_42_0_0_16_3_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_17Status_BTN" ,getValue(P_FSG_42_0_0_17Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_17_FctLstItemEn" ,getValue(P_FSG_42_0_0_17_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_17_FctEn" ,getValue(P_FSG_42_0_0_17_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_17_ErrEn" ,getValue(P_FSG_42_0_0_17_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_17_ErrCode" ,getValue(P_FSG_42_0_0_17_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_17_2" ,getValue(P_FSG_42_0_0_17_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_17_3" ,getValue(P_FSG_42_0_0_17_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_17_3_0" ,getValue(P_FSG_42_0_0_17_3_0), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_17_1" ,getValue(P_FSG_42_0_0_17_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_17_1_range" ,getValue(P_FSG_42_0_0_17_1_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_18Status_BTN" ,getValue(P_FSG_42_0_0_18Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_18_FctLstItemEn" ,getValue(P_FSG_42_0_0_18_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_18_FctEn" ,getValue(P_FSG_42_0_0_18_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_18_ErrEn" ,getValue(P_FSG_42_0_0_18_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_18_ErrCode" ,getValue(P_FSG_42_0_0_18_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_18_4" ,getValue(P_FSG_42_0_0_18_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_18_4_range" ,getValue(P_FSG_42_0_0_18_4_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_18_3" ,getValue(P_FSG_42_0_0_18_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_18_3_range" ,getValue(P_FSG_42_0_0_18_3_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_18_2" ,getValue(P_FSG_42_0_0_18_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_18_2_0" ,getValue(P_FSG_42_0_0_18_2_0), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_18_1" ,getValue(P_FSG_42_0_0_18_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_18_1_range" ,getValue(P_FSG_42_0_0_18_1_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_18_5" ,getValue(P_FSG_42_0_0_18_5), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_42_0_0_18_5_range" ,getValue(P_FSG_42_0_0_18_5_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_19Status_BTN" ,getValue(P_FSG_42_0_0_19Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_19_FctLstItemEn" ,getValue(P_FSG_42_0_0_19_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_19_FctEn" ,getValue(P_FSG_42_0_0_19_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_19_ErrEn" ,getValue(P_FSG_42_0_0_19_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_19_ErrCode" ,getValue(P_FSG_42_0_0_19_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_19_3" ,getValue(P_FSG_42_0_0_19_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_19_2" ,getValue(P_FSG_42_0_0_19_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_19_6" ,getValue(P_FSG_42_0_0_19_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_19_1" ,getValue(P_FSG_42_0_0_19_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_19_1_0" ,getValue(P_FSG_42_0_0_19_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_19_1_1" ,getValue(P_FSG_42_0_0_19_1_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_19_1_2" ,getValue(P_FSG_42_0_0_19_1_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_19_5" ,getValue(P_FSG_42_0_0_19_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_19_4" ,getValue(P_FSG_42_0_0_19_4), profileFile);
    writeProfileInt("BAP" ,"C_FSG_49_0_0_0_1_FctLstItemEn" ,getValue(C_FSG_49_0_0_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_49_0_0_0_1_FctEn" ,getValue(C_FSG_49_0_0_0_1_FctEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_49_0_0_0_1_ErrEn" ,getValue(C_FSG_49_0_0_0_1_ErrEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_49_0_0_0_1_IntTlgEn" ,getValue(C_FSG_49_0_0_0_1_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_49_0_0_0_1_SegmEn" ,getValue(C_FSG_49_0_0_0_1_SegmEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_49_0_0_0_1_ErrCode" ,getValue(C_FSG_49_0_0_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_0_2Reset_BTN" ,getValue(P_FSG_49_0_0_0_2Reset_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_0_2_FctLstItemEn" ,getValue(P_FSG_49_0_0_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_0_2_FctEn" ,getValue(P_FSG_49_0_0_0_2_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_0_2_ErrEn" ,getValue(P_FSG_49_0_0_0_2_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_0_2_ErrCode" ,getValue(P_FSG_49_0_0_0_2_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_0_3_FctLstItemEn" ,getValue(P_FSG_49_0_0_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_0_3_FctEn" ,getValue(P_FSG_49_0_0_0_3_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_0_3_ErrEn" ,getValue(P_FSG_49_0_0_0_3_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_0_3_IntTlgEn" ,getValue(P_FSG_49_0_0_0_3_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_0_3_SegmEn" ,getValue(P_FSG_49_0_0_0_3_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_0_3_ErrCode" ,getValue(P_FSG_49_0_0_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"FSG49_WriteTabActivation" ,getValue(FSG49_WriteTabActivation), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_34_3min_TO" ,getValue(M_FSG_49_0_0_34_3min_TO), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_45_3min_TO" ,getValue(M_FSG_49_0_0_45_3min_TO), profileFile);
    writeProfileInt("BAP" ,"ERRORLIST_FSG49_0_VT" ,getValue(ERRORLIST_FSG49_0_VT), profileFile);
    writeProfileInt("BAP" ,"BusType_FSG49_0" ,getValue(BusType_FSG49_0), profileFile);
    writeProfileInt("BAP" ,"ON_OFF_FSG49_0" ,getValue(ON_OFF_FSG49_0), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_49_0_0_DFMajor" ,getValue(BAPCFG_FSG_49_0_0_DFMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_49_0_0_DFMinor" ,getValue(BAPCFG_FSG_49_0_0_DFMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_49_0_0_LsgClassMajor" ,getValue(BAPCFG_FSG_49_0_0_LsgClassMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_49_0_0_LsgClassMinor" ,getValue(BAPCFG_FSG_49_0_0_LsgClassMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_49_0_0_ProtocolMajor" ,getValue(BAPCFG_FSG_49_0_0_ProtocolMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_49_0_0_ProtocolMinor" ,getValue(BAPCFG_FSG_49_0_0_ProtocolMinor), profileFile);
    writeProfileInt("BAP" ,"C_FSG_49_0_0_1_FctLstItemEn" ,getValue(C_FSG_49_0_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_49_0_0_1_FctEn" ,getValue(C_FSG_49_0_0_1_FctEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_49_0_0_1_ErrEn" ,getValue(C_FSG_49_0_0_1_ErrEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_49_0_0_1_IntTlgEn" ,getValue(C_FSG_49_0_0_1_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_49_0_0_1_SegmEn" ,getValue(C_FSG_49_0_0_1_SegmEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_49_0_0_1_ErrCode" ,getValue(C_FSG_49_0_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_2Reset_BTN" ,getValue(P_FSG_49_0_0_2Reset_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_2_FctLstItemEn" ,getValue(P_FSG_49_0_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_2_FctEn" ,getValue(P_FSG_49_0_0_2_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_2_ErrEn" ,getValue(P_FSG_49_0_0_2_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_2_ErrCode" ,getValue(P_FSG_49_0_0_2_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_2" ,getValue(P_FSG_49_0_0_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_2_range" ,getValue(P_FSG_49_0_0_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_3Status_BTN" ,getValue(P_FSG_49_0_0_3Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_3_FctLstItemEn" ,getValue(P_FSG_49_0_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_3_FctEn" ,getValue(P_FSG_49_0_0_3_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_3_ErrEn" ,getValue(P_FSG_49_0_0_3_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_3_IntTlgEn" ,getValue(P_FSG_49_0_0_3_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_3_SegmEn" ,getValue(P_FSG_49_0_0_3_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_3_ErrCode" ,getValue(P_FSG_49_0_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_4Status_BTN" ,getValue(P_FSG_49_0_0_4Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_4_FctLstItemEn" ,getValue(P_FSG_49_0_0_4_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_4_FctEn" ,getValue(P_FSG_49_0_0_4_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_4_ErrEn" ,getValue(P_FSG_49_0_0_4_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_4_ErrCode" ,getValue(P_FSG_49_0_0_4_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_4" ,getValue(P_FSG_49_0_0_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14Status_BTN" ,getValue(P_FSG_49_0_0_14Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_FctLstItemEn" ,getValue(P_FSG_49_0_0_14_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_FctEn" ,getValue(P_FSG_49_0_0_14_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_ErrEn" ,getValue(P_FSG_49_0_0_14_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_ErrCode" ,getValue(P_FSG_49_0_0_14_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_3" ,getValue(P_FSG_49_0_0_14_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_3_0" ,getValue(P_FSG_49_0_0_14_3_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_3_1" ,getValue(P_FSG_49_0_0_14_3_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_3_2" ,getValue(P_FSG_49_0_0_14_3_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_3_3" ,getValue(P_FSG_49_0_0_14_3_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_3_4" ,getValue(P_FSG_49_0_0_14_3_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_3_5" ,getValue(P_FSG_49_0_0_14_3_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_3_6" ,getValue(P_FSG_49_0_0_14_3_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_3_7" ,getValue(P_FSG_49_0_0_14_3_7), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_14_1" ,getValue(P_FSG_49_0_0_14_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_14_1_range" ,getValue(P_FSG_49_0_0_14_1_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_4" ,getValue(P_FSG_49_0_0_14_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_4_0" ,getValue(P_FSG_49_0_0_14_4_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_4_1" ,getValue(P_FSG_49_0_0_14_4_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_4_2" ,getValue(P_FSG_49_0_0_14_4_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_4_3" ,getValue(P_FSG_49_0_0_14_4_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_4_4" ,getValue(P_FSG_49_0_0_14_4_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_2" ,getValue(P_FSG_49_0_0_14_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_2_0" ,getValue(P_FSG_49_0_0_14_2_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_2_1" ,getValue(P_FSG_49_0_0_14_2_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_2_2" ,getValue(P_FSG_49_0_0_14_2_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_2_3" ,getValue(P_FSG_49_0_0_14_2_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_2_4" ,getValue(P_FSG_49_0_0_14_2_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_2_5" ,getValue(P_FSG_49_0_0_14_2_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_2_6" ,getValue(P_FSG_49_0_0_14_2_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_14_2_7" ,getValue(P_FSG_49_0_0_14_2_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_15Status_BTN" ,getValue(P_FSG_49_0_0_15Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_15_FctLstItemEn" ,getValue(P_FSG_49_0_0_15_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_15_FctEn" ,getValue(P_FSG_49_0_0_15_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_15_ErrEn" ,getValue(P_FSG_49_0_0_15_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_15_ErrCode" ,getValue(P_FSG_49_0_0_15_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_15_2" ,getValue(P_FSG_49_0_0_15_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_15_1" ,getValue(P_FSG_49_0_0_15_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_16Status_BTN" ,getValue(P_FSG_49_0_0_16Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_16_FctLstItemEn" ,getValue(P_FSG_49_0_0_16_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_16_FctEn" ,getValue(P_FSG_49_0_0_16_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_16_ErrEn" ,getValue(P_FSG_49_0_0_16_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_16_ErrCode" ,getValue(P_FSG_49_0_0_16_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_16_1" ,getValue(P_FSG_49_0_0_16_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_16_6" ,getValue(P_FSG_49_0_0_16_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_16_6_0" ,getValue(P_FSG_49_0_0_16_6_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_16_6_1" ,getValue(P_FSG_49_0_0_16_6_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_16_2" ,getValue(P_FSG_49_0_0_16_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_16_2_range" ,getValue(P_FSG_49_0_0_16_2_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_16_7" ,getValue(P_FSG_49_0_0_16_7), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_16_7_range" ,getValue(P_FSG_49_0_0_16_7_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_16_5" ,getValue(P_FSG_49_0_0_16_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_16_4" ,getValue(P_FSG_49_0_0_16_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_16_4_0" ,getValue(P_FSG_49_0_0_16_4_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_16_4_1" ,getValue(P_FSG_49_0_0_16_4_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_16_4_2" ,getValue(P_FSG_49_0_0_16_4_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_16_4_3" ,getValue(P_FSG_49_0_0_16_4_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_16_3" ,getValue(P_FSG_49_0_0_16_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_17Status_BTN" ,getValue(P_FSG_49_0_0_17Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_17_FctLstItemEn" ,getValue(P_FSG_49_0_0_17_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_17_FctEn" ,getValue(P_FSG_49_0_0_17_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_17_ErrEn" ,getValue(P_FSG_49_0_0_17_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_17_IntTlgEn" ,getValue(P_FSG_49_0_0_17_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_17_SegmEn" ,getValue(P_FSG_49_0_0_17_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_17_ErrCode" ,getValue(P_FSG_49_0_0_17_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_17_1_len" ,getValue(P_FSG_49_0_0_17_1_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_17_1_cnt" ,getValue(P_FSG_49_0_0_17_1_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_18Status_BTN" ,getValue(P_FSG_49_0_0_18Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_18_FctLstItemEn" ,getValue(P_FSG_49_0_0_18_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_18_FctEn" ,getValue(P_FSG_49_0_0_18_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_18_ErrEn" ,getValue(P_FSG_49_0_0_18_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_18_ErrCode" ,getValue(P_FSG_49_0_0_18_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_18_1" ,getValue(P_FSG_49_0_0_18_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_18_1_range" ,getValue(P_FSG_49_0_0_18_1_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_18_5" ,getValue(P_FSG_49_0_0_18_5), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_18_5_range" ,getValue(P_FSG_49_0_0_18_5_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_18_3" ,getValue(P_FSG_49_0_0_18_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_18_3_range" ,getValue(P_FSG_49_0_0_18_3_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_18_6" ,getValue(P_FSG_49_0_0_18_6), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_18_4" ,getValue(P_FSG_49_0_0_18_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_18_4_range" ,getValue(P_FSG_49_0_0_18_4_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_18_2" ,getValue(P_FSG_49_0_0_18_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_18_2_range" ,getValue(P_FSG_49_0_0_18_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_19Status_BTN" ,getValue(P_FSG_49_0_0_19Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_19_FctLstItemEn" ,getValue(P_FSG_49_0_0_19_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_19_FctEn" ,getValue(P_FSG_49_0_0_19_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_19_ErrEn" ,getValue(P_FSG_49_0_0_19_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_19_ErrCode" ,getValue(P_FSG_49_0_0_19_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_19" ,getValue(P_FSG_49_0_0_19), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_19_1" ,getValue(P_FSG_49_0_0_19_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_19_1_0" ,getValue(P_FSG_49_0_0_19_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_19_1_1" ,getValue(P_FSG_49_0_0_19_1_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_19_1_2" ,getValue(P_FSG_49_0_0_19_1_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_19_1_3" ,getValue(P_FSG_49_0_0_19_1_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_19_1_4" ,getValue(P_FSG_49_0_0_19_1_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_19_1_5" ,getValue(P_FSG_49_0_0_19_1_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_19_1_6" ,getValue(P_FSG_49_0_0_19_1_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_19_1_7" ,getValue(P_FSG_49_0_0_19_1_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_20Status_BTN" ,getValue(P_FSG_49_0_0_20Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_20_FctLstItemEn" ,getValue(P_FSG_49_0_0_20_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_20_FctEn" ,getValue(P_FSG_49_0_0_20_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_20_ErrEn" ,getValue(P_FSG_49_0_0_20_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_20_ErrCode" ,getValue(P_FSG_49_0_0_20_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_20_2" ,getValue(P_FSG_49_0_0_20_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_20_1" ,getValue(P_FSG_49_0_0_20_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21Status_BTN" ,getValue(P_FSG_49_0_0_21Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_FctLstItemEn" ,getValue(P_FSG_49_0_0_21_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_FctEn" ,getValue(P_FSG_49_0_0_21_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_ErrEn" ,getValue(P_FSG_49_0_0_21_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_IntTlgEn" ,getValue(P_FSG_49_0_0_21_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_SegmEn" ,getValue(P_FSG_49_0_0_21_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_ErrCode" ,getValue(P_FSG_49_0_0_21_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_9" ,getValue(P_FSG_49_0_0_21_9), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_5" ,getValue(P_FSG_49_0_0_21_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_4_len" ,getValue(P_FSG_49_0_0_21_4_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_4_cnt" ,getValue(P_FSG_49_0_0_21_4_cnt), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_21_3" ,getValue(P_FSG_49_0_0_21_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_21_3_range" ,getValue(P_FSG_49_0_0_21_3_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_1_len" ,getValue(P_FSG_49_0_0_21_1_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_1_cnt" ,getValue(P_FSG_49_0_0_21_1_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_6_len" ,getValue(P_FSG_49_0_0_21_6_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_6_cnt" ,getValue(P_FSG_49_0_0_21_6_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_2" ,getValue(P_FSG_49_0_0_21_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_7" ,getValue(P_FSG_49_0_0_21_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_10" ,getValue(P_FSG_49_0_0_21_10), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_10_0" ,getValue(P_FSG_49_0_0_21_10_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_10_1" ,getValue(P_FSG_49_0_0_21_10_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_10_2" ,getValue(P_FSG_49_0_0_21_10_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_10_3" ,getValue(P_FSG_49_0_0_21_10_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_11" ,getValue(P_FSG_49_0_0_21_11), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_11_0" ,getValue(P_FSG_49_0_0_21_11_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_11_1" ,getValue(P_FSG_49_0_0_21_11_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_11_2" ,getValue(P_FSG_49_0_0_21_11_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_11_3" ,getValue(P_FSG_49_0_0_21_11_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_8_len" ,getValue(P_FSG_49_0_0_21_8_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_21_8_cnt" ,getValue(P_FSG_49_0_0_21_8_cnt), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_21_12" ,getValue(P_FSG_49_0_0_21_12), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_21_12_range" ,getValue(P_FSG_49_0_0_21_12_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_22Status_BTN" ,getValue(P_FSG_49_0_0_22Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_22_FctLstItemEn" ,getValue(P_FSG_49_0_0_22_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_22_FctEn" ,getValue(P_FSG_49_0_0_22_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_22_ErrEn" ,getValue(P_FSG_49_0_0_22_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_22_IntTlgEn" ,getValue(P_FSG_49_0_0_22_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_22_SegmEn" ,getValue(P_FSG_49_0_0_22_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_22_ErrCode" ,getValue(P_FSG_49_0_0_22_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_22_5" ,getValue(P_FSG_49_0_0_22_5), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_22_5_range" ,getValue(P_FSG_49_0_0_22_5_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_22_6" ,getValue(P_FSG_49_0_0_22_6), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_22_6_range" ,getValue(P_FSG_49_0_0_22_6_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_22_4" ,getValue(P_FSG_49_0_0_22_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_22_4_range" ,getValue(P_FSG_49_0_0_22_4_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_22_2" ,getValue(P_FSG_49_0_0_22_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_22_2_range" ,getValue(P_FSG_49_0_0_22_2_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_22_1" ,getValue(P_FSG_49_0_0_22_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_22_1_range" ,getValue(P_FSG_49_0_0_22_1_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_22_3" ,getValue(P_FSG_49_0_0_22_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_22_3_range" ,getValue(P_FSG_49_0_0_22_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23Changed_BTN" ,getValue(A_FSG_49_0_0_23Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23Status_BTN" ,getValue(A_FSG_49_0_0_23Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_FctLstItemEn" ,getValue(A_FSG_49_0_0_23_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_FctEn" ,getValue(A_FSG_49_0_0_23_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_ErrEn" ,getValue(A_FSG_49_0_0_23_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_IntTlgEn" ,getValue(A_FSG_49_0_0_23_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_SegmEn" ,getValue(A_FSG_49_0_0_23_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_AT" ,getValue(A_FSG_49_0_0_23_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_ErrCode" ,getValue(A_FSG_49_0_0_23_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_DataIndex" ,getValue(A_FSG_49_0_0_23_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_DataIndex_Incr" ,getValue(A_FSG_49_0_0_23_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_DataIndex_Decr" ,getValue(A_FSG_49_0_0_23_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_loadArray_Btn" ,getValue(A_FSG_49_0_0_23_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_generateData_Btn" ,getValue(A_FSG_49_0_0_23_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_3" ,getValue(A_FSG_49_0_0_23_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_2" ,getValue(A_FSG_49_0_0_23_Data_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_3" ,getValue(A_FSG_49_0_0_23_Data_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_3_0" ,getValue(A_FSG_49_0_0_23_Data_3_0), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_3_1" ,getValue(A_FSG_49_0_0_23_Data_3_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_3_2" ,getValue(A_FSG_49_0_0_23_Data_3_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_3_3" ,getValue(A_FSG_49_0_0_23_Data_3_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_3_4" ,getValue(A_FSG_49_0_0_23_Data_3_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_3_5" ,getValue(A_FSG_49_0_0_23_Data_3_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_3_6" ,getValue(A_FSG_49_0_0_23_Data_3_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_3_7" ,getValue(A_FSG_49_0_0_23_Data_3_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_3_8" ,getValue(A_FSG_49_0_0_23_Data_3_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_3_9" ,getValue(A_FSG_49_0_0_23_Data_3_9), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_3_10" ,getValue(A_FSG_49_0_0_23_Data_3_10), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_3_11" ,getValue(A_FSG_49_0_0_23_Data_3_11), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_3_12" ,getValue(A_FSG_49_0_0_23_Data_3_12), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_23_5" ,getValue(A_FSG_49_0_0_23_5), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_23_5_range" ,getValue(A_FSG_49_0_0_23_5_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_1" ,getValue(A_FSG_49_0_0_23_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_23_4" ,getValue(A_FSG_49_0_0_23_4), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_23_4_range" ,getValue(A_FSG_49_0_0_23_4_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_7_len" ,getValue(A_FSG_49_0_0_23_Data_7_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_7_cnt" ,getValue(A_FSG_49_0_0_23_Data_7_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_23_Data_5" ,getValue(A_FSG_49_0_0_23_Data_5), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_23_Data_5_range" ,getValue(A_FSG_49_0_0_23_Data_5_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_23_Data_1" ,getValue(A_FSG_49_0_0_23_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_23_Data_1_range" ,getValue(A_FSG_49_0_0_23_Data_1_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_8_len" ,getValue(A_FSG_49_0_0_23_Data_8_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_8_cnt" ,getValue(A_FSG_49_0_0_23_Data_8_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Data_6" ,getValue(A_FSG_49_0_0_23_Data_6), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_23_2" ,getValue(A_FSG_49_0_0_23_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_23_2_range" ,getValue(A_FSG_49_0_0_23_2_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_23_Data_4" ,getValue(A_FSG_49_0_0_23_Data_4), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_23_Data_4_range" ,getValue(A_FSG_49_0_0_23_Data_4_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_RecAdr" ,getValue(A_FSG_49_0_0_23_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Direction" ,getValue(A_FSG_49_0_0_23_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Shift" ,getValue(A_FSG_49_0_0_23_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_TransPos" ,getValue(A_FSG_49_0_0_23_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_IndexSize" ,getValue(A_FSG_49_0_0_23_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Start" ,getValue(A_FSG_49_0_0_23_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Elements" ,getValue(A_FSG_49_0_0_23_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_1_Changed" ,getValue(A_FSG_49_0_0_23_1_Changed), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_23_2_Changed" ,getValue(A_FSG_49_0_0_23_2_Changed), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_23_2_Changed_range" ,getValue(A_FSG_49_0_0_23_2_Changed_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Changed_RecAdr" ,getValue(A_FSG_49_0_0_23_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Changed_Direction" ,getValue(A_FSG_49_0_0_23_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Changed_Shift" ,getValue(A_FSG_49_0_0_23_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Changed_TransPos" ,getValue(A_FSG_49_0_0_23_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Changed_IndexSize" ,getValue(A_FSG_49_0_0_23_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Changed_Start" ,getValue(A_FSG_49_0_0_23_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_Changed_Elements" ,getValue(A_FSG_49_0_0_23_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_23_2_SetGet" ,getValue(A_FSG_49_0_0_23_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_23_2_SetGet_range" ,getValue(A_FSG_49_0_0_23_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_1_SetGet" ,getValue(A_FSG_49_0_0_23_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_3_SetGet" ,getValue(A_FSG_49_0_0_23_3_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_23_4_SetGet" ,getValue(A_FSG_49_0_0_23_4_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_23_4_SetGet_range" ,getValue(A_FSG_49_0_0_23_4_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_SetGet_RecAdr" ,getValue(A_FSG_49_0_0_23_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_SetGet_Direction" ,getValue(A_FSG_49_0_0_23_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_SetGet_Shift" ,getValue(A_FSG_49_0_0_23_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_SetGet_IndexSize" ,getValue(A_FSG_49_0_0_23_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_SetGet_Start" ,getValue(A_FSG_49_0_0_23_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_23_SetGet_Elements" ,getValue(A_FSG_49_0_0_23_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_24Result_BTN" ,getValue(M_FSG_49_0_0_24Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_24_FctLstItemEn" ,getValue(M_FSG_49_0_0_24_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_24_FctEn" ,getValue(M_FSG_49_0_0_24_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_24_ErrEn" ,getValue(M_FSG_49_0_0_24_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_24_ErrCode" ,getValue(M_FSG_49_0_0_24_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_24_Result" ,getValue(M_FSG_49_0_0_24_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_24_Result_1" ,getValue(M_FSG_49_0_0_24_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_24_Processing" ,getValue(M_FSG_49_0_0_24_Processing), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_24_Processing_1" ,getValue(M_FSG_49_0_0_24_Processing_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_24_Processing_1_range" ,getValue(M_FSG_49_0_0_24_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_24_Start_1" ,getValue(M_FSG_49_0_0_24_Start_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_24_Start_2" ,getValue(M_FSG_49_0_0_24_Start_2), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_24_Start_2_range" ,getValue(M_FSG_49_0_0_24_Start_2_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_24_Start_3" ,getValue(M_FSG_49_0_0_24_Start_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25Status_BTN" ,getValue(P_FSG_49_0_0_25Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_FctLstItemEn" ,getValue(P_FSG_49_0_0_25_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_FctEn" ,getValue(P_FSG_49_0_0_25_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_ErrEn" ,getValue(P_FSG_49_0_0_25_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_ErrCode" ,getValue(P_FSG_49_0_0_25_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_2" ,getValue(P_FSG_49_0_0_25_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_2_0" ,getValue(P_FSG_49_0_0_25_2_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_2_1" ,getValue(P_FSG_49_0_0_25_2_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_2_2" ,getValue(P_FSG_49_0_0_25_2_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_2_3" ,getValue(P_FSG_49_0_0_25_2_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_2_4" ,getValue(P_FSG_49_0_0_25_2_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_2_5" ,getValue(P_FSG_49_0_0_25_2_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_2_6" ,getValue(P_FSG_49_0_0_25_2_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_1" ,getValue(P_FSG_49_0_0_25_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_1_0" ,getValue(P_FSG_49_0_0_25_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_1_1" ,getValue(P_FSG_49_0_0_25_1_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_1_2" ,getValue(P_FSG_49_0_0_25_1_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_1_3" ,getValue(P_FSG_49_0_0_25_1_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_1_4" ,getValue(P_FSG_49_0_0_25_1_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_1_5" ,getValue(P_FSG_49_0_0_25_1_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_25_1_6" ,getValue(P_FSG_49_0_0_25_1_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_26Status_BTN" ,getValue(P_FSG_49_0_0_26Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_26_FctLstItemEn" ,getValue(P_FSG_49_0_0_26_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_26_FctEn" ,getValue(P_FSG_49_0_0_26_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_26_ErrEn" ,getValue(P_FSG_49_0_0_26_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_26_IntTlgEn" ,getValue(P_FSG_49_0_0_26_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_26_SegmEn" ,getValue(P_FSG_49_0_0_26_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_26_ErrCode" ,getValue(P_FSG_49_0_0_26_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_26_2_Hour" ,getValue(P_FSG_49_0_0_26_2_Hour), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_26_2_Hour_range" ,getValue(P_FSG_49_0_0_26_2_Hour_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_26_2_Minute" ,getValue(P_FSG_49_0_0_26_2_Minute), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_26_2_Minute_range" ,getValue(P_FSG_49_0_0_26_2_Minute_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_26_3_len" ,getValue(P_FSG_49_0_0_26_3_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_26_3_cnt" ,getValue(P_FSG_49_0_0_26_3_cnt), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_26_1_CurrentMsgNumber" ,getValue(P_FSG_49_0_0_26_1_CurrentMsgNumber), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_26_1_CurrentMsgNumber_range" ,getValue(P_FSG_49_0_0_26_1_CurrentMsgNumber_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_26_1_TotalMsgNumber" ,getValue(P_FSG_49_0_0_26_1_TotalMsgNumber), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_26_1_TotalMsgNumber_range" ,getValue(P_FSG_49_0_0_26_1_TotalMsgNumber_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27Changed_BTN" ,getValue(A_FSG_49_0_0_27Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27Status_BTN" ,getValue(A_FSG_49_0_0_27Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_FctLstItemEn" ,getValue(A_FSG_49_0_0_27_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_FctEn" ,getValue(A_FSG_49_0_0_27_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_ErrEn" ,getValue(A_FSG_49_0_0_27_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_IntTlgEn" ,getValue(A_FSG_49_0_0_27_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_SegmEn" ,getValue(A_FSG_49_0_0_27_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_AT" ,getValue(A_FSG_49_0_0_27_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_ErrCode" ,getValue(A_FSG_49_0_0_27_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_DataIndex" ,getValue(A_FSG_49_0_0_27_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_DataIndex_Incr" ,getValue(A_FSG_49_0_0_27_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_DataIndex_Decr" ,getValue(A_FSG_49_0_0_27_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_loadArray_Btn" ,getValue(A_FSG_49_0_0_27_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_generateData_Btn" ,getValue(A_FSG_49_0_0_27_generateData_Btn), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_27_Data_4" ,getValue(A_FSG_49_0_0_27_Data_4), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_27_Data_4_range" ,getValue(A_FSG_49_0_0_27_Data_4_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_27_2" ,getValue(A_FSG_49_0_0_27_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_27_2_range" ,getValue(A_FSG_49_0_0_27_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_1" ,getValue(A_FSG_49_0_0_27_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_27_Data_1" ,getValue(A_FSG_49_0_0_27_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_27_Data_1_range" ,getValue(A_FSG_49_0_0_27_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_27_3" ,getValue(A_FSG_49_0_0_27_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_27_3_range" ,getValue(A_FSG_49_0_0_27_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_Data_5_len" ,getValue(A_FSG_49_0_0_27_Data_5_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_Data_5_cnt" ,getValue(A_FSG_49_0_0_27_Data_5_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_Data_2" ,getValue(A_FSG_49_0_0_27_Data_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_Data_2_0" ,getValue(A_FSG_49_0_0_27_Data_2_0), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_27_Data_3" ,getValue(A_FSG_49_0_0_27_Data_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_27_Data_3_range" ,getValue(A_FSG_49_0_0_27_Data_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_RecAdr" ,getValue(A_FSG_49_0_0_27_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_Direction" ,getValue(A_FSG_49_0_0_27_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_Shift" ,getValue(A_FSG_49_0_0_27_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_TransPos" ,getValue(A_FSG_49_0_0_27_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_IndexSize" ,getValue(A_FSG_49_0_0_27_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_Start" ,getValue(A_FSG_49_0_0_27_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_Elements" ,getValue(A_FSG_49_0_0_27_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_Changed_RecAdr" ,getValue(A_FSG_49_0_0_27_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_Changed_Direction" ,getValue(A_FSG_49_0_0_27_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_Changed_Shift" ,getValue(A_FSG_49_0_0_27_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_Changed_TransPos" ,getValue(A_FSG_49_0_0_27_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_Changed_IndexSize" ,getValue(A_FSG_49_0_0_27_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_Changed_Start" ,getValue(A_FSG_49_0_0_27_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_Changed_Elements" ,getValue(A_FSG_49_0_0_27_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_27_2_SetGet" ,getValue(A_FSG_49_0_0_27_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_27_2_SetGet_range" ,getValue(A_FSG_49_0_0_27_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_1_SetGet" ,getValue(A_FSG_49_0_0_27_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_SetGet_RecAdr" ,getValue(A_FSG_49_0_0_27_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_SetGet_Direction" ,getValue(A_FSG_49_0_0_27_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_SetGet_Shift" ,getValue(A_FSG_49_0_0_27_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_SetGet_IndexSize" ,getValue(A_FSG_49_0_0_27_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_SetGet_Start" ,getValue(A_FSG_49_0_0_27_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_27_SetGet_Elements" ,getValue(A_FSG_49_0_0_27_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_28Status_BTN" ,getValue(P_FSG_49_0_0_28Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_28_FctLstItemEn" ,getValue(P_FSG_49_0_0_28_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_28_FctEn" ,getValue(P_FSG_49_0_0_28_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_28_ErrEn" ,getValue(P_FSG_49_0_0_28_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_28_IntTlgEn" ,getValue(P_FSG_49_0_0_28_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_28_SegmEn" ,getValue(P_FSG_49_0_0_28_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_28_ErrCode" ,getValue(P_FSG_49_0_0_28_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_28_1" ,getValue(P_FSG_49_0_0_28_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_28_2_len" ,getValue(P_FSG_49_0_0_28_2_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_28_2_cnt" ,getValue(P_FSG_49_0_0_28_2_cnt), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_29Result_BTN" ,getValue(M_FSG_49_0_0_29Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_29_FctLstItemEn" ,getValue(M_FSG_49_0_0_29_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_29_FctEn" ,getValue(M_FSG_49_0_0_29_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_29_ErrEn" ,getValue(M_FSG_49_0_0_29_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_29_ErrCode" ,getValue(M_FSG_49_0_0_29_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_29_Result" ,getValue(M_FSG_49_0_0_29_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_29_Result_1" ,getValue(M_FSG_49_0_0_29_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_29_Processing" ,getValue(M_FSG_49_0_0_29_Processing), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_29_Processing_1" ,getValue(M_FSG_49_0_0_29_Processing_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_29_Processing_1_range" ,getValue(M_FSG_49_0_0_29_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_29_Start" ,getValue(M_FSG_49_0_0_29_Start), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_29_Start_0" ,getValue(M_FSG_49_0_0_29_Start_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_30Status_BTN" ,getValue(P_FSG_49_0_0_30Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_30_FctLstItemEn" ,getValue(P_FSG_49_0_0_30_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_30_FctEn" ,getValue(P_FSG_49_0_0_30_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_30_ErrEn" ,getValue(P_FSG_49_0_0_30_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_30_ErrCode" ,getValue(P_FSG_49_0_0_30_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_30" ,getValue(P_FSG_49_0_0_30), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_30_1" ,getValue(P_FSG_49_0_0_30_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_31Status_BTN" ,getValue(P_FSG_49_0_0_31Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_31_FctLstItemEn" ,getValue(P_FSG_49_0_0_31_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_31_FctEn" ,getValue(P_FSG_49_0_0_31_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_31_ErrEn" ,getValue(P_FSG_49_0_0_31_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_31_ErrCode" ,getValue(P_FSG_49_0_0_31_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_31" ,getValue(P_FSG_49_0_0_31), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_31_1" ,getValue(P_FSG_49_0_0_31_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32Changed_BTN" ,getValue(A_FSG_49_0_0_32Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32Status_BTN" ,getValue(A_FSG_49_0_0_32Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_FctLstItemEn" ,getValue(A_FSG_49_0_0_32_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_FctEn" ,getValue(A_FSG_49_0_0_32_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_ErrEn" ,getValue(A_FSG_49_0_0_32_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_IntTlgEn" ,getValue(A_FSG_49_0_0_32_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_SegmEn" ,getValue(A_FSG_49_0_0_32_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_AT" ,getValue(A_FSG_49_0_0_32_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_ErrCode" ,getValue(A_FSG_49_0_0_32_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_DataIndex" ,getValue(A_FSG_49_0_0_32_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_DataIndex_Incr" ,getValue(A_FSG_49_0_0_32_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_DataIndex_Decr" ,getValue(A_FSG_49_0_0_32_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_loadArray_Btn" ,getValue(A_FSG_49_0_0_32_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_generateData_Btn" ,getValue(A_FSG_49_0_0_32_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Data_4" ,getValue(A_FSG_49_0_0_32_Data_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Data_5" ,getValue(A_FSG_49_0_0_32_Data_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Data_5_0" ,getValue(A_FSG_49_0_0_32_Data_5_0), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Data_5_1" ,getValue(A_FSG_49_0_0_32_Data_5_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Data_5_2" ,getValue(A_FSG_49_0_0_32_Data_5_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Data_5_3" ,getValue(A_FSG_49_0_0_32_Data_5_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Data_5_4" ,getValue(A_FSG_49_0_0_32_Data_5_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Data_5_5" ,getValue(A_FSG_49_0_0_32_Data_5_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Data_5_6" ,getValue(A_FSG_49_0_0_32_Data_5_6), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_32_3" ,getValue(A_FSG_49_0_0_32_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_32_3_range" ,getValue(A_FSG_49_0_0_32_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_1" ,getValue(A_FSG_49_0_0_32_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Data_6_len" ,getValue(A_FSG_49_0_0_32_Data_6_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Data_6_cnt" ,getValue(A_FSG_49_0_0_32_Data_6_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Data_2" ,getValue(A_FSG_49_0_0_32_Data_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_32_Data_3" ,getValue(A_FSG_49_0_0_32_Data_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_32_Data_3_range" ,getValue(A_FSG_49_0_0_32_Data_3_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_32_Data_1" ,getValue(A_FSG_49_0_0_32_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_32_Data_1_range" ,getValue(A_FSG_49_0_0_32_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_32_2" ,getValue(A_FSG_49_0_0_32_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_32_2_range" ,getValue(A_FSG_49_0_0_32_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_RecAdr" ,getValue(A_FSG_49_0_0_32_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Direction" ,getValue(A_FSG_49_0_0_32_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Shift" ,getValue(A_FSG_49_0_0_32_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_TransPos" ,getValue(A_FSG_49_0_0_32_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_IndexSize" ,getValue(A_FSG_49_0_0_32_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Start" ,getValue(A_FSG_49_0_0_32_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Elements" ,getValue(A_FSG_49_0_0_32_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Changed_RecAdr" ,getValue(A_FSG_49_0_0_32_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Changed_Direction" ,getValue(A_FSG_49_0_0_32_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Changed_Shift" ,getValue(A_FSG_49_0_0_32_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Changed_TransPos" ,getValue(A_FSG_49_0_0_32_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Changed_IndexSize" ,getValue(A_FSG_49_0_0_32_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Changed_Start" ,getValue(A_FSG_49_0_0_32_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_Changed_Elements" ,getValue(A_FSG_49_0_0_32_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_32_2_SetGet" ,getValue(A_FSG_49_0_0_32_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_32_2_SetGet_range" ,getValue(A_FSG_49_0_0_32_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_1_SetGet" ,getValue(A_FSG_49_0_0_32_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_SetGet_RecAdr" ,getValue(A_FSG_49_0_0_32_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_SetGet_Direction" ,getValue(A_FSG_49_0_0_32_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_SetGet_Shift" ,getValue(A_FSG_49_0_0_32_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_SetGet_IndexSize" ,getValue(A_FSG_49_0_0_32_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_SetGet_Start" ,getValue(A_FSG_49_0_0_32_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_32_SetGet_Elements" ,getValue(A_FSG_49_0_0_32_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33Changed_BTN" ,getValue(A_FSG_49_0_0_33Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33Status_BTN" ,getValue(A_FSG_49_0_0_33Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_FctLstItemEn" ,getValue(A_FSG_49_0_0_33_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_FctEn" ,getValue(A_FSG_49_0_0_33_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_ErrEn" ,getValue(A_FSG_49_0_0_33_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_IntTlgEn" ,getValue(A_FSG_49_0_0_33_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_SegmEn" ,getValue(A_FSG_49_0_0_33_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_AT" ,getValue(A_FSG_49_0_0_33_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_ErrCode" ,getValue(A_FSG_49_0_0_33_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_DataIndex" ,getValue(A_FSG_49_0_0_33_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_DataIndex_Incr" ,getValue(A_FSG_49_0_0_33_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_DataIndex_Decr" ,getValue(A_FSG_49_0_0_33_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_loadArray_Btn" ,getValue(A_FSG_49_0_0_33_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_generateData_Btn" ,getValue(A_FSG_49_0_0_33_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Data_5_len" ,getValue(A_FSG_49_0_0_33_Data_5_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Data_5_cnt" ,getValue(A_FSG_49_0_0_33_Data_5_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Data_3" ,getValue(A_FSG_49_0_0_33_Data_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_33_2" ,getValue(A_FSG_49_0_0_33_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_33_2_range" ,getValue(A_FSG_49_0_0_33_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_1" ,getValue(A_FSG_49_0_0_33_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_33_Data_1" ,getValue(A_FSG_49_0_0_33_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_33_Data_1_range" ,getValue(A_FSG_49_0_0_33_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_33_3" ,getValue(A_FSG_49_0_0_33_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_33_3_range" ,getValue(A_FSG_49_0_0_33_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Data_4" ,getValue(A_FSG_49_0_0_33_Data_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Data_4_0" ,getValue(A_FSG_49_0_0_33_Data_4_0), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Data_4_1" ,getValue(A_FSG_49_0_0_33_Data_4_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Data_4_2" ,getValue(A_FSG_49_0_0_33_Data_4_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Data_4_3" ,getValue(A_FSG_49_0_0_33_Data_4_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Data_4_4" ,getValue(A_FSG_49_0_0_33_Data_4_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Data_4_5" ,getValue(A_FSG_49_0_0_33_Data_4_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Data_4_6" ,getValue(A_FSG_49_0_0_33_Data_4_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Data_4_7" ,getValue(A_FSG_49_0_0_33_Data_4_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Data_4_8" ,getValue(A_FSG_49_0_0_33_Data_4_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Data_4_9" ,getValue(A_FSG_49_0_0_33_Data_4_9), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Data_4_10" ,getValue(A_FSG_49_0_0_33_Data_4_10), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_33_Data_2" ,getValue(A_FSG_49_0_0_33_Data_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_33_Data_2_range" ,getValue(A_FSG_49_0_0_33_Data_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_RecAdr" ,getValue(A_FSG_49_0_0_33_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Direction" ,getValue(A_FSG_49_0_0_33_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Shift" ,getValue(A_FSG_49_0_0_33_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_TransPos" ,getValue(A_FSG_49_0_0_33_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_IndexSize" ,getValue(A_FSG_49_0_0_33_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Start" ,getValue(A_FSG_49_0_0_33_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Elements" ,getValue(A_FSG_49_0_0_33_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Changed_RecAdr" ,getValue(A_FSG_49_0_0_33_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Changed_Direction" ,getValue(A_FSG_49_0_0_33_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Changed_Shift" ,getValue(A_FSG_49_0_0_33_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Changed_TransPos" ,getValue(A_FSG_49_0_0_33_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Changed_IndexSize" ,getValue(A_FSG_49_0_0_33_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Changed_Start" ,getValue(A_FSG_49_0_0_33_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_Changed_Elements" ,getValue(A_FSG_49_0_0_33_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_33_2_SetGet" ,getValue(A_FSG_49_0_0_33_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_33_2_SetGet_range" ,getValue(A_FSG_49_0_0_33_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_1_SetGet" ,getValue(A_FSG_49_0_0_33_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_SetGet_RecAdr" ,getValue(A_FSG_49_0_0_33_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_SetGet_Direction" ,getValue(A_FSG_49_0_0_33_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_SetGet_Shift" ,getValue(A_FSG_49_0_0_33_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_SetGet_IndexSize" ,getValue(A_FSG_49_0_0_33_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_SetGet_Start" ,getValue(A_FSG_49_0_0_33_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_33_SetGet_Elements" ,getValue(A_FSG_49_0_0_33_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_34Result_BTN" ,getValue(M_FSG_49_0_0_34Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_34_FctLstItemEn" ,getValue(M_FSG_49_0_0_34_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_34_FctEn" ,getValue(M_FSG_49_0_0_34_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_34_ErrEn" ,getValue(M_FSG_49_0_0_34_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_34_ErrCode" ,getValue(M_FSG_49_0_0_34_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_34_Result" ,getValue(M_FSG_49_0_0_34_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_34_Result_1" ,getValue(M_FSG_49_0_0_34_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_34_Processing" ,getValue(M_FSG_49_0_0_34_Processing), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_34_Processing_1" ,getValue(M_FSG_49_0_0_34_Processing_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_34_Processing_1_range" ,getValue(M_FSG_49_0_0_34_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_34_Start" ,getValue(M_FSG_49_0_0_34_Start), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_34_Start_1" ,getValue(M_FSG_49_0_0_34_Start_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_34_Start_1_range" ,getValue(M_FSG_49_0_0_34_Start_1_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_35Status_BTN" ,getValue(P_FSG_49_0_0_35Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_35_FctLstItemEn" ,getValue(P_FSG_49_0_0_35_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_35_FctEn" ,getValue(P_FSG_49_0_0_35_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_35_ErrEn" ,getValue(P_FSG_49_0_0_35_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_35_ErrCode" ,getValue(P_FSG_49_0_0_35_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_35_3" ,getValue(P_FSG_49_0_0_35_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_35_3_range" ,getValue(P_FSG_49_0_0_35_3_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_35_1" ,getValue(P_FSG_49_0_0_35_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_35_1_range" ,getValue(P_FSG_49_0_0_35_1_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_35_2" ,getValue(P_FSG_49_0_0_35_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_35_2_range" ,getValue(P_FSG_49_0_0_35_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36Changed_BTN" ,getValue(A_FSG_49_0_0_36Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36Status_BTN" ,getValue(A_FSG_49_0_0_36Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_FctLstItemEn" ,getValue(A_FSG_49_0_0_36_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_FctEn" ,getValue(A_FSG_49_0_0_36_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_ErrEn" ,getValue(A_FSG_49_0_0_36_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_IntTlgEn" ,getValue(A_FSG_49_0_0_36_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_SegmEn" ,getValue(A_FSG_49_0_0_36_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_AT" ,getValue(A_FSG_49_0_0_36_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_ErrCode" ,getValue(A_FSG_49_0_0_36_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_DataIndex" ,getValue(A_FSG_49_0_0_36_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_DataIndex_Incr" ,getValue(A_FSG_49_0_0_36_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_DataIndex_Decr" ,getValue(A_FSG_49_0_0_36_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_loadArray_Btn" ,getValue(A_FSG_49_0_0_36_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_generateData_Btn" ,getValue(A_FSG_49_0_0_36_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Data_4_len" ,getValue(A_FSG_49_0_0_36_Data_4_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Data_4_cnt" ,getValue(A_FSG_49_0_0_36_Data_4_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Data_3" ,getValue(A_FSG_49_0_0_36_Data_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Data_3_0" ,getValue(A_FSG_49_0_0_36_Data_3_0), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Data_3_1" ,getValue(A_FSG_49_0_0_36_Data_3_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Data_3_2" ,getValue(A_FSG_49_0_0_36_Data_3_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Data_3_3" ,getValue(A_FSG_49_0_0_36_Data_3_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Data_3_4" ,getValue(A_FSG_49_0_0_36_Data_3_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Data_3_5" ,getValue(A_FSG_49_0_0_36_Data_3_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Data_3_6" ,getValue(A_FSG_49_0_0_36_Data_3_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Data_2" ,getValue(A_FSG_49_0_0_36_Data_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_36_2" ,getValue(A_FSG_49_0_0_36_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_36_2_range" ,getValue(A_FSG_49_0_0_36_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_1" ,getValue(A_FSG_49_0_0_36_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_36_Data_1" ,getValue(A_FSG_49_0_0_36_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_36_Data_1_range" ,getValue(A_FSG_49_0_0_36_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_36_4" ,getValue(A_FSG_49_0_0_36_4), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_36_4_range" ,getValue(A_FSG_49_0_0_36_4_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_36_3" ,getValue(A_FSG_49_0_0_36_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_36_3_range" ,getValue(A_FSG_49_0_0_36_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_RecAdr" ,getValue(A_FSG_49_0_0_36_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Direction" ,getValue(A_FSG_49_0_0_36_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Shift" ,getValue(A_FSG_49_0_0_36_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_TransPos" ,getValue(A_FSG_49_0_0_36_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_IndexSize" ,getValue(A_FSG_49_0_0_36_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Start" ,getValue(A_FSG_49_0_0_36_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Elements" ,getValue(A_FSG_49_0_0_36_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Changed_RecAdr" ,getValue(A_FSG_49_0_0_36_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Changed_Direction" ,getValue(A_FSG_49_0_0_36_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Changed_Shift" ,getValue(A_FSG_49_0_0_36_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Changed_TransPos" ,getValue(A_FSG_49_0_0_36_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Changed_IndexSize" ,getValue(A_FSG_49_0_0_36_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Changed_Start" ,getValue(A_FSG_49_0_0_36_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_Changed_Elements" ,getValue(A_FSG_49_0_0_36_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_36_2_SetGet" ,getValue(A_FSG_49_0_0_36_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_36_2_SetGet_range" ,getValue(A_FSG_49_0_0_36_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_1_SetGet" ,getValue(A_FSG_49_0_0_36_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_SetGet_RecAdr" ,getValue(A_FSG_49_0_0_36_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_SetGet_Direction" ,getValue(A_FSG_49_0_0_36_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_SetGet_Shift" ,getValue(A_FSG_49_0_0_36_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_SetGet_IndexSize" ,getValue(A_FSG_49_0_0_36_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_SetGet_Start" ,getValue(A_FSG_49_0_0_36_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_36_SetGet_Elements" ,getValue(A_FSG_49_0_0_36_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_37Status_BTN" ,getValue(P_FSG_49_0_0_37Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_37_FctLstItemEn" ,getValue(P_FSG_49_0_0_37_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_37_FctEn" ,getValue(P_FSG_49_0_0_37_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_37_ErrEn" ,getValue(P_FSG_49_0_0_37_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_37_IntTlgEn" ,getValue(P_FSG_49_0_0_37_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_37_SegmEn" ,getValue(P_FSG_49_0_0_37_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_37_ErrCode" ,getValue(P_FSG_49_0_0_37_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_37_1" ,getValue(P_FSG_49_0_0_37_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_37_2_len" ,getValue(P_FSG_49_0_0_37_2_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_37_2_cnt" ,getValue(P_FSG_49_0_0_37_2_cnt), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_38Result_BTN" ,getValue(M_FSG_49_0_0_38Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_38_FctLstItemEn" ,getValue(M_FSG_49_0_0_38_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_38_FctEn" ,getValue(M_FSG_49_0_0_38_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_38_ErrEn" ,getValue(M_FSG_49_0_0_38_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_38_ErrCode" ,getValue(M_FSG_49_0_0_38_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_38_Result" ,getValue(M_FSG_49_0_0_38_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_38_Result_1" ,getValue(M_FSG_49_0_0_38_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_38_Processing" ,getValue(M_FSG_49_0_0_38_Processing), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_38_Processing_1" ,getValue(M_FSG_49_0_0_38_Processing_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_38_Processing_1_range" ,getValue(M_FSG_49_0_0_38_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_38_Start_1" ,getValue(M_FSG_49_0_0_38_Start_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_38_Start_2" ,getValue(M_FSG_49_0_0_38_Start_2), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_38_Start_2_range" ,getValue(M_FSG_49_0_0_38_Start_2_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_39Result_BTN" ,getValue(M_FSG_49_0_0_39Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_39_FctLstItemEn" ,getValue(M_FSG_49_0_0_39_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_39_FctEn" ,getValue(M_FSG_49_0_0_39_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_39_ErrEn" ,getValue(M_FSG_49_0_0_39_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_39_IntTlgEn" ,getValue(M_FSG_49_0_0_39_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_39_SegmEn" ,getValue(M_FSG_49_0_0_39_SegmEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_39_ErrCode" ,getValue(M_FSG_49_0_0_39_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_39_Result_1" ,getValue(M_FSG_49_0_0_39_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_39_Result_2_len" ,getValue(M_FSG_49_0_0_39_Result_2_len), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_39_Result_2_cnt" ,getValue(M_FSG_49_0_0_39_Result_2_cnt), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_39_Result_3_len" ,getValue(M_FSG_49_0_0_39_Result_3_len), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_39_Result_3_cnt" ,getValue(M_FSG_49_0_0_39_Result_3_cnt), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_39_Result_4_len" ,getValue(M_FSG_49_0_0_39_Result_4_len), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_39_Result_4_cnt" ,getValue(M_FSG_49_0_0_39_Result_4_cnt), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_39_Processing_1_len" ,getValue(M_FSG_49_0_0_39_Processing_1_len), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_39_Processing_1_cnt" ,getValue(M_FSG_49_0_0_39_Processing_1_cnt), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_39_Start" ,getValue(M_FSG_49_0_0_39_Start), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_39_Start_1" ,getValue(M_FSG_49_0_0_39_Start_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_39_Start_1_range" ,getValue(M_FSG_49_0_0_39_Start_1_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_40Status_BTN" ,getValue(P_FSG_49_0_0_40Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_40_FctLstItemEn" ,getValue(P_FSG_49_0_0_40_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_40_FctEn" ,getValue(P_FSG_49_0_0_40_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_40_ErrEn" ,getValue(P_FSG_49_0_0_40_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_40_ErrCode" ,getValue(P_FSG_49_0_0_40_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_40" ,getValue(P_FSG_49_0_0_40), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_40_1" ,getValue(P_FSG_49_0_0_40_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_41Status_BTN" ,getValue(P_FSG_49_0_0_41Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_41_FctLstItemEn" ,getValue(P_FSG_49_0_0_41_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_41_FctEn" ,getValue(P_FSG_49_0_0_41_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_41_ErrEn" ,getValue(P_FSG_49_0_0_41_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_41_ErrCode" ,getValue(P_FSG_49_0_0_41_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_41" ,getValue(P_FSG_49_0_0_41), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_41_1" ,getValue(P_FSG_49_0_0_41_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42Status_BTN" ,getValue(P_FSG_49_0_0_42Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_FctLstItemEn" ,getValue(P_FSG_49_0_0_42_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_FctEn" ,getValue(P_FSG_49_0_0_42_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_ErrEn" ,getValue(P_FSG_49_0_0_42_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_IntTlgEn" ,getValue(P_FSG_49_0_0_42_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_SegmEn" ,getValue(P_FSG_49_0_0_42_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_ErrCode" ,getValue(P_FSG_49_0_0_42_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_3" ,getValue(P_FSG_49_0_0_42_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_3_1" ,getValue(P_FSG_49_0_0_42_3_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_3_4" ,getValue(P_FSG_49_0_0_42_3_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_2" ,getValue(P_FSG_49_0_0_42_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_2_0" ,getValue(P_FSG_49_0_0_42_2_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_2_1" ,getValue(P_FSG_49_0_0_42_2_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_2_3" ,getValue(P_FSG_49_0_0_42_2_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_2_4" ,getValue(P_FSG_49_0_0_42_2_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_2_5" ,getValue(P_FSG_49_0_0_42_2_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_2_6" ,getValue(P_FSG_49_0_0_42_2_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_2_7" ,getValue(P_FSG_49_0_0_42_2_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_16" ,getValue(P_FSG_49_0_0_42_1_16), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_17" ,getValue(P_FSG_49_0_0_42_1_17), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_18" ,getValue(P_FSG_49_0_0_42_1_18), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_19" ,getValue(P_FSG_49_0_0_42_1_19), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_20" ,getValue(P_FSG_49_0_0_42_1_20), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_21" ,getValue(P_FSG_49_0_0_42_1_21), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_22" ,getValue(P_FSG_49_0_0_42_1_22), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_25" ,getValue(P_FSG_49_0_0_42_1_25), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_26" ,getValue(P_FSG_49_0_0_42_1_26), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_28" ,getValue(P_FSG_49_0_0_42_1_28), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_30" ,getValue(P_FSG_49_0_0_42_1_30), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_31" ,getValue(P_FSG_49_0_0_42_1_31), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_35" ,getValue(P_FSG_49_0_0_42_1_35), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_37" ,getValue(P_FSG_49_0_0_42_1_37), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_40" ,getValue(P_FSG_49_0_0_42_1_40), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_41" ,getValue(P_FSG_49_0_0_42_1_41), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_43" ,getValue(P_FSG_49_0_0_42_1_43), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_46" ,getValue(P_FSG_49_0_0_42_1_46), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_42_1_47" ,getValue(P_FSG_49_0_0_42_1_47), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_43Status_BTN" ,getValue(P_FSG_49_0_0_43Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_43_FctLstItemEn" ,getValue(P_FSG_49_0_0_43_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_43_FctEn" ,getValue(P_FSG_49_0_0_43_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_43_ErrEn" ,getValue(P_FSG_49_0_0_43_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_43_ErrCode" ,getValue(P_FSG_49_0_0_43_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_43" ,getValue(P_FSG_49_0_0_43), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_43_1" ,getValue(P_FSG_49_0_0_43_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_43_1_0" ,getValue(P_FSG_49_0_0_43_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_43_1_1" ,getValue(P_FSG_49_0_0_43_1_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_44Result_BTN" ,getValue(M_FSG_49_0_0_44Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_44_FctLstItemEn" ,getValue(M_FSG_49_0_0_44_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_44_FctEn" ,getValue(M_FSG_49_0_0_44_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_44_ErrEn" ,getValue(M_FSG_49_0_0_44_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_44_IntTlgEn" ,getValue(M_FSG_49_0_0_44_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_44_SegmEn" ,getValue(M_FSG_49_0_0_44_SegmEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_44_ErrCode" ,getValue(M_FSG_49_0_0_44_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_44_Result_1" ,getValue(M_FSG_49_0_0_44_Result_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_44_Result_2" ,getValue(M_FSG_49_0_0_44_Result_2), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_44_Result_2_range" ,getValue(M_FSG_49_0_0_44_Result_2_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_44_Result_3" ,getValue(M_FSG_49_0_0_44_Result_3), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_44_Result_3_range" ,getValue(M_FSG_49_0_0_44_Result_3_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_44_Result_4" ,getValue(M_FSG_49_0_0_44_Result_4), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_44_Result_4_range" ,getValue(M_FSG_49_0_0_44_Result_4_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_44_Processing_1" ,getValue(M_FSG_49_0_0_44_Processing_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_44_Processing_1_range" ,getValue(M_FSG_49_0_0_44_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_44_Processing_2" ,getValue(M_FSG_49_0_0_44_Processing_2), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_44_Processing_2_range" ,getValue(M_FSG_49_0_0_44_Processing_2_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_44_Processing_3" ,getValue(M_FSG_49_0_0_44_Processing_3), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_44_Processing_3_range" ,getValue(M_FSG_49_0_0_44_Processing_3_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_44_Processing_4" ,getValue(M_FSG_49_0_0_44_Processing_4), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_44_Processing_4_range" ,getValue(M_FSG_49_0_0_44_Processing_4_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_44_Start_1" ,getValue(M_FSG_49_0_0_44_Start_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_44_Start_1_range" ,getValue(M_FSG_49_0_0_44_Start_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_44_Start_2" ,getValue(M_FSG_49_0_0_44_Start_2), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_44_Start_2_range" ,getValue(M_FSG_49_0_0_44_Start_2_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_44_Start_3" ,getValue(M_FSG_49_0_0_44_Start_3), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_45Result_BTN" ,getValue(M_FSG_49_0_0_45Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_45_FctLstItemEn" ,getValue(M_FSG_49_0_0_45_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_45_FctEn" ,getValue(M_FSG_49_0_0_45_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_45_ErrEn" ,getValue(M_FSG_49_0_0_45_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_45_ErrCode" ,getValue(M_FSG_49_0_0_45_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_45_Result" ,getValue(M_FSG_49_0_0_45_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_45_Result_1" ,getValue(M_FSG_49_0_0_45_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_45_Processing" ,getValue(M_FSG_49_0_0_45_Processing), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_45_Processing_1" ,getValue(M_FSG_49_0_0_45_Processing_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_49_0_0_45_Processing_1_range" ,getValue(M_FSG_49_0_0_45_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_45_Start" ,getValue(M_FSG_49_0_0_45_Start), profileFile);
    writeProfileInt("BAP" ,"M_FSG_49_0_0_45_Start_1" ,getValue(M_FSG_49_0_0_45_Start_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_46Status_BTN" ,getValue(P_FSG_49_0_0_46Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_46_FctLstItemEn" ,getValue(P_FSG_49_0_0_46_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_46_FctEn" ,getValue(P_FSG_49_0_0_46_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_46_ErrEn" ,getValue(P_FSG_49_0_0_46_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_46_ErrCode" ,getValue(P_FSG_49_0_0_46_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_46_1" ,getValue(P_FSG_49_0_0_46_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_46_2" ,getValue(P_FSG_49_0_0_46_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_46_2_range" ,getValue(P_FSG_49_0_0_46_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_46_3" ,getValue(P_FSG_49_0_0_46_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_46_4" ,getValue(P_FSG_49_0_0_46_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_46_4_range" ,getValue(P_FSG_49_0_0_46_4_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_47Status_BTN" ,getValue(P_FSG_49_0_0_47Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_47_FctLstItemEn" ,getValue(P_FSG_49_0_0_47_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_47_FctEn" ,getValue(P_FSG_49_0_0_47_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_47_ErrEn" ,getValue(P_FSG_49_0_0_47_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_47_ErrCode" ,getValue(P_FSG_49_0_0_47_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_47_3" ,getValue(P_FSG_49_0_0_47_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_47_3_range" ,getValue(P_FSG_49_0_0_47_3_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_47_4" ,getValue(P_FSG_49_0_0_47_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_47_4_range" ,getValue(P_FSG_49_0_0_47_4_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_47_1" ,getValue(P_FSG_49_0_0_47_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_47_2" ,getValue(P_FSG_49_0_0_47_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_47_2_0" ,getValue(P_FSG_49_0_0_47_2_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_48Status_BTN" ,getValue(P_FSG_49_0_0_48Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_48_FctLstItemEn" ,getValue(P_FSG_49_0_0_48_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_48_FctEn" ,getValue(P_FSG_49_0_0_48_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_48_ErrEn" ,getValue(P_FSG_49_0_0_48_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_48_ErrCode" ,getValue(P_FSG_49_0_0_48_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_48_2" ,getValue(P_FSG_49_0_0_48_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_48_2_range" ,getValue(P_FSG_49_0_0_48_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_48_1" ,getValue(P_FSG_49_0_0_48_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_49Status_BTN" ,getValue(P_FSG_49_0_0_49Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_49_FctLstItemEn" ,getValue(P_FSG_49_0_0_49_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_49_FctEn" ,getValue(P_FSG_49_0_0_49_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_49_ErrEn" ,getValue(P_FSG_49_0_0_49_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_49_ErrCode" ,getValue(P_FSG_49_0_0_49_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_49_2" ,getValue(P_FSG_49_0_0_49_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_49_2_range" ,getValue(P_FSG_49_0_0_49_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_49_1" ,getValue(P_FSG_49_0_0_49_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_49_3" ,getValue(P_FSG_49_0_0_49_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_49_3_range" ,getValue(P_FSG_49_0_0_49_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50Changed_BTN" ,getValue(A_FSG_49_0_0_50Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50Status_BTN" ,getValue(A_FSG_49_0_0_50Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_FctLstItemEn" ,getValue(A_FSG_49_0_0_50_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_FctEn" ,getValue(A_FSG_49_0_0_50_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_ErrEn" ,getValue(A_FSG_49_0_0_50_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_IntTlgEn" ,getValue(A_FSG_49_0_0_50_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_SegmEn" ,getValue(A_FSG_49_0_0_50_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_AT" ,getValue(A_FSG_49_0_0_50_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_ErrCode" ,getValue(A_FSG_49_0_0_50_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_DataIndex" ,getValue(A_FSG_49_0_0_50_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_DataIndex_Incr" ,getValue(A_FSG_49_0_0_50_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_DataIndex_Decr" ,getValue(A_FSG_49_0_0_50_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_loadArray_Btn" ,getValue(A_FSG_49_0_0_50_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_generateData_Btn" ,getValue(A_FSG_49_0_0_50_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Data_8_len" ,getValue(A_FSG_49_0_0_50_Data_8_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Data_8_cnt" ,getValue(A_FSG_49_0_0_50_Data_8_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Data_2" ,getValue(A_FSG_49_0_0_50_Data_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Data_2_0" ,getValue(A_FSG_49_0_0_50_Data_2_0), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Data_2_1" ,getValue(A_FSG_49_0_0_50_Data_2_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Data_2_2" ,getValue(A_FSG_49_0_0_50_Data_2_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Data_2_3" ,getValue(A_FSG_49_0_0_50_Data_2_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Data_2_4" ,getValue(A_FSG_49_0_0_50_Data_2_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Data_2_5" ,getValue(A_FSG_49_0_0_50_Data_2_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Data_2_6" ,getValue(A_FSG_49_0_0_50_Data_2_6), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_50_3" ,getValue(A_FSG_49_0_0_50_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_50_3_range" ,getValue(A_FSG_49_0_0_50_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_1" ,getValue(A_FSG_49_0_0_50_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Data_4_len" ,getValue(A_FSG_49_0_0_50_Data_4_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Data_4_cnt" ,getValue(A_FSG_49_0_0_50_Data_4_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Data_6" ,getValue(A_FSG_49_0_0_50_Data_6), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_50_Data_1" ,getValue(A_FSG_49_0_0_50_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_50_Data_1_range" ,getValue(A_FSG_49_0_0_50_Data_1_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Data_5_len" ,getValue(A_FSG_49_0_0_50_Data_5_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Data_5_cnt" ,getValue(A_FSG_49_0_0_50_Data_5_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_50_2" ,getValue(A_FSG_49_0_0_50_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_50_2_range" ,getValue(A_FSG_49_0_0_50_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Data_7_len" ,getValue(A_FSG_49_0_0_50_Data_7_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Data_7_cnt" ,getValue(A_FSG_49_0_0_50_Data_7_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_50_Data_3" ,getValue(A_FSG_49_0_0_50_Data_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_50_Data_3_range" ,getValue(A_FSG_49_0_0_50_Data_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_RecAdr" ,getValue(A_FSG_49_0_0_50_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Direction" ,getValue(A_FSG_49_0_0_50_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Shift" ,getValue(A_FSG_49_0_0_50_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_TransPos" ,getValue(A_FSG_49_0_0_50_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_IndexSize" ,getValue(A_FSG_49_0_0_50_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Start" ,getValue(A_FSG_49_0_0_50_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Elements" ,getValue(A_FSG_49_0_0_50_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Changed_RecAdr" ,getValue(A_FSG_49_0_0_50_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Changed_Direction" ,getValue(A_FSG_49_0_0_50_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Changed_Shift" ,getValue(A_FSG_49_0_0_50_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Changed_TransPos" ,getValue(A_FSG_49_0_0_50_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Changed_IndexSize" ,getValue(A_FSG_49_0_0_50_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Changed_Start" ,getValue(A_FSG_49_0_0_50_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_Changed_Elements" ,getValue(A_FSG_49_0_0_50_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_50_2_SetGet" ,getValue(A_FSG_49_0_0_50_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_50_2_SetGet_range" ,getValue(A_FSG_49_0_0_50_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_1_SetGet" ,getValue(A_FSG_49_0_0_50_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_SetGet_RecAdr" ,getValue(A_FSG_49_0_0_50_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_SetGet_Direction" ,getValue(A_FSG_49_0_0_50_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_SetGet_Shift" ,getValue(A_FSG_49_0_0_50_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_SetGet_IndexSize" ,getValue(A_FSG_49_0_0_50_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_SetGet_Start" ,getValue(A_FSG_49_0_0_50_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_50_SetGet_Elements" ,getValue(A_FSG_49_0_0_50_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_51Status_BTN" ,getValue(P_FSG_49_0_0_51Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_51_FctLstItemEn" ,getValue(P_FSG_49_0_0_51_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_51_FctEn" ,getValue(P_FSG_49_0_0_51_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_51_ErrEn" ,getValue(P_FSG_49_0_0_51_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_51_ErrCode" ,getValue(P_FSG_49_0_0_51_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_51_4" ,getValue(P_FSG_49_0_0_51_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_51_4_range" ,getValue(P_FSG_49_0_0_51_4_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_51_1" ,getValue(P_FSG_49_0_0_51_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_51_1_range" ,getValue(P_FSG_49_0_0_51_1_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_51_2" ,getValue(P_FSG_49_0_0_51_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_51_2_range" ,getValue(P_FSG_49_0_0_51_2_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_51_3" ,getValue(P_FSG_49_0_0_51_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_51_3_range" ,getValue(P_FSG_49_0_0_51_3_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_52Status_BTN" ,getValue(P_FSG_49_0_0_52Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_52_FctLstItemEn" ,getValue(P_FSG_49_0_0_52_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_52_FctEn" ,getValue(P_FSG_49_0_0_52_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_52_ErrEn" ,getValue(P_FSG_49_0_0_52_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_52_ErrCode" ,getValue(P_FSG_49_0_0_52_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_52_4" ,getValue(P_FSG_49_0_0_52_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_52_4_range" ,getValue(P_FSG_49_0_0_52_4_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_52_1" ,getValue(P_FSG_49_0_0_52_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_52_1_range" ,getValue(P_FSG_49_0_0_52_1_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_52_2" ,getValue(P_FSG_49_0_0_52_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_52_2_range" ,getValue(P_FSG_49_0_0_52_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_52_3" ,getValue(P_FSG_49_0_0_52_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_52_3_0" ,getValue(P_FSG_49_0_0_52_3_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_53Status_BTN" ,getValue(P_FSG_49_0_0_53Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_53_FctLstItemEn" ,getValue(P_FSG_49_0_0_53_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_53_FctEn" ,getValue(P_FSG_49_0_0_53_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_53_ErrEn" ,getValue(P_FSG_49_0_0_53_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_53_ErrCode" ,getValue(P_FSG_49_0_0_53_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_53_4" ,getValue(P_FSG_49_0_0_53_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_53_4_range" ,getValue(P_FSG_49_0_0_53_4_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_53_3" ,getValue(P_FSG_49_0_0_53_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_53_3_range" ,getValue(P_FSG_49_0_0_53_3_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_53_2" ,getValue(P_FSG_49_0_0_53_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_53_2_range" ,getValue(P_FSG_49_0_0_53_2_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_53_6" ,getValue(P_FSG_49_0_0_53_6), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_53_6_range" ,getValue(P_FSG_49_0_0_53_6_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_53_5" ,getValue(P_FSG_49_0_0_53_5), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_53_5_range" ,getValue(P_FSG_49_0_0_53_5_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_53_1" ,getValue(P_FSG_49_0_0_53_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_53_1_range" ,getValue(P_FSG_49_0_0_53_1_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54Status_BTN" ,getValue(P_FSG_49_0_0_54Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_FctLstItemEn" ,getValue(P_FSG_49_0_0_54_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_FctEn" ,getValue(P_FSG_49_0_0_54_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_ErrEn" ,getValue(P_FSG_49_0_0_54_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_IntTlgEn" ,getValue(P_FSG_49_0_0_54_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_SegmEn" ,getValue(P_FSG_49_0_0_54_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_ErrCode" ,getValue(P_FSG_49_0_0_54_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_16_len" ,getValue(P_FSG_49_0_0_54_16_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_16_cnt" ,getValue(P_FSG_49_0_0_54_16_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_14_len" ,getValue(P_FSG_49_0_0_54_14_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_14_cnt" ,getValue(P_FSG_49_0_0_54_14_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_12_len" ,getValue(P_FSG_49_0_0_54_12_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_12_cnt" ,getValue(P_FSG_49_0_0_54_12_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_10_len" ,getValue(P_FSG_49_0_0_54_10_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_10_cnt" ,getValue(P_FSG_49_0_0_54_10_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_8_len" ,getValue(P_FSG_49_0_0_54_8_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_8_cnt" ,getValue(P_FSG_49_0_0_54_8_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_6_len" ,getValue(P_FSG_49_0_0_54_6_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_6_cnt" ,getValue(P_FSG_49_0_0_54_6_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_4_len" ,getValue(P_FSG_49_0_0_54_4_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_4_cnt" ,getValue(P_FSG_49_0_0_54_4_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_1_len" ,getValue(P_FSG_49_0_0_54_1_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_1_cnt" ,getValue(P_FSG_49_0_0_54_1_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_19" ,getValue(P_FSG_49_0_0_54_19), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_19_0" ,getValue(P_FSG_49_0_0_54_19_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_19_1" ,getValue(P_FSG_49_0_0_54_19_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_19_2" ,getValue(P_FSG_49_0_0_54_19_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_19_3" ,getValue(P_FSG_49_0_0_54_19_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_19_4" ,getValue(P_FSG_49_0_0_54_19_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_19_5" ,getValue(P_FSG_49_0_0_54_19_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_19_6" ,getValue(P_FSG_49_0_0_54_19_6), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_54_3" ,getValue(P_FSG_49_0_0_54_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_54_3_range" ,getValue(P_FSG_49_0_0_54_3_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_54_20" ,getValue(P_FSG_49_0_0_54_20), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_54_20_range" ,getValue(P_FSG_49_0_0_54_20_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_17" ,getValue(P_FSG_49_0_0_54_17), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_18" ,getValue(P_FSG_49_0_0_54_18), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_18_0" ,getValue(P_FSG_49_0_0_54_18_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_18_1" ,getValue(P_FSG_49_0_0_54_18_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_18_2" ,getValue(P_FSG_49_0_0_54_18_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_18_3" ,getValue(P_FSG_49_0_0_54_18_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_18_4" ,getValue(P_FSG_49_0_0_54_18_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_15" ,getValue(P_FSG_49_0_0_54_15), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_13" ,getValue(P_FSG_49_0_0_54_13), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_11" ,getValue(P_FSG_49_0_0_54_11), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_9" ,getValue(P_FSG_49_0_0_54_9), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_7" ,getValue(P_FSG_49_0_0_54_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_5" ,getValue(P_FSG_49_0_0_54_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_54_2" ,getValue(P_FSG_49_0_0_54_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_55Status_BTN" ,getValue(P_FSG_49_0_0_55Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_55_FctLstItemEn" ,getValue(P_FSG_49_0_0_55_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_55_FctEn" ,getValue(P_FSG_49_0_0_55_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_55_ErrEn" ,getValue(P_FSG_49_0_0_55_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_55_ErrCode" ,getValue(P_FSG_49_0_0_55_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_55_4" ,getValue(P_FSG_49_0_0_55_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_55_4_range" ,getValue(P_FSG_49_0_0_55_4_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_55_3" ,getValue(P_FSG_49_0_0_55_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_55_3_range" ,getValue(P_FSG_49_0_0_55_3_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_55_1" ,getValue(P_FSG_49_0_0_55_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_55_1_range" ,getValue(P_FSG_49_0_0_55_1_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_55_6" ,getValue(P_FSG_49_0_0_55_6), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_55_6_range" ,getValue(P_FSG_49_0_0_55_6_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_55_2" ,getValue(P_FSG_49_0_0_55_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_55_2_range" ,getValue(P_FSG_49_0_0_55_2_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_55_5" ,getValue(P_FSG_49_0_0_55_5), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_55_5_range" ,getValue(P_FSG_49_0_0_55_5_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56Changed_BTN" ,getValue(A_FSG_49_0_0_56Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56Status_BTN" ,getValue(A_FSG_49_0_0_56Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_FctLstItemEn" ,getValue(A_FSG_49_0_0_56_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_FctEn" ,getValue(A_FSG_49_0_0_56_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_ErrEn" ,getValue(A_FSG_49_0_0_56_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_IntTlgEn" ,getValue(A_FSG_49_0_0_56_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_SegmEn" ,getValue(A_FSG_49_0_0_56_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_AT" ,getValue(A_FSG_49_0_0_56_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_ErrCode" ,getValue(A_FSG_49_0_0_56_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_DataIndex" ,getValue(A_FSG_49_0_0_56_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_DataIndex_Incr" ,getValue(A_FSG_49_0_0_56_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_DataIndex_Decr" ,getValue(A_FSG_49_0_0_56_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_loadArray_Btn" ,getValue(A_FSG_49_0_0_56_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_generateData_Btn" ,getValue(A_FSG_49_0_0_56_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Data_4" ,getValue(A_FSG_49_0_0_56_Data_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Data_4_0" ,getValue(A_FSG_49_0_0_56_Data_4_0), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Data_4_1" ,getValue(A_FSG_49_0_0_56_Data_4_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Data_4_2" ,getValue(A_FSG_49_0_0_56_Data_4_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Data_4_3" ,getValue(A_FSG_49_0_0_56_Data_4_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Data_4_4" ,getValue(A_FSG_49_0_0_56_Data_4_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Data_4_5" ,getValue(A_FSG_49_0_0_56_Data_4_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Data_4_6" ,getValue(A_FSG_49_0_0_56_Data_4_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Data_4_7" ,getValue(A_FSG_49_0_0_56_Data_4_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Data_4_8" ,getValue(A_FSG_49_0_0_56_Data_4_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Data_4_9" ,getValue(A_FSG_49_0_0_56_Data_4_9), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Data_4_10" ,getValue(A_FSG_49_0_0_56_Data_4_10), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Data_4_11" ,getValue(A_FSG_49_0_0_56_Data_4_11), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_56_3" ,getValue(A_FSG_49_0_0_56_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_56_3_range" ,getValue(A_FSG_49_0_0_56_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_1" ,getValue(A_FSG_49_0_0_56_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Data_3" ,getValue(A_FSG_49_0_0_56_Data_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Data_5_len" ,getValue(A_FSG_49_0_0_56_Data_5_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Data_5_cnt" ,getValue(A_FSG_49_0_0_56_Data_5_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_56_Data_2" ,getValue(A_FSG_49_0_0_56_Data_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_56_Data_2_range" ,getValue(A_FSG_49_0_0_56_Data_2_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_56_Data_1" ,getValue(A_FSG_49_0_0_56_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_56_Data_1_range" ,getValue(A_FSG_49_0_0_56_Data_1_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Data_6_len" ,getValue(A_FSG_49_0_0_56_Data_6_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Data_6_cnt" ,getValue(A_FSG_49_0_0_56_Data_6_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_56_2" ,getValue(A_FSG_49_0_0_56_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_56_2_range" ,getValue(A_FSG_49_0_0_56_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_RecAdr" ,getValue(A_FSG_49_0_0_56_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Direction" ,getValue(A_FSG_49_0_0_56_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Shift" ,getValue(A_FSG_49_0_0_56_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_TransPos" ,getValue(A_FSG_49_0_0_56_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_IndexSize" ,getValue(A_FSG_49_0_0_56_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Start" ,getValue(A_FSG_49_0_0_56_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Elements" ,getValue(A_FSG_49_0_0_56_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Changed_RecAdr" ,getValue(A_FSG_49_0_0_56_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Changed_Direction" ,getValue(A_FSG_49_0_0_56_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Changed_Shift" ,getValue(A_FSG_49_0_0_56_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Changed_TransPos" ,getValue(A_FSG_49_0_0_56_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Changed_IndexSize" ,getValue(A_FSG_49_0_0_56_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Changed_Start" ,getValue(A_FSG_49_0_0_56_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_Changed_Elements" ,getValue(A_FSG_49_0_0_56_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_56_2_SetGet" ,getValue(A_FSG_49_0_0_56_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_56_2_SetGet_range" ,getValue(A_FSG_49_0_0_56_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_1_SetGet" ,getValue(A_FSG_49_0_0_56_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_SetGet_RecAdr" ,getValue(A_FSG_49_0_0_56_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_SetGet_Direction" ,getValue(A_FSG_49_0_0_56_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_SetGet_Shift" ,getValue(A_FSG_49_0_0_56_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_SetGet_IndexSize" ,getValue(A_FSG_49_0_0_56_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_SetGet_Start" ,getValue(A_FSG_49_0_0_56_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_56_SetGet_Elements" ,getValue(A_FSG_49_0_0_56_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_57Status_BTN" ,getValue(P_FSG_49_0_0_57Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_57_FctLstItemEn" ,getValue(P_FSG_49_0_0_57_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_57_FctEn" ,getValue(P_FSG_49_0_0_57_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_57_ErrEn" ,getValue(P_FSG_49_0_0_57_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_57_IntTlgEn" ,getValue(P_FSG_49_0_0_57_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_57_SegmEn" ,getValue(P_FSG_49_0_0_57_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_57_ErrCode" ,getValue(P_FSG_49_0_0_57_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_57_6" ,getValue(P_FSG_49_0_0_57_6), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_57_6_range" ,getValue(P_FSG_49_0_0_57_6_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_57_5" ,getValue(P_FSG_49_0_0_57_5), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_57_5_range" ,getValue(P_FSG_49_0_0_57_5_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_57_2_len" ,getValue(P_FSG_49_0_0_57_2_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_57_2_cnt" ,getValue(P_FSG_49_0_0_57_2_cnt), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_57_4" ,getValue(P_FSG_49_0_0_57_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_57_4_range" ,getValue(P_FSG_49_0_0_57_4_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_57_1" ,getValue(P_FSG_49_0_0_57_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_57_3_len" ,getValue(P_FSG_49_0_0_57_3_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_57_3_cnt" ,getValue(P_FSG_49_0_0_57_3_cnt), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_57_7" ,getValue(P_FSG_49_0_0_57_7), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_57_7_range" ,getValue(P_FSG_49_0_0_57_7_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58Changed_BTN" ,getValue(A_FSG_49_0_0_58Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58Status_BTN" ,getValue(A_FSG_49_0_0_58Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_FctLstItemEn" ,getValue(A_FSG_49_0_0_58_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_FctEn" ,getValue(A_FSG_49_0_0_58_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_ErrEn" ,getValue(A_FSG_49_0_0_58_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_IntTlgEn" ,getValue(A_FSG_49_0_0_58_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_SegmEn" ,getValue(A_FSG_49_0_0_58_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_AT" ,getValue(A_FSG_49_0_0_58_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_ErrCode" ,getValue(A_FSG_49_0_0_58_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_DataIndex" ,getValue(A_FSG_49_0_0_58_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_DataIndex_Incr" ,getValue(A_FSG_49_0_0_58_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_DataIndex_Decr" ,getValue(A_FSG_49_0_0_58_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_loadArray_Btn" ,getValue(A_FSG_49_0_0_58_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_generateData_Btn" ,getValue(A_FSG_49_0_0_58_generateData_Btn), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_58_3" ,getValue(A_FSG_49_0_0_58_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_58_3_range" ,getValue(A_FSG_49_0_0_58_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_1" ,getValue(A_FSG_49_0_0_58_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_Data_6_len" ,getValue(A_FSG_49_0_0_58_Data_6_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_Data_6_cnt" ,getValue(A_FSG_49_0_0_58_Data_6_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_58_Data_1" ,getValue(A_FSG_49_0_0_58_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_58_Data_1_range" ,getValue(A_FSG_49_0_0_58_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_58_Data_3" ,getValue(A_FSG_49_0_0_58_Data_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_58_Data_3_range" ,getValue(A_FSG_49_0_0_58_Data_3_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_58_2" ,getValue(A_FSG_49_0_0_58_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_58_2_range" ,getValue(A_FSG_49_0_0_58_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_Data_4_len" ,getValue(A_FSG_49_0_0_58_Data_4_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_Data_4_cnt" ,getValue(A_FSG_49_0_0_58_Data_4_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_58_Data_5" ,getValue(A_FSG_49_0_0_58_Data_5), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_58_Data_5_range" ,getValue(A_FSG_49_0_0_58_Data_5_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_Data_2" ,getValue(A_FSG_49_0_0_58_Data_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_RecAdr" ,getValue(A_FSG_49_0_0_58_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_Direction" ,getValue(A_FSG_49_0_0_58_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_Shift" ,getValue(A_FSG_49_0_0_58_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_TransPos" ,getValue(A_FSG_49_0_0_58_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_IndexSize" ,getValue(A_FSG_49_0_0_58_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_Start" ,getValue(A_FSG_49_0_0_58_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_Elements" ,getValue(A_FSG_49_0_0_58_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_Changed_RecAdr" ,getValue(A_FSG_49_0_0_58_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_Changed_Direction" ,getValue(A_FSG_49_0_0_58_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_Changed_Shift" ,getValue(A_FSG_49_0_0_58_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_Changed_TransPos" ,getValue(A_FSG_49_0_0_58_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_Changed_IndexSize" ,getValue(A_FSG_49_0_0_58_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_Changed_Start" ,getValue(A_FSG_49_0_0_58_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_Changed_Elements" ,getValue(A_FSG_49_0_0_58_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_58_2_SetGet" ,getValue(A_FSG_49_0_0_58_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_58_2_SetGet_range" ,getValue(A_FSG_49_0_0_58_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_1_SetGet" ,getValue(A_FSG_49_0_0_58_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_SetGet_RecAdr" ,getValue(A_FSG_49_0_0_58_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_SetGet_Direction" ,getValue(A_FSG_49_0_0_58_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_SetGet_Shift" ,getValue(A_FSG_49_0_0_58_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_SetGet_IndexSize" ,getValue(A_FSG_49_0_0_58_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_SetGet_Start" ,getValue(A_FSG_49_0_0_58_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_58_SetGet_Elements" ,getValue(A_FSG_49_0_0_58_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59Changed_BTN" ,getValue(A_FSG_49_0_0_59Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59Status_BTN" ,getValue(A_FSG_49_0_0_59Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_FctLstItemEn" ,getValue(A_FSG_49_0_0_59_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_FctEn" ,getValue(A_FSG_49_0_0_59_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_ErrEn" ,getValue(A_FSG_49_0_0_59_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_IntTlgEn" ,getValue(A_FSG_49_0_0_59_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_SegmEn" ,getValue(A_FSG_49_0_0_59_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_AT" ,getValue(A_FSG_49_0_0_59_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_ErrCode" ,getValue(A_FSG_49_0_0_59_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_DataIndex" ,getValue(A_FSG_49_0_0_59_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_DataIndex_Incr" ,getValue(A_FSG_49_0_0_59_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_DataIndex_Decr" ,getValue(A_FSG_49_0_0_59_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_loadArray_Btn" ,getValue(A_FSG_49_0_0_59_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_generateData_Btn" ,getValue(A_FSG_49_0_0_59_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Data_4" ,getValue(A_FSG_49_0_0_59_Data_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Data_4_0" ,getValue(A_FSG_49_0_0_59_Data_4_0), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Data_4_1" ,getValue(A_FSG_49_0_0_59_Data_4_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Data_4_2" ,getValue(A_FSG_49_0_0_59_Data_4_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Data_4_3" ,getValue(A_FSG_49_0_0_59_Data_4_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Data_4_4" ,getValue(A_FSG_49_0_0_59_Data_4_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Data_4_5" ,getValue(A_FSG_49_0_0_59_Data_4_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Data_4_6" ,getValue(A_FSG_49_0_0_59_Data_4_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Data_4_7" ,getValue(A_FSG_49_0_0_59_Data_4_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Data_4_8" ,getValue(A_FSG_49_0_0_59_Data_4_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Data_4_9" ,getValue(A_FSG_49_0_0_59_Data_4_9), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Data_4_10" ,getValue(A_FSG_49_0_0_59_Data_4_10), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Data_4_11" ,getValue(A_FSG_49_0_0_59_Data_4_11), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_59_3" ,getValue(A_FSG_49_0_0_59_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_59_3_range" ,getValue(A_FSG_49_0_0_59_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_1" ,getValue(A_FSG_49_0_0_59_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Data_3" ,getValue(A_FSG_49_0_0_59_Data_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Data_5_len" ,getValue(A_FSG_49_0_0_59_Data_5_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Data_5_cnt" ,getValue(A_FSG_49_0_0_59_Data_5_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_59_Data_2" ,getValue(A_FSG_49_0_0_59_Data_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_59_Data_2_range" ,getValue(A_FSG_49_0_0_59_Data_2_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_59_Data_1" ,getValue(A_FSG_49_0_0_59_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_59_Data_1_range" ,getValue(A_FSG_49_0_0_59_Data_1_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Data_6_len" ,getValue(A_FSG_49_0_0_59_Data_6_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Data_6_cnt" ,getValue(A_FSG_49_0_0_59_Data_6_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_59_2" ,getValue(A_FSG_49_0_0_59_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_59_2_range" ,getValue(A_FSG_49_0_0_59_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_RecAdr" ,getValue(A_FSG_49_0_0_59_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Direction" ,getValue(A_FSG_49_0_0_59_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Shift" ,getValue(A_FSG_49_0_0_59_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_TransPos" ,getValue(A_FSG_49_0_0_59_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_IndexSize" ,getValue(A_FSG_49_0_0_59_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Start" ,getValue(A_FSG_49_0_0_59_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Elements" ,getValue(A_FSG_49_0_0_59_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Changed_RecAdr" ,getValue(A_FSG_49_0_0_59_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Changed_Direction" ,getValue(A_FSG_49_0_0_59_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Changed_Shift" ,getValue(A_FSG_49_0_0_59_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Changed_TransPos" ,getValue(A_FSG_49_0_0_59_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Changed_IndexSize" ,getValue(A_FSG_49_0_0_59_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Changed_Start" ,getValue(A_FSG_49_0_0_59_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_Changed_Elements" ,getValue(A_FSG_49_0_0_59_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_59_2_SetGet" ,getValue(A_FSG_49_0_0_59_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_49_0_0_59_2_SetGet_range" ,getValue(A_FSG_49_0_0_59_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_1_SetGet" ,getValue(A_FSG_49_0_0_59_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_SetGet_RecAdr" ,getValue(A_FSG_49_0_0_59_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_SetGet_Direction" ,getValue(A_FSG_49_0_0_59_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_SetGet_Shift" ,getValue(A_FSG_49_0_0_59_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_SetGet_IndexSize" ,getValue(A_FSG_49_0_0_59_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_SetGet_Start" ,getValue(A_FSG_49_0_0_59_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_49_0_0_59_SetGet_Elements" ,getValue(A_FSG_49_0_0_59_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_60Status_BTN" ,getValue(P_FSG_49_0_0_60Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_60_FctLstItemEn" ,getValue(P_FSG_49_0_0_60_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_60_FctEn" ,getValue(P_FSG_49_0_0_60_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_60_ErrEn" ,getValue(P_FSG_49_0_0_60_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_60_ErrCode" ,getValue(P_FSG_49_0_0_60_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_60_5" ,getValue(P_FSG_49_0_0_60_5), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_60_5_range" ,getValue(P_FSG_49_0_0_60_5_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_60_4" ,getValue(P_FSG_49_0_0_60_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_60_4_range" ,getValue(P_FSG_49_0_0_60_4_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_60_1" ,getValue(P_FSG_49_0_0_60_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_60_8" ,getValue(P_FSG_49_0_0_60_8), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_60_8_range" ,getValue(P_FSG_49_0_0_60_8_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_60_3" ,getValue(P_FSG_49_0_0_60_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_49_0_0_60_2" ,getValue(P_FSG_49_0_0_60_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_60_7" ,getValue(P_FSG_49_0_0_60_7), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_60_7_range" ,getValue(P_FSG_49_0_0_60_7_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_60_6" ,getValue(P_FSG_49_0_0_60_6), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_49_0_0_60_6_range" ,getValue(P_FSG_49_0_0_60_6_range), profileFile);
    writeProfileInt("BAP" ,"C_FSG_50_0_0_0_1_FctLstItemEn" ,getValue(C_FSG_50_0_0_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_50_0_0_0_1_FctEn" ,getValue(C_FSG_50_0_0_0_1_FctEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_50_0_0_0_1_ErrEn" ,getValue(C_FSG_50_0_0_0_1_ErrEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_50_0_0_0_1_IntTlgEn" ,getValue(C_FSG_50_0_0_0_1_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_50_0_0_0_1_SegmEn" ,getValue(C_FSG_50_0_0_0_1_SegmEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_50_0_0_0_1_ErrCode" ,getValue(C_FSG_50_0_0_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_0_2Reset_BTN" ,getValue(P_FSG_50_0_0_0_2Reset_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_0_2_FctLstItemEn" ,getValue(P_FSG_50_0_0_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_0_2_FctEn" ,getValue(P_FSG_50_0_0_0_2_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_0_2_ErrEn" ,getValue(P_FSG_50_0_0_0_2_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_0_2_ErrCode" ,getValue(P_FSG_50_0_0_0_2_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_0_3_FctLstItemEn" ,getValue(P_FSG_50_0_0_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_0_3_FctEn" ,getValue(P_FSG_50_0_0_0_3_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_0_3_ErrEn" ,getValue(P_FSG_50_0_0_0_3_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_0_3_IntTlgEn" ,getValue(P_FSG_50_0_0_0_3_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_0_3_SegmEn" ,getValue(P_FSG_50_0_0_0_3_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_0_3_ErrCode" ,getValue(P_FSG_50_0_0_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"FSG50_0_0_Channel" ,getValue(FSG50_0_0_Channel), profileFile);
    writeProfileInt("BAP" ,"FSG50_0_0_BusType" ,getValue(FSG50_0_0_BusType), profileFile);
    writeProfileInt("BAP" ,"FSG50_0_1_Channel" ,getValue(FSG50_0_1_Channel), profileFile);
    writeProfileInt("BAP" ,"FSG50_0_1_BusType" ,getValue(FSG50_0_1_BusType), profileFile);
    writeProfileInt("BAP" ,"FSG50_0_2_Channel" ,getValue(FSG50_0_2_Channel), profileFile);
    writeProfileInt("BAP" ,"FSG50_0_2_BusType" ,getValue(FSG50_0_2_BusType), profileFile);
    writeProfileInt("BAP" ,"FSG50_0_3_Channel" ,getValue(FSG50_0_3_Channel), profileFile);
    writeProfileInt("BAP" ,"FSG50_0_3_BusType" ,getValue(FSG50_0_3_BusType), profileFile);
    writeProfileInt("BAP" ,"FSG50_0_4_Channel" ,getValue(FSG50_0_4_Channel), profileFile);
    writeProfileInt("BAP" ,"FSG50_0_4_BusType" ,getValue(FSG50_0_4_BusType), profileFile);
    writeProfileInt("BAP" ,"FSG50_0_5_Channel" ,getValue(FSG50_0_5_Channel), profileFile);
    writeProfileInt("BAP" ,"FSG50_0_5_BusType" ,getValue(FSG50_0_5_BusType), profileFile);
    writeProfileInt("BAP" ,"FSG50_0_6_Channel" ,getValue(FSG50_0_6_Channel), profileFile);
    writeProfileInt("BAP" ,"FSG50_0_6_BusType" ,getValue(FSG50_0_6_BusType), profileFile);
    writeProfileInt("BAP" ,"FSG50_0_7_Channel" ,getValue(FSG50_0_7_Channel), profileFile);
    writeProfileInt("BAP" ,"FSG50_0_7_BusType" ,getValue(FSG50_0_7_BusType), profileFile);
    writeProfileInt("BAP" ,"ERRORLIST_FSG50_0_VT" ,getValue(ERRORLIST_FSG50_0_VT), profileFile);
    writeProfileInt("BAP" ,"BusType_FSG50_0" ,getValue(BusType_FSG50_0), profileFile);
    writeProfileInt("BAP" ,"ON_OFF_FSG50_0" ,getValue(ON_OFF_FSG50_0), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_50_0_0_DFMajor" ,getValue(BAPCFG_FSG_50_0_0_DFMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_50_0_0_DFMinor" ,getValue(BAPCFG_FSG_50_0_0_DFMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_50_0_0_LsgClassMajor" ,getValue(BAPCFG_FSG_50_0_0_LsgClassMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_50_0_0_LsgClassMinor" ,getValue(BAPCFG_FSG_50_0_0_LsgClassMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_50_0_0_ProtocolMajor" ,getValue(BAPCFG_FSG_50_0_0_ProtocolMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_50_0_0_ProtocolMinor" ,getValue(BAPCFG_FSG_50_0_0_ProtocolMinor), profileFile);
    writeProfileInt("BAP" ,"C_FSG_50_0_0_1_FctLstItemEn" ,getValue(C_FSG_50_0_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_50_0_0_1_FctEn" ,getValue(C_FSG_50_0_0_1_FctEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_50_0_0_1_ErrEn" ,getValue(C_FSG_50_0_0_1_ErrEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_50_0_0_1_IntTlgEn" ,getValue(C_FSG_50_0_0_1_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_50_0_0_1_SegmEn" ,getValue(C_FSG_50_0_0_1_SegmEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_50_0_0_1_ErrCode" ,getValue(C_FSG_50_0_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_2Reset_BTN" ,getValue(P_FSG_50_0_0_2Reset_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_2_FctLstItemEn" ,getValue(P_FSG_50_0_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_2_FctEn" ,getValue(P_FSG_50_0_0_2_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_2_ErrEn" ,getValue(P_FSG_50_0_0_2_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_2_ErrCode" ,getValue(P_FSG_50_0_0_2_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_2" ,getValue(P_FSG_50_0_0_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_2_range" ,getValue(P_FSG_50_0_0_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_3Status_BTN" ,getValue(P_FSG_50_0_0_3Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_3_FctLstItemEn" ,getValue(P_FSG_50_0_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_3_FctEn" ,getValue(P_FSG_50_0_0_3_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_3_ErrEn" ,getValue(P_FSG_50_0_0_3_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_3_IntTlgEn" ,getValue(P_FSG_50_0_0_3_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_3_SegmEn" ,getValue(P_FSG_50_0_0_3_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_3_ErrCode" ,getValue(P_FSG_50_0_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_4Status_BTN" ,getValue(P_FSG_50_0_0_4Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_4_FctLstItemEn" ,getValue(P_FSG_50_0_0_4_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_4_FctEn" ,getValue(P_FSG_50_0_0_4_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_4_ErrEn" ,getValue(P_FSG_50_0_0_4_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_4_ErrCode" ,getValue(P_FSG_50_0_0_4_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_4" ,getValue(P_FSG_50_0_0_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_15Status_BTN" ,getValue(P_FSG_50_0_0_15Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_15_FctLstItemEn" ,getValue(P_FSG_50_0_0_15_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_15_FctEn" ,getValue(P_FSG_50_0_0_15_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_15_ErrEn" ,getValue(P_FSG_50_0_0_15_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_15_ErrCode" ,getValue(P_FSG_50_0_0_15_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_15" ,getValue(P_FSG_50_0_0_15), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_15_1" ,getValue(P_FSG_50_0_0_15_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_16Status_BTN" ,getValue(P_FSG_50_0_0_16Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_16_FctLstItemEn" ,getValue(P_FSG_50_0_0_16_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_16_FctEn" ,getValue(P_FSG_50_0_0_16_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_16_ErrEn" ,getValue(P_FSG_50_0_0_16_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_16_ErrCode" ,getValue(P_FSG_50_0_0_16_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_16_1" ,getValue(P_FSG_50_0_0_16_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_16_2" ,getValue(P_FSG_50_0_0_16_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_16_2_range" ,getValue(P_FSG_50_0_0_16_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_17Status_BTN" ,getValue(P_FSG_50_0_0_17Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_17_FctLstItemEn" ,getValue(P_FSG_50_0_0_17_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_17_FctEn" ,getValue(P_FSG_50_0_0_17_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_17_ErrEn" ,getValue(P_FSG_50_0_0_17_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_17_ErrCode" ,getValue(P_FSG_50_0_0_17_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_17" ,getValue(P_FSG_50_0_0_17), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_17_1" ,getValue(P_FSG_50_0_0_17_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_18Status_BTN" ,getValue(P_FSG_50_0_0_18Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_18_FctLstItemEn" ,getValue(P_FSG_50_0_0_18_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_18_FctEn" ,getValue(P_FSG_50_0_0_18_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_18_ErrEn" ,getValue(P_FSG_50_0_0_18_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_18_IntTlgEn" ,getValue(P_FSG_50_0_0_18_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_18_SegmEn" ,getValue(P_FSG_50_0_0_18_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_18_ErrCode" ,getValue(P_FSG_50_0_0_18_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_18_2_BargraphOnOff" ,getValue(P_FSG_50_0_0_18_2_BargraphOnOff), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_18_2_Bargraph" ,getValue(P_FSG_50_0_0_18_2_Bargraph), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_18_2_Bargraph_range" ,getValue(P_FSG_50_0_0_18_2_Bargraph_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_18_1_Distance" ,getValue(P_FSG_50_0_0_18_1_Distance), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_18_1_Distance_range" ,getValue(P_FSG_50_0_0_18_1_Distance_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_18_1_Unit" ,getValue(P_FSG_50_0_0_18_1_Unit), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_18_3" ,getValue(P_FSG_50_0_0_18_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_18_3_0" ,getValue(P_FSG_50_0_0_18_3_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_19Status_BTN" ,getValue(P_FSG_50_0_0_19Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_19_FctLstItemEn" ,getValue(P_FSG_50_0_0_19_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_19_FctEn" ,getValue(P_FSG_50_0_0_19_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_19_ErrEn" ,getValue(P_FSG_50_0_0_19_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_19_IntTlgEn" ,getValue(P_FSG_50_0_0_19_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_19_SegmEn" ,getValue(P_FSG_50_0_0_19_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_19_ErrCode" ,getValue(P_FSG_50_0_0_19_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_19_1_len" ,getValue(P_FSG_50_0_0_19_1_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_19_1_cnt" ,getValue(P_FSG_50_0_0_19_1_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_20Status_BTN" ,getValue(P_FSG_50_0_0_20Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_20_FctLstItemEn" ,getValue(P_FSG_50_0_0_20_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_20_FctEn" ,getValue(P_FSG_50_0_0_20_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_20_ErrEn" ,getValue(P_FSG_50_0_0_20_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_20_IntTlgEn" ,getValue(P_FSG_50_0_0_20_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_20_SegmEn" ,getValue(P_FSG_50_0_0_20_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_20_ErrCode" ,getValue(P_FSG_50_0_0_20_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_20_2_len" ,getValue(P_FSG_50_0_0_20_2_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_20_2_cnt" ,getValue(P_FSG_50_0_0_20_2_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_20_1_len" ,getValue(P_FSG_50_0_0_20_1_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_20_1_cnt" ,getValue(P_FSG_50_0_0_20_1_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_21Status_BTN" ,getValue(P_FSG_50_0_0_21Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_21_FctLstItemEn" ,getValue(P_FSG_50_0_0_21_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_21_FctEn" ,getValue(P_FSG_50_0_0_21_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_21_ErrEn" ,getValue(P_FSG_50_0_0_21_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_21_ErrCode" ,getValue(P_FSG_50_0_0_21_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_21_2" ,getValue(P_FSG_50_0_0_21_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_21_2_0" ,getValue(P_FSG_50_0_0_21_2_0), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_21_1_Distance" ,getValue(P_FSG_50_0_0_21_1_Distance), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_21_1_Distance_range" ,getValue(P_FSG_50_0_0_21_1_Distance_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_21_1_Unit" ,getValue(P_FSG_50_0_0_21_1_Unit), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_21_3" ,getValue(P_FSG_50_0_0_21_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_21_3_0" ,getValue(P_FSG_50_0_0_21_3_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_22Status_BTN" ,getValue(P_FSG_50_0_0_22Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_22_FctLstItemEn" ,getValue(P_FSG_50_0_0_22_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_22_FctEn" ,getValue(P_FSG_50_0_0_22_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_22_ErrEn" ,getValue(P_FSG_50_0_0_22_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_22_IntTlgEn" ,getValue(P_FSG_50_0_0_22_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_22_SegmEn" ,getValue(P_FSG_50_0_0_22_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_22_ErrCode" ,getValue(P_FSG_50_0_0_22_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_22_1_TimeInfoType" ,getValue(P_FSG_50_0_0_22_1_TimeInfoType), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_22_1_NavigationTimeFormat" ,getValue(P_FSG_50_0_0_22_1_NavigationTimeFormat), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_22_1_Minute" ,getValue(P_FSG_50_0_0_22_1_Minute), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_22_1_Minute_range" ,getValue(P_FSG_50_0_0_22_1_Minute_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_22_1_Hour" ,getValue(P_FSG_50_0_0_22_1_Hour), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_22_1_Hour_range" ,getValue(P_FSG_50_0_0_22_1_Hour_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_22_1_Day" ,getValue(P_FSG_50_0_0_22_1_Day), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_22_1_Day_range" ,getValue(P_FSG_50_0_0_22_1_Day_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_22_1_Month" ,getValue(P_FSG_50_0_0_22_1_Month), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_22_1_Month_range" ,getValue(P_FSG_50_0_0_22_1_Month_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_22_1_Year" ,getValue(P_FSG_50_0_0_22_1_Year), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_22_1_Year_range" ,getValue(P_FSG_50_0_0_22_1_Year_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_22_2" ,getValue(P_FSG_50_0_0_22_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_22_2_1" ,getValue(P_FSG_50_0_0_22_2_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_22_2_2" ,getValue(P_FSG_50_0_0_22_2_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_22_2_3" ,getValue(P_FSG_50_0_0_22_2_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_22_2_4" ,getValue(P_FSG_50_0_0_22_2_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_22_2_5" ,getValue(P_FSG_50_0_0_22_2_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23Status_BTN" ,getValue(P_FSG_50_0_0_23Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_FctLstItemEn" ,getValue(P_FSG_50_0_0_23_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_FctEn" ,getValue(P_FSG_50_0_0_23_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_ErrEn" ,getValue(P_FSG_50_0_0_23_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_IntTlgEn" ,getValue(P_FSG_50_0_0_23_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_SegmEn" ,getValue(P_FSG_50_0_0_23_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_ErrCode" ,getValue(P_FSG_50_0_0_23_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_MainElement" ,getValue(P_FSG_50_0_0_23_3_MainElement), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_Direction" ,getValue(P_FSG_50_0_0_23_3_Direction), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_Direction_range" ,getValue(P_FSG_50_0_0_23_3_Direction_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_Z_LevelGuidance" ,getValue(P_FSG_50_0_0_23_3_Z_LevelGuidance), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_Sidestreets_len" ,getValue(P_FSG_50_0_0_23_3_Sidestreets_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_Sidestreets_cnt" ,getValue(P_FSG_50_0_0_23_3_Sidestreets_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_MainElement" ,getValue(P_FSG_50_0_0_23_2_MainElement), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_Direction" ,getValue(P_FSG_50_0_0_23_2_Direction), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_Direction_range" ,getValue(P_FSG_50_0_0_23_2_Direction_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_Z_LevelGuidance" ,getValue(P_FSG_50_0_0_23_2_Z_LevelGuidance), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_Sidestreets_len" ,getValue(P_FSG_50_0_0_23_2_Sidestreets_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_Sidestreets_cnt" ,getValue(P_FSG_50_0_0_23_2_Sidestreets_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_MainElement" ,getValue(P_FSG_50_0_0_23_1_MainElement), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_Direction" ,getValue(P_FSG_50_0_0_23_1_Direction), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_Direction_range" ,getValue(P_FSG_50_0_0_23_1_Direction_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_Z_LevelGuidance" ,getValue(P_FSG_50_0_0_23_1_Z_LevelGuidance), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_Sidestreets_len" ,getValue(P_FSG_50_0_0_23_1_Sidestreets_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_Sidestreets_cnt" ,getValue(P_FSG_50_0_0_23_1_Sidestreets_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24Changed_BTN" ,getValue(A_FSG_50_0_0_24Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24Status_BTN" ,getValue(A_FSG_50_0_0_24Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_FctLstItemEn" ,getValue(A_FSG_50_0_0_24_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_FctEn" ,getValue(A_FSG_50_0_0_24_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_ErrEn" ,getValue(A_FSG_50_0_0_24_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_IntTlgEn" ,getValue(A_FSG_50_0_0_24_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_SegmEn" ,getValue(A_FSG_50_0_0_24_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_AT" ,getValue(A_FSG_50_0_0_24_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_ErrCode" ,getValue(A_FSG_50_0_0_24_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_DataIndex" ,getValue(A_FSG_50_0_0_24_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_DataIndex_Incr" ,getValue(A_FSG_50_0_0_24_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_DataIndex_Decr" ,getValue(A_FSG_50_0_0_24_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_loadArray_Btn" ,getValue(A_FSG_50_0_0_24_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_generateData_Btn" ,getValue(A_FSG_50_0_0_24_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_4" ,getValue(A_FSG_50_0_0_24_Data_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_len" ,getValue(A_FSG_50_0_0_24_Data_3_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_cnt" ,getValue(A_FSG_50_0_0_24_Data_3_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_8" ,getValue(A_FSG_50_0_0_24_Data_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_3" ,getValue(A_FSG_50_0_0_24_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_24_Data_2" ,getValue(A_FSG_50_0_0_24_Data_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_24_Data_2_range" ,getValue(A_FSG_50_0_0_24_Data_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_5" ,getValue(A_FSG_50_0_0_24_Data_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_7" ,getValue(A_FSG_50_0_0_24_Data_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_1" ,getValue(A_FSG_50_0_0_24_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_6" ,getValue(A_FSG_50_0_0_24_Data_6), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_24_Data_1" ,getValue(A_FSG_50_0_0_24_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_24_Data_1_range" ,getValue(A_FSG_50_0_0_24_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_24_2" ,getValue(A_FSG_50_0_0_24_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_24_2_range" ,getValue(A_FSG_50_0_0_24_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_RecAdr" ,getValue(A_FSG_50_0_0_24_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Direction" ,getValue(A_FSG_50_0_0_24_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Shift" ,getValue(A_FSG_50_0_0_24_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_TransPos" ,getValue(A_FSG_50_0_0_24_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_IndexSize" ,getValue(A_FSG_50_0_0_24_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Start" ,getValue(A_FSG_50_0_0_24_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Elements" ,getValue(A_FSG_50_0_0_24_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_1_Changed" ,getValue(A_FSG_50_0_0_24_1_Changed), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Changed_RecAdr" ,getValue(A_FSG_50_0_0_24_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Changed_Direction" ,getValue(A_FSG_50_0_0_24_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Changed_Shift" ,getValue(A_FSG_50_0_0_24_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Changed_TransPos" ,getValue(A_FSG_50_0_0_24_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Changed_IndexSize" ,getValue(A_FSG_50_0_0_24_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Changed_Start" ,getValue(A_FSG_50_0_0_24_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Changed_Elements" ,getValue(A_FSG_50_0_0_24_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_24_2_SetGet" ,getValue(A_FSG_50_0_0_24_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_24_2_SetGet_range" ,getValue(A_FSG_50_0_0_24_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_1_SetGet" ,getValue(A_FSG_50_0_0_24_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_SetGet_RecAdr" ,getValue(A_FSG_50_0_0_24_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_SetGet_Direction" ,getValue(A_FSG_50_0_0_24_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_SetGet_Shift" ,getValue(A_FSG_50_0_0_24_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_SetGet_IndexSize" ,getValue(A_FSG_50_0_0_24_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_SetGet_Start" ,getValue(A_FSG_50_0_0_24_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_SetGet_Elements" ,getValue(A_FSG_50_0_0_24_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_25Status_BTN" ,getValue(P_FSG_50_0_0_25Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_25_FctLstItemEn" ,getValue(P_FSG_50_0_0_25_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_25_FctEn" ,getValue(P_FSG_50_0_0_25_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_25_ErrEn" ,getValue(P_FSG_50_0_0_25_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_25_IntTlgEn" ,getValue(P_FSG_50_0_0_25_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_25_SegmEn" ,getValue(P_FSG_50_0_0_25_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_25_ErrCode" ,getValue(P_FSG_50_0_0_25_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_25_1" ,getValue(P_FSG_50_0_0_25_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_25_1_range" ,getValue(P_FSG_50_0_0_25_1_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_25_3" ,getValue(P_FSG_50_0_0_25_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_25_2" ,getValue(P_FSG_50_0_0_25_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_25_4_Priority" ,getValue(P_FSG_50_0_0_25_4_Priority), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_25_4_Priority_range" ,getValue(P_FSG_50_0_0_25_4_Priority_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_25_4_StreetName_len" ,getValue(P_FSG_50_0_0_25_4_StreetName_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_25_4_StreetName_cnt" ,getValue(P_FSG_50_0_0_25_4_StreetName_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_25_4_Location_len" ,getValue(P_FSG_50_0_0_25_4_Location_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_25_4_Location_cnt" ,getValue(P_FSG_50_0_0_25_4_Location_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_25_4_Infotext_len" ,getValue(P_FSG_50_0_0_25_4_Infotext_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_25_4_Infotext_cnt" ,getValue(P_FSG_50_0_0_25_4_Infotext_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_25_4_Length_Validity" ,getValue(P_FSG_50_0_0_25_4_Length_Validity), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_25_4_Length_Validity_0" ,getValue(P_FSG_50_0_0_25_4_Length_Validity_0), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_25_4_Length_Value" ,getValue(P_FSG_50_0_0_25_4_Length_Value), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_25_4_Length_Value_range" ,getValue(P_FSG_50_0_0_25_4_Length_Value_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_25_4_Length_Unit" ,getValue(P_FSG_50_0_0_25_4_Length_Unit), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_26Status_BTN" ,getValue(P_FSG_50_0_0_26Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_26_FctLstItemEn" ,getValue(P_FSG_50_0_0_26_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_26_FctEn" ,getValue(P_FSG_50_0_0_26_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_26_ErrEn" ,getValue(P_FSG_50_0_0_26_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_26_ErrCode" ,getValue(P_FSG_50_0_0_26_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_26" ,getValue(P_FSG_50_0_0_26), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_26_1" ,getValue(P_FSG_50_0_0_26_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_27Status_BTN" ,getValue(P_FSG_50_0_0_27Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_27_FctLstItemEn" ,getValue(P_FSG_50_0_0_27_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_27_FctEn" ,getValue(P_FSG_50_0_0_27_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_27_ErrEn" ,getValue(P_FSG_50_0_0_27_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_27_ErrCode" ,getValue(P_FSG_50_0_0_27_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_27" ,getValue(P_FSG_50_0_0_27), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_27_1" ,getValue(P_FSG_50_0_0_27_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_28Status_BTN" ,getValue(P_FSG_50_0_0_28Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_28_FctLstItemEn" ,getValue(P_FSG_50_0_0_28_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_28_FctEn" ,getValue(P_FSG_50_0_0_28_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_28_ErrEn" ,getValue(P_FSG_50_0_0_28_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_28_ErrCode" ,getValue(P_FSG_50_0_0_28_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_28_1" ,getValue(P_FSG_50_0_0_28_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_28_1_0" ,getValue(P_FSG_50_0_0_28_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_28_2" ,getValue(P_FSG_50_0_0_28_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29Changed_BTN" ,getValue(A_FSG_50_0_0_29Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29Status_BTN" ,getValue(A_FSG_50_0_0_29Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_FctLstItemEn" ,getValue(A_FSG_50_0_0_29_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_FctEn" ,getValue(A_FSG_50_0_0_29_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_ErrEn" ,getValue(A_FSG_50_0_0_29_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_IntTlgEn" ,getValue(A_FSG_50_0_0_29_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_SegmEn" ,getValue(A_FSG_50_0_0_29_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_AT" ,getValue(A_FSG_50_0_0_29_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_ErrCode" ,getValue(A_FSG_50_0_0_29_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_DataIndex" ,getValue(A_FSG_50_0_0_29_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_DataIndex_Incr" ,getValue(A_FSG_50_0_0_29_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_DataIndex_Decr" ,getValue(A_FSG_50_0_0_29_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_loadArray_Btn" ,getValue(A_FSG_50_0_0_29_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_generateData_Btn" ,getValue(A_FSG_50_0_0_29_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_Data_2" ,getValue(A_FSG_50_0_0_29_Data_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_29_2" ,getValue(A_FSG_50_0_0_29_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_29_2_range" ,getValue(A_FSG_50_0_0_29_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_1" ,getValue(A_FSG_50_0_0_29_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_29_Data_1" ,getValue(A_FSG_50_0_0_29_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_29_Data_1_range" ,getValue(A_FSG_50_0_0_29_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_29_3" ,getValue(A_FSG_50_0_0_29_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_29_3_range" ,getValue(A_FSG_50_0_0_29_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_Data_3_len" ,getValue(A_FSG_50_0_0_29_Data_3_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_Data_3_cnt" ,getValue(A_FSG_50_0_0_29_Data_3_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_RecAdr" ,getValue(A_FSG_50_0_0_29_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_Direction" ,getValue(A_FSG_50_0_0_29_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_Shift" ,getValue(A_FSG_50_0_0_29_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_TransPos" ,getValue(A_FSG_50_0_0_29_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_IndexSize" ,getValue(A_FSG_50_0_0_29_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_Start" ,getValue(A_FSG_50_0_0_29_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_Elements" ,getValue(A_FSG_50_0_0_29_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_Changed_RecAdr" ,getValue(A_FSG_50_0_0_29_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_Changed_Direction" ,getValue(A_FSG_50_0_0_29_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_Changed_Shift" ,getValue(A_FSG_50_0_0_29_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_Changed_TransPos" ,getValue(A_FSG_50_0_0_29_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_Changed_IndexSize" ,getValue(A_FSG_50_0_0_29_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_Changed_Start" ,getValue(A_FSG_50_0_0_29_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_Changed_Elements" ,getValue(A_FSG_50_0_0_29_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_29_2_SetGet" ,getValue(A_FSG_50_0_0_29_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_29_2_SetGet_range" ,getValue(A_FSG_50_0_0_29_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_1_SetGet" ,getValue(A_FSG_50_0_0_29_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_SetGet_RecAdr" ,getValue(A_FSG_50_0_0_29_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_SetGet_Direction" ,getValue(A_FSG_50_0_0_29_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_SetGet_Shift" ,getValue(A_FSG_50_0_0_29_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_SetGet_IndexSize" ,getValue(A_FSG_50_0_0_29_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_SetGet_Start" ,getValue(A_FSG_50_0_0_29_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_29_SetGet_Elements" ,getValue(A_FSG_50_0_0_29_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30Changed_BTN" ,getValue(A_FSG_50_0_0_30Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30Status_BTN" ,getValue(A_FSG_50_0_0_30Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_FctLstItemEn" ,getValue(A_FSG_50_0_0_30_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_FctEn" ,getValue(A_FSG_50_0_0_30_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_ErrEn" ,getValue(A_FSG_50_0_0_30_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_IntTlgEn" ,getValue(A_FSG_50_0_0_30_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_SegmEn" ,getValue(A_FSG_50_0_0_30_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_AT" ,getValue(A_FSG_50_0_0_30_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_ErrCode" ,getValue(A_FSG_50_0_0_30_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_DataIndex" ,getValue(A_FSG_50_0_0_30_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_DataIndex_Incr" ,getValue(A_FSG_50_0_0_30_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_DataIndex_Decr" ,getValue(A_FSG_50_0_0_30_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_loadArray_Btn" ,getValue(A_FSG_50_0_0_30_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_generateData_Btn" ,getValue(A_FSG_50_0_0_30_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_Data_2" ,getValue(A_FSG_50_0_0_30_Data_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_30_2" ,getValue(A_FSG_50_0_0_30_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_30_2_range" ,getValue(A_FSG_50_0_0_30_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_1" ,getValue(A_FSG_50_0_0_30_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_30_Data_1" ,getValue(A_FSG_50_0_0_30_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_30_Data_1_range" ,getValue(A_FSG_50_0_0_30_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_30_3" ,getValue(A_FSG_50_0_0_30_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_30_3_range" ,getValue(A_FSG_50_0_0_30_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_Data_3_len" ,getValue(A_FSG_50_0_0_30_Data_3_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_Data_3_cnt" ,getValue(A_FSG_50_0_0_30_Data_3_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_RecAdr" ,getValue(A_FSG_50_0_0_30_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_Direction" ,getValue(A_FSG_50_0_0_30_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_Shift" ,getValue(A_FSG_50_0_0_30_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_TransPos" ,getValue(A_FSG_50_0_0_30_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_IndexSize" ,getValue(A_FSG_50_0_0_30_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_Start" ,getValue(A_FSG_50_0_0_30_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_Elements" ,getValue(A_FSG_50_0_0_30_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_Changed_RecAdr" ,getValue(A_FSG_50_0_0_30_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_Changed_Direction" ,getValue(A_FSG_50_0_0_30_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_Changed_Shift" ,getValue(A_FSG_50_0_0_30_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_Changed_TransPos" ,getValue(A_FSG_50_0_0_30_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_Changed_IndexSize" ,getValue(A_FSG_50_0_0_30_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_Changed_Start" ,getValue(A_FSG_50_0_0_30_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_Changed_Elements" ,getValue(A_FSG_50_0_0_30_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_30_2_SetGet" ,getValue(A_FSG_50_0_0_30_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_30_2_SetGet_range" ,getValue(A_FSG_50_0_0_30_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_1_SetGet" ,getValue(A_FSG_50_0_0_30_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_SetGet_RecAdr" ,getValue(A_FSG_50_0_0_30_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_SetGet_Direction" ,getValue(A_FSG_50_0_0_30_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_SetGet_Shift" ,getValue(A_FSG_50_0_0_30_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_SetGet_IndexSize" ,getValue(A_FSG_50_0_0_30_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_SetGet_Start" ,getValue(A_FSG_50_0_0_30_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_30_SetGet_Elements" ,getValue(A_FSG_50_0_0_30_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_31Status_BTN" ,getValue(P_FSG_50_0_0_31Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_31_FctLstItemEn" ,getValue(P_FSG_50_0_0_31_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_31_FctEn" ,getValue(P_FSG_50_0_0_31_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_31_ErrEn" ,getValue(P_FSG_50_0_0_31_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_31_ErrCode" ,getValue(P_FSG_50_0_0_31_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_31" ,getValue(P_FSG_50_0_0_31), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_31_1" ,getValue(P_FSG_50_0_0_31_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32Changed_BTN" ,getValue(A_FSG_50_0_0_32Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32Status_BTN" ,getValue(A_FSG_50_0_0_32Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_FctLstItemEn" ,getValue(A_FSG_50_0_0_32_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_FctEn" ,getValue(A_FSG_50_0_0_32_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_ErrEn" ,getValue(A_FSG_50_0_0_32_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_IntTlgEn" ,getValue(A_FSG_50_0_0_32_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_SegmEn" ,getValue(A_FSG_50_0_0_32_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_AT" ,getValue(A_FSG_50_0_0_32_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_ErrCode" ,getValue(A_FSG_50_0_0_32_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_DataIndex" ,getValue(A_FSG_50_0_0_32_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_DataIndex_Incr" ,getValue(A_FSG_50_0_0_32_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_DataIndex_Decr" ,getValue(A_FSG_50_0_0_32_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_loadArray_Btn" ,getValue(A_FSG_50_0_0_32_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_generateData_Btn" ,getValue(A_FSG_50_0_0_32_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_Data_3_len" ,getValue(A_FSG_50_0_0_32_Data_3_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_Data_3_cnt" ,getValue(A_FSG_50_0_0_32_Data_3_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_Data_2_len" ,getValue(A_FSG_50_0_0_32_Data_2_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_Data_2_cnt" ,getValue(A_FSG_50_0_0_32_Data_2_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_32_2" ,getValue(A_FSG_50_0_0_32_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_32_2_range" ,getValue(A_FSG_50_0_0_32_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_1" ,getValue(A_FSG_50_0_0_32_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_32_Data_1" ,getValue(A_FSG_50_0_0_32_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_32_Data_1_range" ,getValue(A_FSG_50_0_0_32_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_32_3" ,getValue(A_FSG_50_0_0_32_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_32_3_range" ,getValue(A_FSG_50_0_0_32_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_RecAdr" ,getValue(A_FSG_50_0_0_32_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_Direction" ,getValue(A_FSG_50_0_0_32_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_Shift" ,getValue(A_FSG_50_0_0_32_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_TransPos" ,getValue(A_FSG_50_0_0_32_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_IndexSize" ,getValue(A_FSG_50_0_0_32_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_Start" ,getValue(A_FSG_50_0_0_32_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_Elements" ,getValue(A_FSG_50_0_0_32_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_Changed_RecAdr" ,getValue(A_FSG_50_0_0_32_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_Changed_Direction" ,getValue(A_FSG_50_0_0_32_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_Changed_Shift" ,getValue(A_FSG_50_0_0_32_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_Changed_TransPos" ,getValue(A_FSG_50_0_0_32_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_Changed_IndexSize" ,getValue(A_FSG_50_0_0_32_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_Changed_Start" ,getValue(A_FSG_50_0_0_32_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_Changed_Elements" ,getValue(A_FSG_50_0_0_32_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_32_2_SetGet" ,getValue(A_FSG_50_0_0_32_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_32_2_SetGet_range" ,getValue(A_FSG_50_0_0_32_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_1_SetGet" ,getValue(A_FSG_50_0_0_32_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_SetGet_RecAdr" ,getValue(A_FSG_50_0_0_32_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_SetGet_Direction" ,getValue(A_FSG_50_0_0_32_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_SetGet_Shift" ,getValue(A_FSG_50_0_0_32_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_SetGet_IndexSize" ,getValue(A_FSG_50_0_0_32_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_SetGet_Start" ,getValue(A_FSG_50_0_0_32_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_32_SetGet_Elements" ,getValue(A_FSG_50_0_0_32_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33Changed_BTN" ,getValue(A_FSG_50_0_0_33Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33Status_BTN" ,getValue(A_FSG_50_0_0_33Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_FctLstItemEn" ,getValue(A_FSG_50_0_0_33_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_FctEn" ,getValue(A_FSG_50_0_0_33_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_ErrEn" ,getValue(A_FSG_50_0_0_33_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_IntTlgEn" ,getValue(A_FSG_50_0_0_33_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_SegmEn" ,getValue(A_FSG_50_0_0_33_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_AT" ,getValue(A_FSG_50_0_0_33_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_ErrCode" ,getValue(A_FSG_50_0_0_33_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_DataIndex" ,getValue(A_FSG_50_0_0_33_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_DataIndex_Incr" ,getValue(A_FSG_50_0_0_33_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_DataIndex_Decr" ,getValue(A_FSG_50_0_0_33_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_loadArray_Btn" ,getValue(A_FSG_50_0_0_33_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_generateData_Btn" ,getValue(A_FSG_50_0_0_33_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_12" ,getValue(A_FSG_50_0_0_33_Data_12), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_10_len" ,getValue(A_FSG_50_0_0_33_Data_10_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_10_cnt" ,getValue(A_FSG_50_0_0_33_Data_10_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_9_len" ,getValue(A_FSG_50_0_0_33_Data_9_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_9_cnt" ,getValue(A_FSG_50_0_0_33_Data_9_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_33_5" ,getValue(A_FSG_50_0_0_33_5), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_33_5_range" ,getValue(A_FSG_50_0_0_33_5_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_33_4" ,getValue(A_FSG_50_0_0_33_4), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_33_4_range" ,getValue(A_FSG_50_0_0_33_4_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_1" ,getValue(A_FSG_50_0_0_33_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_4_len" ,getValue(A_FSG_50_0_0_33_Data_4_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_4_cnt" ,getValue(A_FSG_50_0_0_33_Data_4_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_11" ,getValue(A_FSG_50_0_0_33_Data_11), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_2_len" ,getValue(A_FSG_50_0_0_33_Data_2_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_2_cnt" ,getValue(A_FSG_50_0_0_33_Data_2_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_5_len" ,getValue(A_FSG_50_0_0_33_Data_5_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_5_cnt" ,getValue(A_FSG_50_0_0_33_Data_5_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_33_Data_1" ,getValue(A_FSG_50_0_0_33_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_33_Data_1_range" ,getValue(A_FSG_50_0_0_33_Data_1_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_3_len" ,getValue(A_FSG_50_0_0_33_Data_3_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_3_cnt" ,getValue(A_FSG_50_0_0_33_Data_3_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_3" ,getValue(A_FSG_50_0_0_33_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_33_2" ,getValue(A_FSG_50_0_0_33_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_33_2_range" ,getValue(A_FSG_50_0_0_33_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_8_len" ,getValue(A_FSG_50_0_0_33_Data_8_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_8_cnt" ,getValue(A_FSG_50_0_0_33_Data_8_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_7_len" ,getValue(A_FSG_50_0_0_33_Data_7_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_7_cnt" ,getValue(A_FSG_50_0_0_33_Data_7_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_6_len" ,getValue(A_FSG_50_0_0_33_Data_6_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Data_6_cnt" ,getValue(A_FSG_50_0_0_33_Data_6_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_RecAdr" ,getValue(A_FSG_50_0_0_33_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Direction" ,getValue(A_FSG_50_0_0_33_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Shift" ,getValue(A_FSG_50_0_0_33_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_TransPos" ,getValue(A_FSG_50_0_0_33_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_IndexSize" ,getValue(A_FSG_50_0_0_33_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Start" ,getValue(A_FSG_50_0_0_33_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Elements" ,getValue(A_FSG_50_0_0_33_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Changed_RecAdr" ,getValue(A_FSG_50_0_0_33_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Changed_Direction" ,getValue(A_FSG_50_0_0_33_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Changed_Shift" ,getValue(A_FSG_50_0_0_33_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Changed_TransPos" ,getValue(A_FSG_50_0_0_33_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Changed_IndexSize" ,getValue(A_FSG_50_0_0_33_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Changed_Start" ,getValue(A_FSG_50_0_0_33_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_Changed_Elements" ,getValue(A_FSG_50_0_0_33_Changed_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_3_SetGet" ,getValue(A_FSG_50_0_0_33_3_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_33_2_SetGet" ,getValue(A_FSG_50_0_0_33_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_33_2_SetGet_range" ,getValue(A_FSG_50_0_0_33_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_1_SetGet" ,getValue(A_FSG_50_0_0_33_1_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_33_4_SetGet" ,getValue(A_FSG_50_0_0_33_4_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_33_4_SetGet_range" ,getValue(A_FSG_50_0_0_33_4_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_SetGet_RecAdr" ,getValue(A_FSG_50_0_0_33_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_SetGet_Direction" ,getValue(A_FSG_50_0_0_33_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_SetGet_Shift" ,getValue(A_FSG_50_0_0_33_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_SetGet_IndexSize" ,getValue(A_FSG_50_0_0_33_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_SetGet_Start" ,getValue(A_FSG_50_0_0_33_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_33_SetGet_Elements" ,getValue(A_FSG_50_0_0_33_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_34Result_BTN" ,getValue(M_FSG_50_0_0_34Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_34_FctLstItemEn" ,getValue(M_FSG_50_0_0_34_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_34_FctEn" ,getValue(M_FSG_50_0_0_34_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_34_ErrEn" ,getValue(M_FSG_50_0_0_34_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_34_ErrCode" ,getValue(M_FSG_50_0_0_34_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_34_Result" ,getValue(M_FSG_50_0_0_34_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_34_Result_1" ,getValue(M_FSG_50_0_0_34_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_34_Processing" ,getValue(M_FSG_50_0_0_34_Processing), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_34_Processing_1" ,getValue(M_FSG_50_0_0_34_Processing_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_34_Processing_1_range" ,getValue(M_FSG_50_0_0_34_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_34_Start_1" ,getValue(M_FSG_50_0_0_34_Start_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_34_Start_2" ,getValue(M_FSG_50_0_0_34_Start_2), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_34_Start_3" ,getValue(M_FSG_50_0_0_34_Start_3), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_34_Start_3_range" ,getValue(M_FSG_50_0_0_34_Start_3_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_35Result_BTN" ,getValue(M_FSG_50_0_0_35Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_35_FctLstItemEn" ,getValue(M_FSG_50_0_0_35_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_35_FctEn" ,getValue(M_FSG_50_0_0_35_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_35_ErrEn" ,getValue(M_FSG_50_0_0_35_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_35_ErrCode" ,getValue(M_FSG_50_0_0_35_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_35_Result" ,getValue(M_FSG_50_0_0_35_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_35_Result_1" ,getValue(M_FSG_50_0_0_35_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_35_Processing" ,getValue(M_FSG_50_0_0_35_Processing), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_35_Processing_1" ,getValue(M_FSG_50_0_0_35_Processing_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_35_Processing_1_range" ,getValue(M_FSG_50_0_0_35_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_35_Start" ,getValue(M_FSG_50_0_0_35_Start), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_35_Start_1" ,getValue(M_FSG_50_0_0_35_Start_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_36Status_BTN" ,getValue(P_FSG_50_0_0_36Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_36_FctLstItemEn" ,getValue(P_FSG_50_0_0_36_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_36_FctEn" ,getValue(P_FSG_50_0_0_36_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_36_ErrEn" ,getValue(P_FSG_50_0_0_36_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_36_ErrCode" ,getValue(P_FSG_50_0_0_36_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_36" ,getValue(P_FSG_50_0_0_36), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_36_1" ,getValue(P_FSG_50_0_0_36_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37Status_BTN" ,getValue(P_FSG_50_0_0_37Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_FctLstItemEn" ,getValue(P_FSG_50_0_0_37_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_FctEn" ,getValue(P_FSG_50_0_0_37_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_ErrEn" ,getValue(P_FSG_50_0_0_37_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_IntTlgEn" ,getValue(P_FSG_50_0_0_37_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_SegmEn" ,getValue(P_FSG_50_0_0_37_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_ErrCode" ,getValue(P_FSG_50_0_0_37_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_3" ,getValue(P_FSG_50_0_0_37_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_3_0" ,getValue(P_FSG_50_0_0_37_3_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_3_1" ,getValue(P_FSG_50_0_0_37_3_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_3_4" ,getValue(P_FSG_50_0_0_37_3_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_2" ,getValue(P_FSG_50_0_0_37_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_2_0" ,getValue(P_FSG_50_0_0_37_2_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_2_1" ,getValue(P_FSG_50_0_0_37_2_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_2_2" ,getValue(P_FSG_50_0_0_37_2_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_2_5" ,getValue(P_FSG_50_0_0_37_2_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_2_6" ,getValue(P_FSG_50_0_0_37_2_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_2_7" ,getValue(P_FSG_50_0_0_37_2_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_16" ,getValue(P_FSG_50_0_0_37_1_16), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_17" ,getValue(P_FSG_50_0_0_37_1_17), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_18" ,getValue(P_FSG_50_0_0_37_1_18), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_19" ,getValue(P_FSG_50_0_0_37_1_19), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_20" ,getValue(P_FSG_50_0_0_37_1_20), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_21" ,getValue(P_FSG_50_0_0_37_1_21), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_22" ,getValue(P_FSG_50_0_0_37_1_22), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_23" ,getValue(P_FSG_50_0_0_37_1_23), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_25" ,getValue(P_FSG_50_0_0_37_1_25), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_26" ,getValue(P_FSG_50_0_0_37_1_26), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_27" ,getValue(P_FSG_50_0_0_37_1_27), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_28" ,getValue(P_FSG_50_0_0_37_1_28), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_31" ,getValue(P_FSG_50_0_0_37_1_31), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_36" ,getValue(P_FSG_50_0_0_37_1_36), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_38" ,getValue(P_FSG_50_0_0_37_1_38), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_39" ,getValue(P_FSG_50_0_0_37_1_39), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_40" ,getValue(P_FSG_50_0_0_37_1_40), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_43" ,getValue(P_FSG_50_0_0_37_1_43), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_44" ,getValue(P_FSG_50_0_0_37_1_44), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_45" ,getValue(P_FSG_50_0_0_37_1_45), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_46" ,getValue(P_FSG_50_0_0_37_1_46), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_37_1_47" ,getValue(P_FSG_50_0_0_37_1_47), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_38Status_BTN" ,getValue(P_FSG_50_0_0_38Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_38_FctLstItemEn" ,getValue(P_FSG_50_0_0_38_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_38_FctEn" ,getValue(P_FSG_50_0_0_38_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_38_ErrEn" ,getValue(P_FSG_50_0_0_38_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_38_ErrCode" ,getValue(P_FSG_50_0_0_38_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_38" ,getValue(P_FSG_50_0_0_38), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_38_1" ,getValue(P_FSG_50_0_0_38_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_39Status_BTN" ,getValue(P_FSG_50_0_0_39Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_39_FctLstItemEn" ,getValue(P_FSG_50_0_0_39_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_39_FctEn" ,getValue(P_FSG_50_0_0_39_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_39_ErrEn" ,getValue(P_FSG_50_0_0_39_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_39_ErrCode" ,getValue(P_FSG_50_0_0_39_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_39" ,getValue(P_FSG_50_0_0_39), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_39_1" ,getValue(P_FSG_50_0_0_39_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_40Status_BTN" ,getValue(P_FSG_50_0_0_40Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_40_FctLstItemEn" ,getValue(P_FSG_50_0_0_40_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_40_FctEn" ,getValue(P_FSG_50_0_0_40_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_40_ErrEn" ,getValue(P_FSG_50_0_0_40_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_40_ErrCode" ,getValue(P_FSG_50_0_0_40_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_40" ,getValue(P_FSG_50_0_0_40), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_40_1" ,getValue(P_FSG_50_0_0_40_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_41Result_BTN" ,getValue(M_FSG_50_0_0_41Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_41_FctLstItemEn" ,getValue(M_FSG_50_0_0_41_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_41_FctEn" ,getValue(M_FSG_50_0_0_41_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_41_ErrEn" ,getValue(M_FSG_50_0_0_41_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_41_IntTlgEn" ,getValue(M_FSG_50_0_0_41_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_41_SegmEn" ,getValue(M_FSG_50_0_0_41_SegmEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_41_ErrCode" ,getValue(M_FSG_50_0_0_41_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_41_Result_1" ,getValue(M_FSG_50_0_0_41_Result_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_41_Result_2" ,getValue(M_FSG_50_0_0_41_Result_2), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_41_Result_2_range" ,getValue(M_FSG_50_0_0_41_Result_2_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_41_Result_3" ,getValue(M_FSG_50_0_0_41_Result_3), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_41_Result_3_range" ,getValue(M_FSG_50_0_0_41_Result_3_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_41_Result_4" ,getValue(M_FSG_50_0_0_41_Result_4), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_41_Result_4_range" ,getValue(M_FSG_50_0_0_41_Result_4_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_41_Processing_1_len" ,getValue(M_FSG_50_0_0_41_Processing_1_len), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_41_Processing_1_cnt" ,getValue(M_FSG_50_0_0_41_Processing_1_cnt), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_41_Start_1" ,getValue(M_FSG_50_0_0_41_Start_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_41_Start_1_range" ,getValue(M_FSG_50_0_0_41_Start_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_41_Start_2" ,getValue(M_FSG_50_0_0_41_Start_2), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_41_Start_2_range" ,getValue(M_FSG_50_0_0_41_Start_2_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_41_Start_3" ,getValue(M_FSG_50_0_0_41_Start_3), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_42Result_BTN" ,getValue(M_FSG_50_0_0_42Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_42_FctLstItemEn" ,getValue(M_FSG_50_0_0_42_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_42_FctEn" ,getValue(M_FSG_50_0_0_42_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_42_ErrEn" ,getValue(M_FSG_50_0_0_42_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_42_ErrCode" ,getValue(M_FSG_50_0_0_42_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_42_Result_1" ,getValue(M_FSG_50_0_0_42_Result_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_42_Result_2" ,getValue(M_FSG_50_0_0_42_Result_2), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_42_Result_2_range" ,getValue(M_FSG_50_0_0_42_Result_2_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_42_Result_3" ,getValue(M_FSG_50_0_0_42_Result_3), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_42_Result_3_range" ,getValue(M_FSG_50_0_0_42_Result_3_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_42_Processing_1" ,getValue(M_FSG_50_0_0_42_Processing_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_42_Processing_1_range" ,getValue(M_FSG_50_0_0_42_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_42_Processing_2" ,getValue(M_FSG_50_0_0_42_Processing_2), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_42_Processing_2_range" ,getValue(M_FSG_50_0_0_42_Processing_2_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_42_Start_1" ,getValue(M_FSG_50_0_0_42_Start_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_42_Start_2_len" ,getValue(M_FSG_50_0_0_42_Start_2_len), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_42_Start_2_cnt" ,getValue(M_FSG_50_0_0_42_Start_2_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_43Status_BTN" ,getValue(P_FSG_50_0_0_43Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_43_FctLstItemEn" ,getValue(P_FSG_50_0_0_43_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_43_FctEn" ,getValue(P_FSG_50_0_0_43_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_43_ErrEn" ,getValue(P_FSG_50_0_0_43_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_43_ErrCode" ,getValue(P_FSG_50_0_0_43_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_43_4" ,getValue(P_FSG_50_0_0_43_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_43_4_0" ,getValue(P_FSG_50_0_0_43_4_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_43_4_1" ,getValue(P_FSG_50_0_0_43_4_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_43_4_2" ,getValue(P_FSG_50_0_0_43_4_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_43_4_3" ,getValue(P_FSG_50_0_0_43_4_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_43_4_4" ,getValue(P_FSG_50_0_0_43_4_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_43_4_5" ,getValue(P_FSG_50_0_0_43_4_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_43_3" ,getValue(P_FSG_50_0_0_43_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_43_2" ,getValue(P_FSG_50_0_0_43_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_43_1" ,getValue(P_FSG_50_0_0_43_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44Status_BTN" ,getValue(P_FSG_50_0_0_44Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_FctLstItemEn" ,getValue(P_FSG_50_0_0_44_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_FctEn" ,getValue(P_FSG_50_0_0_44_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_ErrEn" ,getValue(P_FSG_50_0_0_44_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_IntTlgEn" ,getValue(P_FSG_50_0_0_44_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_SegmEn" ,getValue(P_FSG_50_0_0_44_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_ErrCode" ,getValue(P_FSG_50_0_0_44_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_7" ,getValue(P_FSG_50_0_0_44_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_7_0" ,getValue(P_FSG_50_0_0_44_7_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_5" ,getValue(P_FSG_50_0_0_44_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_5_0" ,getValue(P_FSG_50_0_0_44_5_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_5_1" ,getValue(P_FSG_50_0_0_44_5_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_5_2" ,getValue(P_FSG_50_0_0_44_5_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_4" ,getValue(P_FSG_50_0_0_44_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_4_0" ,getValue(P_FSG_50_0_0_44_4_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_4_1" ,getValue(P_FSG_50_0_0_44_4_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_4_2" ,getValue(P_FSG_50_0_0_44_4_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_1" ,getValue(P_FSG_50_0_0_44_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_2" ,getValue(P_FSG_50_0_0_44_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_6" ,getValue(P_FSG_50_0_0_44_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_3" ,getValue(P_FSG_50_0_0_44_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_3_0" ,getValue(P_FSG_50_0_0_44_3_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_3_1" ,getValue(P_FSG_50_0_0_44_3_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_3_2" ,getValue(P_FSG_50_0_0_44_3_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_44_3_3" ,getValue(P_FSG_50_0_0_44_3_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_45Status_BTN" ,getValue(P_FSG_50_0_0_45Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_45_FctLstItemEn" ,getValue(P_FSG_50_0_0_45_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_45_FctEn" ,getValue(P_FSG_50_0_0_45_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_45_ErrEn" ,getValue(P_FSG_50_0_0_45_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_45_ErrCode" ,getValue(P_FSG_50_0_0_45_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_45_6" ,getValue(P_FSG_50_0_0_45_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_45_6_0" ,getValue(P_FSG_50_0_0_45_6_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_45_5" ,getValue(P_FSG_50_0_0_45_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_45_2" ,getValue(P_FSG_50_0_0_45_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_45_4" ,getValue(P_FSG_50_0_0_45_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_45_4_range" ,getValue(P_FSG_50_0_0_45_4_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_45_3" ,getValue(P_FSG_50_0_0_45_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_45_3_0" ,getValue(P_FSG_50_0_0_45_3_0), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_45_1" ,getValue(P_FSG_50_0_0_45_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_45_1_range" ,getValue(P_FSG_50_0_0_45_1_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46Status_BTN" ,getValue(P_FSG_50_0_0_46Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_FctLstItemEn" ,getValue(P_FSG_50_0_0_46_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_FctEn" ,getValue(P_FSG_50_0_0_46_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_ErrEn" ,getValue(P_FSG_50_0_0_46_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_IntTlgEn" ,getValue(P_FSG_50_0_0_46_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_SegmEn" ,getValue(P_FSG_50_0_0_46_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_ErrCode" ,getValue(P_FSG_50_0_0_46_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_46_3" ,getValue(P_FSG_50_0_0_46_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_46_3_range" ,getValue(P_FSG_50_0_0_46_3_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_7_len" ,getValue(P_FSG_50_0_0_46_7_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_7_cnt" ,getValue(P_FSG_50_0_0_46_7_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_5_len" ,getValue(P_FSG_50_0_0_46_5_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_5_cnt" ,getValue(P_FSG_50_0_0_46_5_cnt), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_46_1_Latitude" ,getValue(P_FSG_50_0_0_46_1_Latitude), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_46_1_Latitude_range" ,getValue(P_FSG_50_0_0_46_1_Latitude_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_46_1_Longitude" ,getValue(P_FSG_50_0_0_46_1_Longitude), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_46_1_Longitude_range" ,getValue(P_FSG_50_0_0_46_1_Longitude_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_6_len" ,getValue(P_FSG_50_0_0_46_6_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_6_cnt" ,getValue(P_FSG_50_0_0_46_6_cnt), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_46_2" ,getValue(P_FSG_50_0_0_46_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_46_2_range" ,getValue(P_FSG_50_0_0_46_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_4" ,getValue(P_FSG_50_0_0_46_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_8_len" ,getValue(P_FSG_50_0_0_46_8_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_8_cnt" ,getValue(P_FSG_50_0_0_46_8_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_10_len" ,getValue(P_FSG_50_0_0_46_10_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_10_cnt" ,getValue(P_FSG_50_0_0_46_10_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_9_len" ,getValue(P_FSG_50_0_0_46_9_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_46_9_cnt" ,getValue(P_FSG_50_0_0_46_9_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_47Status_BTN" ,getValue(P_FSG_50_0_0_47Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_47_FctLstItemEn" ,getValue(P_FSG_50_0_0_47_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_47_FctEn" ,getValue(P_FSG_50_0_0_47_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_47_ErrEn" ,getValue(P_FSG_50_0_0_47_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_47_ErrCode" ,getValue(P_FSG_50_0_0_47_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_47_1" ,getValue(P_FSG_50_0_0_47_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_47_1_range" ,getValue(P_FSG_50_0_0_47_1_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_47_2" ,getValue(P_FSG_50_0_0_47_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_48Status_BTN" ,getValue(P_FSG_50_0_0_48Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_48_FctLstItemEn" ,getValue(P_FSG_50_0_0_48_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_48_FctEn" ,getValue(P_FSG_50_0_0_48_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_48_ErrEn" ,getValue(P_FSG_50_0_0_48_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_48_ErrCode" ,getValue(P_FSG_50_0_0_48_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_48_1" ,getValue(P_FSG_50_0_0_48_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_48_2" ,getValue(P_FSG_50_0_0_48_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_48_2_range" ,getValue(P_FSG_50_0_0_48_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_48_3" ,getValue(P_FSG_50_0_0_48_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_49Status_BTN" ,getValue(P_FSG_50_0_0_49Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_49_FctLstItemEn" ,getValue(P_FSG_50_0_0_49_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_49_FctEn" ,getValue(P_FSG_50_0_0_49_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_49_ErrEn" ,getValue(P_FSG_50_0_0_49_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_49_ErrCode" ,getValue(P_FSG_50_0_0_49_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_49_1" ,getValue(P_FSG_50_0_0_49_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_49_2" ,getValue(P_FSG_50_0_0_49_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_49_2_range" ,getValue(P_FSG_50_0_0_49_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50Status_BTN" ,getValue(P_FSG_50_0_0_50Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_FctLstItemEn" ,getValue(P_FSG_50_0_0_50_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_FctEn" ,getValue(P_FSG_50_0_0_50_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_ErrEn" ,getValue(P_FSG_50_0_0_50_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_IntTlgEn" ,getValue(P_FSG_50_0_0_50_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_SegmEn" ,getValue(P_FSG_50_0_0_50_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_ErrCode" ,getValue(P_FSG_50_0_0_50_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_1" ,getValue(P_FSG_50_0_0_50_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_1_0" ,getValue(P_FSG_50_0_0_50_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_1_1" ,getValue(P_FSG_50_0_0_50_1_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_4_TimeInfoType" ,getValue(P_FSG_50_0_0_50_4_TimeInfoType), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_4_NavigationTimeFormat" ,getValue(P_FSG_50_0_0_50_4_NavigationTimeFormat), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_50_4_Minute" ,getValue(P_FSG_50_0_0_50_4_Minute), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_50_4_Minute_range" ,getValue(P_FSG_50_0_0_50_4_Minute_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_50_4_Hour" ,getValue(P_FSG_50_0_0_50_4_Hour), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_50_4_Hour_range" ,getValue(P_FSG_50_0_0_50_4_Hour_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_50_4_Day" ,getValue(P_FSG_50_0_0_50_4_Day), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_50_4_Day_range" ,getValue(P_FSG_50_0_0_50_4_Day_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_50_4_Month" ,getValue(P_FSG_50_0_0_50_4_Month), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_50_4_Month_range" ,getValue(P_FSG_50_0_0_50_4_Month_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_50_4_Year" ,getValue(P_FSG_50_0_0_50_4_Year), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_50_4_Year_range" ,getValue(P_FSG_50_0_0_50_4_Year_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_50_3_Distance" ,getValue(P_FSG_50_0_0_50_3_Distance), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_50_3_Distance_range" ,getValue(P_FSG_50_0_0_50_3_Distance_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_3_Unit" ,getValue(P_FSG_50_0_0_50_3_Unit), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_3_TypeOfDistance" ,getValue(P_FSG_50_0_0_50_3_TypeOfDistance), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_5" ,getValue(P_FSG_50_0_0_50_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_5_0" ,getValue(P_FSG_50_0_0_50_5_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_5_1" ,getValue(P_FSG_50_0_0_50_5_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_5_2" ,getValue(P_FSG_50_0_0_50_5_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_5_3" ,getValue(P_FSG_50_0_0_50_5_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_5_4" ,getValue(P_FSG_50_0_0_50_5_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_50_5_5" ,getValue(P_FSG_50_0_0_50_5_5), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_50_2_Minute" ,getValue(P_FSG_50_0_0_50_2_Minute), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_50_2_Minute_range" ,getValue(P_FSG_50_0_0_50_2_Minute_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_50_2_Hour" ,getValue(P_FSG_50_0_0_50_2_Hour), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_50_2_Hour_range" ,getValue(P_FSG_50_0_0_50_2_Hour_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_51Result_BTN" ,getValue(M_FSG_50_0_0_51Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_51_FctLstItemEn" ,getValue(M_FSG_50_0_0_51_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_51_FctEn" ,getValue(M_FSG_50_0_0_51_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_51_ErrEn" ,getValue(M_FSG_50_0_0_51_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_51_ErrCode" ,getValue(M_FSG_50_0_0_51_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_51_Result_1" ,getValue(M_FSG_50_0_0_51_Result_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_51_Result_1_range" ,getValue(M_FSG_50_0_0_51_Result_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_51_Result_2" ,getValue(M_FSG_50_0_0_51_Result_2), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_51_Processing_1" ,getValue(M_FSG_50_0_0_51_Processing_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_51_Processing_1_range" ,getValue(M_FSG_50_0_0_51_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_51_Processing_2" ,getValue(M_FSG_50_0_0_51_Processing_2), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_51_Processing_2_range" ,getValue(M_FSG_50_0_0_51_Processing_2_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_51_Start_1" ,getValue(M_FSG_50_0_0_51_Start_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_51_Start_2" ,getValue(M_FSG_50_0_0_51_Start_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52Changed_BTN" ,getValue(A_FSG_50_0_0_52Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52Status_BTN" ,getValue(A_FSG_50_0_0_52Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_FctLstItemEn" ,getValue(A_FSG_50_0_0_52_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_FctEn" ,getValue(A_FSG_50_0_0_52_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_ErrEn" ,getValue(A_FSG_50_0_0_52_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_IntTlgEn" ,getValue(A_FSG_50_0_0_52_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_SegmEn" ,getValue(A_FSG_50_0_0_52_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_AT" ,getValue(A_FSG_50_0_0_52_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_ErrCode" ,getValue(A_FSG_50_0_0_52_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_DataIndex" ,getValue(A_FSG_50_0_0_52_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_DataIndex_Incr" ,getValue(A_FSG_50_0_0_52_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_DataIndex_Decr" ,getValue(A_FSG_50_0_0_52_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_loadArray_Btn" ,getValue(A_FSG_50_0_0_52_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_generateData_Btn" ,getValue(A_FSG_50_0_0_52_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Data_6" ,getValue(A_FSG_50_0_0_52_Data_6), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_52_3" ,getValue(A_FSG_50_0_0_52_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_52_3_range" ,getValue(A_FSG_50_0_0_52_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_1" ,getValue(A_FSG_50_0_0_52_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Data_8_len" ,getValue(A_FSG_50_0_0_52_Data_8_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Data_8_cnt" ,getValue(A_FSG_50_0_0_52_Data_8_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Data_7_len" ,getValue(A_FSG_50_0_0_52_Data_7_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Data_7_cnt" ,getValue(A_FSG_50_0_0_52_Data_7_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Data_3" ,getValue(A_FSG_50_0_0_52_Data_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Data_9_len" ,getValue(A_FSG_50_0_0_52_Data_9_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Data_9_cnt" ,getValue(A_FSG_50_0_0_52_Data_9_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Data_2" ,getValue(A_FSG_50_0_0_52_Data_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_52_Data_1" ,getValue(A_FSG_50_0_0_52_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_52_Data_1_range" ,getValue(A_FSG_50_0_0_52_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_52_Data_5" ,getValue(A_FSG_50_0_0_52_Data_5), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_52_Data_5_range" ,getValue(A_FSG_50_0_0_52_Data_5_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_52_2" ,getValue(A_FSG_50_0_0_52_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_52_2_range" ,getValue(A_FSG_50_0_0_52_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Data_10_len" ,getValue(A_FSG_50_0_0_52_Data_10_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Data_10_cnt" ,getValue(A_FSG_50_0_0_52_Data_10_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Data_4" ,getValue(A_FSG_50_0_0_52_Data_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_RecAdr" ,getValue(A_FSG_50_0_0_52_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Direction" ,getValue(A_FSG_50_0_0_52_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Shift" ,getValue(A_FSG_50_0_0_52_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_TransPos" ,getValue(A_FSG_50_0_0_52_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_IndexSize" ,getValue(A_FSG_50_0_0_52_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Start" ,getValue(A_FSG_50_0_0_52_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Elements" ,getValue(A_FSG_50_0_0_52_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Changed_RecAdr" ,getValue(A_FSG_50_0_0_52_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Changed_Direction" ,getValue(A_FSG_50_0_0_52_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Changed_Shift" ,getValue(A_FSG_50_0_0_52_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Changed_TransPos" ,getValue(A_FSG_50_0_0_52_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Changed_IndexSize" ,getValue(A_FSG_50_0_0_52_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Changed_Start" ,getValue(A_FSG_50_0_0_52_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_Changed_Elements" ,getValue(A_FSG_50_0_0_52_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_52_2_SetGet" ,getValue(A_FSG_50_0_0_52_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_52_2_SetGet_range" ,getValue(A_FSG_50_0_0_52_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_1_SetGet" ,getValue(A_FSG_50_0_0_52_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_SetGet_RecAdr" ,getValue(A_FSG_50_0_0_52_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_SetGet_Direction" ,getValue(A_FSG_50_0_0_52_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_SetGet_Shift" ,getValue(A_FSG_50_0_0_52_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_SetGet_IndexSize" ,getValue(A_FSG_50_0_0_52_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_SetGet_Start" ,getValue(A_FSG_50_0_0_52_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_52_SetGet_Elements" ,getValue(A_FSG_50_0_0_52_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_53Status_BTN" ,getValue(P_FSG_50_0_0_53Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_53_FctLstItemEn" ,getValue(P_FSG_50_0_0_53_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_53_FctEn" ,getValue(P_FSG_50_0_0_53_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_53_ErrEn" ,getValue(P_FSG_50_0_0_53_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_53_ErrCode" ,getValue(P_FSG_50_0_0_53_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_53_1" ,getValue(P_FSG_50_0_0_53_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_53_1_0" ,getValue(P_FSG_50_0_0_53_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_53_1_1" ,getValue(P_FSG_50_0_0_53_1_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_53_1_2" ,getValue(P_FSG_50_0_0_53_1_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_53_6" ,getValue(P_FSG_50_0_0_53_6), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_53_6_range" ,getValue(P_FSG_50_0_0_53_6_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_53_5" ,getValue(P_FSG_50_0_0_53_5), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_53_5_range" ,getValue(P_FSG_50_0_0_53_5_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_53_4" ,getValue(P_FSG_50_0_0_53_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_53_4_range" ,getValue(P_FSG_50_0_0_53_4_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_53_2" ,getValue(P_FSG_50_0_0_53_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_53_2_0" ,getValue(P_FSG_50_0_0_53_2_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_53_3" ,getValue(P_FSG_50_0_0_53_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_53_3_0" ,getValue(P_FSG_50_0_0_53_3_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_53_3_1" ,getValue(P_FSG_50_0_0_53_3_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_53_3_2" ,getValue(P_FSG_50_0_0_53_3_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_53_3_3" ,getValue(P_FSG_50_0_0_53_3_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_53_3_4" ,getValue(P_FSG_50_0_0_53_3_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_53_3_5" ,getValue(P_FSG_50_0_0_53_3_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_54Status_BTN" ,getValue(P_FSG_50_0_0_54Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_54_FctLstItemEn" ,getValue(P_FSG_50_0_0_54_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_54_FctEn" ,getValue(P_FSG_50_0_0_54_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_54_ErrEn" ,getValue(P_FSG_50_0_0_54_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_54_ErrCode" ,getValue(P_FSG_50_0_0_54_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_54" ,getValue(P_FSG_50_0_0_54), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_54_1" ,getValue(P_FSG_50_0_0_54_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_54_1_0" ,getValue(P_FSG_50_0_0_54_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_54_1_1" ,getValue(P_FSG_50_0_0_54_1_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_54_1_2" ,getValue(P_FSG_50_0_0_54_1_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_55Status_BTN" ,getValue(P_FSG_50_0_0_55Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_55_FctLstItemEn" ,getValue(P_FSG_50_0_0_55_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_55_FctEn" ,getValue(P_FSG_50_0_0_55_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_55_ErrEn" ,getValue(P_FSG_50_0_0_55_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_55_ErrCode" ,getValue(P_FSG_50_0_0_55_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_55_1" ,getValue(P_FSG_50_0_0_55_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_55_4" ,getValue(P_FSG_50_0_0_55_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_55_4_range" ,getValue(P_FSG_50_0_0_55_4_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_55_3" ,getValue(P_FSG_50_0_0_55_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_55_3_range" ,getValue(P_FSG_50_0_0_55_3_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_55_2" ,getValue(P_FSG_50_0_0_55_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_55_2_range" ,getValue(P_FSG_50_0_0_55_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_56Status_BTN" ,getValue(P_FSG_50_0_0_56Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_56_FctLstItemEn" ,getValue(P_FSG_50_0_0_56_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_56_FctEn" ,getValue(P_FSG_50_0_0_56_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_56_ErrEn" ,getValue(P_FSG_50_0_0_56_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_56_ErrCode" ,getValue(P_FSG_50_0_0_56_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_56_2" ,getValue(P_FSG_50_0_0_56_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_56_2_range" ,getValue(P_FSG_50_0_0_56_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_56_1" ,getValue(P_FSG_50_0_0_56_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57Status_BTN" ,getValue(P_FSG_50_0_0_57Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_FctLstItemEn" ,getValue(P_FSG_50_0_0_57_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_FctEn" ,getValue(P_FSG_50_0_0_57_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_ErrEn" ,getValue(P_FSG_50_0_0_57_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_ErrCode" ,getValue(P_FSG_50_0_0_57_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_57_4" ,getValue(P_FSG_50_0_0_57_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_57_4_range" ,getValue(P_FSG_50_0_0_57_4_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_57_3" ,getValue(P_FSG_50_0_0_57_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_57_3_range" ,getValue(P_FSG_50_0_0_57_3_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_2" ,getValue(P_FSG_50_0_0_57_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_2_0" ,getValue(P_FSG_50_0_0_57_2_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_2_1" ,getValue(P_FSG_50_0_0_57_2_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_2_2" ,getValue(P_FSG_50_0_0_57_2_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_2_3" ,getValue(P_FSG_50_0_0_57_2_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_2_4" ,getValue(P_FSG_50_0_0_57_2_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_2_5" ,getValue(P_FSG_50_0_0_57_2_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_2_6" ,getValue(P_FSG_50_0_0_57_2_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_2_7" ,getValue(P_FSG_50_0_0_57_2_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_1" ,getValue(P_FSG_50_0_0_57_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_1_0" ,getValue(P_FSG_50_0_0_57_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_1_1" ,getValue(P_FSG_50_0_0_57_1_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_1_2" ,getValue(P_FSG_50_0_0_57_1_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_1_3" ,getValue(P_FSG_50_0_0_57_1_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_1_4" ,getValue(P_FSG_50_0_0_57_1_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_1_5" ,getValue(P_FSG_50_0_0_57_1_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_1_6" ,getValue(P_FSG_50_0_0_57_1_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_57_1_7" ,getValue(P_FSG_50_0_0_57_1_7), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_57_6" ,getValue(P_FSG_50_0_0_57_6), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_57_6_range" ,getValue(P_FSG_50_0_0_57_6_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_57_5" ,getValue(P_FSG_50_0_0_57_5), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_57_5_range" ,getValue(P_FSG_50_0_0_57_5_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58Changed_BTN" ,getValue(A_FSG_50_0_0_58Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58Status_BTN" ,getValue(A_FSG_50_0_0_58Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_FctLstItemEn" ,getValue(A_FSG_50_0_0_58_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_FctEn" ,getValue(A_FSG_50_0_0_58_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_ErrEn" ,getValue(A_FSG_50_0_0_58_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_IntTlgEn" ,getValue(A_FSG_50_0_0_58_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_SegmEn" ,getValue(A_FSG_50_0_0_58_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_AT" ,getValue(A_FSG_50_0_0_58_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_ErrCode" ,getValue(A_FSG_50_0_0_58_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_DataIndex" ,getValue(A_FSG_50_0_0_58_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_DataIndex_Incr" ,getValue(A_FSG_50_0_0_58_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_DataIndex_Decr" ,getValue(A_FSG_50_0_0_58_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_loadArray_Btn" ,getValue(A_FSG_50_0_0_58_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_generateData_Btn" ,getValue(A_FSG_50_0_0_58_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_Data_2" ,getValue(A_FSG_50_0_0_58_Data_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_58_Data_4" ,getValue(A_FSG_50_0_0_58_Data_4), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_58_Data_4_range" ,getValue(A_FSG_50_0_0_58_Data_4_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_Data_5_len" ,getValue(A_FSG_50_0_0_58_Data_5_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_Data_5_cnt" ,getValue(A_FSG_50_0_0_58_Data_5_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_58_2" ,getValue(A_FSG_50_0_0_58_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_58_2_range" ,getValue(A_FSG_50_0_0_58_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_1" ,getValue(A_FSG_50_0_0_58_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_Data_3_len" ,getValue(A_FSG_50_0_0_58_Data_3_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_Data_3_cnt" ,getValue(A_FSG_50_0_0_58_Data_3_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_58_Data_1" ,getValue(A_FSG_50_0_0_58_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_58_Data_1_range" ,getValue(A_FSG_50_0_0_58_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_58_3" ,getValue(A_FSG_50_0_0_58_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_58_3_range" ,getValue(A_FSG_50_0_0_58_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_RecAdr" ,getValue(A_FSG_50_0_0_58_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_Direction" ,getValue(A_FSG_50_0_0_58_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_Shift" ,getValue(A_FSG_50_0_0_58_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_TransPos" ,getValue(A_FSG_50_0_0_58_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_IndexSize" ,getValue(A_FSG_50_0_0_58_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_Start" ,getValue(A_FSG_50_0_0_58_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_Elements" ,getValue(A_FSG_50_0_0_58_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_Changed_RecAdr" ,getValue(A_FSG_50_0_0_58_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_Changed_Direction" ,getValue(A_FSG_50_0_0_58_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_Changed_Shift" ,getValue(A_FSG_50_0_0_58_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_Changed_TransPos" ,getValue(A_FSG_50_0_0_58_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_Changed_IndexSize" ,getValue(A_FSG_50_0_0_58_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_Changed_Start" ,getValue(A_FSG_50_0_0_58_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_Changed_Elements" ,getValue(A_FSG_50_0_0_58_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_58_2_SetGet" ,getValue(A_FSG_50_0_0_58_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_58_2_SetGet_range" ,getValue(A_FSG_50_0_0_58_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_1_SetGet" ,getValue(A_FSG_50_0_0_58_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_SetGet_RecAdr" ,getValue(A_FSG_50_0_0_58_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_SetGet_Direction" ,getValue(A_FSG_50_0_0_58_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_SetGet_Shift" ,getValue(A_FSG_50_0_0_58_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_SetGet_IndexSize" ,getValue(A_FSG_50_0_0_58_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_SetGet_Start" ,getValue(A_FSG_50_0_0_58_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_58_SetGet_Elements" ,getValue(A_FSG_50_0_0_58_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_59Result_BTN" ,getValue(M_FSG_50_0_0_59Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_59_FctLstItemEn" ,getValue(M_FSG_50_0_0_59_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_59_FctEn" ,getValue(M_FSG_50_0_0_59_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_59_ErrEn" ,getValue(M_FSG_50_0_0_59_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_59_ErrCode" ,getValue(M_FSG_50_0_0_59_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_59_Result_1" ,getValue(M_FSG_50_0_0_59_Result_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_59_Result_2" ,getValue(M_FSG_50_0_0_59_Result_2), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_59_Result_2_range" ,getValue(M_FSG_50_0_0_59_Result_2_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_59_Result_3" ,getValue(M_FSG_50_0_0_59_Result_3), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_59_Processing_1" ,getValue(M_FSG_50_0_0_59_Processing_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_59_Processing_2" ,getValue(M_FSG_50_0_0_59_Processing_2), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_59_Processing_2_range" ,getValue(M_FSG_50_0_0_59_Processing_2_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_59_Processing_3" ,getValue(M_FSG_50_0_0_59_Processing_3), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_59_Processing_3_range" ,getValue(M_FSG_50_0_0_59_Processing_3_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_50_0_0_59_Start_1" ,getValue(M_FSG_50_0_0_59_Start_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_59_Start_2" ,getValue(M_FSG_50_0_0_59_Start_2), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_59_Start_2_range" ,getValue(M_FSG_50_0_0_59_Start_2_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_59_Start_3" ,getValue(M_FSG_50_0_0_59_Start_3), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_59_Start_3_range" ,getValue(M_FSG_50_0_0_59_Start_3_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_59_Start_4" ,getValue(M_FSG_50_0_0_59_Start_4), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_50_0_0_59_Start_4_range" ,getValue(M_FSG_50_0_0_59_Start_4_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_60Status_BTN" ,getValue(P_FSG_50_0_0_60Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_60_FctLstItemEn" ,getValue(P_FSG_50_0_0_60_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_60_FctEn" ,getValue(P_FSG_50_0_0_60_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_60_ErrEn" ,getValue(P_FSG_50_0_0_60_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_60_IntTlgEn" ,getValue(P_FSG_50_0_0_60_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_60_SegmEn" ,getValue(P_FSG_50_0_0_60_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_60_ErrCode" ,getValue(P_FSG_50_0_0_60_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_60_6" ,getValue(P_FSG_50_0_0_60_6), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_60_6_range" ,getValue(P_FSG_50_0_0_60_6_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_60_4" ,getValue(P_FSG_50_0_0_60_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_60_4_range" ,getValue(P_FSG_50_0_0_60_4_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_60_5" ,getValue(P_FSG_50_0_0_60_5), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_60_5_range" ,getValue(P_FSG_50_0_0_60_5_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_60_2" ,getValue(P_FSG_50_0_0_60_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_60_2_range" ,getValue(P_FSG_50_0_0_60_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_60_3" ,getValue(P_FSG_50_0_0_60_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_60_8" ,getValue(P_FSG_50_0_0_60_8), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_60_8_0" ,getValue(P_FSG_50_0_0_60_8_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_60_8_1" ,getValue(P_FSG_50_0_0_60_8_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_60_7" ,getValue(P_FSG_50_0_0_60_7), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_60_7_range" ,getValue(P_FSG_50_0_0_60_7_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_60_1_Distance" ,getValue(P_FSG_50_0_0_60_1_Distance), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_50_0_0_60_1_Distance_range" ,getValue(P_FSG_50_0_0_60_1_Distance_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_60_1_Unit" ,getValue(P_FSG_50_0_0_60_1_Unit), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61Changed_BTN" ,getValue(A_FSG_50_0_0_61Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61Status_BTN" ,getValue(A_FSG_50_0_0_61Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_FctLstItemEn" ,getValue(A_FSG_50_0_0_61_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_FctEn" ,getValue(A_FSG_50_0_0_61_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_ErrEn" ,getValue(A_FSG_50_0_0_61_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_IntTlgEn" ,getValue(A_FSG_50_0_0_61_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_SegmEn" ,getValue(A_FSG_50_0_0_61_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_AT" ,getValue(A_FSG_50_0_0_61_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_ErrCode" ,getValue(A_FSG_50_0_0_61_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_DataIndex" ,getValue(A_FSG_50_0_0_61_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_DataIndex_Incr" ,getValue(A_FSG_50_0_0_61_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_DataIndex_Decr" ,getValue(A_FSG_50_0_0_61_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_loadArray_Btn" ,getValue(A_FSG_50_0_0_61_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_generateData_Btn" ,getValue(A_FSG_50_0_0_61_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Data_8" ,getValue(A_FSG_50_0_0_61_Data_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Data_7_len" ,getValue(A_FSG_50_0_0_61_Data_7_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Data_7_cnt" ,getValue(A_FSG_50_0_0_61_Data_7_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_3" ,getValue(A_FSG_50_0_0_61_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Data_9" ,getValue(A_FSG_50_0_0_61_Data_9), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Data_12" ,getValue(A_FSG_50_0_0_61_Data_12), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_1" ,getValue(A_FSG_50_0_0_61_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Data_10" ,getValue(A_FSG_50_0_0_61_Data_10), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_61_Data_1" ,getValue(A_FSG_50_0_0_61_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_61_Data_1_range" ,getValue(A_FSG_50_0_0_61_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_61_Data_4" ,getValue(A_FSG_50_0_0_61_Data_4), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_61_Data_4_range" ,getValue(A_FSG_50_0_0_61_Data_4_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Data_2" ,getValue(A_FSG_50_0_0_61_Data_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_61_2" ,getValue(A_FSG_50_0_0_61_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_61_2_range" ,getValue(A_FSG_50_0_0_61_2_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_61_Data_3" ,getValue(A_FSG_50_0_0_61_Data_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_61_Data_3_range" ,getValue(A_FSG_50_0_0_61_Data_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Data_6" ,getValue(A_FSG_50_0_0_61_Data_6), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_61_4" ,getValue(A_FSG_50_0_0_61_4), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_61_4_range" ,getValue(A_FSG_50_0_0_61_4_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Data_11" ,getValue(A_FSG_50_0_0_61_Data_11), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Data_11_0" ,getValue(A_FSG_50_0_0_61_Data_11_0), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Data_11_1" ,getValue(A_FSG_50_0_0_61_Data_11_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Data_5" ,getValue(A_FSG_50_0_0_61_Data_5), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_61_5" ,getValue(A_FSG_50_0_0_61_5), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_61_5_range" ,getValue(A_FSG_50_0_0_61_5_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_RecAdr" ,getValue(A_FSG_50_0_0_61_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Direction" ,getValue(A_FSG_50_0_0_61_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Shift" ,getValue(A_FSG_50_0_0_61_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_TransPos" ,getValue(A_FSG_50_0_0_61_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_IndexSize" ,getValue(A_FSG_50_0_0_61_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Start" ,getValue(A_FSG_50_0_0_61_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Elements" ,getValue(A_FSG_50_0_0_61_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_61_3_Changed" ,getValue(A_FSG_50_0_0_61_3_Changed), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_61_3_Changed_range" ,getValue(A_FSG_50_0_0_61_3_Changed_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_1_Changed" ,getValue(A_FSG_50_0_0_61_1_Changed), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_61_2_Changed" ,getValue(A_FSG_50_0_0_61_2_Changed), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_61_2_Changed_range" ,getValue(A_FSG_50_0_0_61_2_Changed_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Changed_RecAdr" ,getValue(A_FSG_50_0_0_61_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Changed_Direction" ,getValue(A_FSG_50_0_0_61_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Changed_Shift" ,getValue(A_FSG_50_0_0_61_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Changed_TransPos" ,getValue(A_FSG_50_0_0_61_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Changed_IndexSize" ,getValue(A_FSG_50_0_0_61_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Changed_Start" ,getValue(A_FSG_50_0_0_61_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_Changed_Elements" ,getValue(A_FSG_50_0_0_61_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_61_2_SetGet" ,getValue(A_FSG_50_0_0_61_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_61_2_SetGet_range" ,getValue(A_FSG_50_0_0_61_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_1_SetGet" ,getValue(A_FSG_50_0_0_61_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_SetGet_RecAdr" ,getValue(A_FSG_50_0_0_61_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_SetGet_Direction" ,getValue(A_FSG_50_0_0_61_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_SetGet_Shift" ,getValue(A_FSG_50_0_0_61_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_SetGet_IndexSize" ,getValue(A_FSG_50_0_0_61_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_SetGet_Start" ,getValue(A_FSG_50_0_0_61_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_61_SetGet_Elements" ,getValue(A_FSG_50_0_0_61_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62Changed_BTN" ,getValue(A_FSG_50_0_0_62Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62Status_BTN" ,getValue(A_FSG_50_0_0_62Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_FctLstItemEn" ,getValue(A_FSG_50_0_0_62_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_FctEn" ,getValue(A_FSG_50_0_0_62_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_ErrEn" ,getValue(A_FSG_50_0_0_62_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_IntTlgEn" ,getValue(A_FSG_50_0_0_62_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_SegmEn" ,getValue(A_FSG_50_0_0_62_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_AT" ,getValue(A_FSG_50_0_0_62_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_ErrCode" ,getValue(A_FSG_50_0_0_62_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_DataIndex" ,getValue(A_FSG_50_0_0_62_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_DataIndex_Incr" ,getValue(A_FSG_50_0_0_62_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_DataIndex_Decr" ,getValue(A_FSG_50_0_0_62_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_loadArray_Btn" ,getValue(A_FSG_50_0_0_62_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_generateData_Btn" ,getValue(A_FSG_50_0_0_62_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_Data_2" ,getValue(A_FSG_50_0_0_62_Data_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_Data_5_len" ,getValue(A_FSG_50_0_0_62_Data_5_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_Data_5_cnt" ,getValue(A_FSG_50_0_0_62_Data_5_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_62_2" ,getValue(A_FSG_50_0_0_62_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_62_2_range" ,getValue(A_FSG_50_0_0_62_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_1" ,getValue(A_FSG_50_0_0_62_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_Data_3_len" ,getValue(A_FSG_50_0_0_62_Data_3_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_Data_3_cnt" ,getValue(A_FSG_50_0_0_62_Data_3_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_62_Data_1" ,getValue(A_FSG_50_0_0_62_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_62_Data_1_range" ,getValue(A_FSG_50_0_0_62_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_62_3" ,getValue(A_FSG_50_0_0_62_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_62_3_range" ,getValue(A_FSG_50_0_0_62_3_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_62_Data_4" ,getValue(A_FSG_50_0_0_62_Data_4), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_62_Data_4_range" ,getValue(A_FSG_50_0_0_62_Data_4_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_RecAdr" ,getValue(A_FSG_50_0_0_62_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_Direction" ,getValue(A_FSG_50_0_0_62_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_Shift" ,getValue(A_FSG_50_0_0_62_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_TransPos" ,getValue(A_FSG_50_0_0_62_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_IndexSize" ,getValue(A_FSG_50_0_0_62_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_Start" ,getValue(A_FSG_50_0_0_62_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_Elements" ,getValue(A_FSG_50_0_0_62_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_Changed_RecAdr" ,getValue(A_FSG_50_0_0_62_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_Changed_Direction" ,getValue(A_FSG_50_0_0_62_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_Changed_Shift" ,getValue(A_FSG_50_0_0_62_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_Changed_TransPos" ,getValue(A_FSG_50_0_0_62_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_Changed_IndexSize" ,getValue(A_FSG_50_0_0_62_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_Changed_Start" ,getValue(A_FSG_50_0_0_62_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_Changed_Elements" ,getValue(A_FSG_50_0_0_62_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_62_2_SetGet" ,getValue(A_FSG_50_0_0_62_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_50_0_0_62_2_SetGet_range" ,getValue(A_FSG_50_0_0_62_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_1_SetGet" ,getValue(A_FSG_50_0_0_62_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_SetGet_RecAdr" ,getValue(A_FSG_50_0_0_62_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_SetGet_Direction" ,getValue(A_FSG_50_0_0_62_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_SetGet_Shift" ,getValue(A_FSG_50_0_0_62_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_SetGet_IndexSize" ,getValue(A_FSG_50_0_0_62_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_SetGet_Start" ,getValue(A_FSG_50_0_0_62_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_62_SetGet_Elements" ,getValue(A_FSG_50_0_0_62_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_1" ,getValue(P_FSG_50_0_0_23_1_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_2" ,getValue(P_FSG_50_0_0_23_1_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_3" ,getValue(P_FSG_50_0_0_23_1_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_4" ,getValue(P_FSG_50_0_0_23_1_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_5" ,getValue(P_FSG_50_0_0_23_1_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_6" ,getValue(P_FSG_50_0_0_23_1_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_7" ,getValue(P_FSG_50_0_0_23_1_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_8" ,getValue(P_FSG_50_0_0_23_1_8), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_9" ,getValue(P_FSG_50_0_0_23_1_9), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_10" ,getValue(P_FSG_50_0_0_23_1_10), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_11" ,getValue(P_FSG_50_0_0_23_1_11), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_12" ,getValue(P_FSG_50_0_0_23_1_12), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_13" ,getValue(P_FSG_50_0_0_23_1_13), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_14" ,getValue(P_FSG_50_0_0_23_1_14), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_15" ,getValue(P_FSG_50_0_0_23_1_15), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_16" ,getValue(P_FSG_50_0_0_23_1_16), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_17" ,getValue(P_FSG_50_0_0_23_1_17), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_18" ,getValue(P_FSG_50_0_0_23_1_18), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_19" ,getValue(P_FSG_50_0_0_23_1_19), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_1" ,getValue(P_FSG_50_0_0_23_2_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_2" ,getValue(P_FSG_50_0_0_23_2_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_3" ,getValue(P_FSG_50_0_0_23_2_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_4" ,getValue(P_FSG_50_0_0_23_2_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_5" ,getValue(P_FSG_50_0_0_23_2_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_6" ,getValue(P_FSG_50_0_0_23_2_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_7" ,getValue(P_FSG_50_0_0_23_2_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_8" ,getValue(P_FSG_50_0_0_23_2_8), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_9" ,getValue(P_FSG_50_0_0_23_2_9), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_10" ,getValue(P_FSG_50_0_0_23_2_10), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_11" ,getValue(P_FSG_50_0_0_23_2_11), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_12" ,getValue(P_FSG_50_0_0_23_2_12), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_13" ,getValue(P_FSG_50_0_0_23_2_13), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_14" ,getValue(P_FSG_50_0_0_23_2_14), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_15" ,getValue(P_FSG_50_0_0_23_2_15), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_16" ,getValue(P_FSG_50_0_0_23_2_16), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_17" ,getValue(P_FSG_50_0_0_23_2_17), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_18" ,getValue(P_FSG_50_0_0_23_2_18), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_19" ,getValue(P_FSG_50_0_0_23_2_19), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_1" ,getValue(P_FSG_50_0_0_23_3_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_2" ,getValue(P_FSG_50_0_0_23_3_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_3" ,getValue(P_FSG_50_0_0_23_3_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_4" ,getValue(P_FSG_50_0_0_23_3_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_5" ,getValue(P_FSG_50_0_0_23_3_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_6" ,getValue(P_FSG_50_0_0_23_3_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_7" ,getValue(P_FSG_50_0_0_23_3_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_8" ,getValue(P_FSG_50_0_0_23_3_8), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_9" ,getValue(P_FSG_50_0_0_23_3_9), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_10" ,getValue(P_FSG_50_0_0_23_3_10), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_11" ,getValue(P_FSG_50_0_0_23_3_11), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_12" ,getValue(P_FSG_50_0_0_23_3_12), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_13" ,getValue(P_FSG_50_0_0_23_3_13), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_14" ,getValue(P_FSG_50_0_0_23_3_14), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_15" ,getValue(P_FSG_50_0_0_23_3_15), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_16" ,getValue(P_FSG_50_0_0_23_3_16), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_17" ,getValue(P_FSG_50_0_0_23_3_17), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_18" ,getValue(P_FSG_50_0_0_23_3_18), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_19" ,getValue(P_FSG_50_0_0_23_3_19), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_FRU" ,getValue(A_FSG_50_0_0_24_FRU), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24Status_BTN2" ,getValue(A_FSG_50_0_0_24Status_BTN2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_len_8" ,getValue(A_FSG_50_0_0_24_Data_3_len_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_len_6" ,getValue(A_FSG_50_0_0_24_Data_3_len_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_len_5" ,getValue(A_FSG_50_0_0_24_Data_3_len_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_len_4" ,getValue(A_FSG_50_0_0_24_Data_3_len_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_len_3" ,getValue(A_FSG_50_0_0_24_Data_3_len_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_len_2" ,getValue(A_FSG_50_0_0_24_Data_3_len_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_len_1" ,getValue(A_FSG_50_0_0_24_Data_3_len_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_3_1" ,getValue(A_FSG_50_0_0_24_Data_3_3_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_2_1" ,getValue(A_FSG_50_0_0_24_Data_3_2_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_1_1" ,getValue(A_FSG_50_0_0_24_Data_3_1_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_2_1" ,getValue(A_FSG_50_0_0_24_Data_2_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_1_1" ,getValue(A_FSG_50_0_0_24_Data_1_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_1_2" ,getValue(A_FSG_50_0_0_24_Data_1_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_2_2" ,getValue(A_FSG_50_0_0_24_Data_2_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_3_2" ,getValue(A_FSG_50_0_0_24_Data_3_3_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_1_2" ,getValue(A_FSG_50_0_0_24_Data_3_1_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_2_2" ,getValue(A_FSG_50_0_0_24_Data_3_2_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_1_3" ,getValue(A_FSG_50_0_0_24_Data_1_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_2_3" ,getValue(A_FSG_50_0_0_24_Data_2_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_1_3" ,getValue(A_FSG_50_0_0_24_Data_3_1_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_3_3" ,getValue(A_FSG_50_0_0_24_Data_3_3_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_2_3" ,getValue(A_FSG_50_0_0_24_Data_3_2_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_1_4" ,getValue(A_FSG_50_0_0_24_Data_1_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_2_4" ,getValue(A_FSG_50_0_0_24_Data_2_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_3_4" ,getValue(A_FSG_50_0_0_24_Data_3_3_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_1_4" ,getValue(A_FSG_50_0_0_24_Data_3_1_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_2_4" ,getValue(A_FSG_50_0_0_24_Data_3_2_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_1_5" ,getValue(A_FSG_50_0_0_24_Data_1_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_2_5" ,getValue(A_FSG_50_0_0_24_Data_2_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_3_5" ,getValue(A_FSG_50_0_0_24_Data_3_3_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_1_5" ,getValue(A_FSG_50_0_0_24_Data_3_1_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_2_5" ,getValue(A_FSG_50_0_0_24_Data_3_2_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_1_6" ,getValue(A_FSG_50_0_0_24_Data_1_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_2_6" ,getValue(A_FSG_50_0_0_24_Data_2_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_3_6" ,getValue(A_FSG_50_0_0_24_Data_3_3_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_1_6" ,getValue(A_FSG_50_0_0_24_Data_3_1_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_2_6" ,getValue(A_FSG_50_0_0_24_Data_3_2_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_1_7" ,getValue(A_FSG_50_0_0_24_Data_1_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_2_7" ,getValue(A_FSG_50_0_0_24_Data_2_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_3_7" ,getValue(A_FSG_50_0_0_24_Data_3_3_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_1_7" ,getValue(A_FSG_50_0_0_24_Data_3_1_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_2_7" ,getValue(A_FSG_50_0_0_24_Data_3_2_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_1_8" ,getValue(A_FSG_50_0_0_24_Data_1_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_2_8" ,getValue(A_FSG_50_0_0_24_Data_2_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_3_8" ,getValue(A_FSG_50_0_0_24_Data_3_3_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_1_8" ,getValue(A_FSG_50_0_0_24_Data_3_1_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_2_8" ,getValue(A_FSG_50_0_0_24_Data_3_2_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_2_8" ,getValue(A_FSG_50_0_0_24_Data_3_empty_2_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_2_7" ,getValue(A_FSG_50_0_0_24_Data_3_empty_2_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_2_6" ,getValue(A_FSG_50_0_0_24_Data_3_empty_2_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_2_5" ,getValue(A_FSG_50_0_0_24_Data_3_empty_2_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_2_4" ,getValue(A_FSG_50_0_0_24_Data_3_empty_2_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_2_3" ,getValue(A_FSG_50_0_0_24_Data_3_empty_2_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_2_2" ,getValue(A_FSG_50_0_0_24_Data_3_empty_2_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_2_1" ,getValue(A_FSG_50_0_0_24_Data_3_empty_2_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_1_8" ,getValue(A_FSG_50_0_0_24_Data_3_empty_1_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_1_7" ,getValue(A_FSG_50_0_0_24_Data_3_empty_1_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_1_6" ,getValue(A_FSG_50_0_0_24_Data_3_empty_1_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_1_5" ,getValue(A_FSG_50_0_0_24_Data_3_empty_1_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_1_4" ,getValue(A_FSG_50_0_0_24_Data_3_empty_1_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_1_3" ,getValue(A_FSG_50_0_0_24_Data_3_empty_1_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_1_2" ,getValue(A_FSG_50_0_0_24_Data_3_empty_1_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_1_1" ,getValue(A_FSG_50_0_0_24_Data_3_empty_1_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_8_8" ,getValue(A_FSG_50_0_0_24_Data_8_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_8_7" ,getValue(A_FSG_50_0_0_24_Data_8_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_8_6" ,getValue(A_FSG_50_0_0_24_Data_8_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_8_5" ,getValue(A_FSG_50_0_0_24_Data_8_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_8_4" ,getValue(A_FSG_50_0_0_24_Data_8_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_8_3" ,getValue(A_FSG_50_0_0_24_Data_8_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_8_2" ,getValue(A_FSG_50_0_0_24_Data_8_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_8_1" ,getValue(A_FSG_50_0_0_24_Data_8_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_7_8" ,getValue(A_FSG_50_0_0_24_Data_7_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_7_7" ,getValue(A_FSG_50_0_0_24_Data_7_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_7_6" ,getValue(A_FSG_50_0_0_24_Data_7_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_7_5" ,getValue(A_FSG_50_0_0_24_Data_7_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_7_4" ,getValue(A_FSG_50_0_0_24_Data_7_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_7_3" ,getValue(A_FSG_50_0_0_24_Data_7_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_7_2" ,getValue(A_FSG_50_0_0_24_Data_7_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_7_1" ,getValue(A_FSG_50_0_0_24_Data_7_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_6_8" ,getValue(A_FSG_50_0_0_24_Data_6_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_6_7" ,getValue(A_FSG_50_0_0_24_Data_6_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_6_6" ,getValue(A_FSG_50_0_0_24_Data_6_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_6_5" ,getValue(A_FSG_50_0_0_24_Data_6_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_6_4" ,getValue(A_FSG_50_0_0_24_Data_6_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_6_3" ,getValue(A_FSG_50_0_0_24_Data_6_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_6_2" ,getValue(A_FSG_50_0_0_24_Data_6_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_6_1" ,getValue(A_FSG_50_0_0_24_Data_6_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_5_8" ,getValue(A_FSG_50_0_0_24_Data_5_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_5_7" ,getValue(A_FSG_50_0_0_24_Data_5_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_5_6" ,getValue(A_FSG_50_0_0_24_Data_5_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_5_5" ,getValue(A_FSG_50_0_0_24_Data_5_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_5_4" ,getValue(A_FSG_50_0_0_24_Data_5_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_5_3" ,getValue(A_FSG_50_0_0_24_Data_5_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_5_2" ,getValue(A_FSG_50_0_0_24_Data_5_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_5_1" ,getValue(A_FSG_50_0_0_24_Data_5_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_4_8" ,getValue(A_FSG_50_0_0_24_Data_4_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_4_7" ,getValue(A_FSG_50_0_0_24_Data_4_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_4_6" ,getValue(A_FSG_50_0_0_24_Data_4_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_4_5" ,getValue(A_FSG_50_0_0_24_Data_4_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_4_4" ,getValue(A_FSG_50_0_0_24_Data_4_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_4_3" ,getValue(A_FSG_50_0_0_24_Data_4_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_4_2" ,getValue(A_FSG_50_0_0_24_Data_4_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_4_1" ,getValue(A_FSG_50_0_0_24_Data_4_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_3_8" ,getValue(A_FSG_50_0_0_24_Data_3_empty_3_8), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_3_7" ,getValue(A_FSG_50_0_0_24_Data_3_empty_3_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_3_6" ,getValue(A_FSG_50_0_0_24_Data_3_empty_3_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_3_5" ,getValue(A_FSG_50_0_0_24_Data_3_empty_3_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_3_4" ,getValue(A_FSG_50_0_0_24_Data_3_empty_3_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_3_3" ,getValue(A_FSG_50_0_0_24_Data_3_empty_3_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_3_2" ,getValue(A_FSG_50_0_0_24_Data_3_empty_3_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_50_0_0_24_Data_3_empty_3_1" ,getValue(A_FSG_50_0_0_24_Data_3_empty_3_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_3_BuildString" ,getValue(P_FSG_50_0_0_23_3_BuildString), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_2_BuildString" ,getValue(P_FSG_50_0_0_23_2_BuildString), profileFile);
    writeProfileInt("BAP" ,"P_FSG_50_0_0_23_1_BuildString" ,getValue(P_FSG_50_0_0_23_1_BuildString), profileFile);
    writeProfileInt("BAP" ,"C_FSG_52_0_0_0_1_FctLstItemEn" ,getValue(C_FSG_52_0_0_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_52_0_0_0_1_FctEn" ,getValue(C_FSG_52_0_0_0_1_FctEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_52_0_0_0_1_ErrEn" ,getValue(C_FSG_52_0_0_0_1_ErrEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_52_0_0_0_1_IntTlgEn" ,getValue(C_FSG_52_0_0_0_1_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_52_0_0_0_1_SegmEn" ,getValue(C_FSG_52_0_0_0_1_SegmEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_52_0_0_0_1_ErrCode" ,getValue(C_FSG_52_0_0_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_0_2Reset_BTN" ,getValue(P_FSG_52_0_0_0_2Reset_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_0_2_FctLstItemEn" ,getValue(P_FSG_52_0_0_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_0_2_FctEn" ,getValue(P_FSG_52_0_0_0_2_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_0_2_ErrEn" ,getValue(P_FSG_52_0_0_0_2_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_0_2_ErrCode" ,getValue(P_FSG_52_0_0_0_2_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_0_3_FctLstItemEn" ,getValue(P_FSG_52_0_0_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_0_3_FctEn" ,getValue(P_FSG_52_0_0_0_3_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_0_3_ErrEn" ,getValue(P_FSG_52_0_0_0_3_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_0_3_IntTlgEn" ,getValue(P_FSG_52_0_0_0_3_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_0_3_SegmEn" ,getValue(P_FSG_52_0_0_0_3_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_0_3_ErrCode" ,getValue(P_FSG_52_0_0_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"ERRORLIST_FSG52_0_VT" ,getValue(ERRORLIST_FSG52_0_VT), profileFile);
    writeProfileInt("BAP" ,"ON_OFF_FSG52_0" ,getValue(ON_OFF_FSG52_0), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_52_0_0_DFMajor" ,getValue(BAPCFG_FSG_52_0_0_DFMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_52_0_0_DFMinor" ,getValue(BAPCFG_FSG_52_0_0_DFMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_52_0_0_LsgClassMajor" ,getValue(BAPCFG_FSG_52_0_0_LsgClassMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_52_0_0_LsgClassMinor" ,getValue(BAPCFG_FSG_52_0_0_LsgClassMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_52_0_0_ProtocolMajor" ,getValue(BAPCFG_FSG_52_0_0_ProtocolMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_52_0_0_ProtocolMinor" ,getValue(BAPCFG_FSG_52_0_0_ProtocolMinor), profileFile);
    writeProfileInt("BAP" ,"C_FSG_52_0_0_1_FctLstItemEn" ,getValue(C_FSG_52_0_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_52_0_0_1_FctEn" ,getValue(C_FSG_52_0_0_1_FctEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_52_0_0_1_ErrEn" ,getValue(C_FSG_52_0_0_1_ErrEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_52_0_0_1_IntTlgEn" ,getValue(C_FSG_52_0_0_1_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_52_0_0_1_SegmEn" ,getValue(C_FSG_52_0_0_1_SegmEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_52_0_0_1_ErrCode" ,getValue(C_FSG_52_0_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_2Reset_BTN" ,getValue(P_FSG_52_0_0_2Reset_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_2_FctLstItemEn" ,getValue(P_FSG_52_0_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_2_FctEn" ,getValue(P_FSG_52_0_0_2_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_2_ErrEn" ,getValue(P_FSG_52_0_0_2_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_2_ErrCode" ,getValue(P_FSG_52_0_0_2_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_52_0_0_2" ,getValue(P_FSG_52_0_0_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_52_0_0_2_range" ,getValue(P_FSG_52_0_0_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_3Status_BTN" ,getValue(P_FSG_52_0_0_3Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_3_FctLstItemEn" ,getValue(P_FSG_52_0_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_3_FctEn" ,getValue(P_FSG_52_0_0_3_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_3_ErrEn" ,getValue(P_FSG_52_0_0_3_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_3_IntTlgEn" ,getValue(P_FSG_52_0_0_3_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_3_SegmEn" ,getValue(P_FSG_52_0_0_3_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_3_ErrCode" ,getValue(P_FSG_52_0_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_4Status_BTN" ,getValue(P_FSG_52_0_0_4Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_4_FctLstItemEn" ,getValue(P_FSG_52_0_0_4_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_4_FctEn" ,getValue(P_FSG_52_0_0_4_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_4_ErrEn" ,getValue(P_FSG_52_0_0_4_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_4_ErrCode" ,getValue(P_FSG_52_0_0_4_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_4" ,getValue(P_FSG_52_0_0_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_14Status_BTN" ,getValue(P_FSG_52_0_0_14Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_14_FctLstItemEn" ,getValue(P_FSG_52_0_0_14_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_14_FctEn" ,getValue(P_FSG_52_0_0_14_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_14_ErrEn" ,getValue(P_FSG_52_0_0_14_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_14_ErrCode" ,getValue(P_FSG_52_0_0_14_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_14" ,getValue(P_FSG_52_0_0_14), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_14_1" ,getValue(P_FSG_52_0_0_14_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_14_1_0" ,getValue(P_FSG_52_0_0_14_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_14_1_1" ,getValue(P_FSG_52_0_0_14_1_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_14_1_2" ,getValue(P_FSG_52_0_0_14_1_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_14_1_3" ,getValue(P_FSG_52_0_0_14_1_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_14_1_4" ,getValue(P_FSG_52_0_0_14_1_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_15Status_BTN" ,getValue(P_FSG_52_0_0_15Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_15_FctLstItemEn" ,getValue(P_FSG_52_0_0_15_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_15_FctEn" ,getValue(P_FSG_52_0_0_15_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_15_ErrEn" ,getValue(P_FSG_52_0_0_15_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_15_ErrCode" ,getValue(P_FSG_52_0_0_15_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_15" ,getValue(P_FSG_52_0_0_15), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_15_1" ,getValue(P_FSG_52_0_0_15_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_16Status_BTN" ,getValue(P_FSG_52_0_0_16Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_16_FctLstItemEn" ,getValue(P_FSG_52_0_0_16_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_16_FctEn" ,getValue(P_FSG_52_0_0_16_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_16_ErrEn" ,getValue(P_FSG_52_0_0_16_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_16_ErrCode" ,getValue(P_FSG_52_0_0_16_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_16" ,getValue(P_FSG_52_0_0_16), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_16_1" ,getValue(P_FSG_52_0_0_16_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_16_1_0" ,getValue(P_FSG_52_0_0_16_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_16_1_1" ,getValue(P_FSG_52_0_0_16_1_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_16_1_2" ,getValue(P_FSG_52_0_0_16_1_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_16_1_3" ,getValue(P_FSG_52_0_0_16_1_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_16_1_4" ,getValue(P_FSG_52_0_0_16_1_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_16_1_5" ,getValue(P_FSG_52_0_0_16_1_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_17Status_BTN" ,getValue(P_FSG_52_0_0_17Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_17StatusAck_BTN" ,getValue(P_FSG_52_0_0_17StatusAck_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_17_FctLstItemEn" ,getValue(P_FSG_52_0_0_17_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_17_FctEn" ,getValue(P_FSG_52_0_0_17_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_17_ErrEn" ,getValue(P_FSG_52_0_0_17_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_17_ErrCode" ,getValue(P_FSG_52_0_0_17_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_17_Ack_5" ,getValue(P_FSG_52_0_0_17_Ack_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_17_Ack_4" ,getValue(P_FSG_52_0_0_17_Ack_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_17_Ack_3" ,getValue(P_FSG_52_0_0_17_Ack_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_17_Ack_2" ,getValue(P_FSG_52_0_0_17_Ack_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_17_Ack_1" ,getValue(P_FSG_52_0_0_17_Ack_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_17_5" ,getValue(P_FSG_52_0_0_17_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_17_4" ,getValue(P_FSG_52_0_0_17_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_17_3" ,getValue(P_FSG_52_0_0_17_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_17_2" ,getValue(P_FSG_52_0_0_17_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_17_1" ,getValue(P_FSG_52_0_0_17_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_18Status_BTN" ,getValue(P_FSG_52_0_0_18Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_18_FctLstItemEn" ,getValue(P_FSG_52_0_0_18_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_18_FctEn" ,getValue(P_FSG_52_0_0_18_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_18_ErrEn" ,getValue(P_FSG_52_0_0_18_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_18_ErrCode" ,getValue(P_FSG_52_0_0_18_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_18_2" ,getValue(P_FSG_52_0_0_18_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_18_1" ,getValue(P_FSG_52_0_0_18_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_18_3" ,getValue(P_FSG_52_0_0_18_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19Status_BTN" ,getValue(P_FSG_52_0_0_19Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_FctLstItemEn" ,getValue(P_FSG_52_0_0_19_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_FctEn" ,getValue(P_FSG_52_0_0_19_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_ErrEn" ,getValue(P_FSG_52_0_0_19_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_IntTlgEn" ,getValue(P_FSG_52_0_0_19_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_SegmEn" ,getValue(P_FSG_52_0_0_19_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_ErrCode" ,getValue(P_FSG_52_0_0_19_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_10" ,getValue(P_FSG_52_0_0_19_10), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_4" ,getValue(P_FSG_52_0_0_19_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_9_len" ,getValue(P_FSG_52_0_0_19_9_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_9_cnt" ,getValue(P_FSG_52_0_0_19_9_cnt), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_52_0_0_19_11" ,getValue(P_FSG_52_0_0_19_11), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_52_0_0_19_11_range" ,getValue(P_FSG_52_0_0_19_11_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_2" ,getValue(P_FSG_52_0_0_19_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_8_OptionType" ,getValue(P_FSG_52_0_0_19_8_OptionType), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_8_OptionString_len" ,getValue(P_FSG_52_0_0_19_8_OptionString_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_8_OptionString_cnt" ,getValue(P_FSG_52_0_0_19_8_OptionString_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_7_OptionType" ,getValue(P_FSG_52_0_0_19_7_OptionType), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_7_OptionString_len" ,getValue(P_FSG_52_0_0_19_7_OptionString_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_7_OptionString_cnt" ,getValue(P_FSG_52_0_0_19_7_OptionString_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_3" ,getValue(P_FSG_52_0_0_19_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_6_OptionType" ,getValue(P_FSG_52_0_0_19_6_OptionType), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_6_OptionString_len" ,getValue(P_FSG_52_0_0_19_6_OptionString_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_6_OptionString_cnt" ,getValue(P_FSG_52_0_0_19_6_OptionString_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_5_OptionType" ,getValue(P_FSG_52_0_0_19_5_OptionType), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_5_OptionString_len" ,getValue(P_FSG_52_0_0_19_5_OptionString_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_52_0_0_19_5_OptionString_cnt" ,getValue(P_FSG_52_0_0_19_5_OptionString_cnt), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_52_0_0_19_1" ,getValue(P_FSG_52_0_0_19_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_52_0_0_19_1_range" ,getValue(P_FSG_52_0_0_19_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_52_0_0_20Result_BTN" ,getValue(M_FSG_52_0_0_20Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_52_0_0_20_FctLstItemEn" ,getValue(M_FSG_52_0_0_20_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_52_0_0_20_FctEn" ,getValue(M_FSG_52_0_0_20_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_52_0_0_20_ErrEn" ,getValue(M_FSG_52_0_0_20_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_52_0_0_20_ErrCode" ,getValue(M_FSG_52_0_0_20_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_52_0_0_20_Result" ,getValue(M_FSG_52_0_0_20_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_52_0_0_20_Result_1" ,getValue(M_FSG_52_0_0_20_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_52_0_0_20_Processing_1_range" ,getValue(M_FSG_52_0_0_20_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_52_0_0_20_Processing_1_range" ,getValue(M_FSG_52_0_0_20_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_52_0_0_20_Processing_1_range" ,getValue(M_FSG_52_0_0_20_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_52_0_0_20_Start_1" ,getValue(M_FSG_52_0_0_20_Start_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_52_0_0_20_Start_1_range" ,getValue(M_FSG_52_0_0_20_Start_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_52_0_0_20_Start_2" ,getValue(M_FSG_52_0_0_20_Start_2), profileFile);
    writeProfileInt("BAP" ,"C_FSG_60_0_0_0_1_FctLstItemEn" ,getValue(C_FSG_60_0_0_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_60_0_0_0_1_FctEn" ,getValue(C_FSG_60_0_0_0_1_FctEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_60_0_0_0_1_ErrEn" ,getValue(C_FSG_60_0_0_0_1_ErrEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_60_0_0_0_1_IntTlgEn" ,getValue(C_FSG_60_0_0_0_1_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_60_0_0_0_1_SegmEn" ,getValue(C_FSG_60_0_0_0_1_SegmEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_60_0_0_0_1_ErrCode" ,getValue(C_FSG_60_0_0_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_0_2Reset_BTN" ,getValue(P_FSG_60_0_0_0_2Reset_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_0_2_FctLstItemEn" ,getValue(P_FSG_60_0_0_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_0_2_FctEn" ,getValue(P_FSG_60_0_0_0_2_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_0_2_ErrEn" ,getValue(P_FSG_60_0_0_0_2_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_0_2_ErrCode" ,getValue(P_FSG_60_0_0_0_2_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_0_3_FctLstItemEn" ,getValue(P_FSG_60_0_0_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_0_3_FctEn" ,getValue(P_FSG_60_0_0_0_3_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_0_3_ErrEn" ,getValue(P_FSG_60_0_0_0_3_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_0_3_IntTlgEn" ,getValue(P_FSG_60_0_0_0_3_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_0_3_SegmEn" ,getValue(P_FSG_60_0_0_0_3_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_0_3_ErrCode" ,getValue(P_FSG_60_0_0_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"ERRORLIST_FSG60_0_VT" ,getValue(ERRORLIST_FSG60_0_VT), profileFile);
    writeProfileInt("BAP" ,"BusType_FSG60_0" ,getValue(BusType_FSG60_0), profileFile);
    writeProfileInt("BAP" ,"ON_OFF_FSG60_0" ,getValue(ON_OFF_FSG60_0), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_60_0_0_DFMajor" ,getValue(BAPCFG_FSG_60_0_0_DFMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_60_0_0_DFMinor" ,getValue(BAPCFG_FSG_60_0_0_DFMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_60_0_0_LsgClassMajor" ,getValue(BAPCFG_FSG_60_0_0_LsgClassMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_60_0_0_LsgClassMinor" ,getValue(BAPCFG_FSG_60_0_0_LsgClassMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_60_0_0_ProtocolMajor" ,getValue(BAPCFG_FSG_60_0_0_ProtocolMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_60_0_0_ProtocolMinor" ,getValue(BAPCFG_FSG_60_0_0_ProtocolMinor), profileFile);
    writeProfileInt("BAP" ,"C_FSG_60_0_0_1_FctLstItemEn" ,getValue(C_FSG_60_0_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_60_0_0_1_FctEn" ,getValue(C_FSG_60_0_0_1_FctEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_60_0_0_1_ErrEn" ,getValue(C_FSG_60_0_0_1_ErrEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_60_0_0_1_IntTlgEn" ,getValue(C_FSG_60_0_0_1_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_60_0_0_1_SegmEn" ,getValue(C_FSG_60_0_0_1_SegmEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_60_0_0_1_ErrCode" ,getValue(C_FSG_60_0_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_2Reset_BTN" ,getValue(P_FSG_60_0_0_2Reset_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_2_FctLstItemEn" ,getValue(P_FSG_60_0_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_2_FctEn" ,getValue(P_FSG_60_0_0_2_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_2_ErrEn" ,getValue(P_FSG_60_0_0_2_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_2_ErrCode" ,getValue(P_FSG_60_0_0_2_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_2" ,getValue(P_FSG_60_0_0_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_2_range" ,getValue(P_FSG_60_0_0_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_3Status_BTN" ,getValue(P_FSG_60_0_0_3Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_3_FctLstItemEn" ,getValue(P_FSG_60_0_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_3_FctEn" ,getValue(P_FSG_60_0_0_3_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_3_ErrEn" ,getValue(P_FSG_60_0_0_3_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_3_IntTlgEn" ,getValue(P_FSG_60_0_0_3_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_3_SegmEn" ,getValue(P_FSG_60_0_0_3_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_3_ErrCode" ,getValue(P_FSG_60_0_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_4Status_BTN" ,getValue(P_FSG_60_0_0_4Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_4_FctLstItemEn" ,getValue(P_FSG_60_0_0_4_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_4_FctEn" ,getValue(P_FSG_60_0_0_4_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_4_ErrEn" ,getValue(P_FSG_60_0_0_4_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_4_ErrCode" ,getValue(P_FSG_60_0_0_4_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_4" ,getValue(P_FSG_60_0_0_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_13Status_BTN" ,getValue(P_FSG_60_0_0_13Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_13_FctLstItemEn" ,getValue(P_FSG_60_0_0_13_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_13_FctEn" ,getValue(P_FSG_60_0_0_13_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_13_ErrEn" ,getValue(P_FSG_60_0_0_13_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_13_ErrCode" ,getValue(P_FSG_60_0_0_13_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_13" ,getValue(P_FSG_60_0_0_13), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_13_1" ,getValue(P_FSG_60_0_0_13_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_13_1_0" ,getValue(P_FSG_60_0_0_13_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_13_1_4" ,getValue(P_FSG_60_0_0_13_1_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_14Status_BTN" ,getValue(P_FSG_60_0_0_14Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_14_FctLstItemEn" ,getValue(P_FSG_60_0_0_14_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_14_FctEn" ,getValue(P_FSG_60_0_0_14_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_14_ErrEn" ,getValue(P_FSG_60_0_0_14_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_14_ErrCode" ,getValue(P_FSG_60_0_0_14_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_14_3" ,getValue(P_FSG_60_0_0_14_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_14_3_range" ,getValue(P_FSG_60_0_0_14_3_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_14_1" ,getValue(P_FSG_60_0_0_14_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_14_1_0" ,getValue(P_FSG_60_0_0_14_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_14_1_1" ,getValue(P_FSG_60_0_0_14_1_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_14_1_2" ,getValue(P_FSG_60_0_0_14_1_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_14_1_3" ,getValue(P_FSG_60_0_0_14_1_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_14_1_4" ,getValue(P_FSG_60_0_0_14_1_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_14_1_5" ,getValue(P_FSG_60_0_0_14_1_5), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_14_2" ,getValue(P_FSG_60_0_0_14_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_14_2_range" ,getValue(P_FSG_60_0_0_14_2_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_14_6" ,getValue(P_FSG_60_0_0_14_6), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_14_6_range" ,getValue(P_FSG_60_0_0_14_6_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_14_5" ,getValue(P_FSG_60_0_0_14_5), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_14_5_range" ,getValue(P_FSG_60_0_0_14_5_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_14_4" ,getValue(P_FSG_60_0_0_14_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_14_4_range" ,getValue(P_FSG_60_0_0_14_4_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_15Status_BTN" ,getValue(P_FSG_60_0_0_15Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_15_FctLstItemEn" ,getValue(P_FSG_60_0_0_15_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_15_FctEn" ,getValue(P_FSG_60_0_0_15_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_15_ErrEn" ,getValue(P_FSG_60_0_0_15_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_15_ErrCode" ,getValue(P_FSG_60_0_0_15_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_15" ,getValue(P_FSG_60_0_0_15), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_15_1" ,getValue(P_FSG_60_0_0_15_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_16Status_BTN" ,getValue(P_FSG_60_0_0_16Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_16_FctLstItemEn" ,getValue(P_FSG_60_0_0_16_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_16_FctEn" ,getValue(P_FSG_60_0_0_16_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_16_ErrEn" ,getValue(P_FSG_60_0_0_16_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_16_ErrCode" ,getValue(P_FSG_60_0_0_16_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_16_1" ,getValue(P_FSG_60_0_0_16_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_16_2" ,getValue(P_FSG_60_0_0_16_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_16_3" ,getValue(P_FSG_60_0_0_16_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_16_3_0" ,getValue(P_FSG_60_0_0_16_3_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17Status_BTN" ,getValue(P_FSG_60_0_0_17Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_FctLstItemEn" ,getValue(P_FSG_60_0_0_17_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_FctEn" ,getValue(P_FSG_60_0_0_17_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_ErrEn" ,getValue(P_FSG_60_0_0_17_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_ErrCode" ,getValue(P_FSG_60_0_0_17_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_1" ,getValue(P_FSG_60_0_0_17_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_2" ,getValue(P_FSG_60_0_0_17_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_4" ,getValue(P_FSG_60_0_0_17_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_4_0" ,getValue(P_FSG_60_0_0_17_4_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_4_1" ,getValue(P_FSG_60_0_0_17_4_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_4_2" ,getValue(P_FSG_60_0_0_17_4_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_4_3" ,getValue(P_FSG_60_0_0_17_4_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_4_4" ,getValue(P_FSG_60_0_0_17_4_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_4_5" ,getValue(P_FSG_60_0_0_17_4_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_4_6" ,getValue(P_FSG_60_0_0_17_4_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_4_7" ,getValue(P_FSG_60_0_0_17_4_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_4_8" ,getValue(P_FSG_60_0_0_17_4_8), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_4_9" ,getValue(P_FSG_60_0_0_17_4_9), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_4_10" ,getValue(P_FSG_60_0_0_17_4_10), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_4_11" ,getValue(P_FSG_60_0_0_17_4_11), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_4_12" ,getValue(P_FSG_60_0_0_17_4_12), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_4_13" ,getValue(P_FSG_60_0_0_17_4_13), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_4_14" ,getValue(P_FSG_60_0_0_17_4_14), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_4_15" ,getValue(P_FSG_60_0_0_17_4_15), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_17_3_Value" ,getValue(P_FSG_60_0_0_17_3_Value), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_17_3_Value_range" ,getValue(P_FSG_60_0_0_17_3_Value_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_17_3_Unit" ,getValue(P_FSG_60_0_0_17_3_Unit), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_18Status_BTN" ,getValue(P_FSG_60_0_0_18Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_18_FctLstItemEn" ,getValue(P_FSG_60_0_0_18_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_18_FctEn" ,getValue(P_FSG_60_0_0_18_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_18_ErrEn" ,getValue(P_FSG_60_0_0_18_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_18_ErrCode" ,getValue(P_FSG_60_0_0_18_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_18_4" ,getValue(P_FSG_60_0_0_18_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_18_4_range" ,getValue(P_FSG_60_0_0_18_4_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_18_2" ,getValue(P_FSG_60_0_0_18_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_18_1" ,getValue(P_FSG_60_0_0_18_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_18_1_0" ,getValue(P_FSG_60_0_0_18_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_18_1_1" ,getValue(P_FSG_60_0_0_18_1_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_18_3_Distance_Value" ,getValue(P_FSG_60_0_0_18_3_Distance_Value), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_18_3_Distance_Value_range" ,getValue(P_FSG_60_0_0_18_3_Distance_Value_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_18_3_Distance_Unit" ,getValue(P_FSG_60_0_0_18_3_Distance_Unit), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_19Status_BTN" ,getValue(P_FSG_60_0_0_19Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_19StatusAck_BTN" ,getValue(P_FSG_60_0_0_19StatusAck_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_19_FctLstItemEn" ,getValue(P_FSG_60_0_0_19_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_19_FctEn" ,getValue(P_FSG_60_0_0_19_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_19_ErrEn" ,getValue(P_FSG_60_0_0_19_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_19_ErrCode" ,getValue(P_FSG_60_0_0_19_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_19_Ack_2" ,getValue(P_FSG_60_0_0_19_Ack_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_19_Ack_3" ,getValue(P_FSG_60_0_0_19_Ack_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_19_Ack_1" ,getValue(P_FSG_60_0_0_19_Ack_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_19_Ack_1_range" ,getValue(P_FSG_60_0_0_19_Ack_1_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_19_2" ,getValue(P_FSG_60_0_0_19_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_19_3" ,getValue(P_FSG_60_0_0_19_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_19_1" ,getValue(P_FSG_60_0_0_19_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_19_1_range" ,getValue(P_FSG_60_0_0_19_1_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_20Status_BTN" ,getValue(P_FSG_60_0_0_20Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_20_FctLstItemEn" ,getValue(P_FSG_60_0_0_20_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_20_FctEn" ,getValue(P_FSG_60_0_0_20_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_20_ErrEn" ,getValue(P_FSG_60_0_0_20_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_20_ErrCode" ,getValue(P_FSG_60_0_0_20_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_20_2" ,getValue(P_FSG_60_0_0_20_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_20_2_range" ,getValue(P_FSG_60_0_0_20_2_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_20_1" ,getValue(P_FSG_60_0_0_20_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_60_0_0_20_1_range" ,getValue(P_FSG_60_0_0_20_1_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_21Status_BTN" ,getValue(P_FSG_60_0_0_21Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_21_FctLstItemEn" ,getValue(P_FSG_60_0_0_21_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_21_FctEn" ,getValue(P_FSG_60_0_0_21_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_21_ErrEn" ,getValue(P_FSG_60_0_0_21_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_21_ErrCode" ,getValue(P_FSG_60_0_0_21_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_21" ,getValue(P_FSG_60_0_0_21), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_21_1" ,getValue(P_FSG_60_0_0_21_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_21_1_0" ,getValue(P_FSG_60_0_0_21_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_21_1_1" ,getValue(P_FSG_60_0_0_21_1_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_21_1_2" ,getValue(P_FSG_60_0_0_21_1_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_22Status_BTN" ,getValue(P_FSG_60_0_0_22Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_22_FctLstItemEn" ,getValue(P_FSG_60_0_0_22_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_22_FctEn" ,getValue(P_FSG_60_0_0_22_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_22_ErrEn" ,getValue(P_FSG_60_0_0_22_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_22_ErrCode" ,getValue(P_FSG_60_0_0_22_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_22_1" ,getValue(P_FSG_60_0_0_22_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_22_2" ,getValue(P_FSG_60_0_0_22_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_22_3" ,getValue(P_FSG_60_0_0_22_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_22_3_0" ,getValue(P_FSG_60_0_0_22_3_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_23Status_BTN" ,getValue(P_FSG_60_0_0_23Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_23_FctLstItemEn" ,getValue(P_FSG_60_0_0_23_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_23_FctEn" ,getValue(P_FSG_60_0_0_23_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_23_ErrEn" ,getValue(P_FSG_60_0_0_23_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_23_ErrCode" ,getValue(P_FSG_60_0_0_23_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_23_1" ,getValue(P_FSG_60_0_0_23_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_23_2" ,getValue(P_FSG_60_0_0_23_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_23_3" ,getValue(P_FSG_60_0_0_23_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_23_3_0" ,getValue(P_FSG_60_0_0_23_3_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_24Status_BTN" ,getValue(P_FSG_60_0_0_24Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_24_FctLstItemEn" ,getValue(P_FSG_60_0_0_24_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_24_FctEn" ,getValue(P_FSG_60_0_0_24_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_24_ErrEn" ,getValue(P_FSG_60_0_0_24_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_24_ErrCode" ,getValue(P_FSG_60_0_0_24_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_24_1" ,getValue(P_FSG_60_0_0_24_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_24_2" ,getValue(P_FSG_60_0_0_24_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_24_3" ,getValue(P_FSG_60_0_0_24_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_24_3_0" ,getValue(P_FSG_60_0_0_24_3_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_25Status_BTN" ,getValue(P_FSG_60_0_0_25Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_25_FctLstItemEn" ,getValue(P_FSG_60_0_0_25_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_25_FctEn" ,getValue(P_FSG_60_0_0_25_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_25_ErrEn" ,getValue(P_FSG_60_0_0_25_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_25_ErrCode" ,getValue(P_FSG_60_0_0_25_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_25_1" ,getValue(P_FSG_60_0_0_25_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_25_2" ,getValue(P_FSG_60_0_0_25_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_25_3" ,getValue(P_FSG_60_0_0_25_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_60_0_0_25_3_0" ,getValue(P_FSG_60_0_0_25_3_0), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26Changed_BTN" ,getValue(A_FSG_60_0_0_26Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26Status_BTN" ,getValue(A_FSG_60_0_0_26Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_FctLstItemEn" ,getValue(A_FSG_60_0_0_26_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_FctEn" ,getValue(A_FSG_60_0_0_26_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_ErrEn" ,getValue(A_FSG_60_0_0_26_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_IntTlgEn" ,getValue(A_FSG_60_0_0_26_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_SegmEn" ,getValue(A_FSG_60_0_0_26_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_AT" ,getValue(A_FSG_60_0_0_26_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_ErrCode" ,getValue(A_FSG_60_0_0_26_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_DataIndex" ,getValue(A_FSG_60_0_0_26_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_DataIndex_Incr" ,getValue(A_FSG_60_0_0_26_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_DataIndex_Decr" ,getValue(A_FSG_60_0_0_26_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_loadArray_Btn" ,getValue(A_FSG_60_0_0_26_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_generateData_Btn" ,getValue(A_FSG_60_0_0_26_generateData_Btn), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_Data_4" ,getValue(A_FSG_60_0_0_26_Data_4), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_Data_4_range" ,getValue(A_FSG_60_0_0_26_Data_4_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_2" ,getValue(A_FSG_60_0_0_26_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_3" ,getValue(A_FSG_60_0_0_26_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_3_range" ,getValue(A_FSG_60_0_0_26_3_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_7" ,getValue(A_FSG_60_0_0_26_7), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_7_range" ,getValue(A_FSG_60_0_0_26_7_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Data_3" ,getValue(A_FSG_60_0_0_26_Data_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Data_3_0" ,getValue(A_FSG_60_0_0_26_Data_3_0), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Data_3_4" ,getValue(A_FSG_60_0_0_26_Data_3_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Data_3_5" ,getValue(A_FSG_60_0_0_26_Data_3_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Data_3_6" ,getValue(A_FSG_60_0_0_26_Data_3_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Data_3_7" ,getValue(A_FSG_60_0_0_26_Data_3_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_5" ,getValue(A_FSG_60_0_0_26_5), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_Data_2" ,getValue(A_FSG_60_0_0_26_Data_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_Data_2_range" ,getValue(A_FSG_60_0_0_26_Data_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_1" ,getValue(A_FSG_60_0_0_26_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Data_5_len" ,getValue(A_FSG_60_0_0_26_Data_5_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Data_5_cnt" ,getValue(A_FSG_60_0_0_26_Data_5_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_6" ,getValue(A_FSG_60_0_0_26_6), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_6_range" ,getValue(A_FSG_60_0_0_26_6_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_4" ,getValue(A_FSG_60_0_0_26_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_4_0" ,getValue(A_FSG_60_0_0_26_4_0), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_4_1" ,getValue(A_FSG_60_0_0_26_4_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_4_2" ,getValue(A_FSG_60_0_0_26_4_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_Data_1" ,getValue(A_FSG_60_0_0_26_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_Data_1_range" ,getValue(A_FSG_60_0_0_26_Data_1_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_RecAdr" ,getValue(A_FSG_60_0_0_26_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Direction" ,getValue(A_FSG_60_0_0_26_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Shift" ,getValue(A_FSG_60_0_0_26_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_TransPos" ,getValue(A_FSG_60_0_0_26_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_IndexSize" ,getValue(A_FSG_60_0_0_26_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Start" ,getValue(A_FSG_60_0_0_26_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Elements" ,getValue(A_FSG_60_0_0_26_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_2_Changed" ,getValue(A_FSG_60_0_0_26_2_Changed), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_1_Changed" ,getValue(A_FSG_60_0_0_26_1_Changed), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_3_Changed" ,getValue(A_FSG_60_0_0_26_3_Changed), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_3_Changed_range" ,getValue(A_FSG_60_0_0_26_3_Changed_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Changed_RecAdr" ,getValue(A_FSG_60_0_0_26_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Changed_Direction" ,getValue(A_FSG_60_0_0_26_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Changed_Shift" ,getValue(A_FSG_60_0_0_26_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Changed_TransPos" ,getValue(A_FSG_60_0_0_26_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Changed_IndexSize" ,getValue(A_FSG_60_0_0_26_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Changed_Start" ,getValue(A_FSG_60_0_0_26_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Changed_Elements" ,getValue(A_FSG_60_0_0_26_Changed_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_DataIndex_SetGet" ,getValue(A_FSG_60_0_0_26_DataIndex_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_DataIndex_SetGet_Incr" ,getValue(A_FSG_60_0_0_26_DataIndex_SetGet_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_DataIndex_SetGet_Decr" ,getValue(A_FSG_60_0_0_26_DataIndex_SetGet_Decr), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_Data_4_SetGet" ,getValue(A_FSG_60_0_0_26_Data_4_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_Data_4_SetGet_range" ,getValue(A_FSG_60_0_0_26_Data_4_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_2_SetGet" ,getValue(A_FSG_60_0_0_26_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_3_SetGet" ,getValue(A_FSG_60_0_0_26_3_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_3_SetGet_range" ,getValue(A_FSG_60_0_0_26_3_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Data_3_SetGet" ,getValue(A_FSG_60_0_0_26_Data_3_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Data_3_SetGet_0" ,getValue(A_FSG_60_0_0_26_Data_3_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Data_3_SetGet_4" ,getValue(A_FSG_60_0_0_26_Data_3_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Data_3_SetGet_5" ,getValue(A_FSG_60_0_0_26_Data_3_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Data_3_SetGet_6" ,getValue(A_FSG_60_0_0_26_Data_3_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Data_3_SetGet_7" ,getValue(A_FSG_60_0_0_26_Data_3_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_4_SetGet" ,getValue(A_FSG_60_0_0_26_4_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_Data_2_SetGet" ,getValue(A_FSG_60_0_0_26_Data_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_Data_2_SetGet_range" ,getValue(A_FSG_60_0_0_26_Data_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_1_SetGet" ,getValue(A_FSG_60_0_0_26_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Data_5_SetGet_len" ,getValue(A_FSG_60_0_0_26_Data_5_SetGet_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_Data_5_SetGet_cnt" ,getValue(A_FSG_60_0_0_26_Data_5_SetGet_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_5_SetGet" ,getValue(A_FSG_60_0_0_26_5_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_5_SetGet_range" ,getValue(A_FSG_60_0_0_26_5_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_Data_1_SetGet" ,getValue(A_FSG_60_0_0_26_Data_1_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_60_0_0_26_Data_1_SetGet_range" ,getValue(A_FSG_60_0_0_26_Data_1_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_SetGet_RecAdr" ,getValue(A_FSG_60_0_0_26_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_SetGet_Direction" ,getValue(A_FSG_60_0_0_26_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_SetGet_Shift" ,getValue(A_FSG_60_0_0_26_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_SetGet_IndexSize" ,getValue(A_FSG_60_0_0_26_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_SetGet_Start" ,getValue(A_FSG_60_0_0_26_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_60_0_0_26_SetGet_Elements" ,getValue(A_FSG_60_0_0_26_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"ERRORLIST_ASG18_1_VT" ,getValue(ERRORLIST_ASG18_1_VT), profileFile);
    writeProfileInt("BAP" ,"ON_OFF_ASG18_1" ,getValue(ON_OFF_ASG18_1), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_18_1_0_DFMajor" ,getValue(BAPCFG_ASG_18_1_0_DFMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_18_1_0_DFMinor" ,getValue(BAPCFG_ASG_18_1_0_DFMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_18_1_0_LsgClassMajor" ,getValue(BAPCFG_ASG_18_1_0_LsgClassMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_18_1_0_LsgClassMinor" ,getValue(BAPCFG_ASG_18_1_0_LsgClassMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_18_1_0_ProtocolMajor" ,getValue(BAPCFG_ASG_18_1_0_ProtocolMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_18_1_0_ProtocolMinor" ,getValue(BAPCFG_ASG_18_1_0_ProtocolMinor), profileFile);
    writeProfileInt("BAP" ,"C_ASG_18_1_0_1GetAll_BTN" ,getValue(C_ASG_18_1_0_1GetAll_BTN), profileFile);
    writeProfileInt("BAP" ,"C_ASG_18_1_0_1_FctLstItemEn" ,getValue(C_ASG_18_1_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_ASG_18_1_0_1_ErrCode" ,getValue(C_ASG_18_1_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_2Get_BTN" ,getValue(P_ASG_18_1_0_2Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_2_FctLstItemEn" ,getValue(P_ASG_18_1_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_2_ErrCode" ,getValue(P_ASG_18_1_0_2_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_2" ,getValue(P_ASG_18_1_0_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_2_range" ,getValue(P_ASG_18_1_0_2_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_3Get_BTN" ,getValue(P_ASG_18_1_0_3Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_3_FctLstItemEn" ,getValue(P_ASG_18_1_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_3_ErrCode" ,getValue(P_ASG_18_1_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_4Get_BTN" ,getValue(P_ASG_18_1_0_4Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_4_FctLstItemEn" ,getValue(P_ASG_18_1_0_4_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_4_ErrCode" ,getValue(P_ASG_18_1_0_4_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_4" ,getValue(P_ASG_18_1_0_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_4_range" ,getValue(P_ASG_18_1_0_4_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_13Get_BTN" ,getValue(P_ASG_18_1_0_13Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_13SetGet_BTN" ,getValue(P_ASG_18_1_0_13SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_13_FctLstItemEn" ,getValue(P_ASG_18_1_0_13_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_13_ErrCode" ,getValue(P_ASG_18_1_0_13_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_13" ,getValue(P_ASG_18_1_0_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_13_1" ,getValue(P_ASG_18_1_0_13_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_13_1_0" ,getValue(P_ASG_18_1_0_13_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_13_1_4" ,getValue(P_ASG_18_1_0_13_1_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_15Get_BTN" ,getValue(P_ASG_18_1_0_15Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_15_FctLstItemEn" ,getValue(P_ASG_18_1_0_15_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_15_ErrCode" ,getValue(P_ASG_18_1_0_15_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_15" ,getValue(P_ASG_18_1_0_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_15_1" ,getValue(P_ASG_18_1_0_15_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_16Get_BTN" ,getValue(P_ASG_18_1_0_16Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_16_FctLstItemEn" ,getValue(P_ASG_18_1_0_16_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_16_ErrCode" ,getValue(P_ASG_18_1_0_16_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_16_3" ,getValue(P_ASG_18_1_0_16_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_16_3_range" ,getValue(P_ASG_18_1_0_16_3_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_16_2" ,getValue(P_ASG_18_1_0_16_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_16_2_0" ,getValue(P_ASG_18_1_0_16_2_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_16_1" ,getValue(P_ASG_18_1_0_16_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_17Get_BTN" ,getValue(P_ASG_18_1_0_17Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_17_FctLstItemEn" ,getValue(P_ASG_18_1_0_17_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_17_ErrCode" ,getValue(P_ASG_18_1_0_17_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_17_1" ,getValue(P_ASG_18_1_0_17_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_17_2" ,getValue(P_ASG_18_1_0_17_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_17_2_range" ,getValue(P_ASG_18_1_0_17_2_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_18Get_BTN" ,getValue(P_ASG_18_1_0_18Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_18_FctLstItemEn" ,getValue(P_ASG_18_1_0_18_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_18_ErrCode" ,getValue(P_ASG_18_1_0_18_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_18_3" ,getValue(P_ASG_18_1_0_18_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_18_3_range" ,getValue(P_ASG_18_1_0_18_3_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_18_2" ,getValue(P_ASG_18_1_0_18_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_18_2_0" ,getValue(P_ASG_18_1_0_18_2_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_18_1" ,getValue(P_ASG_18_1_0_18_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_19Get_BTN" ,getValue(P_ASG_18_1_0_19Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_19_FctLstItemEn" ,getValue(P_ASG_18_1_0_19_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_19_ErrCode" ,getValue(P_ASG_18_1_0_19_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_19_1" ,getValue(P_ASG_18_1_0_19_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_19_2" ,getValue(P_ASG_18_1_0_19_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_19_2_range" ,getValue(P_ASG_18_1_0_19_2_range), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20StartResult_BTN" ,getValue(M_ASG_18_1_0_20StartResult_BTN), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_FctLstItemEn" ,getValue(M_ASG_18_1_0_20_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_ErrCode" ,getValue(M_ASG_18_1_0_20_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_Result" ,getValue(M_ASG_18_1_0_20_Result), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_Result_1" ,getValue(M_ASG_18_1_0_20_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_Result_1_0" ,getValue(M_ASG_18_1_0_20_Result_1_0), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_Result_1_1" ,getValue(M_ASG_18_1_0_20_Result_1_1), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_Result_1_2" ,getValue(M_ASG_18_1_0_20_Result_1_2), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_Result_1_3" ,getValue(M_ASG_18_1_0_20_Result_1_3), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_Processing" ,getValue(M_ASG_18_1_0_20_Processing), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_Processing_1" ,getValue(M_ASG_18_1_0_20_Processing_1), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_Processing_1_0" ,getValue(M_ASG_18_1_0_20_Processing_1_0), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_Processing_1_1" ,getValue(M_ASG_18_1_0_20_Processing_1_1), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_Processing_1_2" ,getValue(M_ASG_18_1_0_20_Processing_1_2), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_Processing_1_3" ,getValue(M_ASG_18_1_0_20_Processing_1_3), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_Start" ,getValue(M_ASG_18_1_0_20_Start), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_Start_1" ,getValue(M_ASG_18_1_0_20_Start_1), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_Start_1_0" ,getValue(M_ASG_18_1_0_20_Start_1_0), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_Start_1_1" ,getValue(M_ASG_18_1_0_20_Start_1_1), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_Start_1_2" ,getValue(M_ASG_18_1_0_20_Start_1_2), profileFile);
    writeProfileInt("BAP" ,"M_ASG_18_1_0_20_Start_1_3" ,getValue(M_ASG_18_1_0_20_Start_1_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_21Get_BTN" ,getValue(P_ASG_18_1_0_21Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_21SetGet_BTN" ,getValue(P_ASG_18_1_0_21SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_21_FctLstItemEn" ,getValue(P_ASG_18_1_0_21_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_21_ErrCode" ,getValue(P_ASG_18_1_0_21_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_18_1_0_21_3" ,getValue(P_ASG_18_1_0_21_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_18_1_0_21_3_range" ,getValue(P_ASG_18_1_0_21_3_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_21_2" ,getValue(P_ASG_18_1_0_21_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_21_2_0" ,getValue(P_ASG_18_1_0_21_2_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_21_1" ,getValue(P_ASG_18_1_0_21_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_21_4" ,getValue(P_ASG_18_1_0_21_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_21_5" ,getValue(P_ASG_18_1_0_21_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_21_5_0" ,getValue(P_ASG_18_1_0_21_5_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_22Get_BTN" ,getValue(P_ASG_18_1_0_22Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_22SetGet_BTN" ,getValue(P_ASG_18_1_0_22SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_22_FctLstItemEn" ,getValue(P_ASG_18_1_0_22_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_22_ErrCode" ,getValue(P_ASG_18_1_0_22_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_18_1_0_22_3" ,getValue(P_ASG_18_1_0_22_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_18_1_0_22_3_range" ,getValue(P_ASG_18_1_0_22_3_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_22_2" ,getValue(P_ASG_18_1_0_22_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_22_2_0" ,getValue(P_ASG_18_1_0_22_2_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_22_1" ,getValue(P_ASG_18_1_0_22_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_22_4" ,getValue(P_ASG_18_1_0_22_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_22_5" ,getValue(P_ASG_18_1_0_22_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_22_5_0" ,getValue(P_ASG_18_1_0_22_5_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_23Get_BTN" ,getValue(P_ASG_18_1_0_23Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_23SetGet_BTN" ,getValue(P_ASG_18_1_0_23SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_23_FctLstItemEn" ,getValue(P_ASG_18_1_0_23_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_23_ErrCode" ,getValue(P_ASG_18_1_0_23_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_18_1_0_23_3" ,getValue(P_ASG_18_1_0_23_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_18_1_0_23_3_range" ,getValue(P_ASG_18_1_0_23_3_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_23_2" ,getValue(P_ASG_18_1_0_23_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_23_2_0" ,getValue(P_ASG_18_1_0_23_2_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_23_1" ,getValue(P_ASG_18_1_0_23_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_23_4" ,getValue(P_ASG_18_1_0_23_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_23_5" ,getValue(P_ASG_18_1_0_23_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_23_5_0" ,getValue(P_ASG_18_1_0_23_5_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_24Get_BTN" ,getValue(P_ASG_18_1_0_24Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_24SetGet_BTN" ,getValue(P_ASG_18_1_0_24SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_24_FctLstItemEn" ,getValue(P_ASG_18_1_0_24_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_24_ErrCode" ,getValue(P_ASG_18_1_0_24_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_18_1_0_24_3" ,getValue(P_ASG_18_1_0_24_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_18_1_0_24_3_range" ,getValue(P_ASG_18_1_0_24_3_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_24_2" ,getValue(P_ASG_18_1_0_24_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_24_2_0" ,getValue(P_ASG_18_1_0_24_2_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_24_1" ,getValue(P_ASG_18_1_0_24_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_24_4" ,getValue(P_ASG_18_1_0_24_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_24_5" ,getValue(P_ASG_18_1_0_24_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_24_5_0" ,getValue(P_ASG_18_1_0_24_5_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_25Get_BTN" ,getValue(P_ASG_18_1_0_25Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_25_FctLstItemEn" ,getValue(P_ASG_18_1_0_25_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_25_ErrCode" ,getValue(P_ASG_18_1_0_25_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_25_1" ,getValue(P_ASG_18_1_0_25_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_25_1_range" ,getValue(P_ASG_18_1_0_25_1_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_25_2" ,getValue(P_ASG_18_1_0_25_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_25_2_0" ,getValue(P_ASG_18_1_0_25_2_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_25_3" ,getValue(P_ASG_18_1_0_25_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_18_1_0_25_3_range" ,getValue(P_ASG_18_1_0_25_3_range), profileFile);
    writeProfileInt("BAP" ,"ERRORLIST_ASG19_1_VT" ,getValue(ERRORLIST_ASG19_1_VT), profileFile);
    writeProfileInt("BAP" ,"BusType_ASG19_1" ,getValue(BusType_ASG19_1), profileFile);
    writeProfileInt("BAP" ,"ON_OFF_ASG19_1" ,getValue(ON_OFF_ASG19_1), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_19_1_0_DFMajor" ,getValue(BAPCFG_ASG_19_1_0_DFMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_19_1_0_DFMinor" ,getValue(BAPCFG_ASG_19_1_0_DFMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_19_1_0_LsgClassMajor" ,getValue(BAPCFG_ASG_19_1_0_LsgClassMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_19_1_0_LsgClassMinor" ,getValue(BAPCFG_ASG_19_1_0_LsgClassMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_19_1_0_ProtocolMajor" ,getValue(BAPCFG_ASG_19_1_0_ProtocolMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_19_1_0_ProtocolMinor" ,getValue(BAPCFG_ASG_19_1_0_ProtocolMinor), profileFile);
    writeProfileInt("BAP" ,"C_ASG_19_1_0_1GetAll_BTN" ,getValue(C_ASG_19_1_0_1GetAll_BTN), profileFile);
    writeProfileInt("BAP" ,"C_ASG_19_1_0_1_FctLstItemEn" ,getValue(C_ASG_19_1_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_ASG_19_1_0_1_ErrCode" ,getValue(C_ASG_19_1_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_2Get_BTN" ,getValue(P_ASG_19_1_0_2Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_2_FctLstItemEn" ,getValue(P_ASG_19_1_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_2_ErrCode" ,getValue(P_ASG_19_1_0_2_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_19_1_0_2" ,getValue(P_ASG_19_1_0_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_19_1_0_2_range" ,getValue(P_ASG_19_1_0_2_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_3Get_BTN" ,getValue(P_ASG_19_1_0_3Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_3_FctLstItemEn" ,getValue(P_ASG_19_1_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_3_ErrCode" ,getValue(P_ASG_19_1_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_4Get_BTN" ,getValue(P_ASG_19_1_0_4Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_4_FctLstItemEn" ,getValue(P_ASG_19_1_0_4_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_4_ErrCode" ,getValue(P_ASG_19_1_0_4_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_4" ,getValue(P_ASG_19_1_0_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_13Get_BTN" ,getValue(P_ASG_19_1_0_13Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_13SetGet_BTN" ,getValue(P_ASG_19_1_0_13SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_13_FctLstItemEn" ,getValue(P_ASG_19_1_0_13_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_13_ErrCode" ,getValue(P_ASG_19_1_0_13_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_13" ,getValue(P_ASG_19_1_0_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_13_1" ,getValue(P_ASG_19_1_0_13_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_13_1_0" ,getValue(P_ASG_19_1_0_13_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_13_1_4" ,getValue(P_ASG_19_1_0_13_1_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_14Get_BTN" ,getValue(P_ASG_19_1_0_14Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_14_FctLstItemEn" ,getValue(P_ASG_19_1_0_14_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_14_ErrCode" ,getValue(P_ASG_19_1_0_14_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_14" ,getValue(P_ASG_19_1_0_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_14_1" ,getValue(P_ASG_19_1_0_14_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_14_1_0" ,getValue(P_ASG_19_1_0_14_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_14_1_1" ,getValue(P_ASG_19_1_0_14_1_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_15Get_BTN" ,getValue(P_ASG_19_1_0_15Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_15_FctLstItemEn" ,getValue(P_ASG_19_1_0_15_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_15_ErrCode" ,getValue(P_ASG_19_1_0_15_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_15" ,getValue(P_ASG_19_1_0_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_15_1" ,getValue(P_ASG_19_1_0_15_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_16Get_BTN" ,getValue(P_ASG_19_1_0_16Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_16SetGet_BTN" ,getValue(P_ASG_19_1_0_16SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_16_FctLstItemEn" ,getValue(P_ASG_19_1_0_16_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_16_ErrCode" ,getValue(P_ASG_19_1_0_16_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_16" ,getValue(P_ASG_19_1_0_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_16_1" ,getValue(P_ASG_19_1_0_16_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_17Get_BTN" ,getValue(P_ASG_19_1_0_17Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_17SetGet_BTN" ,getValue(P_ASG_19_1_0_17SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_17_FctLstItemEn" ,getValue(P_ASG_19_1_0_17_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_17_ErrCode" ,getValue(P_ASG_19_1_0_17_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_17" ,getValue(P_ASG_19_1_0_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_17_1" ,getValue(P_ASG_19_1_0_17_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_18Get_BTN" ,getValue(P_ASG_19_1_0_18Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_18SetGet_BTN" ,getValue(P_ASG_19_1_0_18SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_18_FctLstItemEn" ,getValue(P_ASG_19_1_0_18_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_18_ErrCode" ,getValue(P_ASG_19_1_0_18_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_18_1" ,getValue(P_ASG_19_1_0_18_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_18_2" ,getValue(P_ASG_19_1_0_18_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_19Get_BTN" ,getValue(P_ASG_19_1_0_19Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_19SetGet_BTN" ,getValue(P_ASG_19_1_0_19SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_19_FctLstItemEn" ,getValue(P_ASG_19_1_0_19_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_19_ErrCode" ,getValue(P_ASG_19_1_0_19_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_19" ,getValue(P_ASG_19_1_0_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_19_1" ,getValue(P_ASG_19_1_0_19_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_20Get_BTN" ,getValue(P_ASG_19_1_0_20Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_20SetGet_BTN" ,getValue(P_ASG_19_1_0_20SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_20_FctLstItemEn" ,getValue(P_ASG_19_1_0_20_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_20_ErrCode" ,getValue(P_ASG_19_1_0_20_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_20" ,getValue(P_ASG_19_1_0_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_20_1" ,getValue(P_ASG_19_1_0_20_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_21Get_BTN" ,getValue(P_ASG_19_1_0_21Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_21SetGet_BTN" ,getValue(P_ASG_19_1_0_21SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_21_FctLstItemEn" ,getValue(P_ASG_19_1_0_21_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_21_ErrCode" ,getValue(P_ASG_19_1_0_21_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_21_2" ,getValue(P_ASG_19_1_0_21_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_21_1" ,getValue(P_ASG_19_1_0_21_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_22Get_BTN" ,getValue(P_ASG_19_1_0_22Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_22SetGet_BTN" ,getValue(P_ASG_19_1_0_22SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_22_FctLstItemEn" ,getValue(P_ASG_19_1_0_22_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_22_ErrCode" ,getValue(P_ASG_19_1_0_22_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_22" ,getValue(P_ASG_19_1_0_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_22_1" ,getValue(P_ASG_19_1_0_22_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_23Get_BTN" ,getValue(P_ASG_19_1_0_23Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_23SetGet_BTN" ,getValue(P_ASG_19_1_0_23SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_23_FctLstItemEn" ,getValue(P_ASG_19_1_0_23_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_23_ErrCode" ,getValue(P_ASG_19_1_0_23_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_23" ,getValue(P_ASG_19_1_0_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_23_1" ,getValue(P_ASG_19_1_0_23_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_24Get_BTN" ,getValue(P_ASG_19_1_0_24Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_24SetGet_BTN" ,getValue(P_ASG_19_1_0_24SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_24_FctLstItemEn" ,getValue(P_ASG_19_1_0_24_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_24_ErrCode" ,getValue(P_ASG_19_1_0_24_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_24" ,getValue(P_ASG_19_1_0_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_24_1" ,getValue(P_ASG_19_1_0_24_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_25Get_BTN" ,getValue(P_ASG_19_1_0_25Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_25_FctLstItemEn" ,getValue(P_ASG_19_1_0_25_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_25_ErrCode" ,getValue(P_ASG_19_1_0_25_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_19_1_0_25_6" ,getValue(P_ASG_19_1_0_25_6), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_19_1_0_25_6_range" ,getValue(P_ASG_19_1_0_25_6_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_25_1" ,getValue(P_ASG_19_1_0_25_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_25_1_0" ,getValue(P_ASG_19_1_0_25_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_25_1_1" ,getValue(P_ASG_19_1_0_25_1_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_25_1_2" ,getValue(P_ASG_19_1_0_25_1_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_25_1_3" ,getValue(P_ASG_19_1_0_25_1_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_25_1_4" ,getValue(P_ASG_19_1_0_25_1_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_25_1_5" ,getValue(P_ASG_19_1_0_25_1_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_25_1_6" ,getValue(P_ASG_19_1_0_25_1_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_25_1_7" ,getValue(P_ASG_19_1_0_25_1_7), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_19_1_0_25_5" ,getValue(P_ASG_19_1_0_25_5), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_19_1_0_25_5_range" ,getValue(P_ASG_19_1_0_25_5_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_19_1_0_25_4" ,getValue(P_ASG_19_1_0_25_4), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_19_1_0_25_4_range" ,getValue(P_ASG_19_1_0_25_4_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_19_1_0_25_3" ,getValue(P_ASG_19_1_0_25_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_19_1_0_25_3_range" ,getValue(P_ASG_19_1_0_25_3_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_19_1_0_25_2" ,getValue(P_ASG_19_1_0_25_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_19_1_0_25_2_range" ,getValue(P_ASG_19_1_0_25_2_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_26Get_BTN" ,getValue(P_ASG_19_1_0_26Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_26SetGet_BTN" ,getValue(P_ASG_19_1_0_26SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_26_FctLstItemEn" ,getValue(P_ASG_19_1_0_26_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_26_ErrCode" ,getValue(P_ASG_19_1_0_26_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_26_2" ,getValue(P_ASG_19_1_0_26_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_26_1" ,getValue(P_ASG_19_1_0_26_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_26_3" ,getValue(P_ASG_19_1_0_26_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_26_3_0" ,getValue(P_ASG_19_1_0_26_3_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_27Get_BTN" ,getValue(P_ASG_19_1_0_27Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_27SetGet_BTN" ,getValue(P_ASG_19_1_0_27SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_27_FctLstItemEn" ,getValue(P_ASG_19_1_0_27_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_27_ErrCode" ,getValue(P_ASG_19_1_0_27_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_19_1_0_27_1" ,getValue(P_ASG_19_1_0_27_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_19_1_0_27_2" ,getValue(P_ASG_19_1_0_27_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_19_1_0_27_2_range" ,getValue(P_ASG_19_1_0_27_2_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28Get_BTN" ,getValue(A_ASG_19_1_0_28Get_BTN), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28SetGet_BTN" ,getValue(A_ASG_19_1_0_28SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_FctLstItemEn" ,getValue(A_ASG_19_1_0_28_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_IntTlgEn" ,getValue(A_ASG_19_1_0_28_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_SegmEn" ,getValue(A_ASG_19_1_0_28_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_AT" ,getValue(A_ASG_19_1_0_28_AT), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_ErrCode" ,getValue(A_ASG_19_1_0_28_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_DataIndex_SetGet_Incr" ,getValue(A_ASG_19_1_0_28_DataIndex_SetGet_Incr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_DataIndex_Incr" ,getValue(A_ASG_19_1_0_28_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_DataIndex_Decr" ,getValue(A_ASG_19_1_0_28_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_loadArray_Btn" ,getValue(A_ASG_19_1_0_28_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_generateData_Btn" ,getValue(A_ASG_19_1_0_28_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_2" ,getValue(A_ASG_19_1_0_28_2), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_3" ,getValue(A_ASG_19_1_0_28_3), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_3_range" ,getValue(A_ASG_19_1_0_28_3_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_7" ,getValue(A_ASG_19_1_0_28_7), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_7_range" ,getValue(A_ASG_19_1_0_28_7_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Data_3" ,getValue(A_ASG_19_1_0_28_Data_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Data_3_0" ,getValue(A_ASG_19_1_0_28_Data_3_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Data_3_1" ,getValue(A_ASG_19_1_0_28_Data_3_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Data_3_4" ,getValue(A_ASG_19_1_0_28_Data_3_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Data_3_5" ,getValue(A_ASG_19_1_0_28_Data_3_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Data_3_6" ,getValue(A_ASG_19_1_0_28_Data_3_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Data_3_7" ,getValue(A_ASG_19_1_0_28_Data_3_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_5" ,getValue(A_ASG_19_1_0_28_5), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_Data_2_SetGet_range" ,getValue(A_ASG_19_1_0_28_Data_2_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_Data_2_range" ,getValue(A_ASG_19_1_0_28_Data_2_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_1" ,getValue(A_ASG_19_1_0_28_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Data_4_len" ,getValue(A_ASG_19_1_0_28_Data_4_len), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_6" ,getValue(A_ASG_19_1_0_28_6), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_6_range" ,getValue(A_ASG_19_1_0_28_6_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_4" ,getValue(A_ASG_19_1_0_28_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_4_0" ,getValue(A_ASG_19_1_0_28_4_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_4_1" ,getValue(A_ASG_19_1_0_28_4_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_4_2" ,getValue(A_ASG_19_1_0_28_4_2), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_Data_1_SetGet_range" ,getValue(A_ASG_19_1_0_28_Data_1_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_Data_1_range" ,getValue(A_ASG_19_1_0_28_Data_1_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_RecAdr" ,getValue(A_ASG_19_1_0_28_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Direction" ,getValue(A_ASG_19_1_0_28_Direction), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Shift" ,getValue(A_ASG_19_1_0_28_Shift), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_TransPos" ,getValue(A_ASG_19_1_0_28_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_IndexSize" ,getValue(A_ASG_19_1_0_28_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Start" ,getValue(A_ASG_19_1_0_28_Start), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Elements" ,getValue(A_ASG_19_1_0_28_Elements), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_2_Changed" ,getValue(A_ASG_19_1_0_28_2_Changed), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_1_Changed" ,getValue(A_ASG_19_1_0_28_1_Changed), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_3_Changed" ,getValue(A_ASG_19_1_0_28_3_Changed), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_3_Changed_range" ,getValue(A_ASG_19_1_0_28_3_Changed_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Changed_RecAdr" ,getValue(A_ASG_19_1_0_28_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Changed_Direction" ,getValue(A_ASG_19_1_0_28_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Changed_Shift" ,getValue(A_ASG_19_1_0_28_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Changed_TransPos" ,getValue(A_ASG_19_1_0_28_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Changed_IndexSize" ,getValue(A_ASG_19_1_0_28_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Changed_Start" ,getValue(A_ASG_19_1_0_28_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Changed_Elements" ,getValue(A_ASG_19_1_0_28_Changed_Elements), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_DataIndex_SetGet" ,getValue(A_ASG_19_1_0_28_DataIndex_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_DataIndex_SetGet_Incr" ,getValue(A_ASG_19_1_0_28_DataIndex_SetGet_Incr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_DataIndex_SetGet_Decr" ,getValue(A_ASG_19_1_0_28_DataIndex_SetGet_Decr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_2_SetGet" ,getValue(A_ASG_19_1_0_28_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_3_SetGet" ,getValue(A_ASG_19_1_0_28_3_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_3_SetGet_range" ,getValue(A_ASG_19_1_0_28_3_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Data_3_SetGet" ,getValue(A_ASG_19_1_0_28_Data_3_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Data_3_SetGet_0" ,getValue(A_ASG_19_1_0_28_Data_3_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Data_3_SetGet_1" ,getValue(A_ASG_19_1_0_28_Data_3_SetGet_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Data_3_SetGet_4" ,getValue(A_ASG_19_1_0_28_Data_3_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Data_3_SetGet_5" ,getValue(A_ASG_19_1_0_28_Data_3_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Data_3_SetGet_6" ,getValue(A_ASG_19_1_0_28_Data_3_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Data_3_SetGet_7" ,getValue(A_ASG_19_1_0_28_Data_3_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_4_SetGet" ,getValue(A_ASG_19_1_0_28_4_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_Data_2_SetGet_range" ,getValue(A_ASG_19_1_0_28_Data_2_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_Data_2_SetGet_range" ,getValue(A_ASG_19_1_0_28_Data_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_1_SetGet" ,getValue(A_ASG_19_1_0_28_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_Data_4_SetGet_len" ,getValue(A_ASG_19_1_0_28_Data_4_SetGet_len), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_5_SetGet" ,getValue(A_ASG_19_1_0_28_5_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_5_SetGet_range" ,getValue(A_ASG_19_1_0_28_5_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_Data_1_SetGet_range" ,getValue(A_ASG_19_1_0_28_Data_1_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_19_1_0_28_Data_1_SetGet_range" ,getValue(A_ASG_19_1_0_28_Data_1_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_SetGet_RecAdr" ,getValue(A_ASG_19_1_0_28_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_SetGet_Direction" ,getValue(A_ASG_19_1_0_28_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_SetGet_Shift" ,getValue(A_ASG_19_1_0_28_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_SetGet_IndexSize" ,getValue(A_ASG_19_1_0_28_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_SetGet_Start" ,getValue(A_ASG_19_1_0_28_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_ASG_19_1_0_28_SetGet_Elements" ,getValue(A_ASG_19_1_0_28_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"C_FSG_33_0_0_0_1_FctLstItemEn" ,getValue(C_FSG_33_0_0_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_33_0_0_0_1_FctEn" ,getValue(C_FSG_33_0_0_0_1_FctEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_33_0_0_0_1_ErrEn" ,getValue(C_FSG_33_0_0_0_1_ErrEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_33_0_0_0_1_IntTlgEn" ,getValue(C_FSG_33_0_0_0_1_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_33_0_0_0_1_SegmEn" ,getValue(C_FSG_33_0_0_0_1_SegmEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_33_0_0_0_1_ErrCode" ,getValue(C_FSG_33_0_0_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_0_2Reset_BTN" ,getValue(P_FSG_33_0_0_0_2Reset_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_0_2_FctLstItemEn" ,getValue(P_FSG_33_0_0_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_0_2_FctEn" ,getValue(P_FSG_33_0_0_0_2_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_0_2_ErrEn" ,getValue(P_FSG_33_0_0_0_2_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_0_2_ErrCode" ,getValue(P_FSG_33_0_0_0_2_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_0_3_FctLstItemEn" ,getValue(P_FSG_33_0_0_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_0_3_FctEn" ,getValue(P_FSG_33_0_0_0_3_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_0_3_ErrEn" ,getValue(P_FSG_33_0_0_0_3_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_0_3_IntTlgEn" ,getValue(P_FSG_33_0_0_0_3_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_0_3_SegmEn" ,getValue(P_FSG_33_0_0_0_3_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_0_3_ErrCode" ,getValue(P_FSG_33_0_0_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"FSG33_0_0_Channel" ,getValue(FSG33_0_0_Channel), profileFile);
    writeProfileInt("BAP" ,"FSG33_0_0_BusType" ,getValue(FSG33_0_0_BusType), profileFile);
    writeProfileInt("BAP" ,"FSG33_0_1_Channel" ,getValue(FSG33_0_1_Channel), profileFile);
    writeProfileInt("BAP" ,"FSG33_0_1_BusType" ,getValue(FSG33_0_1_BusType), profileFile);
    writeProfileInt("BAP" ,"FSG33_0_2_Channel" ,getValue(FSG33_0_2_Channel), profileFile);
    writeProfileInt("BAP" ,"FSG33_0_2_BusType" ,getValue(FSG33_0_2_BusType), profileFile);
    writeProfileInt("BAP" ,"FSG33_0_3_Channel" ,getValue(FSG33_0_3_Channel), profileFile);
    writeProfileInt("BAP" ,"FSG33_0_3_BusType" ,getValue(FSG33_0_3_BusType), profileFile);
    writeProfileInt("BAP" ,"FSG33_0_4_Channel" ,getValue(FSG33_0_4_Channel), profileFile);
    writeProfileInt("BAP" ,"FSG33_0_4_BusType" ,getValue(FSG33_0_4_BusType), profileFile);
    writeProfileInt("BAP" ,"ERRORLIST_FSG33_0_VT" ,getValue(ERRORLIST_FSG33_0_VT), profileFile);
    writeProfileInt("BAP" ,"BusType_FSG33_0" ,getValue(BusType_FSG33_0), profileFile);
    writeProfileInt("BAP" ,"ON_OFF_FSG33_0" ,getValue(ON_OFF_FSG33_0), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_33_0_0_DFMajor" ,getValue(BAPCFG_FSG_33_0_0_DFMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_33_0_0_DFMinor" ,getValue(BAPCFG_FSG_33_0_0_DFMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_33_0_0_LsgClassMajor" ,getValue(BAPCFG_FSG_33_0_0_LsgClassMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_33_0_0_LsgClassMinor" ,getValue(BAPCFG_FSG_33_0_0_LsgClassMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_33_0_0_ProtocolMajor" ,getValue(BAPCFG_FSG_33_0_0_ProtocolMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_33_0_0_ProtocolMinor" ,getValue(BAPCFG_FSG_33_0_0_ProtocolMinor), profileFile);
    writeProfileInt("BAP" ,"C_FSG_33_0_0_1_FctLstItemEn" ,getValue(C_FSG_33_0_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_33_0_0_1_FctEn" ,getValue(C_FSG_33_0_0_1_FctEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_33_0_0_1_ErrEn" ,getValue(C_FSG_33_0_0_1_ErrEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_33_0_0_1_IntTlgEn" ,getValue(C_FSG_33_0_0_1_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_33_0_0_1_SegmEn" ,getValue(C_FSG_33_0_0_1_SegmEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_33_0_0_1_ErrCode" ,getValue(C_FSG_33_0_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_2Reset_BTN" ,getValue(P_FSG_33_0_0_2Reset_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_2_FctLstItemEn" ,getValue(P_FSG_33_0_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_2_FctEn" ,getValue(P_FSG_33_0_0_2_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_2_ErrEn" ,getValue(P_FSG_33_0_0_2_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_2_ErrCode" ,getValue(P_FSG_33_0_0_2_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_2" ,getValue(P_FSG_33_0_0_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_2_range" ,getValue(P_FSG_33_0_0_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_3Status_BTN" ,getValue(P_FSG_33_0_0_3Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_3_FctLstItemEn" ,getValue(P_FSG_33_0_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_3_FctEn" ,getValue(P_FSG_33_0_0_3_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_3_ErrEn" ,getValue(P_FSG_33_0_0_3_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_3_IntTlgEn" ,getValue(P_FSG_33_0_0_3_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_3_SegmEn" ,getValue(P_FSG_33_0_0_3_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_3_ErrCode" ,getValue(P_FSG_33_0_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_4Status_BTN" ,getValue(P_FSG_33_0_0_4Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_4_FctLstItemEn" ,getValue(P_FSG_33_0_0_4_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_4_FctEn" ,getValue(P_FSG_33_0_0_4_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_4_ErrEn" ,getValue(P_FSG_33_0_0_4_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_4_ErrCode" ,getValue(P_FSG_33_0_0_4_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_4" ,getValue(P_FSG_33_0_0_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_13Status_BTN" ,getValue(P_FSG_33_0_0_13Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_13_FctLstItemEn" ,getValue(P_FSG_33_0_0_13_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_13_FctEn" ,getValue(P_FSG_33_0_0_13_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_13_ErrEn" ,getValue(P_FSG_33_0_0_13_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_13_ErrCode" ,getValue(P_FSG_33_0_0_13_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_13" ,getValue(P_FSG_33_0_0_13), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_13_1" ,getValue(P_FSG_33_0_0_13_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_13_1_0" ,getValue(P_FSG_33_0_0_13_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_13_1_4" ,getValue(P_FSG_33_0_0_13_1_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_14Status_BTN" ,getValue(P_FSG_33_0_0_14Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_14_FctLstItemEn" ,getValue(P_FSG_33_0_0_14_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_14_FctEn" ,getValue(P_FSG_33_0_0_14_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_14_ErrEn" ,getValue(P_FSG_33_0_0_14_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_14_ErrCode" ,getValue(P_FSG_33_0_0_14_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_14_2" ,getValue(P_FSG_33_0_0_14_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_14_2_range" ,getValue(P_FSG_33_0_0_14_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_14_1" ,getValue(P_FSG_33_0_0_14_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_14_1_0" ,getValue(P_FSG_33_0_0_14_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_14_1_1" ,getValue(P_FSG_33_0_0_14_1_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_14_3" ,getValue(P_FSG_33_0_0_14_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_14_3_range" ,getValue(P_FSG_33_0_0_14_3_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_15Status_BTN" ,getValue(P_FSG_33_0_0_15Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_15_FctLstItemEn" ,getValue(P_FSG_33_0_0_15_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_15_FctEn" ,getValue(P_FSG_33_0_0_15_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_15_ErrEn" ,getValue(P_FSG_33_0_0_15_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_15_ErrCode" ,getValue(P_FSG_33_0_0_15_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_15" ,getValue(P_FSG_33_0_0_15), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_15_1" ,getValue(P_FSG_33_0_0_15_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16Status_BTN" ,getValue(P_FSG_33_0_0_16Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_FctLstItemEn" ,getValue(P_FSG_33_0_0_16_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_FctEn" ,getValue(P_FSG_33_0_0_16_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_ErrEn" ,getValue(P_FSG_33_0_0_16_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_IntTlgEn" ,getValue(P_FSG_33_0_0_16_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_SegmEn" ,getValue(P_FSG_33_0_0_16_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_ErrCode" ,getValue(P_FSG_33_0_0_16_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_3" ,getValue(P_FSG_33_0_0_16_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_4_len" ,getValue(P_FSG_33_0_0_16_4_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_4_cnt" ,getValue(P_FSG_33_0_0_16_4_cnt), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_16_7" ,getValue(P_FSG_33_0_0_16_7), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_16_7_range" ,getValue(P_FSG_33_0_0_16_7_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_10" ,getValue(P_FSG_33_0_0_16_10), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_10_0" ,getValue(P_FSG_33_0_0_16_10_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_10_1" ,getValue(P_FSG_33_0_0_16_10_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_10_2" ,getValue(P_FSG_33_0_0_16_10_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_10_3" ,getValue(P_FSG_33_0_0_16_10_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_10_4" ,getValue(P_FSG_33_0_0_16_10_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_10_5" ,getValue(P_FSG_33_0_0_16_10_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_10_6" ,getValue(P_FSG_33_0_0_16_10_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_10_7" ,getValue(P_FSG_33_0_0_16_10_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_10_8" ,getValue(P_FSG_33_0_0_16_10_8), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_10_9" ,getValue(P_FSG_33_0_0_16_10_9), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_10_10" ,getValue(P_FSG_33_0_0_16_10_10), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_10_11" ,getValue(P_FSG_33_0_0_16_10_11), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_10_12" ,getValue(P_FSG_33_0_0_16_10_12), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_11" ,getValue(P_FSG_33_0_0_16_11), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_14_len" ,getValue(P_FSG_33_0_0_16_14_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_14_cnt" ,getValue(P_FSG_33_0_0_16_14_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_6" ,getValue(P_FSG_33_0_0_16_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_1" ,getValue(P_FSG_33_0_0_16_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_15" ,getValue(P_FSG_33_0_0_16_15), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_15_0" ,getValue(P_FSG_33_0_0_16_15_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_15_1" ,getValue(P_FSG_33_0_0_16_15_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_15_2" ,getValue(P_FSG_33_0_0_16_15_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_15_3" ,getValue(P_FSG_33_0_0_16_15_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_15_4" ,getValue(P_FSG_33_0_0_16_15_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_15_5" ,getValue(P_FSG_33_0_0_16_15_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_15_6" ,getValue(P_FSG_33_0_0_16_15_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_15_7" ,getValue(P_FSG_33_0_0_16_15_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_15_8" ,getValue(P_FSG_33_0_0_16_15_8), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_15_9" ,getValue(P_FSG_33_0_0_16_15_9), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_15_10" ,getValue(P_FSG_33_0_0_16_15_10), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_15_11" ,getValue(P_FSG_33_0_0_16_15_11), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_15_12" ,getValue(P_FSG_33_0_0_16_15_12), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_9_len" ,getValue(P_FSG_33_0_0_16_9_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_9_cnt" ,getValue(P_FSG_33_0_0_16_9_cnt), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_16_2" ,getValue(P_FSG_33_0_0_16_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_16_2_range" ,getValue(P_FSG_33_0_0_16_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_5" ,getValue(P_FSG_33_0_0_16_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_5_0" ,getValue(P_FSG_33_0_0_16_5_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_5_1" ,getValue(P_FSG_33_0_0_16_5_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_5_2" ,getValue(P_FSG_33_0_0_16_5_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_5_3" ,getValue(P_FSG_33_0_0_16_5_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_5_4" ,getValue(P_FSG_33_0_0_16_5_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_5_5" ,getValue(P_FSG_33_0_0_16_5_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_5_6" ,getValue(P_FSG_33_0_0_16_5_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_5_7" ,getValue(P_FSG_33_0_0_16_5_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_5_8" ,getValue(P_FSG_33_0_0_16_5_8), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_5_9" ,getValue(P_FSG_33_0_0_16_5_9), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_5_10" ,getValue(P_FSG_33_0_0_16_5_10), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_5_11" ,getValue(P_FSG_33_0_0_16_5_11), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_5_12" ,getValue(P_FSG_33_0_0_16_5_12), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_13" ,getValue(P_FSG_33_0_0_16_13), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_16_12" ,getValue(P_FSG_33_0_0_16_12), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_16_12_range" ,getValue(P_FSG_33_0_0_16_12_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_16_8" ,getValue(P_FSG_33_0_0_16_8), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_17Status_BTN" ,getValue(P_FSG_33_0_0_17Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_17_FctLstItemEn" ,getValue(P_FSG_33_0_0_17_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_17_FctEn" ,getValue(P_FSG_33_0_0_17_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_17_ErrEn" ,getValue(P_FSG_33_0_0_17_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_17_ErrCode" ,getValue(P_FSG_33_0_0_17_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_17_2" ,getValue(P_FSG_33_0_0_17_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_17_1" ,getValue(P_FSG_33_0_0_17_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_17_1_0" ,getValue(P_FSG_33_0_0_17_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_18Status_BTN" ,getValue(P_FSG_33_0_0_18Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_18_FctLstItemEn" ,getValue(P_FSG_33_0_0_18_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_18_FctEn" ,getValue(P_FSG_33_0_0_18_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_18_ErrEn" ,getValue(P_FSG_33_0_0_18_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_18_ErrCode" ,getValue(P_FSG_33_0_0_18_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_18" ,getValue(P_FSG_33_0_0_18), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_18_1" ,getValue(P_FSG_33_0_0_18_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_18_1_0" ,getValue(P_FSG_33_0_0_18_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19Status_BTN" ,getValue(P_FSG_33_0_0_19Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19_FctLstItemEn" ,getValue(P_FSG_33_0_0_19_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19_FctEn" ,getValue(P_FSG_33_0_0_19_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19_ErrEn" ,getValue(P_FSG_33_0_0_19_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19_ErrCode" ,getValue(P_FSG_33_0_0_19_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19_1" ,getValue(P_FSG_33_0_0_19_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19_1_0" ,getValue(P_FSG_33_0_0_19_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19_1_1" ,getValue(P_FSG_33_0_0_19_1_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19_1_2" ,getValue(P_FSG_33_0_0_19_1_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19_1_3" ,getValue(P_FSG_33_0_0_19_1_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19_1_4" ,getValue(P_FSG_33_0_0_19_1_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19_1_5" ,getValue(P_FSG_33_0_0_19_1_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19_1_6" ,getValue(P_FSG_33_0_0_19_1_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19_1_7" ,getValue(P_FSG_33_0_0_19_1_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19_2" ,getValue(P_FSG_33_0_0_19_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19_2_0" ,getValue(P_FSG_33_0_0_19_2_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19_2_1" ,getValue(P_FSG_33_0_0_19_2_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19_2_2" ,getValue(P_FSG_33_0_0_19_2_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_19_2_3" ,getValue(P_FSG_33_0_0_19_2_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_19_3" ,getValue(P_FSG_33_0_0_19_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_19_3_range" ,getValue(P_FSG_33_0_0_19_3_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_20Status_BTN" ,getValue(P_FSG_33_0_0_20Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_20_FctLstItemEn" ,getValue(P_FSG_33_0_0_20_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_20_FctEn" ,getValue(P_FSG_33_0_0_20_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_20_ErrEn" ,getValue(P_FSG_33_0_0_20_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_20_ErrCode" ,getValue(P_FSG_33_0_0_20_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_20_2" ,getValue(P_FSG_33_0_0_20_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_20_2_range" ,getValue(P_FSG_33_0_0_20_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_20_3" ,getValue(P_FSG_33_0_0_20_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_20_1" ,getValue(P_FSG_33_0_0_20_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_20_1_0" ,getValue(P_FSG_33_0_0_20_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_20_4" ,getValue(P_FSG_33_0_0_20_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_20_5" ,getValue(P_FSG_33_0_0_20_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_20_5_0" ,getValue(P_FSG_33_0_0_20_5_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_21Status_BTN" ,getValue(P_FSG_33_0_0_21Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_21_FctLstItemEn" ,getValue(P_FSG_33_0_0_21_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_21_FctEn" ,getValue(P_FSG_33_0_0_21_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_21_ErrEn" ,getValue(P_FSG_33_0_0_21_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_21_ErrCode" ,getValue(P_FSG_33_0_0_21_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_21_2" ,getValue(P_FSG_33_0_0_21_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_21_1" ,getValue(P_FSG_33_0_0_21_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_21_1_range" ,getValue(P_FSG_33_0_0_21_1_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_21_3" ,getValue(P_FSG_33_0_0_21_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_21_4" ,getValue(P_FSG_33_0_0_21_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_21_4_0" ,getValue(P_FSG_33_0_0_21_4_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_22Status_BTN" ,getValue(P_FSG_33_0_0_22Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_22_FctLstItemEn" ,getValue(P_FSG_33_0_0_22_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_22_FctEn" ,getValue(P_FSG_33_0_0_22_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_22_ErrEn" ,getValue(P_FSG_33_0_0_22_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_22_ErrCode" ,getValue(P_FSG_33_0_0_22_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_22_1" ,getValue(P_FSG_33_0_0_22_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_22_1_0" ,getValue(P_FSG_33_0_0_22_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_22_2" ,getValue(P_FSG_33_0_0_22_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_22_3" ,getValue(P_FSG_33_0_0_22_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_22_3_0" ,getValue(P_FSG_33_0_0_22_3_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23Status_BTN" ,getValue(P_FSG_33_0_0_23Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_FctLstItemEn" ,getValue(P_FSG_33_0_0_23_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_FctEn" ,getValue(P_FSG_33_0_0_23_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_ErrEn" ,getValue(P_FSG_33_0_0_23_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_IntTlgEn" ,getValue(P_FSG_33_0_0_23_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_SegmEn" ,getValue(P_FSG_33_0_0_23_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_ErrCode" ,getValue(P_FSG_33_0_0_23_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_10" ,getValue(P_FSG_33_0_0_23_10), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_10_0" ,getValue(P_FSG_33_0_0_23_10_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_10_1" ,getValue(P_FSG_33_0_0_23_10_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_10_2" ,getValue(P_FSG_33_0_0_23_10_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_10_3" ,getValue(P_FSG_33_0_0_23_10_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_10_4" ,getValue(P_FSG_33_0_0_23_10_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_10_5" ,getValue(P_FSG_33_0_0_23_10_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_10_6" ,getValue(P_FSG_33_0_0_23_10_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_10_7" ,getValue(P_FSG_33_0_0_23_10_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_10_8" ,getValue(P_FSG_33_0_0_23_10_8), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_10_9" ,getValue(P_FSG_33_0_0_23_10_9), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_10_10" ,getValue(P_FSG_33_0_0_23_10_10), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_10_11" ,getValue(P_FSG_33_0_0_23_10_11), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_10_12" ,getValue(P_FSG_33_0_0_23_10_12), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_4_len" ,getValue(P_FSG_33_0_0_23_4_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_4_cnt" ,getValue(P_FSG_33_0_0_23_4_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_6" ,getValue(P_FSG_33_0_0_23_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_1" ,getValue(P_FSG_33_0_0_23_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_23_7" ,getValue(P_FSG_33_0_0_23_7), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_23_7_range" ,getValue(P_FSG_33_0_0_23_7_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_23_2" ,getValue(P_FSG_33_0_0_23_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_33_0_0_23_2_range" ,getValue(P_FSG_33_0_0_23_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_5" ,getValue(P_FSG_33_0_0_23_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_5_0" ,getValue(P_FSG_33_0_0_23_5_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_5_1" ,getValue(P_FSG_33_0_0_23_5_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_5_2" ,getValue(P_FSG_33_0_0_23_5_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_5_3" ,getValue(P_FSG_33_0_0_23_5_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_5_4" ,getValue(P_FSG_33_0_0_23_5_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_5_5" ,getValue(P_FSG_33_0_0_23_5_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_5_6" ,getValue(P_FSG_33_0_0_23_5_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_5_7" ,getValue(P_FSG_33_0_0_23_5_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_5_8" ,getValue(P_FSG_33_0_0_23_5_8), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_5_9" ,getValue(P_FSG_33_0_0_23_5_9), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_5_10" ,getValue(P_FSG_33_0_0_23_5_10), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_5_11" ,getValue(P_FSG_33_0_0_23_5_11), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_5_12" ,getValue(P_FSG_33_0_0_23_5_12), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_8" ,getValue(P_FSG_33_0_0_23_8), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_9_len" ,getValue(P_FSG_33_0_0_23_9_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_9_cnt" ,getValue(P_FSG_33_0_0_23_9_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_33_0_0_23_3" ,getValue(P_FSG_33_0_0_23_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24Changed_BTN" ,getValue(A_FSG_33_0_0_24Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24Status_BTN" ,getValue(A_FSG_33_0_0_24Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_FctLstItemEn" ,getValue(A_FSG_33_0_0_24_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_FctEn" ,getValue(A_FSG_33_0_0_24_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_ErrEn" ,getValue(A_FSG_33_0_0_24_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_IntTlgEn" ,getValue(A_FSG_33_0_0_24_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_SegmEn" ,getValue(A_FSG_33_0_0_24_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_AT" ,getValue(A_FSG_33_0_0_24_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_ErrCode" ,getValue(A_FSG_33_0_0_24_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_DataIndex" ,getValue(A_FSG_33_0_0_24_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_DataIndex_Incr" ,getValue(A_FSG_33_0_0_24_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_DataIndex_Decr" ,getValue(A_FSG_33_0_0_24_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_loadArray_Btn" ,getValue(A_FSG_33_0_0_24_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_generateData_Btn" ,getValue(A_FSG_33_0_0_24_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_2" ,getValue(A_FSG_33_0_0_24_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_3" ,getValue(A_FSG_33_0_0_24_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_3_range" ,getValue(A_FSG_33_0_0_24_3_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_7" ,getValue(A_FSG_33_0_0_24_7), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_7_range" ,getValue(A_FSG_33_0_0_24_7_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Data_3" ,getValue(A_FSG_33_0_0_24_Data_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Data_3_0" ,getValue(A_FSG_33_0_0_24_Data_3_0), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Data_3_1" ,getValue(A_FSG_33_0_0_24_Data_3_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Data_3_4" ,getValue(A_FSG_33_0_0_24_Data_3_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Data_3_5" ,getValue(A_FSG_33_0_0_24_Data_3_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Data_3_6" ,getValue(A_FSG_33_0_0_24_Data_3_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Data_3_7" ,getValue(A_FSG_33_0_0_24_Data_3_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_5" ,getValue(A_FSG_33_0_0_24_5), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_Data_2" ,getValue(A_FSG_33_0_0_24_Data_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_Data_2_range" ,getValue(A_FSG_33_0_0_24_Data_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_1" ,getValue(A_FSG_33_0_0_24_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Data_4_len" ,getValue(A_FSG_33_0_0_24_Data_4_len), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_6" ,getValue(A_FSG_33_0_0_24_6), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_6_range" ,getValue(A_FSG_33_0_0_24_6_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_4" ,getValue(A_FSG_33_0_0_24_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_4_0" ,getValue(A_FSG_33_0_0_24_4_0), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_4_1" ,getValue(A_FSG_33_0_0_24_4_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_4_2" ,getValue(A_FSG_33_0_0_24_4_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_Data_1" ,getValue(A_FSG_33_0_0_24_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_Data_1_range" ,getValue(A_FSG_33_0_0_24_Data_1_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_RecAdr" ,getValue(A_FSG_33_0_0_24_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Direction" ,getValue(A_FSG_33_0_0_24_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Shift" ,getValue(A_FSG_33_0_0_24_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_TransPos" ,getValue(A_FSG_33_0_0_24_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_IndexSize" ,getValue(A_FSG_33_0_0_24_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Start" ,getValue(A_FSG_33_0_0_24_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Elements" ,getValue(A_FSG_33_0_0_24_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_2_Changed" ,getValue(A_FSG_33_0_0_24_2_Changed), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_1_Changed" ,getValue(A_FSG_33_0_0_24_1_Changed), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_3_Changed" ,getValue(A_FSG_33_0_0_24_3_Changed), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_3_Changed_range" ,getValue(A_FSG_33_0_0_24_3_Changed_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Changed_RecAdr" ,getValue(A_FSG_33_0_0_24_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Changed_Direction" ,getValue(A_FSG_33_0_0_24_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Changed_Shift" ,getValue(A_FSG_33_0_0_24_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Changed_TransPos" ,getValue(A_FSG_33_0_0_24_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Changed_IndexSize" ,getValue(A_FSG_33_0_0_24_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Changed_Start" ,getValue(A_FSG_33_0_0_24_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Changed_Elements" ,getValue(A_FSG_33_0_0_24_Changed_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_DataIndex_SetGet" ,getValue(A_FSG_33_0_0_24_DataIndex_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_DataIndex_SetGet_Incr" ,getValue(A_FSG_33_0_0_24_DataIndex_SetGet_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_DataIndex_SetGet_Decr" ,getValue(A_FSG_33_0_0_24_DataIndex_SetGet_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_2_SetGet" ,getValue(A_FSG_33_0_0_24_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_3_SetGet" ,getValue(A_FSG_33_0_0_24_3_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_3_SetGet_range" ,getValue(A_FSG_33_0_0_24_3_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Data_3_SetGet" ,getValue(A_FSG_33_0_0_24_Data_3_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Data_3_SetGet_0" ,getValue(A_FSG_33_0_0_24_Data_3_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Data_3_SetGet_1" ,getValue(A_FSG_33_0_0_24_Data_3_SetGet_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Data_3_SetGet_4" ,getValue(A_FSG_33_0_0_24_Data_3_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Data_3_SetGet_5" ,getValue(A_FSG_33_0_0_24_Data_3_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Data_3_SetGet_6" ,getValue(A_FSG_33_0_0_24_Data_3_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Data_3_SetGet_7" ,getValue(A_FSG_33_0_0_24_Data_3_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_4_SetGet" ,getValue(A_FSG_33_0_0_24_4_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_Data_2_SetGet" ,getValue(A_FSG_33_0_0_24_Data_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_Data_2_SetGet_range" ,getValue(A_FSG_33_0_0_24_Data_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_1_SetGet" ,getValue(A_FSG_33_0_0_24_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_Data_4_SetGet_len" ,getValue(A_FSG_33_0_0_24_Data_4_SetGet_len), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_5_SetGet" ,getValue(A_FSG_33_0_0_24_5_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_5_SetGet_range" ,getValue(A_FSG_33_0_0_24_5_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_Data_1_SetGet" ,getValue(A_FSG_33_0_0_24_Data_1_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_33_0_0_24_Data_1_SetGet_range" ,getValue(A_FSG_33_0_0_24_Data_1_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_SetGet_RecAdr" ,getValue(A_FSG_33_0_0_24_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_SetGet_Direction" ,getValue(A_FSG_33_0_0_24_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_SetGet_Shift" ,getValue(A_FSG_33_0_0_24_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_SetGet_IndexSize" ,getValue(A_FSG_33_0_0_24_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_SetGet_Start" ,getValue(A_FSG_33_0_0_24_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_33_0_0_24_SetGet_Elements" ,getValue(A_FSG_33_0_0_24_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"C_FSG_41_0_0_0_1_FctLstItemEn" ,getValue(C_FSG_41_0_0_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_41_0_0_0_1_FctEn" ,getValue(C_FSG_41_0_0_0_1_FctEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_41_0_0_0_1_ErrEn" ,getValue(C_FSG_41_0_0_0_1_ErrEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_41_0_0_0_1_IntTlgEn" ,getValue(C_FSG_41_0_0_0_1_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_41_0_0_0_1_SegmEn" ,getValue(C_FSG_41_0_0_0_1_SegmEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_41_0_0_0_1_ErrCode" ,getValue(C_FSG_41_0_0_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_0_2Reset_BTN" ,getValue(P_FSG_41_0_0_0_2Reset_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_0_2_FctLstItemEn" ,getValue(P_FSG_41_0_0_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_0_2_FctEn" ,getValue(P_FSG_41_0_0_0_2_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_0_2_ErrEn" ,getValue(P_FSG_41_0_0_0_2_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_0_2_ErrCode" ,getValue(P_FSG_41_0_0_0_2_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_0_3_FctLstItemEn" ,getValue(P_FSG_41_0_0_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_0_3_FctEn" ,getValue(P_FSG_41_0_0_0_3_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_0_3_ErrEn" ,getValue(P_FSG_41_0_0_0_3_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_0_3_IntTlgEn" ,getValue(P_FSG_41_0_0_0_3_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_0_3_SegmEn" ,getValue(P_FSG_41_0_0_0_3_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_0_3_ErrCode" ,getValue(P_FSG_41_0_0_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"ERRORLIST_FSG41_0_VT" ,getValue(ERRORLIST_FSG41_0_VT), profileFile);
    writeProfileInt("BAP" ,"BusType_FSG41_0" ,getValue(BusType_FSG41_0), profileFile);
    writeProfileInt("BAP" ,"ON_OFF_FSG41_0" ,getValue(ON_OFF_FSG41_0), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_41_0_0_DFMajor" ,getValue(BAPCFG_FSG_41_0_0_DFMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_41_0_0_DFMinor" ,getValue(BAPCFG_FSG_41_0_0_DFMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_41_0_0_LsgClassMajor" ,getValue(BAPCFG_FSG_41_0_0_LsgClassMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_41_0_0_LsgClassMinor" ,getValue(BAPCFG_FSG_41_0_0_LsgClassMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_41_0_0_ProtocolMajor" ,getValue(BAPCFG_FSG_41_0_0_ProtocolMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_41_0_0_ProtocolMinor" ,getValue(BAPCFG_FSG_41_0_0_ProtocolMinor), profileFile);
    writeProfileInt("BAP" ,"C_FSG_41_0_0_1_FctLstItemEn" ,getValue(C_FSG_41_0_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_41_0_0_1_FctEn" ,getValue(C_FSG_41_0_0_1_FctEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_41_0_0_1_ErrEn" ,getValue(C_FSG_41_0_0_1_ErrEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_41_0_0_1_IntTlgEn" ,getValue(C_FSG_41_0_0_1_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_41_0_0_1_SegmEn" ,getValue(C_FSG_41_0_0_1_SegmEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_41_0_0_1_ErrCode" ,getValue(C_FSG_41_0_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_2Reset_BTN" ,getValue(P_FSG_41_0_0_2Reset_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_2_FctLstItemEn" ,getValue(P_FSG_41_0_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_2_FctEn" ,getValue(P_FSG_41_0_0_2_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_2_ErrEn" ,getValue(P_FSG_41_0_0_2_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_2_ErrCode" ,getValue(P_FSG_41_0_0_2_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_41_0_0_2" ,getValue(P_FSG_41_0_0_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_41_0_0_2_range" ,getValue(P_FSG_41_0_0_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_3Status_BTN" ,getValue(P_FSG_41_0_0_3Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_3_FctLstItemEn" ,getValue(P_FSG_41_0_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_3_FctEn" ,getValue(P_FSG_41_0_0_3_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_3_ErrEn" ,getValue(P_FSG_41_0_0_3_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_3_IntTlgEn" ,getValue(P_FSG_41_0_0_3_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_3_SegmEn" ,getValue(P_FSG_41_0_0_3_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_3_ErrCode" ,getValue(P_FSG_41_0_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_41_0_0_4Status_BTN" ,getValue(P_FSG_41_0_0_4Status_BTN), profileFile);
