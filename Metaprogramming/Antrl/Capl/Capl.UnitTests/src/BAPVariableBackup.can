/*@!Encoding:utf8*/

void saveBAPSettings( char profileFile[] )
{
    writeProfileInt("BAP" ,"ERRORLIST_ASG15_1_VT" ,getValue(ERRORLIST_ASG15_1_VT), profileFile);
    writeProfileInt("BAP" ,"BusType_ASG15_1" ,getValue(BusType_ASG15_1), profileFile);
    writeProfileInt("BAP" ,"ON_OFF_ASG15_1" ,getValue(ON_OFF_ASG15_1), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_15_1_0_DFMajor" ,getValue(BAPCFG_ASG_15_1_0_DFMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_15_1_0_DFMinor" ,getValue(BAPCFG_ASG_15_1_0_DFMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_15_1_0_LsgClassMajor" ,getValue(BAPCFG_ASG_15_1_0_LsgClassMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_15_1_0_LsgClassMinor" ,getValue(BAPCFG_ASG_15_1_0_LsgClassMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_15_1_0_ProtocolMajor" ,getValue(BAPCFG_ASG_15_1_0_ProtocolMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_15_1_0_ProtocolMinor" ,getValue(BAPCFG_ASG_15_1_0_ProtocolMinor), profileFile);
    writeProfileInt("BAP" ,"C_ASG_15_1_0_1GetAll_BTN" ,getValue(C_ASG_15_1_0_1GetAll_BTN), profileFile);
    writeProfileInt("BAP" ,"C_ASG_15_1_0_1_FctLstItemEn" ,getValue(C_ASG_15_1_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_ASG_15_1_0_1_ErrCode" ,getValue(C_ASG_15_1_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_2Get_BTN" ,getValue(P_ASG_15_1_0_2Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_2_FctLstItemEn" ,getValue(P_ASG_15_1_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_2_ErrCode" ,getValue(P_ASG_15_1_0_2_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_2" ,getValue(P_ASG_15_1_0_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_2_range" ,getValue(P_ASG_15_1_0_2_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_3Get_BTN" ,getValue(P_ASG_15_1_0_3Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_3_FctLstItemEn" ,getValue(P_ASG_15_1_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_3_ErrCode" ,getValue(P_ASG_15_1_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_4Get_BTN" ,getValue(P_ASG_15_1_0_4Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_4_FctLstItemEn" ,getValue(P_ASG_15_1_0_4_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_4_ErrCode" ,getValue(P_ASG_15_1_0_4_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_4" ,getValue(P_ASG_15_1_0_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_13Get_BTN" ,getValue(P_ASG_15_1_0_13Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_13SetGet_BTN" ,getValue(P_ASG_15_1_0_13SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_13_FctLstItemEn" ,getValue(P_ASG_15_1_0_13_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_13_ErrCode" ,getValue(P_ASG_15_1_0_13_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_13" ,getValue(P_ASG_15_1_0_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_13_1" ,getValue(P_ASG_15_1_0_13_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_13_1_0" ,getValue(P_ASG_15_1_0_13_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_13_1_4" ,getValue(P_ASG_15_1_0_13_1_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14Get_BTN" ,getValue(P_ASG_15_1_0_14Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_FctLstItemEn" ,getValue(P_ASG_15_1_0_14_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_ErrCode" ,getValue(P_ASG_15_1_0_14_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_14_6" ,getValue(P_ASG_15_1_0_14_6), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_14_6_range" ,getValue(P_ASG_15_1_0_14_6_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_2" ,getValue(P_ASG_15_1_0_14_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_2_0" ,getValue(P_ASG_15_1_0_14_2_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_2_1" ,getValue(P_ASG_15_1_0_14_2_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_2_2" ,getValue(P_ASG_15_1_0_14_2_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_1" ,getValue(P_ASG_15_1_0_14_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_1_0" ,getValue(P_ASG_15_1_0_14_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_1_1" ,getValue(P_ASG_15_1_0_14_1_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_1_2" ,getValue(P_ASG_15_1_0_14_1_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_1_3" ,getValue(P_ASG_15_1_0_14_1_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_1_4" ,getValue(P_ASG_15_1_0_14_1_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_1_5" ,getValue(P_ASG_15_1_0_14_1_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_1_6" ,getValue(P_ASG_15_1_0_14_1_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_1_7" ,getValue(P_ASG_15_1_0_14_1_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_1_8" ,getValue(P_ASG_15_1_0_14_1_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_1_9" ,getValue(P_ASG_15_1_0_14_1_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_1_10" ,getValue(P_ASG_15_1_0_14_1_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_1_11" ,getValue(P_ASG_15_1_0_14_1_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_1_12" ,getValue(P_ASG_15_1_0_14_1_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_1_13" ,getValue(P_ASG_15_1_0_14_1_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_1_14" ,getValue(P_ASG_15_1_0_14_1_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_1_15" ,getValue(P_ASG_15_1_0_14_1_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_4" ,getValue(P_ASG_15_1_0_14_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_5" ,getValue(P_ASG_15_1_0_14_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_5_0" ,getValue(P_ASG_15_1_0_14_5_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_14_3" ,getValue(P_ASG_15_1_0_14_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_15Get_BTN" ,getValue(P_ASG_15_1_0_15Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_15_FctLstItemEn" ,getValue(P_ASG_15_1_0_15_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_15_ErrCode" ,getValue(P_ASG_15_1_0_15_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_15" ,getValue(P_ASG_15_1_0_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_15_1" ,getValue(P_ASG_15_1_0_15_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16Get_BTN" ,getValue(P_ASG_15_1_0_16Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16SetGet_BTN" ,getValue(P_ASG_15_1_0_16SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_FctLstItemEn" ,getValue(P_ASG_15_1_0_16_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_IntTlgEn" ,getValue(P_ASG_15_1_0_16_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_SegmEn" ,getValue(P_ASG_15_1_0_16_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_ErrCode" ,getValue(P_ASG_15_1_0_16_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_16_6" ,getValue(P_ASG_15_1_0_16_6), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_16_6_range" ,getValue(P_ASG_15_1_0_16_6_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_4" ,getValue(P_ASG_15_1_0_16_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_4_0" ,getValue(P_ASG_15_1_0_16_4_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_4_1" ,getValue(P_ASG_15_1_0_16_4_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_4_2" ,getValue(P_ASG_15_1_0_16_4_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_4_3" ,getValue(P_ASG_15_1_0_16_4_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_4_4" ,getValue(P_ASG_15_1_0_16_4_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_4_5" ,getValue(P_ASG_15_1_0_16_4_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_4_6" ,getValue(P_ASG_15_1_0_16_4_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_4_7" ,getValue(P_ASG_15_1_0_16_4_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_1" ,getValue(P_ASG_15_1_0_16_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_1_0" ,getValue(P_ASG_15_1_0_16_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_1_1" ,getValue(P_ASG_15_1_0_16_1_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_1_2" ,getValue(P_ASG_15_1_0_16_1_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_1_3" ,getValue(P_ASG_15_1_0_16_1_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_1_4" ,getValue(P_ASG_15_1_0_16_1_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_1_5" ,getValue(P_ASG_15_1_0_16_1_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_1_6" ,getValue(P_ASG_15_1_0_16_1_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_1_7" ,getValue(P_ASG_15_1_0_16_1_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_1_8" ,getValue(P_ASG_15_1_0_16_1_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_1_9" ,getValue(P_ASG_15_1_0_16_1_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_1_10" ,getValue(P_ASG_15_1_0_16_1_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_1_11" ,getValue(P_ASG_15_1_0_16_1_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_1_12" ,getValue(P_ASG_15_1_0_16_1_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_1_13" ,getValue(P_ASG_15_1_0_16_1_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_1_14" ,getValue(P_ASG_15_1_0_16_1_14), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_16_5" ,getValue(P_ASG_15_1_0_16_5), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_16_5_range" ,getValue(P_ASG_15_1_0_16_5_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_3" ,getValue(P_ASG_15_1_0_16_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_3_0" ,getValue(P_ASG_15_1_0_16_3_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_3_1" ,getValue(P_ASG_15_1_0_16_3_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_3_2" ,getValue(P_ASG_15_1_0_16_3_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_3_3" ,getValue(P_ASG_15_1_0_16_3_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_3_4" ,getValue(P_ASG_15_1_0_16_3_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_3_5" ,getValue(P_ASG_15_1_0_16_3_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_3_6" ,getValue(P_ASG_15_1_0_16_3_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_3_7" ,getValue(P_ASG_15_1_0_16_3_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_3_8" ,getValue(P_ASG_15_1_0_16_3_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_3_9" ,getValue(P_ASG_15_1_0_16_3_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_3_10" ,getValue(P_ASG_15_1_0_16_3_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_3_11" ,getValue(P_ASG_15_1_0_16_3_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_3_12" ,getValue(P_ASG_15_1_0_16_3_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_3_13" ,getValue(P_ASG_15_1_0_16_3_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_3_14" ,getValue(P_ASG_15_1_0_16_3_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_2" ,getValue(P_ASG_15_1_0_16_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_2_0" ,getValue(P_ASG_15_1_0_16_2_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_2_1" ,getValue(P_ASG_15_1_0_16_2_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_2_2" ,getValue(P_ASG_15_1_0_16_2_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_2_3" ,getValue(P_ASG_15_1_0_16_2_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_2_4" ,getValue(P_ASG_15_1_0_16_2_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_2_5" ,getValue(P_ASG_15_1_0_16_2_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_2_6" ,getValue(P_ASG_15_1_0_16_2_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_2_7" ,getValue(P_ASG_15_1_0_16_2_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_2_8" ,getValue(P_ASG_15_1_0_16_2_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_2_9" ,getValue(P_ASG_15_1_0_16_2_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_2_10" ,getValue(P_ASG_15_1_0_16_2_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_2_11" ,getValue(P_ASG_15_1_0_16_2_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_2_12" ,getValue(P_ASG_15_1_0_16_2_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_2_13" ,getValue(P_ASG_15_1_0_16_2_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_16_2_14" ,getValue(P_ASG_15_1_0_16_2_14), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17StartResult_BTN" ,getValue(M_ASG_15_1_0_17StartResult_BTN), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_FctLstItemEn" ,getValue(M_ASG_15_1_0_17_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_ErrCode" ,getValue(M_ASG_15_1_0_17_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Result" ,getValue(M_ASG_15_1_0_17_Result), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Result_1" ,getValue(M_ASG_15_1_0_17_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Result_1_0" ,getValue(M_ASG_15_1_0_17_Result_1_0), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Processing" ,getValue(M_ASG_15_1_0_17_Processing), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Processing_1" ,getValue(M_ASG_15_1_0_17_Processing_1), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Processing_1_1" ,getValue(M_ASG_15_1_0_17_Processing_1_1), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Processing_1_2" ,getValue(M_ASG_15_1_0_17_Processing_1_2), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Processing_1_3" ,getValue(M_ASG_15_1_0_17_Processing_1_3), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Processing_1_4" ,getValue(M_ASG_15_1_0_17_Processing_1_4), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Processing_1_5" ,getValue(M_ASG_15_1_0_17_Processing_1_5), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Processing_1_6" ,getValue(M_ASG_15_1_0_17_Processing_1_6), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Processing_1_7" ,getValue(M_ASG_15_1_0_17_Processing_1_7), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Start" ,getValue(M_ASG_15_1_0_17_Start), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Start_1" ,getValue(M_ASG_15_1_0_17_Start_1), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Start_1_1" ,getValue(M_ASG_15_1_0_17_Start_1_1), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Start_1_2" ,getValue(M_ASG_15_1_0_17_Start_1_2), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Start_1_3" ,getValue(M_ASG_15_1_0_17_Start_1_3), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Start_1_4" ,getValue(M_ASG_15_1_0_17_Start_1_4), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Start_1_5" ,getValue(M_ASG_15_1_0_17_Start_1_5), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Start_1_6" ,getValue(M_ASG_15_1_0_17_Start_1_6), profileFile);
    writeProfileInt("BAP" ,"M_ASG_15_1_0_17_Start_1_7" ,getValue(M_ASG_15_1_0_17_Start_1_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_18Get_BTN" ,getValue(P_ASG_15_1_0_18Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_18SetGet_BTN" ,getValue(P_ASG_15_1_0_18SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_18_FctLstItemEn" ,getValue(P_ASG_15_1_0_18_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_18_ErrCode" ,getValue(P_ASG_15_1_0_18_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_18_2" ,getValue(P_ASG_15_1_0_18_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_18_2_range" ,getValue(P_ASG_15_1_0_18_2_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_18_4" ,getValue(P_ASG_15_1_0_18_4), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_18_4_range" ,getValue(P_ASG_15_1_0_18_4_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_18_1" ,getValue(P_ASG_15_1_0_18_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_18_1_0" ,getValue(P_ASG_15_1_0_18_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_18_3" ,getValue(P_ASG_15_1_0_18_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_19Get_BTN" ,getValue(P_ASG_15_1_0_19Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_19_FctLstItemEn" ,getValue(P_ASG_15_1_0_19_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_19_ErrCode" ,getValue(P_ASG_15_1_0_19_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_19_4" ,getValue(P_ASG_15_1_0_19_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_19_2" ,getValue(P_ASG_15_1_0_19_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_19_1" ,getValue(P_ASG_15_1_0_19_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_19_1_range" ,getValue(P_ASG_15_1_0_19_1_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_19_3" ,getValue(P_ASG_15_1_0_19_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_19_3_range" ,getValue(P_ASG_15_1_0_19_3_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_20Get_BTN" ,getValue(P_ASG_15_1_0_20Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_20_FctLstItemEn" ,getValue(P_ASG_15_1_0_20_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_20_ErrCode" ,getValue(P_ASG_15_1_0_20_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_20_3" ,getValue(P_ASG_15_1_0_20_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_20_3_range" ,getValue(P_ASG_15_1_0_20_3_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_20_1" ,getValue(P_ASG_15_1_0_20_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_20_1_range" ,getValue(P_ASG_15_1_0_20_1_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_20_2" ,getValue(P_ASG_15_1_0_20_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_20_2_range" ,getValue(P_ASG_15_1_0_20_2_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_20_4" ,getValue(P_ASG_15_1_0_20_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_21Get_BTN" ,getValue(P_ASG_15_1_0_21Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_21_FctLstItemEn" ,getValue(P_ASG_15_1_0_21_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_21_ErrCode" ,getValue(P_ASG_15_1_0_21_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_21_2" ,getValue(P_ASG_15_1_0_21_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_21_1" ,getValue(P_ASG_15_1_0_21_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_21_1_range" ,getValue(P_ASG_15_1_0_21_1_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_22Get_BTN" ,getValue(P_ASG_15_1_0_22Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_22_FctLstItemEn" ,getValue(P_ASG_15_1_0_22_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_22_ErrCode" ,getValue(P_ASG_15_1_0_22_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_22_7" ,getValue(P_ASG_15_1_0_22_7), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_22_7_range" ,getValue(P_ASG_15_1_0_22_7_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_22_5" ,getValue(P_ASG_15_1_0_22_5), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_22_5_range" ,getValue(P_ASG_15_1_0_22_5_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_22_1" ,getValue(P_ASG_15_1_0_22_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_22_1_range" ,getValue(P_ASG_15_1_0_22_1_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_22_8" ,getValue(P_ASG_15_1_0_22_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_22_2" ,getValue(P_ASG_15_1_0_22_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_22_6" ,getValue(P_ASG_15_1_0_22_6), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_22_9" ,getValue(P_ASG_15_1_0_22_9), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_22_9_range" ,getValue(P_ASG_15_1_0_22_9_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_22_3" ,getValue(P_ASG_15_1_0_22_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_22_3_range" ,getValue(P_ASG_15_1_0_22_3_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_22_4" ,getValue(P_ASG_15_1_0_22_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_23Get_BTN" ,getValue(P_ASG_15_1_0_23Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_23_FctLstItemEn" ,getValue(P_ASG_15_1_0_23_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_23_ErrCode" ,getValue(P_ASG_15_1_0_23_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_23_11" ,getValue(P_ASG_15_1_0_23_11), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_23_11_range" ,getValue(P_ASG_15_1_0_23_11_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_23_10" ,getValue(P_ASG_15_1_0_23_10), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_23_10_range" ,getValue(P_ASG_15_1_0_23_10_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_23_9" ,getValue(P_ASG_15_1_0_23_9), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_23_9_range" ,getValue(P_ASG_15_1_0_23_9_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_23_8" ,getValue(P_ASG_15_1_0_23_8), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_23_8_range" ,getValue(P_ASG_15_1_0_23_8_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_23_7" ,getValue(P_ASG_15_1_0_23_7), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_23_7_range" ,getValue(P_ASG_15_1_0_23_7_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_23_6" ,getValue(P_ASG_15_1_0_23_6), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_23_6_range" ,getValue(P_ASG_15_1_0_23_6_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_23_5" ,getValue(P_ASG_15_1_0_23_5), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_23_5_range" ,getValue(P_ASG_15_1_0_23_5_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_23_1" ,getValue(P_ASG_15_1_0_23_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_23_1_range" ,getValue(P_ASG_15_1_0_23_1_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_23_4" ,getValue(P_ASG_15_1_0_23_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_23_2" ,getValue(P_ASG_15_1_0_23_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_23_3" ,getValue(P_ASG_15_1_0_23_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_23_3_range" ,getValue(P_ASG_15_1_0_23_3_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_24Get_BTN" ,getValue(P_ASG_15_1_0_24Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_24_FctLstItemEn" ,getValue(P_ASG_15_1_0_24_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_24_ErrCode" ,getValue(P_ASG_15_1_0_24_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_24_7" ,getValue(P_ASG_15_1_0_24_7), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_24_7_range" ,getValue(P_ASG_15_1_0_24_7_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_24_5" ,getValue(P_ASG_15_1_0_24_5), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_24_5_range" ,getValue(P_ASG_15_1_0_24_5_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_24_1" ,getValue(P_ASG_15_1_0_24_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_24_1_range" ,getValue(P_ASG_15_1_0_24_1_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_24_8" ,getValue(P_ASG_15_1_0_24_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_24_2" ,getValue(P_ASG_15_1_0_24_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_24_6" ,getValue(P_ASG_15_1_0_24_6), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_24_9" ,getValue(P_ASG_15_1_0_24_9), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_24_9_range" ,getValue(P_ASG_15_1_0_24_9_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_24_3" ,getValue(P_ASG_15_1_0_24_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_24_3_range" ,getValue(P_ASG_15_1_0_24_3_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_24_4" ,getValue(P_ASG_15_1_0_24_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_25Get_BTN" ,getValue(P_ASG_15_1_0_25Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_25_FctLstItemEn" ,getValue(P_ASG_15_1_0_25_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_25_ErrCode" ,getValue(P_ASG_15_1_0_25_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_25_11" ,getValue(P_ASG_15_1_0_25_11), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_25_11_range" ,getValue(P_ASG_15_1_0_25_11_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_25_10" ,getValue(P_ASG_15_1_0_25_10), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_25_10_range" ,getValue(P_ASG_15_1_0_25_10_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_25_9" ,getValue(P_ASG_15_1_0_25_9), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_25_9_range" ,getValue(P_ASG_15_1_0_25_9_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_25_8" ,getValue(P_ASG_15_1_0_25_8), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_25_8_range" ,getValue(P_ASG_15_1_0_25_8_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_25_7" ,getValue(P_ASG_15_1_0_25_7), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_25_7_range" ,getValue(P_ASG_15_1_0_25_7_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_25_6" ,getValue(P_ASG_15_1_0_25_6), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_25_6_range" ,getValue(P_ASG_15_1_0_25_6_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_25_5" ,getValue(P_ASG_15_1_0_25_5), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_25_5_range" ,getValue(P_ASG_15_1_0_25_5_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_25_1" ,getValue(P_ASG_15_1_0_25_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_25_1_range" ,getValue(P_ASG_15_1_0_25_1_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_25_4" ,getValue(P_ASG_15_1_0_25_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_25_2" ,getValue(P_ASG_15_1_0_25_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_25_3" ,getValue(P_ASG_15_1_0_25_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_25_3_range" ,getValue(P_ASG_15_1_0_25_3_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_26Get_BTN" ,getValue(P_ASG_15_1_0_26Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_26_FctLstItemEn" ,getValue(P_ASG_15_1_0_26_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_26_ErrCode" ,getValue(P_ASG_15_1_0_26_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_26_7" ,getValue(P_ASG_15_1_0_26_7), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_26_7_range" ,getValue(P_ASG_15_1_0_26_7_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_26_5" ,getValue(P_ASG_15_1_0_26_5), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_26_5_range" ,getValue(P_ASG_15_1_0_26_5_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_26_1" ,getValue(P_ASG_15_1_0_26_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_26_1_range" ,getValue(P_ASG_15_1_0_26_1_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_26_8" ,getValue(P_ASG_15_1_0_26_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_26_2" ,getValue(P_ASG_15_1_0_26_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_26_6" ,getValue(P_ASG_15_1_0_26_6), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_26_9" ,getValue(P_ASG_15_1_0_26_9), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_26_9_range" ,getValue(P_ASG_15_1_0_26_9_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_26_3" ,getValue(P_ASG_15_1_0_26_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_26_3_range" ,getValue(P_ASG_15_1_0_26_3_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_26_4" ,getValue(P_ASG_15_1_0_26_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_27Get_BTN" ,getValue(P_ASG_15_1_0_27Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_27_FctLstItemEn" ,getValue(P_ASG_15_1_0_27_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_27_ErrCode" ,getValue(P_ASG_15_1_0_27_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_27_11" ,getValue(P_ASG_15_1_0_27_11), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_27_11_range" ,getValue(P_ASG_15_1_0_27_11_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_27_10" ,getValue(P_ASG_15_1_0_27_10), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_27_10_range" ,getValue(P_ASG_15_1_0_27_10_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_27_9" ,getValue(P_ASG_15_1_0_27_9), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_27_9_range" ,getValue(P_ASG_15_1_0_27_9_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_27_8" ,getValue(P_ASG_15_1_0_27_8), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_27_8_range" ,getValue(P_ASG_15_1_0_27_8_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_27_7" ,getValue(P_ASG_15_1_0_27_7), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_27_7_range" ,getValue(P_ASG_15_1_0_27_7_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_27_6" ,getValue(P_ASG_15_1_0_27_6), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_27_6_range" ,getValue(P_ASG_15_1_0_27_6_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_27_5" ,getValue(P_ASG_15_1_0_27_5), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_27_5_range" ,getValue(P_ASG_15_1_0_27_5_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_27_1" ,getValue(P_ASG_15_1_0_27_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_27_1_range" ,getValue(P_ASG_15_1_0_27_1_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_27_4" ,getValue(P_ASG_15_1_0_27_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_27_2" ,getValue(P_ASG_15_1_0_27_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_27_3" ,getValue(P_ASG_15_1_0_27_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_27_3_range" ,getValue(P_ASG_15_1_0_27_3_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_28Get_BTN" ,getValue(P_ASG_15_1_0_28Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_28_FctLstItemEn" ,getValue(P_ASG_15_1_0_28_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_28_ErrCode" ,getValue(P_ASG_15_1_0_28_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_2_Year" ,getValue(P_ASG_15_1_0_28_2_Year), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_2_Year_range" ,getValue(P_ASG_15_1_0_28_2_Year_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_2_Month" ,getValue(P_ASG_15_1_0_28_2_Month), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_2_Month_range" ,getValue(P_ASG_15_1_0_28_2_Month_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_2_Day" ,getValue(P_ASG_15_1_0_28_2_Day), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_2_Day_range" ,getValue(P_ASG_15_1_0_28_2_Day_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_2_Hour" ,getValue(P_ASG_15_1_0_28_2_Hour), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_2_Hour_range" ,getValue(P_ASG_15_1_0_28_2_Hour_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_2_Minute" ,getValue(P_ASG_15_1_0_28_2_Minute), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_2_Minute_range" ,getValue(P_ASG_15_1_0_28_2_Minute_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_1_Year" ,getValue(P_ASG_15_1_0_28_1_Year), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_1_Year_range" ,getValue(P_ASG_15_1_0_28_1_Year_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_1_Month" ,getValue(P_ASG_15_1_0_28_1_Month), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_1_Month_range" ,getValue(P_ASG_15_1_0_28_1_Month_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_1_Day" ,getValue(P_ASG_15_1_0_28_1_Day), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_1_Day_range" ,getValue(P_ASG_15_1_0_28_1_Day_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_1_Hour" ,getValue(P_ASG_15_1_0_28_1_Hour), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_1_Hour_range" ,getValue(P_ASG_15_1_0_28_1_Hour_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_1_Minute" ,getValue(P_ASG_15_1_0_28_1_Minute), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_1_Minute_range" ,getValue(P_ASG_15_1_0_28_1_Minute_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_3_Year" ,getValue(P_ASG_15_1_0_28_3_Year), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_3_Year_range" ,getValue(P_ASG_15_1_0_28_3_Year_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_3_Month" ,getValue(P_ASG_15_1_0_28_3_Month), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_3_Month_range" ,getValue(P_ASG_15_1_0_28_3_Month_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_3_Day" ,getValue(P_ASG_15_1_0_28_3_Day), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_3_Day_range" ,getValue(P_ASG_15_1_0_28_3_Day_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_3_Hour" ,getValue(P_ASG_15_1_0_28_3_Hour), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_3_Hour_range" ,getValue(P_ASG_15_1_0_28_3_Hour_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_3_Minute" ,getValue(P_ASG_15_1_0_28_3_Minute), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_28_3_Minute_range" ,getValue(P_ASG_15_1_0_28_3_Minute_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_29Get_BTN" ,getValue(P_ASG_15_1_0_29Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_29_FctLstItemEn" ,getValue(P_ASG_15_1_0_29_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_29_ErrCode" ,getValue(P_ASG_15_1_0_29_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_29_2" ,getValue(P_ASG_15_1_0_29_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_29_2_range" ,getValue(P_ASG_15_1_0_29_2_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_29_1" ,getValue(P_ASG_15_1_0_29_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_29_1_range" ,getValue(P_ASG_15_1_0_29_1_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_30Get_BTN" ,getValue(P_ASG_15_1_0_30Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_30_FctLstItemEn" ,getValue(P_ASG_15_1_0_30_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_30_ErrCode" ,getValue(P_ASG_15_1_0_30_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_30_4" ,getValue(P_ASG_15_1_0_30_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_30_2" ,getValue(P_ASG_15_1_0_30_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_30_3" ,getValue(P_ASG_15_1_0_30_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_30_3_range" ,getValue(P_ASG_15_1_0_30_3_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_30_1" ,getValue(P_ASG_15_1_0_30_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_30_1_range" ,getValue(P_ASG_15_1_0_30_1_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31Get_BTN" ,getValue(A_ASG_15_1_0_31Get_BTN), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_FctLstItemEn" ,getValue(A_ASG_15_1_0_31_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_IntTlgEn" ,getValue(A_ASG_15_1_0_31_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_SegmEn" ,getValue(A_ASG_15_1_0_31_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_AT" ,getValue(A_ASG_15_1_0_31_AT), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_ErrCode" ,getValue(A_ASG_15_1_0_31_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_DataIndex" ,getValue(A_ASG_15_1_0_31_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_DataIndex_Incr" ,getValue(A_ASG_15_1_0_31_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_DataIndex_Decr" ,getValue(A_ASG_15_1_0_31_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_loadArray_Btn" ,getValue(A_ASG_15_1_0_31_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_generateData_Btn" ,getValue(A_ASG_15_1_0_31_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_Data_4_len" ,getValue(A_ASG_15_1_0_31_Data_4_len), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_Data_4_cnt" ,getValue(A_ASG_15_1_0_31_Data_4_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_31_2" ,getValue(A_ASG_15_1_0_31_2), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_31_2_range" ,getValue(A_ASG_15_1_0_31_2_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_1" ,getValue(A_ASG_15_1_0_31_1), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_31_Data_1" ,getValue(A_ASG_15_1_0_31_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_31_Data_1_range" ,getValue(A_ASG_15_1_0_31_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_31_3" ,getValue(A_ASG_15_1_0_31_3), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_31_3_range" ,getValue(A_ASG_15_1_0_31_3_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_Data_2" ,getValue(A_ASG_15_1_0_31_Data_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_Data_3_len" ,getValue(A_ASG_15_1_0_31_Data_3_len), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_Data_3_cnt" ,getValue(A_ASG_15_1_0_31_Data_3_cnt), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_RecAdr" ,getValue(A_ASG_15_1_0_31_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_Direction" ,getValue(A_ASG_15_1_0_31_Direction), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_Shift" ,getValue(A_ASG_15_1_0_31_Shift), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_TransPos" ,getValue(A_ASG_15_1_0_31_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_IndexSize" ,getValue(A_ASG_15_1_0_31_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_Start" ,getValue(A_ASG_15_1_0_31_Start), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_Elements" ,getValue(A_ASG_15_1_0_31_Elements), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_Changed_RecAdr" ,getValue(A_ASG_15_1_0_31_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_Changed_Direction" ,getValue(A_ASG_15_1_0_31_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_Changed_Shift" ,getValue(A_ASG_15_1_0_31_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_Changed_TransPos" ,getValue(A_ASG_15_1_0_31_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_Changed_IndexSize" ,getValue(A_ASG_15_1_0_31_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_Changed_Start" ,getValue(A_ASG_15_1_0_31_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_Changed_Elements" ,getValue(A_ASG_15_1_0_31_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_31_2_SetGet" ,getValue(A_ASG_15_1_0_31_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_31_2_SetGet_range" ,getValue(A_ASG_15_1_0_31_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_1_SetGet" ,getValue(A_ASG_15_1_0_31_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_SetGet_RecAdr" ,getValue(A_ASG_15_1_0_31_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_SetGet_Direction" ,getValue(A_ASG_15_1_0_31_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_SetGet_Shift" ,getValue(A_ASG_15_1_0_31_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_SetGet_IndexSize" ,getValue(A_ASG_15_1_0_31_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_SetGet_Start" ,getValue(A_ASG_15_1_0_31_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_31_SetGet_Elements" ,getValue(A_ASG_15_1_0_31_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_32Get_BTN" ,getValue(P_ASG_15_1_0_32Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_32_FctLstItemEn" ,getValue(P_ASG_15_1_0_32_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_32_ErrCode" ,getValue(P_ASG_15_1_0_32_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_32_2" ,getValue(P_ASG_15_1_0_32_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_32_1" ,getValue(P_ASG_15_1_0_32_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_32_1_range" ,getValue(P_ASG_15_1_0_32_1_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_33Get_BTN" ,getValue(P_ASG_15_1_0_33Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_33_FctLstItemEn" ,getValue(P_ASG_15_1_0_33_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_33_ErrCode" ,getValue(P_ASG_15_1_0_33_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_33_2" ,getValue(P_ASG_15_1_0_33_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_33_1" ,getValue(P_ASG_15_1_0_33_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_33_1_range" ,getValue(P_ASG_15_1_0_33_1_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_34Get_BTN" ,getValue(P_ASG_15_1_0_34Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_34_FctLstItemEn" ,getValue(P_ASG_15_1_0_34_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_34_ErrCode" ,getValue(P_ASG_15_1_0_34_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_34_2" ,getValue(P_ASG_15_1_0_34_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_34_1" ,getValue(P_ASG_15_1_0_34_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_34_1_range" ,getValue(P_ASG_15_1_0_34_1_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_35Get_BTN" ,getValue(P_ASG_15_1_0_35Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_35_FctLstItemEn" ,getValue(P_ASG_15_1_0_35_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_35_ErrCode" ,getValue(P_ASG_15_1_0_35_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_35_7" ,getValue(P_ASG_15_1_0_35_7), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_35_7_range" ,getValue(P_ASG_15_1_0_35_7_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_35_2" ,getValue(P_ASG_15_1_0_35_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_35_2_range" ,getValue(P_ASG_15_1_0_35_2_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_35_5" ,getValue(P_ASG_15_1_0_35_5), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_35_5_range" ,getValue(P_ASG_15_1_0_35_5_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_35_1" ,getValue(P_ASG_15_1_0_35_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_35_1_range" ,getValue(P_ASG_15_1_0_35_1_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_35_4" ,getValue(P_ASG_15_1_0_35_4), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_35_4_range" ,getValue(P_ASG_15_1_0_35_4_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_35_3" ,getValue(P_ASG_15_1_0_35_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_35_8" ,getValue(P_ASG_15_1_0_35_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_35_6" ,getValue(P_ASG_15_1_0_35_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36Get_BTN" ,getValue(A_ASG_15_1_0_36Get_BTN), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36SetGet_BTN" ,getValue(A_ASG_15_1_0_36SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_FctLstItemEn" ,getValue(A_ASG_15_1_0_36_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_IntTlgEn" ,getValue(A_ASG_15_1_0_36_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_SegmEn" ,getValue(A_ASG_15_1_0_36_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_AT" ,getValue(A_ASG_15_1_0_36_AT), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_ErrCode" ,getValue(A_ASG_15_1_0_36_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_DataIndex" ,getValue(A_ASG_15_1_0_36_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_DataIndex_Incr" ,getValue(A_ASG_15_1_0_36_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_DataIndex_Decr" ,getValue(A_ASG_15_1_0_36_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_loadArray_Btn" ,getValue(A_ASG_15_1_0_36_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_generateData_Btn" ,getValue(A_ASG_15_1_0_36_generateData_Btn), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_Data_4" ,getValue(A_ASG_15_1_0_36_Data_4), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_Data_4_range" ,getValue(A_ASG_15_1_0_36_Data_4_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_2" ,getValue(A_ASG_15_1_0_36_2), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_3" ,getValue(A_ASG_15_1_0_36_3), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_3_range" ,getValue(A_ASG_15_1_0_36_3_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_7" ,getValue(A_ASG_15_1_0_36_7), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_7_range" ,getValue(A_ASG_15_1_0_36_7_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Data_3" ,getValue(A_ASG_15_1_0_36_Data_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Data_3_0" ,getValue(A_ASG_15_1_0_36_Data_3_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Data_3_4" ,getValue(A_ASG_15_1_0_36_Data_3_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Data_3_5" ,getValue(A_ASG_15_1_0_36_Data_3_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Data_3_6" ,getValue(A_ASG_15_1_0_36_Data_3_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Data_3_7" ,getValue(A_ASG_15_1_0_36_Data_3_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_5" ,getValue(A_ASG_15_1_0_36_5), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_Data_2" ,getValue(A_ASG_15_1_0_36_Data_2), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_Data_2_range" ,getValue(A_ASG_15_1_0_36_Data_2_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_1" ,getValue(A_ASG_15_1_0_36_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Data_5_len" ,getValue(A_ASG_15_1_0_36_Data_5_len), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Data_5_cnt" ,getValue(A_ASG_15_1_0_36_Data_5_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_6" ,getValue(A_ASG_15_1_0_36_6), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_6_range" ,getValue(A_ASG_15_1_0_36_6_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_4" ,getValue(A_ASG_15_1_0_36_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_4_0" ,getValue(A_ASG_15_1_0_36_4_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_4_1" ,getValue(A_ASG_15_1_0_36_4_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_4_2" ,getValue(A_ASG_15_1_0_36_4_2), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_Data_1" ,getValue(A_ASG_15_1_0_36_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_Data_1_range" ,getValue(A_ASG_15_1_0_36_Data_1_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_RecAdr" ,getValue(A_ASG_15_1_0_36_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Direction" ,getValue(A_ASG_15_1_0_36_Direction), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Shift" ,getValue(A_ASG_15_1_0_36_Shift), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_TransPos" ,getValue(A_ASG_15_1_0_36_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_IndexSize" ,getValue(A_ASG_15_1_0_36_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Start" ,getValue(A_ASG_15_1_0_36_Start), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Elements" ,getValue(A_ASG_15_1_0_36_Elements), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_2_Changed" ,getValue(A_ASG_15_1_0_36_2_Changed), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_1_Changed" ,getValue(A_ASG_15_1_0_36_1_Changed), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_3_Changed" ,getValue(A_ASG_15_1_0_36_3_Changed), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_3_Changed_range" ,getValue(A_ASG_15_1_0_36_3_Changed_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Changed_RecAdr" ,getValue(A_ASG_15_1_0_36_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Changed_Direction" ,getValue(A_ASG_15_1_0_36_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Changed_Shift" ,getValue(A_ASG_15_1_0_36_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Changed_TransPos" ,getValue(A_ASG_15_1_0_36_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Changed_IndexSize" ,getValue(A_ASG_15_1_0_36_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Changed_Start" ,getValue(A_ASG_15_1_0_36_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Changed_Elements" ,getValue(A_ASG_15_1_0_36_Changed_Elements), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_DataIndex_SetGet" ,getValue(A_ASG_15_1_0_36_DataIndex_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_DataIndex_SetGet_Incr" ,getValue(A_ASG_15_1_0_36_DataIndex_SetGet_Incr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_DataIndex_SetGet_Decr" ,getValue(A_ASG_15_1_0_36_DataIndex_SetGet_Decr), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_Data_4_SetGet" ,getValue(A_ASG_15_1_0_36_Data_4_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_Data_4_SetGet_range" ,getValue(A_ASG_15_1_0_36_Data_4_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_2_SetGet" ,getValue(A_ASG_15_1_0_36_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_3_SetGet" ,getValue(A_ASG_15_1_0_36_3_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_3_SetGet_range" ,getValue(A_ASG_15_1_0_36_3_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Data_3_SetGet" ,getValue(A_ASG_15_1_0_36_Data_3_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Data_3_SetGet_0" ,getValue(A_ASG_15_1_0_36_Data_3_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Data_3_SetGet_4" ,getValue(A_ASG_15_1_0_36_Data_3_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Data_3_SetGet_5" ,getValue(A_ASG_15_1_0_36_Data_3_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Data_3_SetGet_6" ,getValue(A_ASG_15_1_0_36_Data_3_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Data_3_SetGet_7" ,getValue(A_ASG_15_1_0_36_Data_3_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_4_SetGet" ,getValue(A_ASG_15_1_0_36_4_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_Data_2_SetGet" ,getValue(A_ASG_15_1_0_36_Data_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_Data_2_SetGet_range" ,getValue(A_ASG_15_1_0_36_Data_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_1_SetGet" ,getValue(A_ASG_15_1_0_36_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Data_5_SetGet_len" ,getValue(A_ASG_15_1_0_36_Data_5_SetGet_len), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_Data_5_SetGet_cnt" ,getValue(A_ASG_15_1_0_36_Data_5_SetGet_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_5_SetGet" ,getValue(A_ASG_15_1_0_36_5_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_5_SetGet_range" ,getValue(A_ASG_15_1_0_36_5_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_Data_1_SetGet" ,getValue(A_ASG_15_1_0_36_Data_1_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_15_1_0_36_Data_1_SetGet_range" ,getValue(A_ASG_15_1_0_36_Data_1_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_SetGet_RecAdr" ,getValue(A_ASG_15_1_0_36_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_SetGet_Direction" ,getValue(A_ASG_15_1_0_36_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_SetGet_Shift" ,getValue(A_ASG_15_1_0_36_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_SetGet_IndexSize" ,getValue(A_ASG_15_1_0_36_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_SetGet_Start" ,getValue(A_ASG_15_1_0_36_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_ASG_15_1_0_36_SetGet_Elements" ,getValue(A_ASG_15_1_0_36_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_37Get_BTN" ,getValue(P_ASG_15_1_0_37Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_37SetGet_BTN" ,getValue(P_ASG_15_1_0_37SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_37_FctLstItemEn" ,getValue(P_ASG_15_1_0_37_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_37_ErrCode" ,getValue(P_ASG_15_1_0_37_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_37_2" ,getValue(P_ASG_15_1_0_37_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_37_2_range" ,getValue(P_ASG_15_1_0_37_2_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_37_4" ,getValue(P_ASG_15_1_0_37_4), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_15_1_0_37_4_range" ,getValue(P_ASG_15_1_0_37_4_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_37_1" ,getValue(P_ASG_15_1_0_37_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_37_1_0" ,getValue(P_ASG_15_1_0_37_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_15_1_0_37_3" ,getValue(P_ASG_15_1_0_37_3), profileFile);
    writeProfileInt("BAP" ,"ERRORLIST_ASG69_0_VT" ,getValue(ERRORLIST_ASG69_0_VT), profileFile);
    writeProfileInt("BAP" ,"BusType_ASG69_0" ,getValue(BusType_ASG69_0), profileFile);
    writeProfileInt("BAP" ,"ON_OFF_ASG69_0" ,getValue(ON_OFF_ASG69_0), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_69_0_0_DFMajor" ,getValue(BAPCFG_ASG_69_0_0_DFMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_69_0_0_DFMinor" ,getValue(BAPCFG_ASG_69_0_0_DFMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_69_0_0_LsgClassMajor" ,getValue(BAPCFG_ASG_69_0_0_LsgClassMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_69_0_0_LsgClassMinor" ,getValue(BAPCFG_ASG_69_0_0_LsgClassMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_69_0_0_ProtocolMajor" ,getValue(BAPCFG_ASG_69_0_0_ProtocolMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_ASG_69_0_0_ProtocolMinor" ,getValue(BAPCFG_ASG_69_0_0_ProtocolMinor), profileFile);
    writeProfileInt("BAP" ,"C_ASG_69_0_0_1GetAll_BTN" ,getValue(C_ASG_69_0_0_1GetAll_BTN), profileFile);
    writeProfileInt("BAP" ,"C_ASG_69_0_0_1_FctLstItemEn" ,getValue(C_ASG_69_0_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_ASG_69_0_0_1_ErrCode" ,getValue(C_ASG_69_0_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_2Get_BTN" ,getValue(P_ASG_69_0_0_2Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_2_FctLstItemEn" ,getValue(P_ASG_69_0_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_2_ErrCode" ,getValue(P_ASG_69_0_0_2_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_2" ,getValue(P_ASG_69_0_0_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_2_range" ,getValue(P_ASG_69_0_0_2_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_3Get_BTN" ,getValue(P_ASG_69_0_0_3Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_3_FctLstItemEn" ,getValue(P_ASG_69_0_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_3_ErrCode" ,getValue(P_ASG_69_0_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_4Get_BTN" ,getValue(P_ASG_69_0_0_4Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_4_FctLstItemEn" ,getValue(P_ASG_69_0_0_4_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_4_ErrCode" ,getValue(P_ASG_69_0_0_4_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_4" ,getValue(P_ASG_69_0_0_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_13Get_BTN" ,getValue(P_ASG_69_0_0_13Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_13SetGet_BTN" ,getValue(P_ASG_69_0_0_13SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_13_FctLstItemEn" ,getValue(P_ASG_69_0_0_13_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_13_ErrCode" ,getValue(P_ASG_69_0_0_13_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_13" ,getValue(P_ASG_69_0_0_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_13_1" ,getValue(P_ASG_69_0_0_13_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_13_1_0" ,getValue(P_ASG_69_0_0_13_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14Get_BTN" ,getValue(P_ASG_69_0_0_14Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_FctLstItemEn" ,getValue(P_ASG_69_0_0_14_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_ErrCode" ,getValue(P_ASG_69_0_0_14_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_14_6" ,getValue(P_ASG_69_0_0_14_6), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_14_6_range" ,getValue(P_ASG_69_0_0_14_6_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_14_1" ,getValue(P_ASG_69_0_0_14_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_14_1_range" ,getValue(P_ASG_69_0_0_14_1_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_5" ,getValue(P_ASG_69_0_0_14_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_5_0" ,getValue(P_ASG_69_0_0_14_5_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_5_1" ,getValue(P_ASG_69_0_0_14_5_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_5_2" ,getValue(P_ASG_69_0_0_14_5_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_5_3" ,getValue(P_ASG_69_0_0_14_5_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_5_4" ,getValue(P_ASG_69_0_0_14_5_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_5_5" ,getValue(P_ASG_69_0_0_14_5_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_3" ,getValue(P_ASG_69_0_0_14_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_3_0" ,getValue(P_ASG_69_0_0_14_3_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_3_1" ,getValue(P_ASG_69_0_0_14_3_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_3_2" ,getValue(P_ASG_69_0_0_14_3_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_2" ,getValue(P_ASG_69_0_0_14_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_2_0" ,getValue(P_ASG_69_0_0_14_2_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_4" ,getValue(P_ASG_69_0_0_14_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_4_0" ,getValue(P_ASG_69_0_0_14_4_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_4_1" ,getValue(P_ASG_69_0_0_14_4_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_4_2" ,getValue(P_ASG_69_0_0_14_4_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_4_3" ,getValue(P_ASG_69_0_0_14_4_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_14_4_4" ,getValue(P_ASG_69_0_0_14_4_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_15Get_BTN" ,getValue(P_ASG_69_0_0_15Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_15_FctLstItemEn" ,getValue(P_ASG_69_0_0_15_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_15_ErrCode" ,getValue(P_ASG_69_0_0_15_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_15" ,getValue(P_ASG_69_0_0_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_15_1" ,getValue(P_ASG_69_0_0_15_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_16Get_BTN" ,getValue(P_ASG_69_0_0_16Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_16SetGet_BTN" ,getValue(P_ASG_69_0_0_16SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_16_FctLstItemEn" ,getValue(P_ASG_69_0_0_16_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_16_ErrCode" ,getValue(P_ASG_69_0_0_16_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_16_1" ,getValue(P_ASG_69_0_0_16_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_16_1_range" ,getValue(P_ASG_69_0_0_16_1_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_16_2" ,getValue(P_ASG_69_0_0_16_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_16_3" ,getValue(P_ASG_69_0_0_16_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_16_3_0" ,getValue(P_ASG_69_0_0_16_3_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_17Get_BTN" ,getValue(P_ASG_69_0_0_17Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_17SetGet_BTN" ,getValue(P_ASG_69_0_0_17SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_17_FctLstItemEn" ,getValue(P_ASG_69_0_0_17_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_17_ErrCode" ,getValue(P_ASG_69_0_0_17_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_17_1" ,getValue(P_ASG_69_0_0_17_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_17_1_range" ,getValue(P_ASG_69_0_0_17_1_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_17_2" ,getValue(P_ASG_69_0_0_17_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_17_3" ,getValue(P_ASG_69_0_0_17_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_17_3_0" ,getValue(P_ASG_69_0_0_17_3_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18Get_BTN" ,getValue(A_ASG_69_0_0_18Get_BTN), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18SetGet_BTN" ,getValue(A_ASG_69_0_0_18SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_FctLstItemEn" ,getValue(A_ASG_69_0_0_18_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_IntTlgEn" ,getValue(A_ASG_69_0_0_18_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_SegmEn" ,getValue(A_ASG_69_0_0_18_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_AT" ,getValue(A_ASG_69_0_0_18_AT), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_ErrCode" ,getValue(A_ASG_69_0_0_18_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_DataIndex" ,getValue(A_ASG_69_0_0_18_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_DataIndex_Incr" ,getValue(A_ASG_69_0_0_18_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_DataIndex_Decr" ,getValue(A_ASG_69_0_0_18_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_loadArray_Btn" ,getValue(A_ASG_69_0_0_18_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_generateData_Btn" ,getValue(A_ASG_69_0_0_18_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_Data_6_len" ,getValue(A_ASG_69_0_0_18_Data_6_len), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_Data_6_cnt" ,getValue(A_ASG_69_0_0_18_Data_6_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_Data_3" ,getValue(A_ASG_69_0_0_18_Data_3), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_Data_3_range" ,getValue(A_ASG_69_0_0_18_Data_3_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_Data_4" ,getValue(A_ASG_69_0_0_18_Data_4), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_Data_4_range" ,getValue(A_ASG_69_0_0_18_Data_4_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_3" ,getValue(A_ASG_69_0_0_18_3), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_3_range" ,getValue(A_ASG_69_0_0_18_3_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_Data_2" ,getValue(A_ASG_69_0_0_18_Data_2), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_Data_2_range" ,getValue(A_ASG_69_0_0_18_Data_2_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_1" ,getValue(A_ASG_69_0_0_18_1), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_Data_1" ,getValue(A_ASG_69_0_0_18_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_Data_1_range" ,getValue(A_ASG_69_0_0_18_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_2" ,getValue(A_ASG_69_0_0_18_2), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_2_range" ,getValue(A_ASG_69_0_0_18_2_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_Data_5" ,getValue(A_ASG_69_0_0_18_Data_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_RecAdr" ,getValue(A_ASG_69_0_0_18_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_Direction" ,getValue(A_ASG_69_0_0_18_Direction), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_Shift" ,getValue(A_ASG_69_0_0_18_Shift), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_TransPos" ,getValue(A_ASG_69_0_0_18_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_IndexSize" ,getValue(A_ASG_69_0_0_18_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_Start" ,getValue(A_ASG_69_0_0_18_Start), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_Elements" ,getValue(A_ASG_69_0_0_18_Elements), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_Changed_RecAdr" ,getValue(A_ASG_69_0_0_18_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_Changed_Direction" ,getValue(A_ASG_69_0_0_18_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_Changed_Shift" ,getValue(A_ASG_69_0_0_18_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_Changed_TransPos" ,getValue(A_ASG_69_0_0_18_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_Changed_IndexSize" ,getValue(A_ASG_69_0_0_18_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_Changed_Start" ,getValue(A_ASG_69_0_0_18_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_Changed_Elements" ,getValue(A_ASG_69_0_0_18_Changed_Elements), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_DataIndex_SetGet" ,getValue(A_ASG_69_0_0_18_DataIndex_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_DataIndex_SetGet_Incr" ,getValue(A_ASG_69_0_0_18_DataIndex_SetGet_Incr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_DataIndex_SetGet_Decr" ,getValue(A_ASG_69_0_0_18_DataIndex_SetGet_Decr), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_Data_4_SetGet" ,getValue(A_ASG_69_0_0_18_Data_4_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_Data_4_SetGet_range" ,getValue(A_ASG_69_0_0_18_Data_4_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_2_SetGet" ,getValue(A_ASG_69_0_0_18_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_2_SetGet_range" ,getValue(A_ASG_69_0_0_18_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_1_SetGet" ,getValue(A_ASG_69_0_0_18_1_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_Data_2_SetGet" ,getValue(A_ASG_69_0_0_18_Data_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_Data_2_SetGet_range" ,getValue(A_ASG_69_0_0_18_Data_2_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_Data_1_SetGet" ,getValue(A_ASG_69_0_0_18_Data_1_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_Data_1_SetGet_range" ,getValue(A_ASG_69_0_0_18_Data_1_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_Data_6_SetGet_len" ,getValue(A_ASG_69_0_0_18_Data_6_SetGet_len), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_Data_6_SetGet_cnt" ,getValue(A_ASG_69_0_0_18_Data_6_SetGet_cnt), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_Data_5_SetGet" ,getValue(A_ASG_69_0_0_18_Data_5_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_Data_3_SetGet" ,getValue(A_ASG_69_0_0_18_Data_3_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_18_Data_3_SetGet_range" ,getValue(A_ASG_69_0_0_18_Data_3_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_SetGet_RecAdr" ,getValue(A_ASG_69_0_0_18_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_SetGet_Direction" ,getValue(A_ASG_69_0_0_18_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_SetGet_Shift" ,getValue(A_ASG_69_0_0_18_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_SetGet_IndexSize" ,getValue(A_ASG_69_0_0_18_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_SetGet_Start" ,getValue(A_ASG_69_0_0_18_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_18_SetGet_Elements" ,getValue(A_ASG_69_0_0_18_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19Get_BTN" ,getValue(P_ASG_69_0_0_19Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_FctLstItemEn" ,getValue(P_ASG_69_0_0_19_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_ErrCode" ,getValue(P_ASG_69_0_0_19_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6" ,getValue(P_ASG_69_0_0_19_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_0" ,getValue(P_ASG_69_0_0_19_6_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_1" ,getValue(P_ASG_69_0_0_19_6_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_2" ,getValue(P_ASG_69_0_0_19_6_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_3" ,getValue(P_ASG_69_0_0_19_6_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_4" ,getValue(P_ASG_69_0_0_19_6_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_5" ,getValue(P_ASG_69_0_0_19_6_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_6" ,getValue(P_ASG_69_0_0_19_6_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_7" ,getValue(P_ASG_69_0_0_19_6_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_8" ,getValue(P_ASG_69_0_0_19_6_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_9" ,getValue(P_ASG_69_0_0_19_6_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_10" ,getValue(P_ASG_69_0_0_19_6_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_11" ,getValue(P_ASG_69_0_0_19_6_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_12" ,getValue(P_ASG_69_0_0_19_6_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_13" ,getValue(P_ASG_69_0_0_19_6_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_14" ,getValue(P_ASG_69_0_0_19_6_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_15" ,getValue(P_ASG_69_0_0_19_6_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_16" ,getValue(P_ASG_69_0_0_19_6_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_17" ,getValue(P_ASG_69_0_0_19_6_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_18" ,getValue(P_ASG_69_0_0_19_6_18), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_19" ,getValue(P_ASG_69_0_0_19_6_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_20" ,getValue(P_ASG_69_0_0_19_6_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_21" ,getValue(P_ASG_69_0_0_19_6_21), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_22" ,getValue(P_ASG_69_0_0_19_6_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_23" ,getValue(P_ASG_69_0_0_19_6_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_24" ,getValue(P_ASG_69_0_0_19_6_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_25" ,getValue(P_ASG_69_0_0_19_6_25), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_26" ,getValue(P_ASG_69_0_0_19_6_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_27" ,getValue(P_ASG_69_0_0_19_6_27), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_28" ,getValue(P_ASG_69_0_0_19_6_28), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_6_29" ,getValue(P_ASG_69_0_0_19_6_29), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5" ,getValue(P_ASG_69_0_0_19_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_0" ,getValue(P_ASG_69_0_0_19_5_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_1" ,getValue(P_ASG_69_0_0_19_5_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_2" ,getValue(P_ASG_69_0_0_19_5_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_3" ,getValue(P_ASG_69_0_0_19_5_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_4" ,getValue(P_ASG_69_0_0_19_5_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_5" ,getValue(P_ASG_69_0_0_19_5_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_6" ,getValue(P_ASG_69_0_0_19_5_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_7" ,getValue(P_ASG_69_0_0_19_5_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_8" ,getValue(P_ASG_69_0_0_19_5_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_9" ,getValue(P_ASG_69_0_0_19_5_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_10" ,getValue(P_ASG_69_0_0_19_5_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_11" ,getValue(P_ASG_69_0_0_19_5_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_12" ,getValue(P_ASG_69_0_0_19_5_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_13" ,getValue(P_ASG_69_0_0_19_5_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_14" ,getValue(P_ASG_69_0_0_19_5_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_15" ,getValue(P_ASG_69_0_0_19_5_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_16" ,getValue(P_ASG_69_0_0_19_5_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_17" ,getValue(P_ASG_69_0_0_19_5_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_18" ,getValue(P_ASG_69_0_0_19_5_18), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_19" ,getValue(P_ASG_69_0_0_19_5_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_20" ,getValue(P_ASG_69_0_0_19_5_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_21" ,getValue(P_ASG_69_0_0_19_5_21), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_22" ,getValue(P_ASG_69_0_0_19_5_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_23" ,getValue(P_ASG_69_0_0_19_5_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_24" ,getValue(P_ASG_69_0_0_19_5_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_25" ,getValue(P_ASG_69_0_0_19_5_25), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_26" ,getValue(P_ASG_69_0_0_19_5_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_27" ,getValue(P_ASG_69_0_0_19_5_27), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_28" ,getValue(P_ASG_69_0_0_19_5_28), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_29" ,getValue(P_ASG_69_0_0_19_5_29), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_30" ,getValue(P_ASG_69_0_0_19_5_30), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_5_31" ,getValue(P_ASG_69_0_0_19_5_31), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_2" ,getValue(P_ASG_69_0_0_19_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_2_0" ,getValue(P_ASG_69_0_0_19_2_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_2_1" ,getValue(P_ASG_69_0_0_19_2_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4" ,getValue(P_ASG_69_0_0_19_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_0" ,getValue(P_ASG_69_0_0_19_4_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_1" ,getValue(P_ASG_69_0_0_19_4_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_2" ,getValue(P_ASG_69_0_0_19_4_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_3" ,getValue(P_ASG_69_0_0_19_4_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_4" ,getValue(P_ASG_69_0_0_19_4_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_5" ,getValue(P_ASG_69_0_0_19_4_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_6" ,getValue(P_ASG_69_0_0_19_4_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_7" ,getValue(P_ASG_69_0_0_19_4_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_8" ,getValue(P_ASG_69_0_0_19_4_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_9" ,getValue(P_ASG_69_0_0_19_4_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_10" ,getValue(P_ASG_69_0_0_19_4_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_11" ,getValue(P_ASG_69_0_0_19_4_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_12" ,getValue(P_ASG_69_0_0_19_4_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_13" ,getValue(P_ASG_69_0_0_19_4_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_14" ,getValue(P_ASG_69_0_0_19_4_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_15" ,getValue(P_ASG_69_0_0_19_4_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_16" ,getValue(P_ASG_69_0_0_19_4_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_17" ,getValue(P_ASG_69_0_0_19_4_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_18" ,getValue(P_ASG_69_0_0_19_4_18), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_19" ,getValue(P_ASG_69_0_0_19_4_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_20" ,getValue(P_ASG_69_0_0_19_4_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_21" ,getValue(P_ASG_69_0_0_19_4_21), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_22" ,getValue(P_ASG_69_0_0_19_4_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_23" ,getValue(P_ASG_69_0_0_19_4_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_24" ,getValue(P_ASG_69_0_0_19_4_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_25" ,getValue(P_ASG_69_0_0_19_4_25), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_26" ,getValue(P_ASG_69_0_0_19_4_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_27" ,getValue(P_ASG_69_0_0_19_4_27), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_28" ,getValue(P_ASG_69_0_0_19_4_28), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_4_29" ,getValue(P_ASG_69_0_0_19_4_29), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3" ,getValue(P_ASG_69_0_0_19_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_0" ,getValue(P_ASG_69_0_0_19_3_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_1" ,getValue(P_ASG_69_0_0_19_3_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_2" ,getValue(P_ASG_69_0_0_19_3_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_3" ,getValue(P_ASG_69_0_0_19_3_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_4" ,getValue(P_ASG_69_0_0_19_3_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_5" ,getValue(P_ASG_69_0_0_19_3_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_6" ,getValue(P_ASG_69_0_0_19_3_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_7" ,getValue(P_ASG_69_0_0_19_3_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_8" ,getValue(P_ASG_69_0_0_19_3_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_9" ,getValue(P_ASG_69_0_0_19_3_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_10" ,getValue(P_ASG_69_0_0_19_3_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_11" ,getValue(P_ASG_69_0_0_19_3_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_12" ,getValue(P_ASG_69_0_0_19_3_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_13" ,getValue(P_ASG_69_0_0_19_3_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_14" ,getValue(P_ASG_69_0_0_19_3_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_15" ,getValue(P_ASG_69_0_0_19_3_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_16" ,getValue(P_ASG_69_0_0_19_3_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_17" ,getValue(P_ASG_69_0_0_19_3_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_18" ,getValue(P_ASG_69_0_0_19_3_18), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_19" ,getValue(P_ASG_69_0_0_19_3_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_20" ,getValue(P_ASG_69_0_0_19_3_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_21" ,getValue(P_ASG_69_0_0_19_3_21), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_22" ,getValue(P_ASG_69_0_0_19_3_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_23" ,getValue(P_ASG_69_0_0_19_3_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_24" ,getValue(P_ASG_69_0_0_19_3_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_25" ,getValue(P_ASG_69_0_0_19_3_25), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_26" ,getValue(P_ASG_69_0_0_19_3_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_27" ,getValue(P_ASG_69_0_0_19_3_27), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_28" ,getValue(P_ASG_69_0_0_19_3_28), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_29" ,getValue(P_ASG_69_0_0_19_3_29), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_30" ,getValue(P_ASG_69_0_0_19_3_30), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_3_31" ,getValue(P_ASG_69_0_0_19_3_31), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1" ,getValue(P_ASG_69_0_0_19_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_0" ,getValue(P_ASG_69_0_0_19_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_1" ,getValue(P_ASG_69_0_0_19_1_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_2" ,getValue(P_ASG_69_0_0_19_1_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_3" ,getValue(P_ASG_69_0_0_19_1_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_4" ,getValue(P_ASG_69_0_0_19_1_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_5" ,getValue(P_ASG_69_0_0_19_1_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_6" ,getValue(P_ASG_69_0_0_19_1_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_7" ,getValue(P_ASG_69_0_0_19_1_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_8" ,getValue(P_ASG_69_0_0_19_1_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_9" ,getValue(P_ASG_69_0_0_19_1_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_10" ,getValue(P_ASG_69_0_0_19_1_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_11" ,getValue(P_ASG_69_0_0_19_1_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_12" ,getValue(P_ASG_69_0_0_19_1_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_13" ,getValue(P_ASG_69_0_0_19_1_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_14" ,getValue(P_ASG_69_0_0_19_1_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_15" ,getValue(P_ASG_69_0_0_19_1_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_16" ,getValue(P_ASG_69_0_0_19_1_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_17" ,getValue(P_ASG_69_0_0_19_1_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_18" ,getValue(P_ASG_69_0_0_19_1_18), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_19" ,getValue(P_ASG_69_0_0_19_1_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_20" ,getValue(P_ASG_69_0_0_19_1_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_21" ,getValue(P_ASG_69_0_0_19_1_21), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_22" ,getValue(P_ASG_69_0_0_19_1_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_23" ,getValue(P_ASG_69_0_0_19_1_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_24" ,getValue(P_ASG_69_0_0_19_1_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_25" ,getValue(P_ASG_69_0_0_19_1_25), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_26" ,getValue(P_ASG_69_0_0_19_1_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_27" ,getValue(P_ASG_69_0_0_19_1_27), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_28" ,getValue(P_ASG_69_0_0_19_1_28), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_19_1_29" ,getValue(P_ASG_69_0_0_19_1_29), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20Get_BTN" ,getValue(P_ASG_69_0_0_20Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20SetGet_BTN" ,getValue(P_ASG_69_0_0_20SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_FctLstItemEn" ,getValue(P_ASG_69_0_0_20_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_ErrCode" ,getValue(P_ASG_69_0_0_20_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_20_3" ,getValue(P_ASG_69_0_0_20_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_20_3_range" ,getValue(P_ASG_69_0_0_20_3_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_20_2" ,getValue(P_ASG_69_0_0_20_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_20_2_range" ,getValue(P_ASG_69_0_0_20_2_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1" ,getValue(P_ASG_69_0_0_20_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_0" ,getValue(P_ASG_69_0_0_20_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_1" ,getValue(P_ASG_69_0_0_20_1_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_2" ,getValue(P_ASG_69_0_0_20_1_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_3" ,getValue(P_ASG_69_0_0_20_1_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_4" ,getValue(P_ASG_69_0_0_20_1_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_5" ,getValue(P_ASG_69_0_0_20_1_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_6" ,getValue(P_ASG_69_0_0_20_1_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_7" ,getValue(P_ASG_69_0_0_20_1_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_8" ,getValue(P_ASG_69_0_0_20_1_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_9" ,getValue(P_ASG_69_0_0_20_1_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_10" ,getValue(P_ASG_69_0_0_20_1_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_11" ,getValue(P_ASG_69_0_0_20_1_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_12" ,getValue(P_ASG_69_0_0_20_1_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_13" ,getValue(P_ASG_69_0_0_20_1_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_14" ,getValue(P_ASG_69_0_0_20_1_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_15" ,getValue(P_ASG_69_0_0_20_1_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_16" ,getValue(P_ASG_69_0_0_20_1_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_17" ,getValue(P_ASG_69_0_0_20_1_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_18" ,getValue(P_ASG_69_0_0_20_1_18), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_19" ,getValue(P_ASG_69_0_0_20_1_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_20" ,getValue(P_ASG_69_0_0_20_1_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_21" ,getValue(P_ASG_69_0_0_20_1_21), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_22" ,getValue(P_ASG_69_0_0_20_1_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_23" ,getValue(P_ASG_69_0_0_20_1_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_24" ,getValue(P_ASG_69_0_0_20_1_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_25" ,getValue(P_ASG_69_0_0_20_1_25), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_26" ,getValue(P_ASG_69_0_0_20_1_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_27" ,getValue(P_ASG_69_0_0_20_1_27), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_28" ,getValue(P_ASG_69_0_0_20_1_28), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_20_1_29" ,getValue(P_ASG_69_0_0_20_1_29), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21Get_BTN" ,getValue(P_ASG_69_0_0_21Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_FctLstItemEn" ,getValue(P_ASG_69_0_0_21_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_ErrCode" ,getValue(P_ASG_69_0_0_21_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6" ,getValue(P_ASG_69_0_0_21_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_0" ,getValue(P_ASG_69_0_0_21_6_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_1" ,getValue(P_ASG_69_0_0_21_6_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_2" ,getValue(P_ASG_69_0_0_21_6_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_3" ,getValue(P_ASG_69_0_0_21_6_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_4" ,getValue(P_ASG_69_0_0_21_6_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_5" ,getValue(P_ASG_69_0_0_21_6_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_6" ,getValue(P_ASG_69_0_0_21_6_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_7" ,getValue(P_ASG_69_0_0_21_6_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_8" ,getValue(P_ASG_69_0_0_21_6_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_9" ,getValue(P_ASG_69_0_0_21_6_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_10" ,getValue(P_ASG_69_0_0_21_6_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_11" ,getValue(P_ASG_69_0_0_21_6_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_12" ,getValue(P_ASG_69_0_0_21_6_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_13" ,getValue(P_ASG_69_0_0_21_6_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_14" ,getValue(P_ASG_69_0_0_21_6_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_15" ,getValue(P_ASG_69_0_0_21_6_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_16" ,getValue(P_ASG_69_0_0_21_6_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_17" ,getValue(P_ASG_69_0_0_21_6_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_18" ,getValue(P_ASG_69_0_0_21_6_18), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_19" ,getValue(P_ASG_69_0_0_21_6_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_20" ,getValue(P_ASG_69_0_0_21_6_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_21" ,getValue(P_ASG_69_0_0_21_6_21), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_22" ,getValue(P_ASG_69_0_0_21_6_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_23" ,getValue(P_ASG_69_0_0_21_6_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_24" ,getValue(P_ASG_69_0_0_21_6_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_25" ,getValue(P_ASG_69_0_0_21_6_25), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_26" ,getValue(P_ASG_69_0_0_21_6_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_27" ,getValue(P_ASG_69_0_0_21_6_27), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_28" ,getValue(P_ASG_69_0_0_21_6_28), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_6_29" ,getValue(P_ASG_69_0_0_21_6_29), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5" ,getValue(P_ASG_69_0_0_21_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_0" ,getValue(P_ASG_69_0_0_21_5_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_1" ,getValue(P_ASG_69_0_0_21_5_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_2" ,getValue(P_ASG_69_0_0_21_5_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_3" ,getValue(P_ASG_69_0_0_21_5_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_4" ,getValue(P_ASG_69_0_0_21_5_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_5" ,getValue(P_ASG_69_0_0_21_5_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_6" ,getValue(P_ASG_69_0_0_21_5_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_7" ,getValue(P_ASG_69_0_0_21_5_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_8" ,getValue(P_ASG_69_0_0_21_5_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_9" ,getValue(P_ASG_69_0_0_21_5_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_10" ,getValue(P_ASG_69_0_0_21_5_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_11" ,getValue(P_ASG_69_0_0_21_5_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_12" ,getValue(P_ASG_69_0_0_21_5_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_13" ,getValue(P_ASG_69_0_0_21_5_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_14" ,getValue(P_ASG_69_0_0_21_5_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_15" ,getValue(P_ASG_69_0_0_21_5_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_16" ,getValue(P_ASG_69_0_0_21_5_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_17" ,getValue(P_ASG_69_0_0_21_5_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_18" ,getValue(P_ASG_69_0_0_21_5_18), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_19" ,getValue(P_ASG_69_0_0_21_5_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_20" ,getValue(P_ASG_69_0_0_21_5_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_21" ,getValue(P_ASG_69_0_0_21_5_21), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_22" ,getValue(P_ASG_69_0_0_21_5_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_23" ,getValue(P_ASG_69_0_0_21_5_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_24" ,getValue(P_ASG_69_0_0_21_5_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_25" ,getValue(P_ASG_69_0_0_21_5_25), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_26" ,getValue(P_ASG_69_0_0_21_5_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_27" ,getValue(P_ASG_69_0_0_21_5_27), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_28" ,getValue(P_ASG_69_0_0_21_5_28), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_29" ,getValue(P_ASG_69_0_0_21_5_29), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_30" ,getValue(P_ASG_69_0_0_21_5_30), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_5_31" ,getValue(P_ASG_69_0_0_21_5_31), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_2" ,getValue(P_ASG_69_0_0_21_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_2_0" ,getValue(P_ASG_69_0_0_21_2_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_2_1" ,getValue(P_ASG_69_0_0_21_2_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4" ,getValue(P_ASG_69_0_0_21_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_0" ,getValue(P_ASG_69_0_0_21_4_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_1" ,getValue(P_ASG_69_0_0_21_4_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_2" ,getValue(P_ASG_69_0_0_21_4_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_3" ,getValue(P_ASG_69_0_0_21_4_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_4" ,getValue(P_ASG_69_0_0_21_4_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_5" ,getValue(P_ASG_69_0_0_21_4_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_6" ,getValue(P_ASG_69_0_0_21_4_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_7" ,getValue(P_ASG_69_0_0_21_4_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_8" ,getValue(P_ASG_69_0_0_21_4_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_9" ,getValue(P_ASG_69_0_0_21_4_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_10" ,getValue(P_ASG_69_0_0_21_4_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_11" ,getValue(P_ASG_69_0_0_21_4_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_12" ,getValue(P_ASG_69_0_0_21_4_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_13" ,getValue(P_ASG_69_0_0_21_4_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_14" ,getValue(P_ASG_69_0_0_21_4_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_15" ,getValue(P_ASG_69_0_0_21_4_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_16" ,getValue(P_ASG_69_0_0_21_4_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_17" ,getValue(P_ASG_69_0_0_21_4_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_18" ,getValue(P_ASG_69_0_0_21_4_18), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_19" ,getValue(P_ASG_69_0_0_21_4_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_20" ,getValue(P_ASG_69_0_0_21_4_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_21" ,getValue(P_ASG_69_0_0_21_4_21), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_22" ,getValue(P_ASG_69_0_0_21_4_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_23" ,getValue(P_ASG_69_0_0_21_4_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_24" ,getValue(P_ASG_69_0_0_21_4_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_25" ,getValue(P_ASG_69_0_0_21_4_25), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_26" ,getValue(P_ASG_69_0_0_21_4_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_27" ,getValue(P_ASG_69_0_0_21_4_27), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_28" ,getValue(P_ASG_69_0_0_21_4_28), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_4_29" ,getValue(P_ASG_69_0_0_21_4_29), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3" ,getValue(P_ASG_69_0_0_21_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_0" ,getValue(P_ASG_69_0_0_21_3_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_1" ,getValue(P_ASG_69_0_0_21_3_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_2" ,getValue(P_ASG_69_0_0_21_3_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_3" ,getValue(P_ASG_69_0_0_21_3_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_4" ,getValue(P_ASG_69_0_0_21_3_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_5" ,getValue(P_ASG_69_0_0_21_3_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_6" ,getValue(P_ASG_69_0_0_21_3_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_7" ,getValue(P_ASG_69_0_0_21_3_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_8" ,getValue(P_ASG_69_0_0_21_3_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_9" ,getValue(P_ASG_69_0_0_21_3_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_10" ,getValue(P_ASG_69_0_0_21_3_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_11" ,getValue(P_ASG_69_0_0_21_3_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_12" ,getValue(P_ASG_69_0_0_21_3_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_13" ,getValue(P_ASG_69_0_0_21_3_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_14" ,getValue(P_ASG_69_0_0_21_3_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_15" ,getValue(P_ASG_69_0_0_21_3_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_16" ,getValue(P_ASG_69_0_0_21_3_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_17" ,getValue(P_ASG_69_0_0_21_3_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_18" ,getValue(P_ASG_69_0_0_21_3_18), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_19" ,getValue(P_ASG_69_0_0_21_3_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_20" ,getValue(P_ASG_69_0_0_21_3_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_21" ,getValue(P_ASG_69_0_0_21_3_21), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_22" ,getValue(P_ASG_69_0_0_21_3_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_23" ,getValue(P_ASG_69_0_0_21_3_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_24" ,getValue(P_ASG_69_0_0_21_3_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_25" ,getValue(P_ASG_69_0_0_21_3_25), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_26" ,getValue(P_ASG_69_0_0_21_3_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_27" ,getValue(P_ASG_69_0_0_21_3_27), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_28" ,getValue(P_ASG_69_0_0_21_3_28), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_29" ,getValue(P_ASG_69_0_0_21_3_29), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_30" ,getValue(P_ASG_69_0_0_21_3_30), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_3_31" ,getValue(P_ASG_69_0_0_21_3_31), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1" ,getValue(P_ASG_69_0_0_21_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_0" ,getValue(P_ASG_69_0_0_21_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_1" ,getValue(P_ASG_69_0_0_21_1_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_2" ,getValue(P_ASG_69_0_0_21_1_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_3" ,getValue(P_ASG_69_0_0_21_1_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_4" ,getValue(P_ASG_69_0_0_21_1_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_5" ,getValue(P_ASG_69_0_0_21_1_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_6" ,getValue(P_ASG_69_0_0_21_1_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_7" ,getValue(P_ASG_69_0_0_21_1_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_8" ,getValue(P_ASG_69_0_0_21_1_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_9" ,getValue(P_ASG_69_0_0_21_1_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_10" ,getValue(P_ASG_69_0_0_21_1_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_11" ,getValue(P_ASG_69_0_0_21_1_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_12" ,getValue(P_ASG_69_0_0_21_1_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_13" ,getValue(P_ASG_69_0_0_21_1_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_14" ,getValue(P_ASG_69_0_0_21_1_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_15" ,getValue(P_ASG_69_0_0_21_1_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_16" ,getValue(P_ASG_69_0_0_21_1_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_17" ,getValue(P_ASG_69_0_0_21_1_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_18" ,getValue(P_ASG_69_0_0_21_1_18), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_19" ,getValue(P_ASG_69_0_0_21_1_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_20" ,getValue(P_ASG_69_0_0_21_1_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_21" ,getValue(P_ASG_69_0_0_21_1_21), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_22" ,getValue(P_ASG_69_0_0_21_1_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_23" ,getValue(P_ASG_69_0_0_21_1_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_24" ,getValue(P_ASG_69_0_0_21_1_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_25" ,getValue(P_ASG_69_0_0_21_1_25), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_26" ,getValue(P_ASG_69_0_0_21_1_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_27" ,getValue(P_ASG_69_0_0_21_1_27), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_28" ,getValue(P_ASG_69_0_0_21_1_28), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_21_1_29" ,getValue(P_ASG_69_0_0_21_1_29), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22Get_BTN" ,getValue(P_ASG_69_0_0_22Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22SetGet_BTN" ,getValue(P_ASG_69_0_0_22SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_FctLstItemEn" ,getValue(P_ASG_69_0_0_22_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_ErrCode" ,getValue(P_ASG_69_0_0_22_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_22_3" ,getValue(P_ASG_69_0_0_22_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_22_3_range" ,getValue(P_ASG_69_0_0_22_3_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_22_2" ,getValue(P_ASG_69_0_0_22_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_22_2_range" ,getValue(P_ASG_69_0_0_22_2_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1" ,getValue(P_ASG_69_0_0_22_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_0" ,getValue(P_ASG_69_0_0_22_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_1" ,getValue(P_ASG_69_0_0_22_1_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_2" ,getValue(P_ASG_69_0_0_22_1_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_3" ,getValue(P_ASG_69_0_0_22_1_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_4" ,getValue(P_ASG_69_0_0_22_1_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_5" ,getValue(P_ASG_69_0_0_22_1_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_6" ,getValue(P_ASG_69_0_0_22_1_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_7" ,getValue(P_ASG_69_0_0_22_1_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_8" ,getValue(P_ASG_69_0_0_22_1_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_9" ,getValue(P_ASG_69_0_0_22_1_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_10" ,getValue(P_ASG_69_0_0_22_1_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_11" ,getValue(P_ASG_69_0_0_22_1_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_12" ,getValue(P_ASG_69_0_0_22_1_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_13" ,getValue(P_ASG_69_0_0_22_1_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_14" ,getValue(P_ASG_69_0_0_22_1_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_15" ,getValue(P_ASG_69_0_0_22_1_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_16" ,getValue(P_ASG_69_0_0_22_1_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_17" ,getValue(P_ASG_69_0_0_22_1_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_18" ,getValue(P_ASG_69_0_0_22_1_18), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_19" ,getValue(P_ASG_69_0_0_22_1_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_20" ,getValue(P_ASG_69_0_0_22_1_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_21" ,getValue(P_ASG_69_0_0_22_1_21), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_22" ,getValue(P_ASG_69_0_0_22_1_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_23" ,getValue(P_ASG_69_0_0_22_1_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_24" ,getValue(P_ASG_69_0_0_22_1_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_25" ,getValue(P_ASG_69_0_0_22_1_25), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_26" ,getValue(P_ASG_69_0_0_22_1_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_27" ,getValue(P_ASG_69_0_0_22_1_27), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_28" ,getValue(P_ASG_69_0_0_22_1_28), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_22_1_29" ,getValue(P_ASG_69_0_0_22_1_29), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23Get_BTN" ,getValue(P_ASG_69_0_0_23Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_FctLstItemEn" ,getValue(P_ASG_69_0_0_23_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_ErrCode" ,getValue(P_ASG_69_0_0_23_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6" ,getValue(P_ASG_69_0_0_23_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_0" ,getValue(P_ASG_69_0_0_23_6_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_1" ,getValue(P_ASG_69_0_0_23_6_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_2" ,getValue(P_ASG_69_0_0_23_6_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_3" ,getValue(P_ASG_69_0_0_23_6_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_4" ,getValue(P_ASG_69_0_0_23_6_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_5" ,getValue(P_ASG_69_0_0_23_6_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_6" ,getValue(P_ASG_69_0_0_23_6_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_7" ,getValue(P_ASG_69_0_0_23_6_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_8" ,getValue(P_ASG_69_0_0_23_6_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_9" ,getValue(P_ASG_69_0_0_23_6_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_10" ,getValue(P_ASG_69_0_0_23_6_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_11" ,getValue(P_ASG_69_0_0_23_6_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_12" ,getValue(P_ASG_69_0_0_23_6_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_13" ,getValue(P_ASG_69_0_0_23_6_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_14" ,getValue(P_ASG_69_0_0_23_6_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_15" ,getValue(P_ASG_69_0_0_23_6_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_16" ,getValue(P_ASG_69_0_0_23_6_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_17" ,getValue(P_ASG_69_0_0_23_6_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_18" ,getValue(P_ASG_69_0_0_23_6_18), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_19" ,getValue(P_ASG_69_0_0_23_6_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_20" ,getValue(P_ASG_69_0_0_23_6_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_21" ,getValue(P_ASG_69_0_0_23_6_21), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_22" ,getValue(P_ASG_69_0_0_23_6_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_23" ,getValue(P_ASG_69_0_0_23_6_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_24" ,getValue(P_ASG_69_0_0_23_6_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_25" ,getValue(P_ASG_69_0_0_23_6_25), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_26" ,getValue(P_ASG_69_0_0_23_6_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_27" ,getValue(P_ASG_69_0_0_23_6_27), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_28" ,getValue(P_ASG_69_0_0_23_6_28), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_6_29" ,getValue(P_ASG_69_0_0_23_6_29), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5" ,getValue(P_ASG_69_0_0_23_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_0" ,getValue(P_ASG_69_0_0_23_5_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_1" ,getValue(P_ASG_69_0_0_23_5_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_2" ,getValue(P_ASG_69_0_0_23_5_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_3" ,getValue(P_ASG_69_0_0_23_5_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_4" ,getValue(P_ASG_69_0_0_23_5_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_5" ,getValue(P_ASG_69_0_0_23_5_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_6" ,getValue(P_ASG_69_0_0_23_5_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_7" ,getValue(P_ASG_69_0_0_23_5_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_8" ,getValue(P_ASG_69_0_0_23_5_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_9" ,getValue(P_ASG_69_0_0_23_5_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_10" ,getValue(P_ASG_69_0_0_23_5_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_11" ,getValue(P_ASG_69_0_0_23_5_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_12" ,getValue(P_ASG_69_0_0_23_5_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_13" ,getValue(P_ASG_69_0_0_23_5_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_14" ,getValue(P_ASG_69_0_0_23_5_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_15" ,getValue(P_ASG_69_0_0_23_5_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_16" ,getValue(P_ASG_69_0_0_23_5_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_17" ,getValue(P_ASG_69_0_0_23_5_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_18" ,getValue(P_ASG_69_0_0_23_5_18), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_19" ,getValue(P_ASG_69_0_0_23_5_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_20" ,getValue(P_ASG_69_0_0_23_5_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_21" ,getValue(P_ASG_69_0_0_23_5_21), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_22" ,getValue(P_ASG_69_0_0_23_5_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_23" ,getValue(P_ASG_69_0_0_23_5_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_24" ,getValue(P_ASG_69_0_0_23_5_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_25" ,getValue(P_ASG_69_0_0_23_5_25), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_26" ,getValue(P_ASG_69_0_0_23_5_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_27" ,getValue(P_ASG_69_0_0_23_5_27), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_28" ,getValue(P_ASG_69_0_0_23_5_28), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_29" ,getValue(P_ASG_69_0_0_23_5_29), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_30" ,getValue(P_ASG_69_0_0_23_5_30), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_5_31" ,getValue(P_ASG_69_0_0_23_5_31), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_2" ,getValue(P_ASG_69_0_0_23_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_2_0" ,getValue(P_ASG_69_0_0_23_2_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_2_1" ,getValue(P_ASG_69_0_0_23_2_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4" ,getValue(P_ASG_69_0_0_23_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_0" ,getValue(P_ASG_69_0_0_23_4_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_1" ,getValue(P_ASG_69_0_0_23_4_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_2" ,getValue(P_ASG_69_0_0_23_4_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_3" ,getValue(P_ASG_69_0_0_23_4_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_4" ,getValue(P_ASG_69_0_0_23_4_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_5" ,getValue(P_ASG_69_0_0_23_4_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_6" ,getValue(P_ASG_69_0_0_23_4_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_7" ,getValue(P_ASG_69_0_0_23_4_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_8" ,getValue(P_ASG_69_0_0_23_4_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_9" ,getValue(P_ASG_69_0_0_23_4_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_10" ,getValue(P_ASG_69_0_0_23_4_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_11" ,getValue(P_ASG_69_0_0_23_4_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_12" ,getValue(P_ASG_69_0_0_23_4_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_13" ,getValue(P_ASG_69_0_0_23_4_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_14" ,getValue(P_ASG_69_0_0_23_4_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_15" ,getValue(P_ASG_69_0_0_23_4_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_16" ,getValue(P_ASG_69_0_0_23_4_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_17" ,getValue(P_ASG_69_0_0_23_4_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_18" ,getValue(P_ASG_69_0_0_23_4_18), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_19" ,getValue(P_ASG_69_0_0_23_4_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_20" ,getValue(P_ASG_69_0_0_23_4_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_21" ,getValue(P_ASG_69_0_0_23_4_21), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_22" ,getValue(P_ASG_69_0_0_23_4_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_23" ,getValue(P_ASG_69_0_0_23_4_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_24" ,getValue(P_ASG_69_0_0_23_4_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_25" ,getValue(P_ASG_69_0_0_23_4_25), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_26" ,getValue(P_ASG_69_0_0_23_4_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_27" ,getValue(P_ASG_69_0_0_23_4_27), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_28" ,getValue(P_ASG_69_0_0_23_4_28), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_4_29" ,getValue(P_ASG_69_0_0_23_4_29), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3" ,getValue(P_ASG_69_0_0_23_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_0" ,getValue(P_ASG_69_0_0_23_3_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_1" ,getValue(P_ASG_69_0_0_23_3_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_2" ,getValue(P_ASG_69_0_0_23_3_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_3" ,getValue(P_ASG_69_0_0_23_3_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_4" ,getValue(P_ASG_69_0_0_23_3_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_5" ,getValue(P_ASG_69_0_0_23_3_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_6" ,getValue(P_ASG_69_0_0_23_3_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_7" ,getValue(P_ASG_69_0_0_23_3_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_8" ,getValue(P_ASG_69_0_0_23_3_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_9" ,getValue(P_ASG_69_0_0_23_3_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_10" ,getValue(P_ASG_69_0_0_23_3_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_11" ,getValue(P_ASG_69_0_0_23_3_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_12" ,getValue(P_ASG_69_0_0_23_3_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_13" ,getValue(P_ASG_69_0_0_23_3_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_14" ,getValue(P_ASG_69_0_0_23_3_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_15" ,getValue(P_ASG_69_0_0_23_3_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_16" ,getValue(P_ASG_69_0_0_23_3_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_17" ,getValue(P_ASG_69_0_0_23_3_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_18" ,getValue(P_ASG_69_0_0_23_3_18), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_19" ,getValue(P_ASG_69_0_0_23_3_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_20" ,getValue(P_ASG_69_0_0_23_3_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_21" ,getValue(P_ASG_69_0_0_23_3_21), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_22" ,getValue(P_ASG_69_0_0_23_3_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_23" ,getValue(P_ASG_69_0_0_23_3_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_24" ,getValue(P_ASG_69_0_0_23_3_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_25" ,getValue(P_ASG_69_0_0_23_3_25), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_26" ,getValue(P_ASG_69_0_0_23_3_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_27" ,getValue(P_ASG_69_0_0_23_3_27), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_28" ,getValue(P_ASG_69_0_0_23_3_28), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_29" ,getValue(P_ASG_69_0_0_23_3_29), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_30" ,getValue(P_ASG_69_0_0_23_3_30), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_3_31" ,getValue(P_ASG_69_0_0_23_3_31), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1" ,getValue(P_ASG_69_0_0_23_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_0" ,getValue(P_ASG_69_0_0_23_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_1" ,getValue(P_ASG_69_0_0_23_1_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_2" ,getValue(P_ASG_69_0_0_23_1_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_3" ,getValue(P_ASG_69_0_0_23_1_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_4" ,getValue(P_ASG_69_0_0_23_1_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_5" ,getValue(P_ASG_69_0_0_23_1_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_6" ,getValue(P_ASG_69_0_0_23_1_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_7" ,getValue(P_ASG_69_0_0_23_1_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_8" ,getValue(P_ASG_69_0_0_23_1_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_9" ,getValue(P_ASG_69_0_0_23_1_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_10" ,getValue(P_ASG_69_0_0_23_1_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_11" ,getValue(P_ASG_69_0_0_23_1_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_12" ,getValue(P_ASG_69_0_0_23_1_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_13" ,getValue(P_ASG_69_0_0_23_1_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_14" ,getValue(P_ASG_69_0_0_23_1_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_15" ,getValue(P_ASG_69_0_0_23_1_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_16" ,getValue(P_ASG_69_0_0_23_1_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_17" ,getValue(P_ASG_69_0_0_23_1_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_18" ,getValue(P_ASG_69_0_0_23_1_18), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_19" ,getValue(P_ASG_69_0_0_23_1_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_20" ,getValue(P_ASG_69_0_0_23_1_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_21" ,getValue(P_ASG_69_0_0_23_1_21), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_22" ,getValue(P_ASG_69_0_0_23_1_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_23" ,getValue(P_ASG_69_0_0_23_1_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_24" ,getValue(P_ASG_69_0_0_23_1_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_25" ,getValue(P_ASG_69_0_0_23_1_25), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_26" ,getValue(P_ASG_69_0_0_23_1_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_27" ,getValue(P_ASG_69_0_0_23_1_27), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_28" ,getValue(P_ASG_69_0_0_23_1_28), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_23_1_29" ,getValue(P_ASG_69_0_0_23_1_29), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24Get_BTN" ,getValue(P_ASG_69_0_0_24Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24SetGet_BTN" ,getValue(P_ASG_69_0_0_24SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_FctLstItemEn" ,getValue(P_ASG_69_0_0_24_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_ErrCode" ,getValue(P_ASG_69_0_0_24_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_24_3" ,getValue(P_ASG_69_0_0_24_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_24_3_range" ,getValue(P_ASG_69_0_0_24_3_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_24_2" ,getValue(P_ASG_69_0_0_24_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_24_2_range" ,getValue(P_ASG_69_0_0_24_2_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1" ,getValue(P_ASG_69_0_0_24_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_0" ,getValue(P_ASG_69_0_0_24_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_1" ,getValue(P_ASG_69_0_0_24_1_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_2" ,getValue(P_ASG_69_0_0_24_1_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_3" ,getValue(P_ASG_69_0_0_24_1_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_4" ,getValue(P_ASG_69_0_0_24_1_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_5" ,getValue(P_ASG_69_0_0_24_1_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_6" ,getValue(P_ASG_69_0_0_24_1_6), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_7" ,getValue(P_ASG_69_0_0_24_1_7), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_8" ,getValue(P_ASG_69_0_0_24_1_8), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_9" ,getValue(P_ASG_69_0_0_24_1_9), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_10" ,getValue(P_ASG_69_0_0_24_1_10), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_11" ,getValue(P_ASG_69_0_0_24_1_11), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_12" ,getValue(P_ASG_69_0_0_24_1_12), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_13" ,getValue(P_ASG_69_0_0_24_1_13), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_14" ,getValue(P_ASG_69_0_0_24_1_14), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_15" ,getValue(P_ASG_69_0_0_24_1_15), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_16" ,getValue(P_ASG_69_0_0_24_1_16), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_17" ,getValue(P_ASG_69_0_0_24_1_17), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_18" ,getValue(P_ASG_69_0_0_24_1_18), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_19" ,getValue(P_ASG_69_0_0_24_1_19), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_20" ,getValue(P_ASG_69_0_0_24_1_20), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_21" ,getValue(P_ASG_69_0_0_24_1_21), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_22" ,getValue(P_ASG_69_0_0_24_1_22), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_23" ,getValue(P_ASG_69_0_0_24_1_23), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_24" ,getValue(P_ASG_69_0_0_24_1_24), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_25" ,getValue(P_ASG_69_0_0_24_1_25), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_26" ,getValue(P_ASG_69_0_0_24_1_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_27" ,getValue(P_ASG_69_0_0_24_1_27), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_28" ,getValue(P_ASG_69_0_0_24_1_28), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_24_1_29" ,getValue(P_ASG_69_0_0_24_1_29), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_25Get_BTN" ,getValue(P_ASG_69_0_0_25Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_25SetGet_BTN" ,getValue(P_ASG_69_0_0_25SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_25_FctLstItemEn" ,getValue(P_ASG_69_0_0_25_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_25_ErrCode" ,getValue(P_ASG_69_0_0_25_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_25_2" ,getValue(P_ASG_69_0_0_25_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_25_2_range" ,getValue(P_ASG_69_0_0_25_2_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_25_1" ,getValue(P_ASG_69_0_0_25_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_25_1_0" ,getValue(P_ASG_69_0_0_25_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_25_1_1" ,getValue(P_ASG_69_0_0_25_1_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_25_1_2" ,getValue(P_ASG_69_0_0_25_1_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_25_3" ,getValue(P_ASG_69_0_0_25_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_25_4" ,getValue(P_ASG_69_0_0_25_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_25_4_0" ,getValue(P_ASG_69_0_0_25_4_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_26Get_BTN" ,getValue(P_ASG_69_0_0_26Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_26SetGet_BTN" ,getValue(P_ASG_69_0_0_26SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_26_FctLstItemEn" ,getValue(P_ASG_69_0_0_26_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_26_ErrCode" ,getValue(P_ASG_69_0_0_26_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_26" ,getValue(P_ASG_69_0_0_26), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_26_1" ,getValue(P_ASG_69_0_0_26_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_26_1_0" ,getValue(P_ASG_69_0_0_26_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_26_1_1" ,getValue(P_ASG_69_0_0_26_1_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_26_1_2" ,getValue(P_ASG_69_0_0_26_1_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_26_1_3" ,getValue(P_ASG_69_0_0_26_1_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_26_1_4" ,getValue(P_ASG_69_0_0_26_1_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_26_1_5" ,getValue(P_ASG_69_0_0_26_1_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27Get_BTN" ,getValue(A_ASG_69_0_0_27Get_BTN), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27SetGet_BTN" ,getValue(A_ASG_69_0_0_27SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_FctLstItemEn" ,getValue(A_ASG_69_0_0_27_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_IntTlgEn" ,getValue(A_ASG_69_0_0_27_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_SegmEn" ,getValue(A_ASG_69_0_0_27_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_AT" ,getValue(A_ASG_69_0_0_27_AT), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_ErrCode" ,getValue(A_ASG_69_0_0_27_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_DataIndex" ,getValue(A_ASG_69_0_0_27_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_DataIndex_Incr" ,getValue(A_ASG_69_0_0_27_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_DataIndex_Decr" ,getValue(A_ASG_69_0_0_27_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_loadArray_Btn" ,getValue(A_ASG_69_0_0_27_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_generateData_Btn" ,getValue(A_ASG_69_0_0_27_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_3" ,getValue(A_ASG_69_0_0_27_Data_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_1" ,getValue(A_ASG_69_0_0_27_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10" ,getValue(A_ASG_69_0_0_27_Data_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_0" ,getValue(A_ASG_69_0_0_27_Data_10_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_1" ,getValue(A_ASG_69_0_0_27_Data_10_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_2" ,getValue(A_ASG_69_0_0_27_Data_10_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_3" ,getValue(A_ASG_69_0_0_27_Data_10_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_4" ,getValue(A_ASG_69_0_0_27_Data_10_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_5" ,getValue(A_ASG_69_0_0_27_Data_10_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_6" ,getValue(A_ASG_69_0_0_27_Data_10_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_7" ,getValue(A_ASG_69_0_0_27_Data_10_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_8" ,getValue(A_ASG_69_0_0_27_Data_10_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_9" ,getValue(A_ASG_69_0_0_27_Data_10_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_10" ,getValue(A_ASG_69_0_0_27_Data_10_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_11" ,getValue(A_ASG_69_0_0_27_Data_10_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_12" ,getValue(A_ASG_69_0_0_27_Data_10_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_13" ,getValue(A_ASG_69_0_0_27_Data_10_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_14" ,getValue(A_ASG_69_0_0_27_Data_10_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_15" ,getValue(A_ASG_69_0_0_27_Data_10_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_16" ,getValue(A_ASG_69_0_0_27_Data_10_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_17" ,getValue(A_ASG_69_0_0_27_Data_10_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_18" ,getValue(A_ASG_69_0_0_27_Data_10_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_19" ,getValue(A_ASG_69_0_0_27_Data_10_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_20" ,getValue(A_ASG_69_0_0_27_Data_10_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_21" ,getValue(A_ASG_69_0_0_27_Data_10_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_22" ,getValue(A_ASG_69_0_0_27_Data_10_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_23" ,getValue(A_ASG_69_0_0_27_Data_10_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_24" ,getValue(A_ASG_69_0_0_27_Data_10_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_25" ,getValue(A_ASG_69_0_0_27_Data_10_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_26" ,getValue(A_ASG_69_0_0_27_Data_10_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_27" ,getValue(A_ASG_69_0_0_27_Data_10_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17" ,getValue(A_ASG_69_0_0_27_Data_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_0" ,getValue(A_ASG_69_0_0_27_Data_17_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_1" ,getValue(A_ASG_69_0_0_27_Data_17_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_2" ,getValue(A_ASG_69_0_0_27_Data_17_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_3" ,getValue(A_ASG_69_0_0_27_Data_17_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_4" ,getValue(A_ASG_69_0_0_27_Data_17_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_5" ,getValue(A_ASG_69_0_0_27_Data_17_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_6" ,getValue(A_ASG_69_0_0_27_Data_17_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_7" ,getValue(A_ASG_69_0_0_27_Data_17_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_8" ,getValue(A_ASG_69_0_0_27_Data_17_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_9" ,getValue(A_ASG_69_0_0_27_Data_17_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_10" ,getValue(A_ASG_69_0_0_27_Data_17_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_11" ,getValue(A_ASG_69_0_0_27_Data_17_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_12" ,getValue(A_ASG_69_0_0_27_Data_17_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_13" ,getValue(A_ASG_69_0_0_27_Data_17_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_14" ,getValue(A_ASG_69_0_0_27_Data_17_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_15" ,getValue(A_ASG_69_0_0_27_Data_17_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_16" ,getValue(A_ASG_69_0_0_27_Data_17_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_17" ,getValue(A_ASG_69_0_0_27_Data_17_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_18" ,getValue(A_ASG_69_0_0_27_Data_17_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_19" ,getValue(A_ASG_69_0_0_27_Data_17_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_20" ,getValue(A_ASG_69_0_0_27_Data_17_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_21" ,getValue(A_ASG_69_0_0_27_Data_17_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_22" ,getValue(A_ASG_69_0_0_27_Data_17_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_23" ,getValue(A_ASG_69_0_0_27_Data_17_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_24" ,getValue(A_ASG_69_0_0_27_Data_17_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_25" ,getValue(A_ASG_69_0_0_27_Data_17_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_26" ,getValue(A_ASG_69_0_0_27_Data_17_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_27" ,getValue(A_ASG_69_0_0_27_Data_17_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_28" ,getValue(A_ASG_69_0_0_27_Data_17_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_29" ,getValue(A_ASG_69_0_0_27_Data_17_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16" ,getValue(A_ASG_69_0_0_27_Data_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_0" ,getValue(A_ASG_69_0_0_27_Data_16_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_1" ,getValue(A_ASG_69_0_0_27_Data_16_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_2" ,getValue(A_ASG_69_0_0_27_Data_16_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_3" ,getValue(A_ASG_69_0_0_27_Data_16_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_4" ,getValue(A_ASG_69_0_0_27_Data_16_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_5" ,getValue(A_ASG_69_0_0_27_Data_16_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_6" ,getValue(A_ASG_69_0_0_27_Data_16_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_7" ,getValue(A_ASG_69_0_0_27_Data_16_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_8" ,getValue(A_ASG_69_0_0_27_Data_16_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_9" ,getValue(A_ASG_69_0_0_27_Data_16_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_10" ,getValue(A_ASG_69_0_0_27_Data_16_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_11" ,getValue(A_ASG_69_0_0_27_Data_16_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_12" ,getValue(A_ASG_69_0_0_27_Data_16_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_13" ,getValue(A_ASG_69_0_0_27_Data_16_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_14" ,getValue(A_ASG_69_0_0_27_Data_16_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_15" ,getValue(A_ASG_69_0_0_27_Data_16_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_16" ,getValue(A_ASG_69_0_0_27_Data_16_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_17" ,getValue(A_ASG_69_0_0_27_Data_16_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_18" ,getValue(A_ASG_69_0_0_27_Data_16_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_19" ,getValue(A_ASG_69_0_0_27_Data_16_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_20" ,getValue(A_ASG_69_0_0_27_Data_16_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_21" ,getValue(A_ASG_69_0_0_27_Data_16_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_22" ,getValue(A_ASG_69_0_0_27_Data_16_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_23" ,getValue(A_ASG_69_0_0_27_Data_16_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_24" ,getValue(A_ASG_69_0_0_27_Data_16_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_25" ,getValue(A_ASG_69_0_0_27_Data_16_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_26" ,getValue(A_ASG_69_0_0_27_Data_16_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_27" ,getValue(A_ASG_69_0_0_27_Data_16_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_28" ,getValue(A_ASG_69_0_0_27_Data_16_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_29" ,getValue(A_ASG_69_0_0_27_Data_16_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_30" ,getValue(A_ASG_69_0_0_27_Data_16_30), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_31" ,getValue(A_ASG_69_0_0_27_Data_16_31), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15" ,getValue(A_ASG_69_0_0_27_Data_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_0" ,getValue(A_ASG_69_0_0_27_Data_15_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_1" ,getValue(A_ASG_69_0_0_27_Data_15_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_2" ,getValue(A_ASG_69_0_0_27_Data_15_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_3" ,getValue(A_ASG_69_0_0_27_Data_15_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_4" ,getValue(A_ASG_69_0_0_27_Data_15_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_5" ,getValue(A_ASG_69_0_0_27_Data_15_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_6" ,getValue(A_ASG_69_0_0_27_Data_15_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_7" ,getValue(A_ASG_69_0_0_27_Data_15_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_8" ,getValue(A_ASG_69_0_0_27_Data_15_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_9" ,getValue(A_ASG_69_0_0_27_Data_15_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_10" ,getValue(A_ASG_69_0_0_27_Data_15_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_11" ,getValue(A_ASG_69_0_0_27_Data_15_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_12" ,getValue(A_ASG_69_0_0_27_Data_15_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_13" ,getValue(A_ASG_69_0_0_27_Data_15_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_14" ,getValue(A_ASG_69_0_0_27_Data_15_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_15" ,getValue(A_ASG_69_0_0_27_Data_15_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_16" ,getValue(A_ASG_69_0_0_27_Data_15_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_17" ,getValue(A_ASG_69_0_0_27_Data_15_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_18" ,getValue(A_ASG_69_0_0_27_Data_15_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_19" ,getValue(A_ASG_69_0_0_27_Data_15_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_20" ,getValue(A_ASG_69_0_0_27_Data_15_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_21" ,getValue(A_ASG_69_0_0_27_Data_15_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_22" ,getValue(A_ASG_69_0_0_27_Data_15_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_23" ,getValue(A_ASG_69_0_0_27_Data_15_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_24" ,getValue(A_ASG_69_0_0_27_Data_15_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_25" ,getValue(A_ASG_69_0_0_27_Data_15_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_26" ,getValue(A_ASG_69_0_0_27_Data_15_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_27" ,getValue(A_ASG_69_0_0_27_Data_15_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14" ,getValue(A_ASG_69_0_0_27_Data_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_0" ,getValue(A_ASG_69_0_0_27_Data_14_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_1" ,getValue(A_ASG_69_0_0_27_Data_14_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_2" ,getValue(A_ASG_69_0_0_27_Data_14_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_3" ,getValue(A_ASG_69_0_0_27_Data_14_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_4" ,getValue(A_ASG_69_0_0_27_Data_14_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_5" ,getValue(A_ASG_69_0_0_27_Data_14_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_6" ,getValue(A_ASG_69_0_0_27_Data_14_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_7" ,getValue(A_ASG_69_0_0_27_Data_14_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_8" ,getValue(A_ASG_69_0_0_27_Data_14_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_9" ,getValue(A_ASG_69_0_0_27_Data_14_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_10" ,getValue(A_ASG_69_0_0_27_Data_14_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_11" ,getValue(A_ASG_69_0_0_27_Data_14_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_12" ,getValue(A_ASG_69_0_0_27_Data_14_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_13" ,getValue(A_ASG_69_0_0_27_Data_14_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_14" ,getValue(A_ASG_69_0_0_27_Data_14_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_15" ,getValue(A_ASG_69_0_0_27_Data_14_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_16" ,getValue(A_ASG_69_0_0_27_Data_14_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_17" ,getValue(A_ASG_69_0_0_27_Data_14_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_18" ,getValue(A_ASG_69_0_0_27_Data_14_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_19" ,getValue(A_ASG_69_0_0_27_Data_14_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_20" ,getValue(A_ASG_69_0_0_27_Data_14_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_21" ,getValue(A_ASG_69_0_0_27_Data_14_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_22" ,getValue(A_ASG_69_0_0_27_Data_14_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_23" ,getValue(A_ASG_69_0_0_27_Data_14_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_24" ,getValue(A_ASG_69_0_0_27_Data_14_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_25" ,getValue(A_ASG_69_0_0_27_Data_14_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_26" ,getValue(A_ASG_69_0_0_27_Data_14_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_27" ,getValue(A_ASG_69_0_0_27_Data_14_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_28" ,getValue(A_ASG_69_0_0_27_Data_14_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_29" ,getValue(A_ASG_69_0_0_27_Data_14_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13" ,getValue(A_ASG_69_0_0_27_Data_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_0" ,getValue(A_ASG_69_0_0_27_Data_13_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_1" ,getValue(A_ASG_69_0_0_27_Data_13_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_2" ,getValue(A_ASG_69_0_0_27_Data_13_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_3" ,getValue(A_ASG_69_0_0_27_Data_13_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_4" ,getValue(A_ASG_69_0_0_27_Data_13_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_5" ,getValue(A_ASG_69_0_0_27_Data_13_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_6" ,getValue(A_ASG_69_0_0_27_Data_13_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_7" ,getValue(A_ASG_69_0_0_27_Data_13_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_8" ,getValue(A_ASG_69_0_0_27_Data_13_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_9" ,getValue(A_ASG_69_0_0_27_Data_13_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_10" ,getValue(A_ASG_69_0_0_27_Data_13_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_11" ,getValue(A_ASG_69_0_0_27_Data_13_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_12" ,getValue(A_ASG_69_0_0_27_Data_13_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_13" ,getValue(A_ASG_69_0_0_27_Data_13_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_14" ,getValue(A_ASG_69_0_0_27_Data_13_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_15" ,getValue(A_ASG_69_0_0_27_Data_13_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_16" ,getValue(A_ASG_69_0_0_27_Data_13_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_17" ,getValue(A_ASG_69_0_0_27_Data_13_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_18" ,getValue(A_ASG_69_0_0_27_Data_13_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_19" ,getValue(A_ASG_69_0_0_27_Data_13_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_20" ,getValue(A_ASG_69_0_0_27_Data_13_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_21" ,getValue(A_ASG_69_0_0_27_Data_13_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_22" ,getValue(A_ASG_69_0_0_27_Data_13_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_23" ,getValue(A_ASG_69_0_0_27_Data_13_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_24" ,getValue(A_ASG_69_0_0_27_Data_13_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_25" ,getValue(A_ASG_69_0_0_27_Data_13_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_26" ,getValue(A_ASG_69_0_0_27_Data_13_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_27" ,getValue(A_ASG_69_0_0_27_Data_13_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_28" ,getValue(A_ASG_69_0_0_27_Data_13_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_29" ,getValue(A_ASG_69_0_0_27_Data_13_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_30" ,getValue(A_ASG_69_0_0_27_Data_13_30), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_31" ,getValue(A_ASG_69_0_0_27_Data_13_31), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9" ,getValue(A_ASG_69_0_0_27_Data_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_0" ,getValue(A_ASG_69_0_0_27_Data_9_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_1" ,getValue(A_ASG_69_0_0_27_Data_9_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_2" ,getValue(A_ASG_69_0_0_27_Data_9_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_3" ,getValue(A_ASG_69_0_0_27_Data_9_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_4" ,getValue(A_ASG_69_0_0_27_Data_9_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_5" ,getValue(A_ASG_69_0_0_27_Data_9_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_6" ,getValue(A_ASG_69_0_0_27_Data_9_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_7" ,getValue(A_ASG_69_0_0_27_Data_9_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_8" ,getValue(A_ASG_69_0_0_27_Data_9_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_9" ,getValue(A_ASG_69_0_0_27_Data_9_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_10" ,getValue(A_ASG_69_0_0_27_Data_9_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_11" ,getValue(A_ASG_69_0_0_27_Data_9_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_12" ,getValue(A_ASG_69_0_0_27_Data_9_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_13" ,getValue(A_ASG_69_0_0_27_Data_9_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_14" ,getValue(A_ASG_69_0_0_27_Data_9_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_15" ,getValue(A_ASG_69_0_0_27_Data_9_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_16" ,getValue(A_ASG_69_0_0_27_Data_9_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_17" ,getValue(A_ASG_69_0_0_27_Data_9_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_18" ,getValue(A_ASG_69_0_0_27_Data_9_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_19" ,getValue(A_ASG_69_0_0_27_Data_9_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_20" ,getValue(A_ASG_69_0_0_27_Data_9_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_21" ,getValue(A_ASG_69_0_0_27_Data_9_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_22" ,getValue(A_ASG_69_0_0_27_Data_9_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_23" ,getValue(A_ASG_69_0_0_27_Data_9_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_24" ,getValue(A_ASG_69_0_0_27_Data_9_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_25" ,getValue(A_ASG_69_0_0_27_Data_9_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_26" ,getValue(A_ASG_69_0_0_27_Data_9_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_27" ,getValue(A_ASG_69_0_0_27_Data_9_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_28" ,getValue(A_ASG_69_0_0_27_Data_9_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_29" ,getValue(A_ASG_69_0_0_27_Data_9_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8" ,getValue(A_ASG_69_0_0_27_Data_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_0" ,getValue(A_ASG_69_0_0_27_Data_8_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_1" ,getValue(A_ASG_69_0_0_27_Data_8_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_2" ,getValue(A_ASG_69_0_0_27_Data_8_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_3" ,getValue(A_ASG_69_0_0_27_Data_8_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_4" ,getValue(A_ASG_69_0_0_27_Data_8_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_5" ,getValue(A_ASG_69_0_0_27_Data_8_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_6" ,getValue(A_ASG_69_0_0_27_Data_8_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_7" ,getValue(A_ASG_69_0_0_27_Data_8_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_8" ,getValue(A_ASG_69_0_0_27_Data_8_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_9" ,getValue(A_ASG_69_0_0_27_Data_8_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_10" ,getValue(A_ASG_69_0_0_27_Data_8_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_11" ,getValue(A_ASG_69_0_0_27_Data_8_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_12" ,getValue(A_ASG_69_0_0_27_Data_8_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_13" ,getValue(A_ASG_69_0_0_27_Data_8_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_14" ,getValue(A_ASG_69_0_0_27_Data_8_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_15" ,getValue(A_ASG_69_0_0_27_Data_8_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_16" ,getValue(A_ASG_69_0_0_27_Data_8_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_17" ,getValue(A_ASG_69_0_0_27_Data_8_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_18" ,getValue(A_ASG_69_0_0_27_Data_8_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_19" ,getValue(A_ASG_69_0_0_27_Data_8_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_20" ,getValue(A_ASG_69_0_0_27_Data_8_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_21" ,getValue(A_ASG_69_0_0_27_Data_8_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_22" ,getValue(A_ASG_69_0_0_27_Data_8_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_23" ,getValue(A_ASG_69_0_0_27_Data_8_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_24" ,getValue(A_ASG_69_0_0_27_Data_8_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_25" ,getValue(A_ASG_69_0_0_27_Data_8_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_26" ,getValue(A_ASG_69_0_0_27_Data_8_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_27" ,getValue(A_ASG_69_0_0_27_Data_8_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_28" ,getValue(A_ASG_69_0_0_27_Data_8_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_29" ,getValue(A_ASG_69_0_0_27_Data_8_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_30" ,getValue(A_ASG_69_0_0_27_Data_8_30), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_31" ,getValue(A_ASG_69_0_0_27_Data_8_31), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_27_3" ,getValue(A_ASG_69_0_0_27_3), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_27_3_range" ,getValue(A_ASG_69_0_0_27_3_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_2" ,getValue(A_ASG_69_0_0_27_Data_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_20_len" ,getValue(A_ASG_69_0_0_27_Data_20_len), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_20_cnt" ,getValue(A_ASG_69_0_0_27_Data_20_cnt), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5" ,getValue(A_ASG_69_0_0_27_Data_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_0" ,getValue(A_ASG_69_0_0_27_Data_5_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_1" ,getValue(A_ASG_69_0_0_27_Data_5_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_2" ,getValue(A_ASG_69_0_0_27_Data_5_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_3" ,getValue(A_ASG_69_0_0_27_Data_5_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_4" ,getValue(A_ASG_69_0_0_27_Data_5_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_5" ,getValue(A_ASG_69_0_0_27_Data_5_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_6" ,getValue(A_ASG_69_0_0_27_Data_5_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_7" ,getValue(A_ASG_69_0_0_27_Data_5_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_8" ,getValue(A_ASG_69_0_0_27_Data_5_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_9" ,getValue(A_ASG_69_0_0_27_Data_5_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_10" ,getValue(A_ASG_69_0_0_27_Data_5_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_11" ,getValue(A_ASG_69_0_0_27_Data_5_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_12" ,getValue(A_ASG_69_0_0_27_Data_5_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_13" ,getValue(A_ASG_69_0_0_27_Data_5_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_14" ,getValue(A_ASG_69_0_0_27_Data_5_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_15" ,getValue(A_ASG_69_0_0_27_Data_5_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_16" ,getValue(A_ASG_69_0_0_27_Data_5_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_17" ,getValue(A_ASG_69_0_0_27_Data_5_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_18" ,getValue(A_ASG_69_0_0_27_Data_5_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_19" ,getValue(A_ASG_69_0_0_27_Data_5_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_20" ,getValue(A_ASG_69_0_0_27_Data_5_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_21" ,getValue(A_ASG_69_0_0_27_Data_5_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_22" ,getValue(A_ASG_69_0_0_27_Data_5_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_23" ,getValue(A_ASG_69_0_0_27_Data_5_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_24" ,getValue(A_ASG_69_0_0_27_Data_5_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_25" ,getValue(A_ASG_69_0_0_27_Data_5_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_26" ,getValue(A_ASG_69_0_0_27_Data_5_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_27" ,getValue(A_ASG_69_0_0_27_Data_5_27), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_27_Data_4" ,getValue(A_ASG_69_0_0_27_Data_4), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_27_Data_4_range" ,getValue(A_ASG_69_0_0_27_Data_4_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_27_Data_1" ,getValue(A_ASG_69_0_0_27_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_27_Data_1_range" ,getValue(A_ASG_69_0_0_27_Data_1_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19" ,getValue(A_ASG_69_0_0_27_Data_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_0" ,getValue(A_ASG_69_0_0_27_Data_19_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_1" ,getValue(A_ASG_69_0_0_27_Data_19_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_2" ,getValue(A_ASG_69_0_0_27_Data_19_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_3" ,getValue(A_ASG_69_0_0_27_Data_19_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_4" ,getValue(A_ASG_69_0_0_27_Data_19_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_5" ,getValue(A_ASG_69_0_0_27_Data_19_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_6" ,getValue(A_ASG_69_0_0_27_Data_19_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_7" ,getValue(A_ASG_69_0_0_27_Data_19_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_8" ,getValue(A_ASG_69_0_0_27_Data_19_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_9" ,getValue(A_ASG_69_0_0_27_Data_19_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_10" ,getValue(A_ASG_69_0_0_27_Data_19_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_11" ,getValue(A_ASG_69_0_0_27_Data_19_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_12" ,getValue(A_ASG_69_0_0_27_Data_19_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_13" ,getValue(A_ASG_69_0_0_27_Data_19_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_14" ,getValue(A_ASG_69_0_0_27_Data_19_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_15" ,getValue(A_ASG_69_0_0_27_Data_19_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_16" ,getValue(A_ASG_69_0_0_27_Data_19_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_17" ,getValue(A_ASG_69_0_0_27_Data_19_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_18" ,getValue(A_ASG_69_0_0_27_Data_19_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_19" ,getValue(A_ASG_69_0_0_27_Data_19_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_20" ,getValue(A_ASG_69_0_0_27_Data_19_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_21" ,getValue(A_ASG_69_0_0_27_Data_19_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_22" ,getValue(A_ASG_69_0_0_27_Data_19_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_23" ,getValue(A_ASG_69_0_0_27_Data_19_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_24" ,getValue(A_ASG_69_0_0_27_Data_19_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_25" ,getValue(A_ASG_69_0_0_27_Data_19_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_26" ,getValue(A_ASG_69_0_0_27_Data_19_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_27" ,getValue(A_ASG_69_0_0_27_Data_19_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_28" ,getValue(A_ASG_69_0_0_27_Data_19_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_29" ,getValue(A_ASG_69_0_0_27_Data_19_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18" ,getValue(A_ASG_69_0_0_27_Data_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_0" ,getValue(A_ASG_69_0_0_27_Data_18_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_1" ,getValue(A_ASG_69_0_0_27_Data_18_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_2" ,getValue(A_ASG_69_0_0_27_Data_18_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_3" ,getValue(A_ASG_69_0_0_27_Data_18_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_4" ,getValue(A_ASG_69_0_0_27_Data_18_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_5" ,getValue(A_ASG_69_0_0_27_Data_18_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_6" ,getValue(A_ASG_69_0_0_27_Data_18_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_7" ,getValue(A_ASG_69_0_0_27_Data_18_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_8" ,getValue(A_ASG_69_0_0_27_Data_18_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_9" ,getValue(A_ASG_69_0_0_27_Data_18_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_10" ,getValue(A_ASG_69_0_0_27_Data_18_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_11" ,getValue(A_ASG_69_0_0_27_Data_18_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_12" ,getValue(A_ASG_69_0_0_27_Data_18_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_13" ,getValue(A_ASG_69_0_0_27_Data_18_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_14" ,getValue(A_ASG_69_0_0_27_Data_18_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_15" ,getValue(A_ASG_69_0_0_27_Data_18_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_16" ,getValue(A_ASG_69_0_0_27_Data_18_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_17" ,getValue(A_ASG_69_0_0_27_Data_18_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_18" ,getValue(A_ASG_69_0_0_27_Data_18_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_19" ,getValue(A_ASG_69_0_0_27_Data_18_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_20" ,getValue(A_ASG_69_0_0_27_Data_18_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_21" ,getValue(A_ASG_69_0_0_27_Data_18_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_22" ,getValue(A_ASG_69_0_0_27_Data_18_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_23" ,getValue(A_ASG_69_0_0_27_Data_18_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_24" ,getValue(A_ASG_69_0_0_27_Data_18_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_25" ,getValue(A_ASG_69_0_0_27_Data_18_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_26" ,getValue(A_ASG_69_0_0_27_Data_18_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_27" ,getValue(A_ASG_69_0_0_27_Data_18_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_28" ,getValue(A_ASG_69_0_0_27_Data_18_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_29" ,getValue(A_ASG_69_0_0_27_Data_18_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_30" ,getValue(A_ASG_69_0_0_27_Data_18_30), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_31" ,getValue(A_ASG_69_0_0_27_Data_18_31), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12" ,getValue(A_ASG_69_0_0_27_Data_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_0" ,getValue(A_ASG_69_0_0_27_Data_12_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_1" ,getValue(A_ASG_69_0_0_27_Data_12_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_2" ,getValue(A_ASG_69_0_0_27_Data_12_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_3" ,getValue(A_ASG_69_0_0_27_Data_12_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_4" ,getValue(A_ASG_69_0_0_27_Data_12_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_5" ,getValue(A_ASG_69_0_0_27_Data_12_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_6" ,getValue(A_ASG_69_0_0_27_Data_12_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_7" ,getValue(A_ASG_69_0_0_27_Data_12_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_8" ,getValue(A_ASG_69_0_0_27_Data_12_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_9" ,getValue(A_ASG_69_0_0_27_Data_12_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_10" ,getValue(A_ASG_69_0_0_27_Data_12_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_11" ,getValue(A_ASG_69_0_0_27_Data_12_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_12" ,getValue(A_ASG_69_0_0_27_Data_12_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_13" ,getValue(A_ASG_69_0_0_27_Data_12_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_14" ,getValue(A_ASG_69_0_0_27_Data_12_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_15" ,getValue(A_ASG_69_0_0_27_Data_12_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_16" ,getValue(A_ASG_69_0_0_27_Data_12_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_17" ,getValue(A_ASG_69_0_0_27_Data_12_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_18" ,getValue(A_ASG_69_0_0_27_Data_12_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_19" ,getValue(A_ASG_69_0_0_27_Data_12_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_20" ,getValue(A_ASG_69_0_0_27_Data_12_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_21" ,getValue(A_ASG_69_0_0_27_Data_12_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_22" ,getValue(A_ASG_69_0_0_27_Data_12_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_23" ,getValue(A_ASG_69_0_0_27_Data_12_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_24" ,getValue(A_ASG_69_0_0_27_Data_12_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_25" ,getValue(A_ASG_69_0_0_27_Data_12_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_26" ,getValue(A_ASG_69_0_0_27_Data_12_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_27" ,getValue(A_ASG_69_0_0_27_Data_12_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_28" ,getValue(A_ASG_69_0_0_27_Data_12_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_29" ,getValue(A_ASG_69_0_0_27_Data_12_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11" ,getValue(A_ASG_69_0_0_27_Data_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_0" ,getValue(A_ASG_69_0_0_27_Data_11_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_1" ,getValue(A_ASG_69_0_0_27_Data_11_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_2" ,getValue(A_ASG_69_0_0_27_Data_11_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_3" ,getValue(A_ASG_69_0_0_27_Data_11_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_4" ,getValue(A_ASG_69_0_0_27_Data_11_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_5" ,getValue(A_ASG_69_0_0_27_Data_11_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_6" ,getValue(A_ASG_69_0_0_27_Data_11_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_7" ,getValue(A_ASG_69_0_0_27_Data_11_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_8" ,getValue(A_ASG_69_0_0_27_Data_11_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_9" ,getValue(A_ASG_69_0_0_27_Data_11_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_10" ,getValue(A_ASG_69_0_0_27_Data_11_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_11" ,getValue(A_ASG_69_0_0_27_Data_11_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_12" ,getValue(A_ASG_69_0_0_27_Data_11_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_13" ,getValue(A_ASG_69_0_0_27_Data_11_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_14" ,getValue(A_ASG_69_0_0_27_Data_11_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_15" ,getValue(A_ASG_69_0_0_27_Data_11_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_16" ,getValue(A_ASG_69_0_0_27_Data_11_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_17" ,getValue(A_ASG_69_0_0_27_Data_11_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_18" ,getValue(A_ASG_69_0_0_27_Data_11_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_19" ,getValue(A_ASG_69_0_0_27_Data_11_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_20" ,getValue(A_ASG_69_0_0_27_Data_11_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_21" ,getValue(A_ASG_69_0_0_27_Data_11_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_22" ,getValue(A_ASG_69_0_0_27_Data_11_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_23" ,getValue(A_ASG_69_0_0_27_Data_11_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_24" ,getValue(A_ASG_69_0_0_27_Data_11_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_25" ,getValue(A_ASG_69_0_0_27_Data_11_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_26" ,getValue(A_ASG_69_0_0_27_Data_11_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_27" ,getValue(A_ASG_69_0_0_27_Data_11_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_28" ,getValue(A_ASG_69_0_0_27_Data_11_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_29" ,getValue(A_ASG_69_0_0_27_Data_11_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_30" ,getValue(A_ASG_69_0_0_27_Data_11_30), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_31" ,getValue(A_ASG_69_0_0_27_Data_11_31), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7" ,getValue(A_ASG_69_0_0_27_Data_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_0" ,getValue(A_ASG_69_0_0_27_Data_7_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_1" ,getValue(A_ASG_69_0_0_27_Data_7_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_2" ,getValue(A_ASG_69_0_0_27_Data_7_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_3" ,getValue(A_ASG_69_0_0_27_Data_7_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_4" ,getValue(A_ASG_69_0_0_27_Data_7_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_5" ,getValue(A_ASG_69_0_0_27_Data_7_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_6" ,getValue(A_ASG_69_0_0_27_Data_7_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_7" ,getValue(A_ASG_69_0_0_27_Data_7_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_8" ,getValue(A_ASG_69_0_0_27_Data_7_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_9" ,getValue(A_ASG_69_0_0_27_Data_7_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_10" ,getValue(A_ASG_69_0_0_27_Data_7_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_11" ,getValue(A_ASG_69_0_0_27_Data_7_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_12" ,getValue(A_ASG_69_0_0_27_Data_7_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_13" ,getValue(A_ASG_69_0_0_27_Data_7_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_14" ,getValue(A_ASG_69_0_0_27_Data_7_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_15" ,getValue(A_ASG_69_0_0_27_Data_7_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_16" ,getValue(A_ASG_69_0_0_27_Data_7_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_17" ,getValue(A_ASG_69_0_0_27_Data_7_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_18" ,getValue(A_ASG_69_0_0_27_Data_7_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_19" ,getValue(A_ASG_69_0_0_27_Data_7_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_20" ,getValue(A_ASG_69_0_0_27_Data_7_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_21" ,getValue(A_ASG_69_0_0_27_Data_7_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_22" ,getValue(A_ASG_69_0_0_27_Data_7_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_23" ,getValue(A_ASG_69_0_0_27_Data_7_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_24" ,getValue(A_ASG_69_0_0_27_Data_7_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_25" ,getValue(A_ASG_69_0_0_27_Data_7_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_26" ,getValue(A_ASG_69_0_0_27_Data_7_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_27" ,getValue(A_ASG_69_0_0_27_Data_7_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_28" ,getValue(A_ASG_69_0_0_27_Data_7_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_29" ,getValue(A_ASG_69_0_0_27_Data_7_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6" ,getValue(A_ASG_69_0_0_27_Data_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_0" ,getValue(A_ASG_69_0_0_27_Data_6_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_1" ,getValue(A_ASG_69_0_0_27_Data_6_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_2" ,getValue(A_ASG_69_0_0_27_Data_6_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_3" ,getValue(A_ASG_69_0_0_27_Data_6_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_4" ,getValue(A_ASG_69_0_0_27_Data_6_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_5" ,getValue(A_ASG_69_0_0_27_Data_6_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_6" ,getValue(A_ASG_69_0_0_27_Data_6_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_7" ,getValue(A_ASG_69_0_0_27_Data_6_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_8" ,getValue(A_ASG_69_0_0_27_Data_6_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_9" ,getValue(A_ASG_69_0_0_27_Data_6_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_10" ,getValue(A_ASG_69_0_0_27_Data_6_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_11" ,getValue(A_ASG_69_0_0_27_Data_6_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_12" ,getValue(A_ASG_69_0_0_27_Data_6_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_13" ,getValue(A_ASG_69_0_0_27_Data_6_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_14" ,getValue(A_ASG_69_0_0_27_Data_6_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_15" ,getValue(A_ASG_69_0_0_27_Data_6_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_16" ,getValue(A_ASG_69_0_0_27_Data_6_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_17" ,getValue(A_ASG_69_0_0_27_Data_6_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_18" ,getValue(A_ASG_69_0_0_27_Data_6_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_19" ,getValue(A_ASG_69_0_0_27_Data_6_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_20" ,getValue(A_ASG_69_0_0_27_Data_6_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_21" ,getValue(A_ASG_69_0_0_27_Data_6_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_22" ,getValue(A_ASG_69_0_0_27_Data_6_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_23" ,getValue(A_ASG_69_0_0_27_Data_6_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_24" ,getValue(A_ASG_69_0_0_27_Data_6_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_25" ,getValue(A_ASG_69_0_0_27_Data_6_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_26" ,getValue(A_ASG_69_0_0_27_Data_6_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_27" ,getValue(A_ASG_69_0_0_27_Data_6_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_28" ,getValue(A_ASG_69_0_0_27_Data_6_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_29" ,getValue(A_ASG_69_0_0_27_Data_6_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_30" ,getValue(A_ASG_69_0_0_27_Data_6_30), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_31" ,getValue(A_ASG_69_0_0_27_Data_6_31), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_27_2" ,getValue(A_ASG_69_0_0_27_2), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_27_2_range" ,getValue(A_ASG_69_0_0_27_2_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_RecAdr" ,getValue(A_ASG_69_0_0_27_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Direction" ,getValue(A_ASG_69_0_0_27_Direction), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Shift" ,getValue(A_ASG_69_0_0_27_Shift), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_TransPos" ,getValue(A_ASG_69_0_0_27_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_IndexSize" ,getValue(A_ASG_69_0_0_27_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Start" ,getValue(A_ASG_69_0_0_27_Start), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Elements" ,getValue(A_ASG_69_0_0_27_Elements), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Changed_RecAdr" ,getValue(A_ASG_69_0_0_27_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Changed_Direction" ,getValue(A_ASG_69_0_0_27_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Changed_Shift" ,getValue(A_ASG_69_0_0_27_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Changed_TransPos" ,getValue(A_ASG_69_0_0_27_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Changed_IndexSize" ,getValue(A_ASG_69_0_0_27_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Changed_Start" ,getValue(A_ASG_69_0_0_27_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Changed_Elements" ,getValue(A_ASG_69_0_0_27_Changed_Elements), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_DataIndex_SetGet" ,getValue(A_ASG_69_0_0_27_DataIndex_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_DataIndex_SetGet_Incr" ,getValue(A_ASG_69_0_0_27_DataIndex_SetGet_Incr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_DataIndex_SetGet_Decr" ,getValue(A_ASG_69_0_0_27_DataIndex_SetGet_Decr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_3_SetGet" ,getValue(A_ASG_69_0_0_27_Data_3_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_1_SetGet" ,getValue(A_ASG_69_0_0_27_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_0" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_1" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_2" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_3" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_4" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_5" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_6" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_7" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_8" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_9" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_10" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_11" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_12" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_13" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_14" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_15" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_16" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_17" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_18" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_19" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_20" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_21" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_22" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_23" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_24" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_25" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_26" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_10_SetGet_27" ,getValue(A_ASG_69_0_0_27_Data_10_SetGet_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_0" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_1" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_2" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_3" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_4" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_5" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_6" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_7" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_8" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_9" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_10" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_11" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_12" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_13" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_14" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_15" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_16" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_17" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_18" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_19" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_20" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_21" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_22" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_23" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_24" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_25" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_26" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_27" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_28" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_17_SetGet_29" ,getValue(A_ASG_69_0_0_27_Data_17_SetGet_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_0" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_1" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_2" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_3" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_4" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_5" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_6" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_7" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_8" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_9" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_10" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_11" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_12" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_13" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_14" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_15" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_16" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_17" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_18" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_19" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_20" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_21" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_22" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_23" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_24" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_25" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_26" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_27" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_28" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_29" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_30" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_30), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_16_SetGet_31" ,getValue(A_ASG_69_0_0_27_Data_16_SetGet_31), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_0" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_1" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_2" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_3" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_4" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_5" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_6" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_7" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_8" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_9" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_10" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_11" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_12" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_13" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_14" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_15" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_16" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_17" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_18" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_19" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_20" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_21" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_22" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_23" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_24" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_25" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_26" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_15_SetGet_27" ,getValue(A_ASG_69_0_0_27_Data_15_SetGet_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_0" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_1" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_2" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_3" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_4" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_5" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_6" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_7" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_8" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_9" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_10" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_11" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_12" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_13" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_14" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_15" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_16" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_17" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_18" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_19" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_20" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_21" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_22" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_23" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_24" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_25" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_26" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_27" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_28" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_14_SetGet_29" ,getValue(A_ASG_69_0_0_27_Data_14_SetGet_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_0" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_1" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_2" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_3" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_4" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_5" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_6" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_7" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_8" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_9" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_10" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_11" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_12" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_13" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_14" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_15" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_16" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_17" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_18" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_19" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_20" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_21" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_22" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_23" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_24" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_25" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_26" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_27" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_28" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_29" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_30" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_30), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_13_SetGet_31" ,getValue(A_ASG_69_0_0_27_Data_13_SetGet_31), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_0" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_1" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_2" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_3" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_4" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_5" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_6" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_7" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_8" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_9" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_10" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_11" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_12" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_13" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_14" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_15" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_16" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_17" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_18" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_19" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_20" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_21" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_22" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_23" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_24" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_25" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_26" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_27" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_28" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_9_SetGet_29" ,getValue(A_ASG_69_0_0_27_Data_9_SetGet_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_0" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_1" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_2" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_3" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_4" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_5" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_6" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_7" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_8" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_9" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_10" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_11" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_12" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_13" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_14" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_15" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_16" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_17" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_18" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_19" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_20" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_21" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_22" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_23" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_24" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_25" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_26" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_27" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_28" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_29" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_30" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_30), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_8_SetGet_31" ,getValue(A_ASG_69_0_0_27_Data_8_SetGet_31), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_2_SetGet" ,getValue(A_ASG_69_0_0_27_Data_2_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_20_SetGet_len" ,getValue(A_ASG_69_0_0_27_Data_20_SetGet_len), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_20_SetGet_cnt" ,getValue(A_ASG_69_0_0_27_Data_20_SetGet_cnt), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_0" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_1" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_2" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_3" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_4" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_5" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_6" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_7" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_8" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_9" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_10" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_11" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_12" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_13" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_14" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_15" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_16" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_17" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_18" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_19" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_20" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_21" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_22" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_23" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_24" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_25" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_26" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_5_SetGet_27" ,getValue(A_ASG_69_0_0_27_Data_5_SetGet_27), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_27_Data_4_SetGet" ,getValue(A_ASG_69_0_0_27_Data_4_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_27_Data_4_SetGet_range" ,getValue(A_ASG_69_0_0_27_Data_4_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_27_Data_1_SetGet" ,getValue(A_ASG_69_0_0_27_Data_1_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_27_Data_1_SetGet_range" ,getValue(A_ASG_69_0_0_27_Data_1_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_0" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_1" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_2" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_3" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_4" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_5" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_6" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_7" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_8" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_9" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_10" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_11" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_12" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_13" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_14" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_15" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_16" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_17" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_18" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_19" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_20" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_21" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_22" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_23" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_24" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_25" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_26" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_27" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_28" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_19_SetGet_29" ,getValue(A_ASG_69_0_0_27_Data_19_SetGet_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_0" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_1" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_2" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_3" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_4" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_5" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_6" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_7" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_8" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_9" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_10" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_11" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_12" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_13" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_14" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_15" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_16" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_17" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_18" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_19" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_20" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_21" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_22" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_23" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_24" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_25" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_26" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_27" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_28" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_29" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_30" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_30), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_18_SetGet_31" ,getValue(A_ASG_69_0_0_27_Data_18_SetGet_31), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_0" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_1" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_2" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_3" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_4" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_5" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_6" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_7" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_8" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_9" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_10" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_11" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_12" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_13" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_14" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_15" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_16" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_17" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_18" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_19" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_20" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_21" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_22" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_23" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_24" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_25" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_26" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_27" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_28" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_12_SetGet_29" ,getValue(A_ASG_69_0_0_27_Data_12_SetGet_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_0" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_1" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_2" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_3" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_4" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_5" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_6" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_7" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_8" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_9" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_10" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_11" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_12" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_13" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_14" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_15" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_16" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_17" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_18" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_19" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_20" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_21" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_22" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_23" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_24" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_25" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_26" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_27" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_28" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_29" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_30" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_30), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_11_SetGet_31" ,getValue(A_ASG_69_0_0_27_Data_11_SetGet_31), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_0" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_1" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_2" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_3" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_4" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_5" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_6" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_7" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_8" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_9" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_10" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_11" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_12" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_13" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_14" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_15" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_16" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_17" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_18" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_19" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_20" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_21" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_22" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_23" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_24" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_25" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_26" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_27" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_28" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_7_SetGet_29" ,getValue(A_ASG_69_0_0_27_Data_7_SetGet_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_0" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_1" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_2" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_2), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_3" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_4" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_5" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_6" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_7" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_8" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_8), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_9" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_9), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_10" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_10), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_11" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_11), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_12" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_12), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_13" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_13), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_14" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_14), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_15" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_15), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_16" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_16), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_17" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_17), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_18" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_18), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_19" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_19), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_20" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_20), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_21" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_21), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_22" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_22), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_23" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_23), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_24" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_24), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_25" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_25), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_26" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_26), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_27" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_27), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_28" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_28), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_29" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_29), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_30" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_30), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_Data_6_SetGet_31" ,getValue(A_ASG_69_0_0_27_Data_6_SetGet_31), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_27_2_SetGet" ,getValue(A_ASG_69_0_0_27_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_27_2_SetGet_range" ,getValue(A_ASG_69_0_0_27_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_SetGet_RecAdr" ,getValue(A_ASG_69_0_0_27_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_SetGet_Direction" ,getValue(A_ASG_69_0_0_27_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_SetGet_Shift" ,getValue(A_ASG_69_0_0_27_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_SetGet_IndexSize" ,getValue(A_ASG_69_0_0_27_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_SetGet_Start" ,getValue(A_ASG_69_0_0_27_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_27_SetGet_Elements" ,getValue(A_ASG_69_0_0_27_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_28Get_BTN" ,getValue(P_ASG_69_0_0_28Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_28SetGet_BTN" ,getValue(P_ASG_69_0_0_28SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_28_FctLstItemEn" ,getValue(P_ASG_69_0_0_28_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_28_ErrCode" ,getValue(P_ASG_69_0_0_28_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_28_3" ,getValue(P_ASG_69_0_0_28_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_28_3_range" ,getValue(P_ASG_69_0_0_28_3_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_28_2" ,getValue(P_ASG_69_0_0_28_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_28_2_range" ,getValue(P_ASG_69_0_0_28_2_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_28_1" ,getValue(P_ASG_69_0_0_28_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_28_1_0" ,getValue(P_ASG_69_0_0_28_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_28_4" ,getValue(P_ASG_69_0_0_28_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_28_5" ,getValue(P_ASG_69_0_0_28_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_28_5_0" ,getValue(P_ASG_69_0_0_28_5_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_29Get_BTN" ,getValue(P_ASG_69_0_0_29Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_29SetGet_BTN" ,getValue(P_ASG_69_0_0_29SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_29_FctLstItemEn" ,getValue(P_ASG_69_0_0_29_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_29_ErrCode" ,getValue(P_ASG_69_0_0_29_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_29_1" ,getValue(P_ASG_69_0_0_29_1), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_29_1_range" ,getValue(P_ASG_69_0_0_29_1_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_29_2" ,getValue(P_ASG_69_0_0_29_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_29_3" ,getValue(P_ASG_69_0_0_29_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_29_3_0" ,getValue(P_ASG_69_0_0_29_3_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_30Get_BTN" ,getValue(P_ASG_69_0_0_30Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_30SetGet_BTN" ,getValue(P_ASG_69_0_0_30SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_30_FctLstItemEn" ,getValue(P_ASG_69_0_0_30_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_30_ErrCode" ,getValue(P_ASG_69_0_0_30_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_30_3" ,getValue(P_ASG_69_0_0_30_3), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_30_3_range" ,getValue(P_ASG_69_0_0_30_3_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_30_2" ,getValue(P_ASG_69_0_0_30_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_30_2_range" ,getValue(P_ASG_69_0_0_30_2_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_30_1" ,getValue(P_ASG_69_0_0_30_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_30_4" ,getValue(P_ASG_69_0_0_30_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_30_5" ,getValue(P_ASG_69_0_0_30_5), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_30_5_0" ,getValue(P_ASG_69_0_0_30_5_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_31Get_BTN" ,getValue(P_ASG_69_0_0_31Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_31SetGet_BTN" ,getValue(P_ASG_69_0_0_31SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_31_FctLstItemEn" ,getValue(P_ASG_69_0_0_31_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_31_ErrCode" ,getValue(P_ASG_69_0_0_31_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_31_5" ,getValue(P_ASG_69_0_0_31_5), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_31_5_range" ,getValue(P_ASG_69_0_0_31_5_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_31_4" ,getValue(P_ASG_69_0_0_31_4), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_31_4_range" ,getValue(P_ASG_69_0_0_31_4_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_31_1" ,getValue(P_ASG_69_0_0_31_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_31_1_0" ,getValue(P_ASG_69_0_0_31_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_31_2" ,getValue(P_ASG_69_0_0_31_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_31_3" ,getValue(P_ASG_69_0_0_31_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_31_3_0" ,getValue(P_ASG_69_0_0_31_3_0), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_31_7" ,getValue(P_ASG_69_0_0_31_7), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_31_7_range" ,getValue(P_ASG_69_0_0_31_7_range), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_31_6" ,getValue(P_ASG_69_0_0_31_6), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_31_6_range" ,getValue(P_ASG_69_0_0_31_6_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_32Get_BTN" ,getValue(P_ASG_69_0_0_32Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_32SetGet_BTN" ,getValue(P_ASG_69_0_0_32SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_32_FctLstItemEn" ,getValue(P_ASG_69_0_0_32_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_32_ErrCode" ,getValue(P_ASG_69_0_0_32_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_32_2" ,getValue(P_ASG_69_0_0_32_2), profileFile);
    writeProfileFloat("BAP" ,"P_ASG_69_0_0_32_2_range" ,getValue(P_ASG_69_0_0_32_2_range), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_32_1" ,getValue(P_ASG_69_0_0_32_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_32_1_0" ,getValue(P_ASG_69_0_0_32_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_32_1_1" ,getValue(P_ASG_69_0_0_32_1_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_32_1_2" ,getValue(P_ASG_69_0_0_32_1_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_32_1_3" ,getValue(P_ASG_69_0_0_32_1_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_32_1_4" ,getValue(P_ASG_69_0_0_32_1_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_32_3" ,getValue(P_ASG_69_0_0_32_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_32_4" ,getValue(P_ASG_69_0_0_32_4), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_32_4_0" ,getValue(P_ASG_69_0_0_32_4_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_33Get_BTN" ,getValue(P_ASG_69_0_0_33Get_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_33SetGet_BTN" ,getValue(P_ASG_69_0_0_33SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_33_FctLstItemEn" ,getValue(P_ASG_69_0_0_33_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_33_ErrCode" ,getValue(P_ASG_69_0_0_33_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_33_1" ,getValue(P_ASG_69_0_0_33_1), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_33_1_0" ,getValue(P_ASG_69_0_0_33_1_0), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_33_2" ,getValue(P_ASG_69_0_0_33_2), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_33_3" ,getValue(P_ASG_69_0_0_33_3), profileFile);
    writeProfileInt("BAP" ,"P_ASG_69_0_0_33_3_0" ,getValue(P_ASG_69_0_0_33_3_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34Get_BTN" ,getValue(A_ASG_69_0_0_34Get_BTN), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34SetGet_BTN" ,getValue(A_ASG_69_0_0_34SetGet_BTN), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_FctLstItemEn" ,getValue(A_ASG_69_0_0_34_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_IntTlgEn" ,getValue(A_ASG_69_0_0_34_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_SegmEn" ,getValue(A_ASG_69_0_0_34_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_AT" ,getValue(A_ASG_69_0_0_34_AT), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_ErrCode" ,getValue(A_ASG_69_0_0_34_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_DataIndex" ,getValue(A_ASG_69_0_0_34_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_DataIndex_Incr" ,getValue(A_ASG_69_0_0_34_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_DataIndex_Decr" ,getValue(A_ASG_69_0_0_34_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_loadArray_Btn" ,getValue(A_ASG_69_0_0_34_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_generateData_Btn" ,getValue(A_ASG_69_0_0_34_generateData_Btn), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_Data_4" ,getValue(A_ASG_69_0_0_34_Data_4), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_Data_4_range" ,getValue(A_ASG_69_0_0_34_Data_4_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_2" ,getValue(A_ASG_69_0_0_34_2), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_3" ,getValue(A_ASG_69_0_0_34_3), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_3_range" ,getValue(A_ASG_69_0_0_34_3_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_7" ,getValue(A_ASG_69_0_0_34_7), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_7_range" ,getValue(A_ASG_69_0_0_34_7_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Data_3" ,getValue(A_ASG_69_0_0_34_Data_3), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Data_3_0" ,getValue(A_ASG_69_0_0_34_Data_3_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Data_3_4" ,getValue(A_ASG_69_0_0_34_Data_3_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Data_3_5" ,getValue(A_ASG_69_0_0_34_Data_3_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Data_3_6" ,getValue(A_ASG_69_0_0_34_Data_3_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Data_3_7" ,getValue(A_ASG_69_0_0_34_Data_3_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_5" ,getValue(A_ASG_69_0_0_34_5), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_Data_2" ,getValue(A_ASG_69_0_0_34_Data_2), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_Data_2_range" ,getValue(A_ASG_69_0_0_34_Data_2_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_1" ,getValue(A_ASG_69_0_0_34_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Data_5_len" ,getValue(A_ASG_69_0_0_34_Data_5_len), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Data_5_cnt" ,getValue(A_ASG_69_0_0_34_Data_5_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_6" ,getValue(A_ASG_69_0_0_34_6), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_6_range" ,getValue(A_ASG_69_0_0_34_6_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_4" ,getValue(A_ASG_69_0_0_34_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_4_0" ,getValue(A_ASG_69_0_0_34_4_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_4_1" ,getValue(A_ASG_69_0_0_34_4_1), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_4_2" ,getValue(A_ASG_69_0_0_34_4_2), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_Data_1" ,getValue(A_ASG_69_0_0_34_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_Data_1_range" ,getValue(A_ASG_69_0_0_34_Data_1_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_RecAdr" ,getValue(A_ASG_69_0_0_34_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Direction" ,getValue(A_ASG_69_0_0_34_Direction), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Shift" ,getValue(A_ASG_69_0_0_34_Shift), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_TransPos" ,getValue(A_ASG_69_0_0_34_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_IndexSize" ,getValue(A_ASG_69_0_0_34_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Start" ,getValue(A_ASG_69_0_0_34_Start), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Elements" ,getValue(A_ASG_69_0_0_34_Elements), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_2_Changed" ,getValue(A_ASG_69_0_0_34_2_Changed), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_1_Changed" ,getValue(A_ASG_69_0_0_34_1_Changed), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_3_Changed" ,getValue(A_ASG_69_0_0_34_3_Changed), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_3_Changed_range" ,getValue(A_ASG_69_0_0_34_3_Changed_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Changed_RecAdr" ,getValue(A_ASG_69_0_0_34_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Changed_Direction" ,getValue(A_ASG_69_0_0_34_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Changed_Shift" ,getValue(A_ASG_69_0_0_34_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Changed_TransPos" ,getValue(A_ASG_69_0_0_34_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Changed_IndexSize" ,getValue(A_ASG_69_0_0_34_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Changed_Start" ,getValue(A_ASG_69_0_0_34_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Changed_Elements" ,getValue(A_ASG_69_0_0_34_Changed_Elements), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_DataIndex_SetGet" ,getValue(A_ASG_69_0_0_34_DataIndex_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_DataIndex_SetGet_Incr" ,getValue(A_ASG_69_0_0_34_DataIndex_SetGet_Incr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_DataIndex_SetGet_Decr" ,getValue(A_ASG_69_0_0_34_DataIndex_SetGet_Decr), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_Data_4_SetGet" ,getValue(A_ASG_69_0_0_34_Data_4_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_Data_4_SetGet_range" ,getValue(A_ASG_69_0_0_34_Data_4_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_2_SetGet" ,getValue(A_ASG_69_0_0_34_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_3_SetGet" ,getValue(A_ASG_69_0_0_34_3_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_3_SetGet_range" ,getValue(A_ASG_69_0_0_34_3_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Data_3_SetGet" ,getValue(A_ASG_69_0_0_34_Data_3_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Data_3_SetGet_0" ,getValue(A_ASG_69_0_0_34_Data_3_SetGet_0), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Data_3_SetGet_4" ,getValue(A_ASG_69_0_0_34_Data_3_SetGet_4), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Data_3_SetGet_5" ,getValue(A_ASG_69_0_0_34_Data_3_SetGet_5), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Data_3_SetGet_6" ,getValue(A_ASG_69_0_0_34_Data_3_SetGet_6), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Data_3_SetGet_7" ,getValue(A_ASG_69_0_0_34_Data_3_SetGet_7), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_4_SetGet" ,getValue(A_ASG_69_0_0_34_4_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_Data_2_SetGet" ,getValue(A_ASG_69_0_0_34_Data_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_Data_2_SetGet_range" ,getValue(A_ASG_69_0_0_34_Data_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_1_SetGet" ,getValue(A_ASG_69_0_0_34_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Data_5_SetGet_len" ,getValue(A_ASG_69_0_0_34_Data_5_SetGet_len), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_Data_5_SetGet_cnt" ,getValue(A_ASG_69_0_0_34_Data_5_SetGet_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_5_SetGet" ,getValue(A_ASG_69_0_0_34_5_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_5_SetGet_range" ,getValue(A_ASG_69_0_0_34_5_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_Data_1_SetGet" ,getValue(A_ASG_69_0_0_34_Data_1_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_ASG_69_0_0_34_Data_1_SetGet_range" ,getValue(A_ASG_69_0_0_34_Data_1_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_SetGet_RecAdr" ,getValue(A_ASG_69_0_0_34_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_SetGet_Direction" ,getValue(A_ASG_69_0_0_34_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_SetGet_Shift" ,getValue(A_ASG_69_0_0_34_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_SetGet_IndexSize" ,getValue(A_ASG_69_0_0_34_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_SetGet_Start" ,getValue(A_ASG_69_0_0_34_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_ASG_69_0_0_34_SetGet_Elements" ,getValue(A_ASG_69_0_0_34_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"C_FSG_40_0_0_0_1_FctLstItemEn" ,getValue(C_FSG_40_0_0_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_40_0_0_0_1_FctEn" ,getValue(C_FSG_40_0_0_0_1_FctEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_40_0_0_0_1_ErrEn" ,getValue(C_FSG_40_0_0_0_1_ErrEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_40_0_0_0_1_IntTlgEn" ,getValue(C_FSG_40_0_0_0_1_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_40_0_0_0_1_SegmEn" ,getValue(C_FSG_40_0_0_0_1_SegmEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_40_0_0_0_1_ErrCode" ,getValue(C_FSG_40_0_0_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_0_2Reset_BTN" ,getValue(P_FSG_40_0_0_0_2Reset_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_0_2_FctLstItemEn" ,getValue(P_FSG_40_0_0_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_0_2_FctEn" ,getValue(P_FSG_40_0_0_0_2_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_0_2_ErrEn" ,getValue(P_FSG_40_0_0_0_2_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_0_2_ErrCode" ,getValue(P_FSG_40_0_0_0_2_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_0_3_FctLstItemEn" ,getValue(P_FSG_40_0_0_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_0_3_FctEn" ,getValue(P_FSG_40_0_0_0_3_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_0_3_ErrEn" ,getValue(P_FSG_40_0_0_0_3_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_0_3_IntTlgEn" ,getValue(P_FSG_40_0_0_0_3_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_0_3_SegmEn" ,getValue(P_FSG_40_0_0_0_3_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_0_3_ErrCode" ,getValue(P_FSG_40_0_0_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"ERRORLIST_FSG40_0_VT" ,getValue(ERRORLIST_FSG40_0_VT), profileFile);
    writeProfileInt("BAP" ,"ON_OFF_FSG40_0" ,getValue(ON_OFF_FSG40_0), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_40_0_0_DFMajor" ,getValue(BAPCFG_FSG_40_0_0_DFMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_40_0_0_DFMinor" ,getValue(BAPCFG_FSG_40_0_0_DFMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_40_0_0_LsgClassMajor" ,getValue(BAPCFG_FSG_40_0_0_LsgClassMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_40_0_0_LsgClassMinor" ,getValue(BAPCFG_FSG_40_0_0_LsgClassMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_40_0_0_ProtocolMajor" ,getValue(BAPCFG_FSG_40_0_0_ProtocolMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_40_0_0_ProtocolMinor" ,getValue(BAPCFG_FSG_40_0_0_ProtocolMinor), profileFile);
    writeProfileInt("BAP" ,"C_FSG_40_0_0_1_FctLstItemEn" ,getValue(C_FSG_40_0_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_40_0_0_1_FctEn" ,getValue(C_FSG_40_0_0_1_FctEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_40_0_0_1_ErrEn" ,getValue(C_FSG_40_0_0_1_ErrEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_40_0_0_1_IntTlgEn" ,getValue(C_FSG_40_0_0_1_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_40_0_0_1_SegmEn" ,getValue(C_FSG_40_0_0_1_SegmEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_40_0_0_1_ErrCode" ,getValue(C_FSG_40_0_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_2Reset_BTN" ,getValue(P_FSG_40_0_0_2Reset_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_2_FctLstItemEn" ,getValue(P_FSG_40_0_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_2_FctEn" ,getValue(P_FSG_40_0_0_2_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_2_ErrEn" ,getValue(P_FSG_40_0_0_2_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_2_ErrCode" ,getValue(P_FSG_40_0_0_2_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_2" ,getValue(P_FSG_40_0_0_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_2_range" ,getValue(P_FSG_40_0_0_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_3Status_BTN" ,getValue(P_FSG_40_0_0_3Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_3_FctLstItemEn" ,getValue(P_FSG_40_0_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_3_FctEn" ,getValue(P_FSG_40_0_0_3_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_3_ErrEn" ,getValue(P_FSG_40_0_0_3_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_3_IntTlgEn" ,getValue(P_FSG_40_0_0_3_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_3_SegmEn" ,getValue(P_FSG_40_0_0_3_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_3_ErrCode" ,getValue(P_FSG_40_0_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_4Status_BTN" ,getValue(P_FSG_40_0_0_4Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_4_FctLstItemEn" ,getValue(P_FSG_40_0_0_4_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_4_FctEn" ,getValue(P_FSG_40_0_0_4_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_4_ErrEn" ,getValue(P_FSG_40_0_0_4_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_4_ErrCode" ,getValue(P_FSG_40_0_0_4_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_4" ,getValue(P_FSG_40_0_0_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_14Status_BTN" ,getValue(P_FSG_40_0_0_14Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_14_FctLstItemEn" ,getValue(P_FSG_40_0_0_14_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_14_FctEn" ,getValue(P_FSG_40_0_0_14_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_14_ErrEn" ,getValue(P_FSG_40_0_0_14_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_14_ErrCode" ,getValue(P_FSG_40_0_0_14_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_14_2" ,getValue(P_FSG_40_0_0_14_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_14_1" ,getValue(P_FSG_40_0_0_14_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_14_1_0" ,getValue(P_FSG_40_0_0_14_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_14_1_1" ,getValue(P_FSG_40_0_0_14_1_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_14_1_2" ,getValue(P_FSG_40_0_0_14_1_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_14_1_3" ,getValue(P_FSG_40_0_0_14_1_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_14_1_4" ,getValue(P_FSG_40_0_0_14_1_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_14_1_5" ,getValue(P_FSG_40_0_0_14_1_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_14_1_6" ,getValue(P_FSG_40_0_0_14_1_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_15Status_BTN" ,getValue(P_FSG_40_0_0_15Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_15_FctLstItemEn" ,getValue(P_FSG_40_0_0_15_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_15_FctEn" ,getValue(P_FSG_40_0_0_15_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_15_ErrEn" ,getValue(P_FSG_40_0_0_15_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_15_ErrCode" ,getValue(P_FSG_40_0_0_15_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_15_1" ,getValue(P_FSG_40_0_0_15_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_15_3" ,getValue(P_FSG_40_0_0_15_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_15_3_0" ,getValue(P_FSG_40_0_0_15_3_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_15_3_1" ,getValue(P_FSG_40_0_0_15_3_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_15_3_2" ,getValue(P_FSG_40_0_0_15_3_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_15_3_3" ,getValue(P_FSG_40_0_0_15_3_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_15_2" ,getValue(P_FSG_40_0_0_15_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16Status_BTN" ,getValue(P_FSG_40_0_0_16Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_FctLstItemEn" ,getValue(P_FSG_40_0_0_16_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_FctEn" ,getValue(P_FSG_40_0_0_16_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_ErrEn" ,getValue(P_FSG_40_0_0_16_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_IntTlgEn" ,getValue(P_FSG_40_0_0_16_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_SegmEn" ,getValue(P_FSG_40_0_0_16_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_ErrCode" ,getValue(P_FSG_40_0_0_16_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_17" ,getValue(P_FSG_40_0_0_16_1_17), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_18" ,getValue(P_FSG_40_0_0_16_1_18), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_19" ,getValue(P_FSG_40_0_0_16_1_19), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_20" ,getValue(P_FSG_40_0_0_16_1_20), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_21" ,getValue(P_FSG_40_0_0_16_1_21), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_22" ,getValue(P_FSG_40_0_0_16_1_22), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_23" ,getValue(P_FSG_40_0_0_16_1_23), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_24" ,getValue(P_FSG_40_0_0_16_1_24), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_25" ,getValue(P_FSG_40_0_0_16_1_25), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_26" ,getValue(P_FSG_40_0_0_16_1_26), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_27" ,getValue(P_FSG_40_0_0_16_1_27), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_28" ,getValue(P_FSG_40_0_0_16_1_28), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_29" ,getValue(P_FSG_40_0_0_16_1_29), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_30" ,getValue(P_FSG_40_0_0_16_1_30), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_31" ,getValue(P_FSG_40_0_0_16_1_31), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_32" ,getValue(P_FSG_40_0_0_16_1_32), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_33" ,getValue(P_FSG_40_0_0_16_1_33), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_34" ,getValue(P_FSG_40_0_0_16_1_34), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_35" ,getValue(P_FSG_40_0_0_16_1_35), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_36" ,getValue(P_FSG_40_0_0_16_1_36), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_37" ,getValue(P_FSG_40_0_0_16_1_37), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_38" ,getValue(P_FSG_40_0_0_16_1_38), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_39" ,getValue(P_FSG_40_0_0_16_1_39), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_40" ,getValue(P_FSG_40_0_0_16_1_40), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_41" ,getValue(P_FSG_40_0_0_16_1_41), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_42" ,getValue(P_FSG_40_0_0_16_1_42), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_43" ,getValue(P_FSG_40_0_0_16_1_43), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_44" ,getValue(P_FSG_40_0_0_16_1_44), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_45" ,getValue(P_FSG_40_0_0_16_1_45), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_46" ,getValue(P_FSG_40_0_0_16_1_46), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_47" ,getValue(P_FSG_40_0_0_16_1_47), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_48" ,getValue(P_FSG_40_0_0_16_1_48), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_49" ,getValue(P_FSG_40_0_0_16_1_49), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_50" ,getValue(P_FSG_40_0_0_16_1_50), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_51" ,getValue(P_FSG_40_0_0_16_1_51), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_52" ,getValue(P_FSG_40_0_0_16_1_52), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_53" ,getValue(P_FSG_40_0_0_16_1_53), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_54" ,getValue(P_FSG_40_0_0_16_1_54), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_55" ,getValue(P_FSG_40_0_0_16_1_55), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_56" ,getValue(P_FSG_40_0_0_16_1_56), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_57" ,getValue(P_FSG_40_0_0_16_1_57), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_58" ,getValue(P_FSG_40_0_0_16_1_58), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_59" ,getValue(P_FSG_40_0_0_16_1_59), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_60" ,getValue(P_FSG_40_0_0_16_1_60), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_61" ,getValue(P_FSG_40_0_0_16_1_61), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_62" ,getValue(P_FSG_40_0_0_16_1_62), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_16_1_63" ,getValue(P_FSG_40_0_0_16_1_63), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_17Status_BTN" ,getValue(P_FSG_40_0_0_17Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_17_FctLstItemEn" ,getValue(P_FSG_40_0_0_17_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_17_FctEn" ,getValue(P_FSG_40_0_0_17_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_17_ErrEn" ,getValue(P_FSG_40_0_0_17_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_17_IntTlgEn" ,getValue(P_FSG_40_0_0_17_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_17_SegmEn" ,getValue(P_FSG_40_0_0_17_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_17_ErrCode" ,getValue(P_FSG_40_0_0_17_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_17_1_len" ,getValue(P_FSG_40_0_0_17_1_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_17_1_cnt" ,getValue(P_FSG_40_0_0_17_1_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_18Status_BTN" ,getValue(P_FSG_40_0_0_18Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_18_FctLstItemEn" ,getValue(P_FSG_40_0_0_18_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_18_FctEn" ,getValue(P_FSG_40_0_0_18_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_18_ErrEn" ,getValue(P_FSG_40_0_0_18_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_18_ErrCode" ,getValue(P_FSG_40_0_0_18_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_18_3" ,getValue(P_FSG_40_0_0_18_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_18_2" ,getValue(P_FSG_40_0_0_18_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_18_1" ,getValue(P_FSG_40_0_0_18_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_19Status_BTN" ,getValue(P_FSG_40_0_0_19Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_19_FctLstItemEn" ,getValue(P_FSG_40_0_0_19_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_19_FctEn" ,getValue(P_FSG_40_0_0_19_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_19_ErrEn" ,getValue(P_FSG_40_0_0_19_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_19_ErrCode" ,getValue(P_FSG_40_0_0_19_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_19" ,getValue(P_FSG_40_0_0_19), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_19_1" ,getValue(P_FSG_40_0_0_19_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_20Status_BTN" ,getValue(P_FSG_40_0_0_20Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_20_FctLstItemEn" ,getValue(P_FSG_40_0_0_20_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_20_FctEn" ,getValue(P_FSG_40_0_0_20_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_20_ErrEn" ,getValue(P_FSG_40_0_0_20_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_20_IntTlgEn" ,getValue(P_FSG_40_0_0_20_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_20_SegmEn" ,getValue(P_FSG_40_0_0_20_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_20_ErrCode" ,getValue(P_FSG_40_0_0_20_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_20_4_len" ,getValue(P_FSG_40_0_0_20_4_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_20_4_cnt" ,getValue(P_FSG_40_0_0_20_4_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_20_3" ,getValue(P_FSG_40_0_0_20_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_20_1" ,getValue(P_FSG_40_0_0_20_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_20_2_len" ,getValue(P_FSG_40_0_0_20_2_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_20_2_cnt" ,getValue(P_FSG_40_0_0_20_2_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_21Status_BTN" ,getValue(P_FSG_40_0_0_21Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_21_FctLstItemEn" ,getValue(P_FSG_40_0_0_21_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_21_FctEn" ,getValue(P_FSG_40_0_0_21_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_21_ErrEn" ,getValue(P_FSG_40_0_0_21_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_21_ErrCode" ,getValue(P_FSG_40_0_0_21_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_21" ,getValue(P_FSG_40_0_0_21), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_21_1" ,getValue(P_FSG_40_0_0_21_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_21_1_range" ,getValue(P_FSG_40_0_0_21_1_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22Status_BTN" ,getValue(P_FSG_40_0_0_22Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_FctLstItemEn" ,getValue(P_FSG_40_0_0_22_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_FctEn" ,getValue(P_FSG_40_0_0_22_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_ErrEn" ,getValue(P_FSG_40_0_0_22_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_IntTlgEn" ,getValue(P_FSG_40_0_0_22_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_SegmEn" ,getValue(P_FSG_40_0_0_22_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_ErrCode" ,getValue(P_FSG_40_0_0_22_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_19" ,getValue(P_FSG_40_0_0_22_19), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_16" ,getValue(P_FSG_40_0_0_22_16), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_13" ,getValue(P_FSG_40_0_0_22_13), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_10" ,getValue(P_FSG_40_0_0_22_10), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_7" ,getValue(P_FSG_40_0_0_22_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_4" ,getValue(P_FSG_40_0_0_22_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_1" ,getValue(P_FSG_40_0_0_22_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_21" ,getValue(P_FSG_40_0_0_22_21), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_21_0" ,getValue(P_FSG_40_0_0_22_21_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_21_1" ,getValue(P_FSG_40_0_0_22_21_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_21_2" ,getValue(P_FSG_40_0_0_22_21_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_21_3" ,getValue(P_FSG_40_0_0_22_21_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_21_4" ,getValue(P_FSG_40_0_0_22_21_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_21_5" ,getValue(P_FSG_40_0_0_22_21_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_21_6" ,getValue(P_FSG_40_0_0_22_21_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_21_7" ,getValue(P_FSG_40_0_0_22_21_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_18" ,getValue(P_FSG_40_0_0_22_18), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_18_0" ,getValue(P_FSG_40_0_0_22_18_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_18_1" ,getValue(P_FSG_40_0_0_22_18_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_18_2" ,getValue(P_FSG_40_0_0_22_18_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_18_3" ,getValue(P_FSG_40_0_0_22_18_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_18_4" ,getValue(P_FSG_40_0_0_22_18_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_18_5" ,getValue(P_FSG_40_0_0_22_18_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_18_6" ,getValue(P_FSG_40_0_0_22_18_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_18_7" ,getValue(P_FSG_40_0_0_22_18_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_15" ,getValue(P_FSG_40_0_0_22_15), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_15_0" ,getValue(P_FSG_40_0_0_22_15_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_15_1" ,getValue(P_FSG_40_0_0_22_15_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_15_2" ,getValue(P_FSG_40_0_0_22_15_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_15_3" ,getValue(P_FSG_40_0_0_22_15_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_15_4" ,getValue(P_FSG_40_0_0_22_15_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_15_5" ,getValue(P_FSG_40_0_0_22_15_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_15_6" ,getValue(P_FSG_40_0_0_22_15_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_15_7" ,getValue(P_FSG_40_0_0_22_15_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_12" ,getValue(P_FSG_40_0_0_22_12), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_12_0" ,getValue(P_FSG_40_0_0_22_12_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_12_1" ,getValue(P_FSG_40_0_0_22_12_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_12_2" ,getValue(P_FSG_40_0_0_22_12_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_12_3" ,getValue(P_FSG_40_0_0_22_12_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_12_4" ,getValue(P_FSG_40_0_0_22_12_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_12_5" ,getValue(P_FSG_40_0_0_22_12_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_12_6" ,getValue(P_FSG_40_0_0_22_12_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_12_7" ,getValue(P_FSG_40_0_0_22_12_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_9" ,getValue(P_FSG_40_0_0_22_9), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_9_0" ,getValue(P_FSG_40_0_0_22_9_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_9_1" ,getValue(P_FSG_40_0_0_22_9_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_9_2" ,getValue(P_FSG_40_0_0_22_9_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_9_3" ,getValue(P_FSG_40_0_0_22_9_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_9_4" ,getValue(P_FSG_40_0_0_22_9_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_9_5" ,getValue(P_FSG_40_0_0_22_9_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_9_6" ,getValue(P_FSG_40_0_0_22_9_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_9_7" ,getValue(P_FSG_40_0_0_22_9_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_6" ,getValue(P_FSG_40_0_0_22_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_6_0" ,getValue(P_FSG_40_0_0_22_6_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_6_1" ,getValue(P_FSG_40_0_0_22_6_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_6_2" ,getValue(P_FSG_40_0_0_22_6_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_6_3" ,getValue(P_FSG_40_0_0_22_6_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_6_4" ,getValue(P_FSG_40_0_0_22_6_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_6_5" ,getValue(P_FSG_40_0_0_22_6_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_6_6" ,getValue(P_FSG_40_0_0_22_6_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_6_7" ,getValue(P_FSG_40_0_0_22_6_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_3" ,getValue(P_FSG_40_0_0_22_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_3_0" ,getValue(P_FSG_40_0_0_22_3_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_3_1" ,getValue(P_FSG_40_0_0_22_3_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_3_2" ,getValue(P_FSG_40_0_0_22_3_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_3_3" ,getValue(P_FSG_40_0_0_22_3_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_3_4" ,getValue(P_FSG_40_0_0_22_3_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_3_5" ,getValue(P_FSG_40_0_0_22_3_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_3_6" ,getValue(P_FSG_40_0_0_22_3_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_3_7" ,getValue(P_FSG_40_0_0_22_3_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_20" ,getValue(P_FSG_40_0_0_22_20), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_17" ,getValue(P_FSG_40_0_0_22_17), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_14" ,getValue(P_FSG_40_0_0_22_14), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_11" ,getValue(P_FSG_40_0_0_22_11), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_8" ,getValue(P_FSG_40_0_0_22_8), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_5" ,getValue(P_FSG_40_0_0_22_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_2" ,getValue(P_FSG_40_0_0_22_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_23" ,getValue(P_FSG_40_0_0_22_23), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_23_0" ,getValue(P_FSG_40_0_0_22_23_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_23_1" ,getValue(P_FSG_40_0_0_22_23_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_23_2" ,getValue(P_FSG_40_0_0_22_23_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_23_3" ,getValue(P_FSG_40_0_0_22_23_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_23_4" ,getValue(P_FSG_40_0_0_22_23_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_23_5" ,getValue(P_FSG_40_0_0_22_23_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_23_6" ,getValue(P_FSG_40_0_0_22_23_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_23_7" ,getValue(P_FSG_40_0_0_22_23_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_22" ,getValue(P_FSG_40_0_0_22_22), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_22_0" ,getValue(P_FSG_40_0_0_22_22_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_22_1" ,getValue(P_FSG_40_0_0_22_22_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_22_2" ,getValue(P_FSG_40_0_0_22_22_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_22_3" ,getValue(P_FSG_40_0_0_22_22_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_22_4" ,getValue(P_FSG_40_0_0_22_22_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_22_5" ,getValue(P_FSG_40_0_0_22_22_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_22_22_6" ,getValue(P_FSG_40_0_0_22_22_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23Status_BTN" ,getValue(P_FSG_40_0_0_23Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_FctLstItemEn" ,getValue(P_FSG_40_0_0_23_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_FctEn" ,getValue(P_FSG_40_0_0_23_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_ErrEn" ,getValue(P_FSG_40_0_0_23_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_IntTlgEn" ,getValue(P_FSG_40_0_0_23_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_SegmEn" ,getValue(P_FSG_40_0_0_23_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_ErrCode" ,getValue(P_FSG_40_0_0_23_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_19_len" ,getValue(P_FSG_40_0_0_23_19_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_19_cnt" ,getValue(P_FSG_40_0_0_23_19_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_16_len" ,getValue(P_FSG_40_0_0_23_16_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_16_cnt" ,getValue(P_FSG_40_0_0_23_16_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_13_len" ,getValue(P_FSG_40_0_0_23_13_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_13_cnt" ,getValue(P_FSG_40_0_0_23_13_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_10_len" ,getValue(P_FSG_40_0_0_23_10_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_10_cnt" ,getValue(P_FSG_40_0_0_23_10_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_7_len" ,getValue(P_FSG_40_0_0_23_7_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_7_cnt" ,getValue(P_FSG_40_0_0_23_7_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_4_len" ,getValue(P_FSG_40_0_0_23_4_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_4_cnt" ,getValue(P_FSG_40_0_0_23_4_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_1_len" ,getValue(P_FSG_40_0_0_23_1_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_1_cnt" ,getValue(P_FSG_40_0_0_23_1_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_20_len" ,getValue(P_FSG_40_0_0_23_20_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_20_cnt" ,getValue(P_FSG_40_0_0_23_20_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_17_len" ,getValue(P_FSG_40_0_0_23_17_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_17_cnt" ,getValue(P_FSG_40_0_0_23_17_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_14_len" ,getValue(P_FSG_40_0_0_23_14_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_14_cnt" ,getValue(P_FSG_40_0_0_23_14_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_11_len" ,getValue(P_FSG_40_0_0_23_11_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_11_cnt" ,getValue(P_FSG_40_0_0_23_11_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_8_len" ,getValue(P_FSG_40_0_0_23_8_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_8_cnt" ,getValue(P_FSG_40_0_0_23_8_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_21" ,getValue(P_FSG_40_0_0_23_21), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_5_len" ,getValue(P_FSG_40_0_0_23_5_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_5_cnt" ,getValue(P_FSG_40_0_0_23_5_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_18" ,getValue(P_FSG_40_0_0_23_18), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_2_len" ,getValue(P_FSG_40_0_0_23_2_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_2_cnt" ,getValue(P_FSG_40_0_0_23_2_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_15" ,getValue(P_FSG_40_0_0_23_15), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_12" ,getValue(P_FSG_40_0_0_23_12), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_9" ,getValue(P_FSG_40_0_0_23_9), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_6" ,getValue(P_FSG_40_0_0_23_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_23_3" ,getValue(P_FSG_40_0_0_23_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_24Status_BTN" ,getValue(P_FSG_40_0_0_24Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_24_FctLstItemEn" ,getValue(P_FSG_40_0_0_24_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_24_FctEn" ,getValue(P_FSG_40_0_0_24_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_24_ErrEn" ,getValue(P_FSG_40_0_0_24_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_24_IntTlgEn" ,getValue(P_FSG_40_0_0_24_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_24_SegmEn" ,getValue(P_FSG_40_0_0_24_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_24_ErrCode" ,getValue(P_FSG_40_0_0_24_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_24_7" ,getValue(P_FSG_40_0_0_24_7), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_24_7_range" ,getValue(P_FSG_40_0_0_24_7_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_24_6" ,getValue(P_FSG_40_0_0_24_6), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_24_6_range" ,getValue(P_FSG_40_0_0_24_6_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_24_5" ,getValue(P_FSG_40_0_0_24_5), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_24_5_range" ,getValue(P_FSG_40_0_0_24_5_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_24_4" ,getValue(P_FSG_40_0_0_24_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_24_4_range" ,getValue(P_FSG_40_0_0_24_4_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_24_3" ,getValue(P_FSG_40_0_0_24_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_24_3_range" ,getValue(P_FSG_40_0_0_24_3_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_24_2" ,getValue(P_FSG_40_0_0_24_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_24_2_range" ,getValue(P_FSG_40_0_0_24_2_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_24_1" ,getValue(P_FSG_40_0_0_24_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_24_1_range" ,getValue(P_FSG_40_0_0_24_1_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_25Status_BTN" ,getValue(P_FSG_40_0_0_25Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_25_FctLstItemEn" ,getValue(P_FSG_40_0_0_25_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_25_FctEn" ,getValue(P_FSG_40_0_0_25_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_25_ErrEn" ,getValue(P_FSG_40_0_0_25_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_25_ErrCode" ,getValue(P_FSG_40_0_0_25_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_25" ,getValue(P_FSG_40_0_0_25), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_25_1" ,getValue(P_FSG_40_0_0_25_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_26Result_BTN" ,getValue(M_FSG_40_0_0_26Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_26_FctLstItemEn" ,getValue(M_FSG_40_0_0_26_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_26_FctEn" ,getValue(M_FSG_40_0_0_26_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_26_ErrEn" ,getValue(M_FSG_40_0_0_26_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_26_ErrCode" ,getValue(M_FSG_40_0_0_26_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_26_Result" ,getValue(M_FSG_40_0_0_26_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_26_Result_1" ,getValue(M_FSG_40_0_0_26_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_26_Processing_1_range" ,getValue(M_FSG_40_0_0_26_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_26_Processing_1_range" ,getValue(M_FSG_40_0_0_26_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_26_Processing_1_range" ,getValue(M_FSG_40_0_0_26_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_26_Start_1_len" ,getValue(M_FSG_40_0_0_26_Start_1_len), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_26_Start_1_cnt" ,getValue(M_FSG_40_0_0_26_Start_1_cnt), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_26_Start_2_len" ,getValue(M_FSG_40_0_0_26_Start_2_len), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_26_Start_2_cnt" ,getValue(M_FSG_40_0_0_26_Start_2_cnt), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_27Result_BTN" ,getValue(M_FSG_40_0_0_27Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_27_FctLstItemEn" ,getValue(M_FSG_40_0_0_27_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_27_FctEn" ,getValue(M_FSG_40_0_0_27_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_27_ErrEn" ,getValue(M_FSG_40_0_0_27_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_27_ErrCode" ,getValue(M_FSG_40_0_0_27_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_27_Result" ,getValue(M_FSG_40_0_0_27_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_27_Result_1" ,getValue(M_FSG_40_0_0_27_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_27_Processing_1_range" ,getValue(M_FSG_40_0_0_27_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_27_Processing_1_range" ,getValue(M_FSG_40_0_0_27_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_27_Processing_1_range" ,getValue(M_FSG_40_0_0_27_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_27_Start" ,getValue(M_FSG_40_0_0_27_Start), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_27_Start_1" ,getValue(M_FSG_40_0_0_27_Start_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_28Result_BTN" ,getValue(M_FSG_40_0_0_28Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_28_FctLstItemEn" ,getValue(M_FSG_40_0_0_28_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_28_FctEn" ,getValue(M_FSG_40_0_0_28_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_28_ErrEn" ,getValue(M_FSG_40_0_0_28_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_28_ErrCode" ,getValue(M_FSG_40_0_0_28_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_28_Result" ,getValue(M_FSG_40_0_0_28_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_28_Result_1" ,getValue(M_FSG_40_0_0_28_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_28_Processing_1_range" ,getValue(M_FSG_40_0_0_28_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_28_Processing_1_range" ,getValue(M_FSG_40_0_0_28_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_28_Processing_1_range" ,getValue(M_FSG_40_0_0_28_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_28_Start" ,getValue(M_FSG_40_0_0_28_Start), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_28_Start_1" ,getValue(M_FSG_40_0_0_28_Start_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_29Result_BTN" ,getValue(M_FSG_40_0_0_29Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_29_FctLstItemEn" ,getValue(M_FSG_40_0_0_29_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_29_FctEn" ,getValue(M_FSG_40_0_0_29_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_29_ErrEn" ,getValue(M_FSG_40_0_0_29_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_29_ErrCode" ,getValue(M_FSG_40_0_0_29_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_29_Result" ,getValue(M_FSG_40_0_0_29_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_29_Result_1" ,getValue(M_FSG_40_0_0_29_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_29_Processing_1_range" ,getValue(M_FSG_40_0_0_29_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_29_Processing_1_range" ,getValue(M_FSG_40_0_0_29_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_29_Processing_1_range" ,getValue(M_FSG_40_0_0_29_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_29_Start" ,getValue(M_FSG_40_0_0_29_Start), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_29_Start_1" ,getValue(M_FSG_40_0_0_29_Start_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_30Result_BTN" ,getValue(M_FSG_40_0_0_30Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_30_FctLstItemEn" ,getValue(M_FSG_40_0_0_30_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_30_FctEn" ,getValue(M_FSG_40_0_0_30_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_30_ErrEn" ,getValue(M_FSG_40_0_0_30_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_30_ErrCode" ,getValue(M_FSG_40_0_0_30_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_30_Result" ,getValue(M_FSG_40_0_0_30_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_30_Result_1" ,getValue(M_FSG_40_0_0_30_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_30_Processing_1_range" ,getValue(M_FSG_40_0_0_30_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_30_Processing_1_range" ,getValue(M_FSG_40_0_0_30_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_30_Processing_1_range" ,getValue(M_FSG_40_0_0_30_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_30_Start" ,getValue(M_FSG_40_0_0_30_Start), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_30_Start_0" ,getValue(M_FSG_40_0_0_30_Start_0), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_31Result_BTN" ,getValue(M_FSG_40_0_0_31Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_31_FctLstItemEn" ,getValue(M_FSG_40_0_0_31_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_31_FctEn" ,getValue(M_FSG_40_0_0_31_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_31_ErrEn" ,getValue(M_FSG_40_0_0_31_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_31_ErrCode" ,getValue(M_FSG_40_0_0_31_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_31_Result" ,getValue(M_FSG_40_0_0_31_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_31_Result_1" ,getValue(M_FSG_40_0_0_31_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_31_Processing_1_range" ,getValue(M_FSG_40_0_0_31_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_31_Processing_1_range" ,getValue(M_FSG_40_0_0_31_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_31_Processing_1_range" ,getValue(M_FSG_40_0_0_31_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_31_Start" ,getValue(M_FSG_40_0_0_31_Start), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_31_Start_0" ,getValue(M_FSG_40_0_0_31_Start_0), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_32Result_BTN" ,getValue(M_FSG_40_0_0_32Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_32_FctLstItemEn" ,getValue(M_FSG_40_0_0_32_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_32_FctEn" ,getValue(M_FSG_40_0_0_32_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_32_ErrEn" ,getValue(M_FSG_40_0_0_32_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_32_ErrCode" ,getValue(M_FSG_40_0_0_32_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_32_Result" ,getValue(M_FSG_40_0_0_32_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_32_Result_1" ,getValue(M_FSG_40_0_0_32_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_32_Processing_1_range" ,getValue(M_FSG_40_0_0_32_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_32_Processing_1_range" ,getValue(M_FSG_40_0_0_32_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_32_Processing_1_range" ,getValue(M_FSG_40_0_0_32_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_32_Start" ,getValue(M_FSG_40_0_0_32_Start), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_32_Start_0" ,getValue(M_FSG_40_0_0_32_Start_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_33Status_BTN" ,getValue(P_FSG_40_0_0_33Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_33_FctLstItemEn" ,getValue(P_FSG_40_0_0_33_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_33_FctEn" ,getValue(P_FSG_40_0_0_33_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_33_ErrEn" ,getValue(P_FSG_40_0_0_33_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_33_ErrCode" ,getValue(P_FSG_40_0_0_33_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_33" ,getValue(P_FSG_40_0_0_33), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_33_1" ,getValue(P_FSG_40_0_0_33_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_33_1_0" ,getValue(P_FSG_40_0_0_33_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_34Status_BTN" ,getValue(P_FSG_40_0_0_34Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_34_FctLstItemEn" ,getValue(P_FSG_40_0_0_34_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_34_FctEn" ,getValue(P_FSG_40_0_0_34_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_34_ErrEn" ,getValue(P_FSG_40_0_0_34_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_34_ErrCode" ,getValue(P_FSG_40_0_0_34_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_34" ,getValue(P_FSG_40_0_0_34), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_34_1" ,getValue(P_FSG_40_0_0_34_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_34_1_0" ,getValue(P_FSG_40_0_0_34_1_0), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_35Result_BTN" ,getValue(M_FSG_40_0_0_35Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_35_FctLstItemEn" ,getValue(M_FSG_40_0_0_35_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_35_FctEn" ,getValue(M_FSG_40_0_0_35_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_35_ErrEn" ,getValue(M_FSG_40_0_0_35_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_35_ErrCode" ,getValue(M_FSG_40_0_0_35_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_35_Result" ,getValue(M_FSG_40_0_0_35_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_35_Result_1" ,getValue(M_FSG_40_0_0_35_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_35_Processing_1_range" ,getValue(M_FSG_40_0_0_35_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_35_Processing_1_range" ,getValue(M_FSG_40_0_0_35_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_35_Processing_1_range" ,getValue(M_FSG_40_0_0_35_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_35_Start" ,getValue(M_FSG_40_0_0_35_Start), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_35_Start_0" ,getValue(M_FSG_40_0_0_35_Start_0), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_36Result_BTN" ,getValue(M_FSG_40_0_0_36Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_36_FctLstItemEn" ,getValue(M_FSG_40_0_0_36_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_36_FctEn" ,getValue(M_FSG_40_0_0_36_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_36_ErrEn" ,getValue(M_FSG_40_0_0_36_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_36_ErrCode" ,getValue(M_FSG_40_0_0_36_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_36_Result" ,getValue(M_FSG_40_0_0_36_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_36_Result_1" ,getValue(M_FSG_40_0_0_36_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_36_Processing_1_range" ,getValue(M_FSG_40_0_0_36_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_36_Processing_1_range" ,getValue(M_FSG_40_0_0_36_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_36_Processing_1_range" ,getValue(M_FSG_40_0_0_36_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_36_Start" ,getValue(M_FSG_40_0_0_36_Start), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_36_Start_0" ,getValue(M_FSG_40_0_0_36_Start_0), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_37Result_BTN" ,getValue(M_FSG_40_0_0_37Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_37_FctLstItemEn" ,getValue(M_FSG_40_0_0_37_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_37_FctEn" ,getValue(M_FSG_40_0_0_37_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_37_ErrEn" ,getValue(M_FSG_40_0_0_37_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_37_ErrCode" ,getValue(M_FSG_40_0_0_37_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_37_Result" ,getValue(M_FSG_40_0_0_37_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_37_Result_1" ,getValue(M_FSG_40_0_0_37_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_37_Processing_1_range" ,getValue(M_FSG_40_0_0_37_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_37_Processing_1_range" ,getValue(M_FSG_40_0_0_37_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_37_Processing_1_range" ,getValue(M_FSG_40_0_0_37_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_37_Start" ,getValue(M_FSG_40_0_0_37_Start), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_37_Start_0" ,getValue(M_FSG_40_0_0_37_Start_0), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_38Result_BTN" ,getValue(M_FSG_40_0_0_38Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_38_FctLstItemEn" ,getValue(M_FSG_40_0_0_38_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_38_FctEn" ,getValue(M_FSG_40_0_0_38_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_38_ErrEn" ,getValue(M_FSG_40_0_0_38_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_38_ErrCode" ,getValue(M_FSG_40_0_0_38_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_38_Result" ,getValue(M_FSG_40_0_0_38_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_38_Result_1" ,getValue(M_FSG_40_0_0_38_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_38_Processing_1_range" ,getValue(M_FSG_40_0_0_38_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_38_Processing_1_range" ,getValue(M_FSG_40_0_0_38_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_38_Processing_1_range" ,getValue(M_FSG_40_0_0_38_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_38_Start" ,getValue(M_FSG_40_0_0_38_Start), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_38_Start_0" ,getValue(M_FSG_40_0_0_38_Start_0), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_39Result_BTN" ,getValue(M_FSG_40_0_0_39Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_39_FctLstItemEn" ,getValue(M_FSG_40_0_0_39_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_39_FctEn" ,getValue(M_FSG_40_0_0_39_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_39_ErrEn" ,getValue(M_FSG_40_0_0_39_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_39_ErrCode" ,getValue(M_FSG_40_0_0_39_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_39_Result" ,getValue(M_FSG_40_0_0_39_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_39_Result_1" ,getValue(M_FSG_40_0_0_39_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_39_Processing_1_range" ,getValue(M_FSG_40_0_0_39_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_39_Processing_1_range" ,getValue(M_FSG_40_0_0_39_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_39_Processing_1_range" ,getValue(M_FSG_40_0_0_39_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_39_Start" ,getValue(M_FSG_40_0_0_39_Start), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_39_Start_0" ,getValue(M_FSG_40_0_0_39_Start_0), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_40Result_BTN" ,getValue(M_FSG_40_0_0_40Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_40_FctLstItemEn" ,getValue(M_FSG_40_0_0_40_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_40_FctEn" ,getValue(M_FSG_40_0_0_40_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_40_ErrEn" ,getValue(M_FSG_40_0_0_40_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_40_ErrCode" ,getValue(M_FSG_40_0_0_40_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_40_Result" ,getValue(M_FSG_40_0_0_40_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_40_Result_1" ,getValue(M_FSG_40_0_0_40_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_40_Processing_1_range" ,getValue(M_FSG_40_0_0_40_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_40_Processing_1_range" ,getValue(M_FSG_40_0_0_40_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_40_Processing_1_range" ,getValue(M_FSG_40_0_0_40_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_40_Start" ,getValue(M_FSG_40_0_0_40_Start), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_40_Start_0" ,getValue(M_FSG_40_0_0_40_Start_0), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_41Result_BTN" ,getValue(M_FSG_40_0_0_41Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_41_FctLstItemEn" ,getValue(M_FSG_40_0_0_41_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_41_FctEn" ,getValue(M_FSG_40_0_0_41_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_41_ErrEn" ,getValue(M_FSG_40_0_0_41_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_41_ErrCode" ,getValue(M_FSG_40_0_0_41_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_41_Result" ,getValue(M_FSG_40_0_0_41_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_41_Result_1" ,getValue(M_FSG_40_0_0_41_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_41_Processing_1_range" ,getValue(M_FSG_40_0_0_41_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_41_Processing_1_range" ,getValue(M_FSG_40_0_0_41_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_41_Processing_1_range" ,getValue(M_FSG_40_0_0_41_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_41_Start" ,getValue(M_FSG_40_0_0_41_Start), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_41_Start_1" ,getValue(M_FSG_40_0_0_41_Start_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_42Status_BTN" ,getValue(P_FSG_40_0_0_42Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_42_FctLstItemEn" ,getValue(P_FSG_40_0_0_42_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_42_FctEn" ,getValue(P_FSG_40_0_0_42_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_42_ErrEn" ,getValue(P_FSG_40_0_0_42_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_42_ErrCode" ,getValue(P_FSG_40_0_0_42_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_42" ,getValue(P_FSG_40_0_0_42), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_42_1" ,getValue(P_FSG_40_0_0_42_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_43Status_BTN" ,getValue(P_FSG_40_0_0_43Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_43_FctLstItemEn" ,getValue(P_FSG_40_0_0_43_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_43_FctEn" ,getValue(P_FSG_40_0_0_43_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_43_ErrEn" ,getValue(P_FSG_40_0_0_43_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_43_ErrCode" ,getValue(P_FSG_40_0_0_43_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_43_5" ,getValue(P_FSG_40_0_0_43_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_43_5_0" ,getValue(P_FSG_40_0_0_43_5_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_43_5_1" ,getValue(P_FSG_40_0_0_43_5_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_43_5_2" ,getValue(P_FSG_40_0_0_43_5_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_43_5_3" ,getValue(P_FSG_40_0_0_43_5_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_43_2" ,getValue(P_FSG_40_0_0_43_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_43_2_range" ,getValue(P_FSG_40_0_0_43_2_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_43_1" ,getValue(P_FSG_40_0_0_43_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_43_1_range" ,getValue(P_FSG_40_0_0_43_1_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_43_4" ,getValue(P_FSG_40_0_0_43_4), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_43_4_range" ,getValue(P_FSG_40_0_0_43_4_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_43_3" ,getValue(P_FSG_40_0_0_43_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_43_3_range" ,getValue(P_FSG_40_0_0_43_3_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_44Status_BTN" ,getValue(P_FSG_40_0_0_44Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_44_FctLstItemEn" ,getValue(P_FSG_40_0_0_44_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_44_FctEn" ,getValue(P_FSG_40_0_0_44_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_44_ErrEn" ,getValue(P_FSG_40_0_0_44_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_44_IntTlgEn" ,getValue(P_FSG_40_0_0_44_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_44_SegmEn" ,getValue(P_FSG_40_0_0_44_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_44_ErrCode" ,getValue(P_FSG_40_0_0_44_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_44_2" ,getValue(P_FSG_40_0_0_44_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_44_2_range" ,getValue(P_FSG_40_0_0_44_2_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_44_1" ,getValue(P_FSG_40_0_0_44_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_44_3" ,getValue(P_FSG_40_0_0_44_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_44_3_range" ,getValue(P_FSG_40_0_0_44_3_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_45Status_BTN" ,getValue(P_FSG_40_0_0_45Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_45_FctLstItemEn" ,getValue(P_FSG_40_0_0_45_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_45_FctEn" ,getValue(P_FSG_40_0_0_45_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_45_ErrEn" ,getValue(P_FSG_40_0_0_45_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_45_ErrCode" ,getValue(P_FSG_40_0_0_45_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_45_2" ,getValue(P_FSG_40_0_0_45_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_45_2_range" ,getValue(P_FSG_40_0_0_45_2_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_45_1" ,getValue(P_FSG_40_0_0_45_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_45_1_range" ,getValue(P_FSG_40_0_0_45_1_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46Changed_BTN" ,getValue(A_FSG_40_0_0_46Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46Status_BTN" ,getValue(A_FSG_40_0_0_46Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_FctLstItemEn" ,getValue(A_FSG_40_0_0_46_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_FctEn" ,getValue(A_FSG_40_0_0_46_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_ErrEn" ,getValue(A_FSG_40_0_0_46_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_IntTlgEn" ,getValue(A_FSG_40_0_0_46_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_SegmEn" ,getValue(A_FSG_40_0_0_46_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_AT" ,getValue(A_FSG_40_0_0_46_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_ErrCode" ,getValue(A_FSG_40_0_0_46_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_DataIndex_SetGet_Incr" ,getValue(A_FSG_40_0_0_46_DataIndex_SetGet_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_DataIndex_Incr" ,getValue(A_FSG_40_0_0_46_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_DataIndex_Decr" ,getValue(A_FSG_40_0_0_46_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_loadArray_Btn" ,getValue(A_FSG_40_0_0_46_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_generateData_Btn" ,getValue(A_FSG_40_0_0_46_generateData_Btn), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_7_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_7_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_7_range" ,getValue(A_FSG_40_0_0_46_Data_7_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Data_4_len" ,getValue(A_FSG_40_0_0_46_Data_4_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Data_4_cnt" ,getValue(A_FSG_40_0_0_46_Data_4_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_3" ,getValue(A_FSG_40_0_0_46_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_3_range" ,getValue(A_FSG_40_0_0_46_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Data_3" ,getValue(A_FSG_40_0_0_46_Data_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_1" ,getValue(A_FSG_40_0_0_46_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_6_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_6_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_6_range" ,getValue(A_FSG_40_0_0_46_Data_6_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_10_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_10_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_10_range" ,getValue(A_FSG_40_0_0_46_Data_10_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Data_2_len" ,getValue(A_FSG_40_0_0_46_Data_2_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Data_2_cnt" ,getValue(A_FSG_40_0_0_46_Data_2_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_9_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_9_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_9_range" ,getValue(A_FSG_40_0_0_46_Data_9_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_8_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_8_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_8_range" ,getValue(A_FSG_40_0_0_46_Data_8_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_5_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_5_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_5_range" ,getValue(A_FSG_40_0_0_46_Data_5_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_10_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_10_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_1_range" ,getValue(A_FSG_40_0_0_46_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_2" ,getValue(A_FSG_40_0_0_46_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_2_range" ,getValue(A_FSG_40_0_0_46_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_RecAdr" ,getValue(A_FSG_40_0_0_46_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Direction" ,getValue(A_FSG_40_0_0_46_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Shift" ,getValue(A_FSG_40_0_0_46_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_TransPos" ,getValue(A_FSG_40_0_0_46_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_IndexSize" ,getValue(A_FSG_40_0_0_46_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Start" ,getValue(A_FSG_40_0_0_46_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Elements" ,getValue(A_FSG_40_0_0_46_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Changed_RecAdr" ,getValue(A_FSG_40_0_0_46_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Changed_Direction" ,getValue(A_FSG_40_0_0_46_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Changed_Shift" ,getValue(A_FSG_40_0_0_46_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Changed_TransPos" ,getValue(A_FSG_40_0_0_46_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Changed_IndexSize" ,getValue(A_FSG_40_0_0_46_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Changed_Start" ,getValue(A_FSG_40_0_0_46_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Changed_Elements" ,getValue(A_FSG_40_0_0_46_Changed_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_DataIndex_SetGet" ,getValue(A_FSG_40_0_0_46_DataIndex_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_DataIndex_SetGet_Incr" ,getValue(A_FSG_40_0_0_46_DataIndex_SetGet_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_DataIndex_SetGet_Decr" ,getValue(A_FSG_40_0_0_46_DataIndex_SetGet_Decr), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_7_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_7_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_7_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_7_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Data_4_SetGet_len" ,getValue(A_FSG_40_0_0_46_Data_4_SetGet_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Data_4_SetGet_cnt" ,getValue(A_FSG_40_0_0_46_Data_4_SetGet_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Data_3_SetGet" ,getValue(A_FSG_40_0_0_46_Data_3_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_1_SetGet" ,getValue(A_FSG_40_0_0_46_1_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_6_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_6_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_6_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_6_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_10_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_10_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_10_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_10_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Data_2_SetGet_len" ,getValue(A_FSG_40_0_0_46_Data_2_SetGet_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_Data_2_SetGet_cnt" ,getValue(A_FSG_40_0_0_46_Data_2_SetGet_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_9_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_9_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_9_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_9_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_8_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_8_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_8_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_8_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_5_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_5_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_5_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_5_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_1_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_1_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_Data_1_SetGet_range" ,getValue(A_FSG_40_0_0_46_Data_1_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_2_SetGet" ,getValue(A_FSG_40_0_0_46_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_46_2_SetGet_range" ,getValue(A_FSG_40_0_0_46_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_SetGet_RecAdr" ,getValue(A_FSG_40_0_0_46_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_SetGet_Direction" ,getValue(A_FSG_40_0_0_46_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_SetGet_Shift" ,getValue(A_FSG_40_0_0_46_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_SetGet_IndexSize" ,getValue(A_FSG_40_0_0_46_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_SetGet_Start" ,getValue(A_FSG_40_0_0_46_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_46_SetGet_Elements" ,getValue(A_FSG_40_0_0_46_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47Changed_BTN" ,getValue(A_FSG_40_0_0_47Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47Status_BTN" ,getValue(A_FSG_40_0_0_47Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_FctLstItemEn" ,getValue(A_FSG_40_0_0_47_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_FctEn" ,getValue(A_FSG_40_0_0_47_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_ErrEn" ,getValue(A_FSG_40_0_0_47_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_IntTlgEn" ,getValue(A_FSG_40_0_0_47_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_SegmEn" ,getValue(A_FSG_40_0_0_47_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_AT" ,getValue(A_FSG_40_0_0_47_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_ErrCode" ,getValue(A_FSG_40_0_0_47_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_DataIndex_SetGet_Incr" ,getValue(A_FSG_40_0_0_47_DataIndex_SetGet_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_DataIndex_Incr" ,getValue(A_FSG_40_0_0_47_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_DataIndex_Decr" ,getValue(A_FSG_40_0_0_47_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_loadArray_Btn" ,getValue(A_FSG_40_0_0_47_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_generateData_Btn" ,getValue(A_FSG_40_0_0_47_generateData_Btn), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_7_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_7_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_7_range" ,getValue(A_FSG_40_0_0_47_Data_7_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Data_4_len" ,getValue(A_FSG_40_0_0_47_Data_4_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Data_4_cnt" ,getValue(A_FSG_40_0_0_47_Data_4_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_3" ,getValue(A_FSG_40_0_0_47_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_3_range" ,getValue(A_FSG_40_0_0_47_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Data_3" ,getValue(A_FSG_40_0_0_47_Data_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_1" ,getValue(A_FSG_40_0_0_47_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_6_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_6_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_6_range" ,getValue(A_FSG_40_0_0_47_Data_6_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_10_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_10_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_10_range" ,getValue(A_FSG_40_0_0_47_Data_10_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Data_2_len" ,getValue(A_FSG_40_0_0_47_Data_2_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Data_2_cnt" ,getValue(A_FSG_40_0_0_47_Data_2_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_9_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_9_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_9_range" ,getValue(A_FSG_40_0_0_47_Data_9_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_8_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_8_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_8_range" ,getValue(A_FSG_40_0_0_47_Data_8_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_5_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_5_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_5_range" ,getValue(A_FSG_40_0_0_47_Data_5_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_10_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_10_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_1_range" ,getValue(A_FSG_40_0_0_47_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_2" ,getValue(A_FSG_40_0_0_47_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_2_range" ,getValue(A_FSG_40_0_0_47_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_RecAdr" ,getValue(A_FSG_40_0_0_47_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Direction" ,getValue(A_FSG_40_0_0_47_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Shift" ,getValue(A_FSG_40_0_0_47_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_TransPos" ,getValue(A_FSG_40_0_0_47_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_IndexSize" ,getValue(A_FSG_40_0_0_47_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Start" ,getValue(A_FSG_40_0_0_47_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Elements" ,getValue(A_FSG_40_0_0_47_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Changed_RecAdr" ,getValue(A_FSG_40_0_0_47_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Changed_Direction" ,getValue(A_FSG_40_0_0_47_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Changed_Shift" ,getValue(A_FSG_40_0_0_47_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Changed_TransPos" ,getValue(A_FSG_40_0_0_47_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Changed_IndexSize" ,getValue(A_FSG_40_0_0_47_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Changed_Start" ,getValue(A_FSG_40_0_0_47_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Changed_Elements" ,getValue(A_FSG_40_0_0_47_Changed_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_DataIndex_SetGet" ,getValue(A_FSG_40_0_0_47_DataIndex_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_DataIndex_SetGet_Incr" ,getValue(A_FSG_40_0_0_47_DataIndex_SetGet_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_DataIndex_SetGet_Decr" ,getValue(A_FSG_40_0_0_47_DataIndex_SetGet_Decr), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_7_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_7_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_7_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_7_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Data_4_SetGet_len" ,getValue(A_FSG_40_0_0_47_Data_4_SetGet_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Data_4_SetGet_cnt" ,getValue(A_FSG_40_0_0_47_Data_4_SetGet_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Data_3_SetGet" ,getValue(A_FSG_40_0_0_47_Data_3_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_1_SetGet" ,getValue(A_FSG_40_0_0_47_1_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_6_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_6_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_6_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_6_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_10_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_10_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_10_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_10_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Data_2_SetGet_len" ,getValue(A_FSG_40_0_0_47_Data_2_SetGet_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_Data_2_SetGet_cnt" ,getValue(A_FSG_40_0_0_47_Data_2_SetGet_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_9_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_9_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_9_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_9_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_8_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_8_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_8_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_8_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_5_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_5_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_5_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_5_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_1_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_1_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_Data_1_SetGet_range" ,getValue(A_FSG_40_0_0_47_Data_1_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_2_SetGet" ,getValue(A_FSG_40_0_0_47_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_47_2_SetGet_range" ,getValue(A_FSG_40_0_0_47_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_SetGet_RecAdr" ,getValue(A_FSG_40_0_0_47_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_SetGet_Direction" ,getValue(A_FSG_40_0_0_47_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_SetGet_Shift" ,getValue(A_FSG_40_0_0_47_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_SetGet_IndexSize" ,getValue(A_FSG_40_0_0_47_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_SetGet_Start" ,getValue(A_FSG_40_0_0_47_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_47_SetGet_Elements" ,getValue(A_FSG_40_0_0_47_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48Changed_BTN" ,getValue(A_FSG_40_0_0_48Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48Status_BTN" ,getValue(A_FSG_40_0_0_48Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_FctLstItemEn" ,getValue(A_FSG_40_0_0_48_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_FctEn" ,getValue(A_FSG_40_0_0_48_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_ErrEn" ,getValue(A_FSG_40_0_0_48_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_IntTlgEn" ,getValue(A_FSG_40_0_0_48_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_SegmEn" ,getValue(A_FSG_40_0_0_48_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_AT" ,getValue(A_FSG_40_0_0_48_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_ErrCode" ,getValue(A_FSG_40_0_0_48_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_DataIndex_SetGet_Incr" ,getValue(A_FSG_40_0_0_48_DataIndex_SetGet_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_DataIndex_Incr" ,getValue(A_FSG_40_0_0_48_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_DataIndex_Decr" ,getValue(A_FSG_40_0_0_48_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_loadArray_Btn" ,getValue(A_FSG_40_0_0_48_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_generateData_Btn" ,getValue(A_FSG_40_0_0_48_generateData_Btn), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_7_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_7_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_7_range" ,getValue(A_FSG_40_0_0_48_Data_7_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Data_4_len" ,getValue(A_FSG_40_0_0_48_Data_4_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Data_4_cnt" ,getValue(A_FSG_40_0_0_48_Data_4_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_3" ,getValue(A_FSG_40_0_0_48_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_3_range" ,getValue(A_FSG_40_0_0_48_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Data_3" ,getValue(A_FSG_40_0_0_48_Data_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_1" ,getValue(A_FSG_40_0_0_48_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_6_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_6_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_6_range" ,getValue(A_FSG_40_0_0_48_Data_6_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_10_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_10_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_10_range" ,getValue(A_FSG_40_0_0_48_Data_10_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Data_2_len" ,getValue(A_FSG_40_0_0_48_Data_2_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Data_2_cnt" ,getValue(A_FSG_40_0_0_48_Data_2_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_9_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_9_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_9_range" ,getValue(A_FSG_40_0_0_48_Data_9_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_8_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_8_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_8_range" ,getValue(A_FSG_40_0_0_48_Data_8_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_5_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_5_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_5_range" ,getValue(A_FSG_40_0_0_48_Data_5_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_10_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_10_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_1_range" ,getValue(A_FSG_40_0_0_48_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_2" ,getValue(A_FSG_40_0_0_48_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_2_range" ,getValue(A_FSG_40_0_0_48_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_RecAdr" ,getValue(A_FSG_40_0_0_48_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Direction" ,getValue(A_FSG_40_0_0_48_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Shift" ,getValue(A_FSG_40_0_0_48_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_TransPos" ,getValue(A_FSG_40_0_0_48_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_IndexSize" ,getValue(A_FSG_40_0_0_48_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Start" ,getValue(A_FSG_40_0_0_48_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Elements" ,getValue(A_FSG_40_0_0_48_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Changed_RecAdr" ,getValue(A_FSG_40_0_0_48_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Changed_Direction" ,getValue(A_FSG_40_0_0_48_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Changed_Shift" ,getValue(A_FSG_40_0_0_48_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Changed_TransPos" ,getValue(A_FSG_40_0_0_48_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Changed_IndexSize" ,getValue(A_FSG_40_0_0_48_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Changed_Start" ,getValue(A_FSG_40_0_0_48_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Changed_Elements" ,getValue(A_FSG_40_0_0_48_Changed_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_DataIndex_SetGet" ,getValue(A_FSG_40_0_0_48_DataIndex_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_DataIndex_SetGet_Incr" ,getValue(A_FSG_40_0_0_48_DataIndex_SetGet_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_DataIndex_SetGet_Decr" ,getValue(A_FSG_40_0_0_48_DataIndex_SetGet_Decr), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_7_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_7_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_7_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_7_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Data_4_SetGet_len" ,getValue(A_FSG_40_0_0_48_Data_4_SetGet_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Data_4_SetGet_cnt" ,getValue(A_FSG_40_0_0_48_Data_4_SetGet_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Data_3_SetGet" ,getValue(A_FSG_40_0_0_48_Data_3_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_1_SetGet" ,getValue(A_FSG_40_0_0_48_1_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_6_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_6_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_6_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_6_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_10_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_10_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_10_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_10_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Data_2_SetGet_len" ,getValue(A_FSG_40_0_0_48_Data_2_SetGet_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_Data_2_SetGet_cnt" ,getValue(A_FSG_40_0_0_48_Data_2_SetGet_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_9_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_9_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_9_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_9_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_8_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_8_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_8_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_8_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_5_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_5_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_5_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_5_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_1_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_1_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_Data_1_SetGet_range" ,getValue(A_FSG_40_0_0_48_Data_1_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_2_SetGet" ,getValue(A_FSG_40_0_0_48_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_48_2_SetGet_range" ,getValue(A_FSG_40_0_0_48_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_SetGet_RecAdr" ,getValue(A_FSG_40_0_0_48_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_SetGet_Direction" ,getValue(A_FSG_40_0_0_48_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_SetGet_Shift" ,getValue(A_FSG_40_0_0_48_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_SetGet_IndexSize" ,getValue(A_FSG_40_0_0_48_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_SetGet_Start" ,getValue(A_FSG_40_0_0_48_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_48_SetGet_Elements" ,getValue(A_FSG_40_0_0_48_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49Changed_BTN" ,getValue(A_FSG_40_0_0_49Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49Status_BTN" ,getValue(A_FSG_40_0_0_49Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_FctLstItemEn" ,getValue(A_FSG_40_0_0_49_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_FctEn" ,getValue(A_FSG_40_0_0_49_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_ErrEn" ,getValue(A_FSG_40_0_0_49_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_IntTlgEn" ,getValue(A_FSG_40_0_0_49_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_SegmEn" ,getValue(A_FSG_40_0_0_49_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_AT" ,getValue(A_FSG_40_0_0_49_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_ErrCode" ,getValue(A_FSG_40_0_0_49_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_DataIndex_SetGet_Incr" ,getValue(A_FSG_40_0_0_49_DataIndex_SetGet_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_DataIndex_Incr" ,getValue(A_FSG_40_0_0_49_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_DataIndex_Decr" ,getValue(A_FSG_40_0_0_49_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_loadArray_Btn" ,getValue(A_FSG_40_0_0_49_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_generateData_Btn" ,getValue(A_FSG_40_0_0_49_generateData_Btn), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_8_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_8_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_8_range" ,getValue(A_FSG_40_0_0_49_Data_8_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Data_4" ,getValue(A_FSG_40_0_0_49_Data_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Data_5_len" ,getValue(A_FSG_40_0_0_49_Data_5_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Data_5_cnt" ,getValue(A_FSG_40_0_0_49_Data_5_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_3" ,getValue(A_FSG_40_0_0_49_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_3_range" ,getValue(A_FSG_40_0_0_49_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Data_3" ,getValue(A_FSG_40_0_0_49_Data_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_1" ,getValue(A_FSG_40_0_0_49_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_7_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_7_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_7_range" ,getValue(A_FSG_40_0_0_49_Data_7_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_11_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_11_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_11_range" ,getValue(A_FSG_40_0_0_49_Data_11_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Data_2_len" ,getValue(A_FSG_40_0_0_49_Data_2_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Data_2_cnt" ,getValue(A_FSG_40_0_0_49_Data_2_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_10_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_10_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_10_range" ,getValue(A_FSG_40_0_0_49_Data_10_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_9_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_9_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_9_range" ,getValue(A_FSG_40_0_0_49_Data_9_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_6_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_6_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_6_range" ,getValue(A_FSG_40_0_0_49_Data_6_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_11_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_11_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_1_range" ,getValue(A_FSG_40_0_0_49_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_2" ,getValue(A_FSG_40_0_0_49_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_2_range" ,getValue(A_FSG_40_0_0_49_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_RecAdr" ,getValue(A_FSG_40_0_0_49_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Direction" ,getValue(A_FSG_40_0_0_49_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Shift" ,getValue(A_FSG_40_0_0_49_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_TransPos" ,getValue(A_FSG_40_0_0_49_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_IndexSize" ,getValue(A_FSG_40_0_0_49_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Start" ,getValue(A_FSG_40_0_0_49_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Elements" ,getValue(A_FSG_40_0_0_49_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Changed_RecAdr" ,getValue(A_FSG_40_0_0_49_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Changed_Direction" ,getValue(A_FSG_40_0_0_49_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Changed_Shift" ,getValue(A_FSG_40_0_0_49_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Changed_TransPos" ,getValue(A_FSG_40_0_0_49_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Changed_IndexSize" ,getValue(A_FSG_40_0_0_49_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Changed_Start" ,getValue(A_FSG_40_0_0_49_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Changed_Elements" ,getValue(A_FSG_40_0_0_49_Changed_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_DataIndex_SetGet" ,getValue(A_FSG_40_0_0_49_DataIndex_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_DataIndex_SetGet_Incr" ,getValue(A_FSG_40_0_0_49_DataIndex_SetGet_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_DataIndex_SetGet_Decr" ,getValue(A_FSG_40_0_0_49_DataIndex_SetGet_Decr), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_8_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_8_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_8_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_8_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Data_4_SetGet" ,getValue(A_FSG_40_0_0_49_Data_4_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Data_5_SetGet_len" ,getValue(A_FSG_40_0_0_49_Data_5_SetGet_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Data_5_SetGet_cnt" ,getValue(A_FSG_40_0_0_49_Data_5_SetGet_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Data_3_SetGet" ,getValue(A_FSG_40_0_0_49_Data_3_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_1_SetGet" ,getValue(A_FSG_40_0_0_49_1_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_7_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_7_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_7_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_7_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_11_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_11_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_11_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_11_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Data_2_SetGet_len" ,getValue(A_FSG_40_0_0_49_Data_2_SetGet_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_Data_2_SetGet_cnt" ,getValue(A_FSG_40_0_0_49_Data_2_SetGet_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_10_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_10_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_10_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_10_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_9_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_9_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_9_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_9_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_6_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_6_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_6_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_6_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_1_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_1_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_Data_1_SetGet_range" ,getValue(A_FSG_40_0_0_49_Data_1_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_2_SetGet" ,getValue(A_FSG_40_0_0_49_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_49_2_SetGet_range" ,getValue(A_FSG_40_0_0_49_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_SetGet_RecAdr" ,getValue(A_FSG_40_0_0_49_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_SetGet_Direction" ,getValue(A_FSG_40_0_0_49_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_SetGet_Shift" ,getValue(A_FSG_40_0_0_49_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_SetGet_IndexSize" ,getValue(A_FSG_40_0_0_49_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_SetGet_Start" ,getValue(A_FSG_40_0_0_49_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_49_SetGet_Elements" ,getValue(A_FSG_40_0_0_49_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_50Result_BTN" ,getValue(M_FSG_40_0_0_50Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_50_FctLstItemEn" ,getValue(M_FSG_40_0_0_50_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_50_FctEn" ,getValue(M_FSG_40_0_0_50_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_50_ErrEn" ,getValue(M_FSG_40_0_0_50_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_50_ErrCode" ,getValue(M_FSG_40_0_0_50_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_50_Result" ,getValue(M_FSG_40_0_0_50_Result), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_50_Result_1" ,getValue(M_FSG_40_0_0_50_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_50_Processing_1_range" ,getValue(M_FSG_40_0_0_50_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_50_Processing_1_range" ,getValue(M_FSG_40_0_0_50_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_50_Processing_1_range" ,getValue(M_FSG_40_0_0_50_Processing_1_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_50_Start" ,getValue(M_FSG_40_0_0_50_Start), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_50_Start_1" ,getValue(M_FSG_40_0_0_50_Start_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_50_Start_1_0" ,getValue(M_FSG_40_0_0_50_Start_1_0), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_50_Start_1_1" ,getValue(M_FSG_40_0_0_50_Start_1_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_50_Start_1_2" ,getValue(M_FSG_40_0_0_50_Start_1_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_51Status_BTN" ,getValue(P_FSG_40_0_0_51Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_51_FctLstItemEn" ,getValue(P_FSG_40_0_0_51_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_51_FctEn" ,getValue(P_FSG_40_0_0_51_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_51_ErrEn" ,getValue(P_FSG_40_0_0_51_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_51_ErrCode" ,getValue(P_FSG_40_0_0_51_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_51_1" ,getValue(P_FSG_40_0_0_51_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_51_2" ,getValue(P_FSG_40_0_0_51_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_51_2_range" ,getValue(P_FSG_40_0_0_51_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52Changed_BTN" ,getValue(A_FSG_40_0_0_52Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52Status_BTN" ,getValue(A_FSG_40_0_0_52Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_FctLstItemEn" ,getValue(A_FSG_40_0_0_52_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_FctEn" ,getValue(A_FSG_40_0_0_52_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_ErrEn" ,getValue(A_FSG_40_0_0_52_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_IntTlgEn" ,getValue(A_FSG_40_0_0_52_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_SegmEn" ,getValue(A_FSG_40_0_0_52_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_AT" ,getValue(A_FSG_40_0_0_52_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_ErrCode" ,getValue(A_FSG_40_0_0_52_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_DataIndex" ,getValue(A_FSG_40_0_0_52_DataIndex), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_DataIndex_Incr" ,getValue(A_FSG_40_0_0_52_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_DataIndex_Decr" ,getValue(A_FSG_40_0_0_52_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_loadArray_Btn" ,getValue(A_FSG_40_0_0_52_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_generateData_Btn" ,getValue(A_FSG_40_0_0_52_generateData_Btn), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_52_3" ,getValue(A_FSG_40_0_0_52_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_52_3_range" ,getValue(A_FSG_40_0_0_52_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_1" ,getValue(A_FSG_40_0_0_52_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_6_len" ,getValue(A_FSG_40_0_0_52_Data_6_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_6_cnt" ,getValue(A_FSG_40_0_0_52_Data_6_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_9" ,getValue(A_FSG_40_0_0_52_Data_9), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_10" ,getValue(A_FSG_40_0_0_52_Data_10), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_10_0" ,getValue(A_FSG_40_0_0_52_Data_10_0), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_10_1" ,getValue(A_FSG_40_0_0_52_Data_10_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_10_2" ,getValue(A_FSG_40_0_0_52_Data_10_2), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_10_3" ,getValue(A_FSG_40_0_0_52_Data_10_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_10_4" ,getValue(A_FSG_40_0_0_52_Data_10_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_10_5" ,getValue(A_FSG_40_0_0_52_Data_10_5), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_52_Data_5" ,getValue(A_FSG_40_0_0_52_Data_5), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_52_Data_5_range" ,getValue(A_FSG_40_0_0_52_Data_5_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_4" ,getValue(A_FSG_40_0_0_52_Data_4), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_4_0" ,getValue(A_FSG_40_0_0_52_Data_4_0), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_4_1" ,getValue(A_FSG_40_0_0_52_Data_4_1), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_2_len" ,getValue(A_FSG_40_0_0_52_Data_2_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_2_cnt" ,getValue(A_FSG_40_0_0_52_Data_2_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_7" ,getValue(A_FSG_40_0_0_52_Data_7), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_7_0" ,getValue(A_FSG_40_0_0_52_Data_7_0), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_8" ,getValue(A_FSG_40_0_0_52_Data_8), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_52_Data_1" ,getValue(A_FSG_40_0_0_52_Data_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_52_Data_1_range" ,getValue(A_FSG_40_0_0_52_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_52_2" ,getValue(A_FSG_40_0_0_52_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_52_2_range" ,getValue(A_FSG_40_0_0_52_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Data_3" ,getValue(A_FSG_40_0_0_52_Data_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_RecAdr" ,getValue(A_FSG_40_0_0_52_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Direction" ,getValue(A_FSG_40_0_0_52_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Shift" ,getValue(A_FSG_40_0_0_52_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_TransPos" ,getValue(A_FSG_40_0_0_52_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_IndexSize" ,getValue(A_FSG_40_0_0_52_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Start" ,getValue(A_FSG_40_0_0_52_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Elements" ,getValue(A_FSG_40_0_0_52_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Changed_RecAdr" ,getValue(A_FSG_40_0_0_52_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Changed_Direction" ,getValue(A_FSG_40_0_0_52_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Changed_Shift" ,getValue(A_FSG_40_0_0_52_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Changed_TransPos" ,getValue(A_FSG_40_0_0_52_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Changed_IndexSize" ,getValue(A_FSG_40_0_0_52_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Changed_Start" ,getValue(A_FSG_40_0_0_52_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_Changed_Elements" ,getValue(A_FSG_40_0_0_52_Changed_Elements), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_52_2_SetGet" ,getValue(A_FSG_40_0_0_52_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_52_2_SetGet_range" ,getValue(A_FSG_40_0_0_52_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_1_SetGet" ,getValue(A_FSG_40_0_0_52_1_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_SetGet_RecAdr" ,getValue(A_FSG_40_0_0_52_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_SetGet_Direction" ,getValue(A_FSG_40_0_0_52_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_SetGet_Shift" ,getValue(A_FSG_40_0_0_52_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_SetGet_IndexSize" ,getValue(A_FSG_40_0_0_52_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_SetGet_Start" ,getValue(A_FSG_40_0_0_52_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_52_SetGet_Elements" ,getValue(A_FSG_40_0_0_52_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_53Result_BTN" ,getValue(M_FSG_40_0_0_53Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_53_FctLstItemEn" ,getValue(M_FSG_40_0_0_53_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_53_FctEn" ,getValue(M_FSG_40_0_0_53_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_53_ErrEn" ,getValue(M_FSG_40_0_0_53_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_53_ErrCode" ,getValue(M_FSG_40_0_0_53_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_53_Result_1" ,getValue(M_FSG_40_0_0_53_Result_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_53_Result_2" ,getValue(M_FSG_40_0_0_53_Result_2), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_53_Result_2_range" ,getValue(M_FSG_40_0_0_53_Result_2_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_53_Result_3" ,getValue(M_FSG_40_0_0_53_Result_3), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_53_Result_3_range" ,getValue(M_FSG_40_0_0_53_Result_3_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_53_Processing_1_len" ,getValue(M_FSG_40_0_0_53_Processing_1_len), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_53_Processing_1_cnt" ,getValue(M_FSG_40_0_0_53_Processing_1_cnt), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_53_Start_1" ,getValue(M_FSG_40_0_0_53_Start_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_53_Start_2_len" ,getValue(M_FSG_40_0_0_53_Start_2_len), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_53_Start_2_cnt" ,getValue(M_FSG_40_0_0_53_Start_2_cnt), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_54Result_BTN" ,getValue(M_FSG_40_0_0_54Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_54_FctLstItemEn" ,getValue(M_FSG_40_0_0_54_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_54_FctEn" ,getValue(M_FSG_40_0_0_54_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_54_ErrEn" ,getValue(M_FSG_40_0_0_54_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_54_IntTlgEn" ,getValue(M_FSG_40_0_0_54_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_54_SegmEn" ,getValue(M_FSG_40_0_0_54_SegmEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_54_ErrCode" ,getValue(M_FSG_40_0_0_54_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_54_Result_1" ,getValue(M_FSG_40_0_0_54_Result_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_54_Result_2" ,getValue(M_FSG_40_0_0_54_Result_2), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_54_Result_2_range" ,getValue(M_FSG_40_0_0_54_Result_2_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_54_Result_3" ,getValue(M_FSG_40_0_0_54_Result_3), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_54_Result_3_range" ,getValue(M_FSG_40_0_0_54_Result_3_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_54_Result_4" ,getValue(M_FSG_40_0_0_54_Result_4), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_54_Result_4_range" ,getValue(M_FSG_40_0_0_54_Result_4_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_54_Processing_1_range" ,getValue(M_FSG_40_0_0_54_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_54_Processing_1_range" ,getValue(M_FSG_40_0_0_54_Processing_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_54_Start_1" ,getValue(M_FSG_40_0_0_54_Start_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_54_Start_1_range" ,getValue(M_FSG_40_0_0_54_Start_1_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_54_Start_2" ,getValue(M_FSG_40_0_0_54_Start_2), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_54_Start_2_range" ,getValue(M_FSG_40_0_0_54_Start_2_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_54_Start_3" ,getValue(M_FSG_40_0_0_54_Start_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_55Status_BTN" ,getValue(P_FSG_40_0_0_55Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_55_FctLstItemEn" ,getValue(P_FSG_40_0_0_55_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_55_FctEn" ,getValue(P_FSG_40_0_0_55_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_55_ErrEn" ,getValue(P_FSG_40_0_0_55_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_55_ErrCode" ,getValue(P_FSG_40_0_0_55_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_55_1" ,getValue(P_FSG_40_0_0_55_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_55_3" ,getValue(P_FSG_40_0_0_55_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_55_3_range" ,getValue(P_FSG_40_0_0_55_3_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_55_2" ,getValue(P_FSG_40_0_0_55_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_56Status_BTN" ,getValue(P_FSG_40_0_0_56Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_56_FctLstItemEn" ,getValue(P_FSG_40_0_0_56_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_56_FctEn" ,getValue(P_FSG_40_0_0_56_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_56_ErrEn" ,getValue(P_FSG_40_0_0_56_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_56_ErrCode" ,getValue(P_FSG_40_0_0_56_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_56" ,getValue(P_FSG_40_0_0_56), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_56_1" ,getValue(P_FSG_40_0_0_56_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_56_1_0" ,getValue(P_FSG_40_0_0_56_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_57Status_BTN" ,getValue(P_FSG_40_0_0_57Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_57_FctLstItemEn" ,getValue(P_FSG_40_0_0_57_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_57_FctEn" ,getValue(P_FSG_40_0_0_57_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_57_ErrEn" ,getValue(P_FSG_40_0_0_57_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_57_ErrCode" ,getValue(P_FSG_40_0_0_57_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_57" ,getValue(P_FSG_40_0_0_57), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_57_1" ,getValue(P_FSG_40_0_0_57_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_57_1_0" ,getValue(P_FSG_40_0_0_57_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_58Status_BTN" ,getValue(P_FSG_40_0_0_58Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_58_FctLstItemEn" ,getValue(P_FSG_40_0_0_58_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_58_FctEn" ,getValue(P_FSG_40_0_0_58_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_58_ErrEn" ,getValue(P_FSG_40_0_0_58_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_58_IntTlgEn" ,getValue(P_FSG_40_0_0_58_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_58_SegmEn" ,getValue(P_FSG_40_0_0_58_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_58_ErrCode" ,getValue(P_FSG_40_0_0_58_ErrCode), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_58_1" ,getValue(P_FSG_40_0_0_58_1), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_58_1_range" ,getValue(P_FSG_40_0_0_58_1_range), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_58_3_len" ,getValue(P_FSG_40_0_0_58_3_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_58_3_cnt" ,getValue(P_FSG_40_0_0_58_3_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_58_2_len" ,getValue(P_FSG_40_0_0_58_2_len), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_58_2_cnt" ,getValue(P_FSG_40_0_0_58_2_cnt), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_58_4" ,getValue(P_FSG_40_0_0_58_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_59Status_BTN" ,getValue(P_FSG_40_0_0_59Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_59_FctLstItemEn" ,getValue(P_FSG_40_0_0_59_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_59_FctEn" ,getValue(P_FSG_40_0_0_59_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_59_ErrEn" ,getValue(P_FSG_40_0_0_59_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_59_ErrCode" ,getValue(P_FSG_40_0_0_59_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_59_1" ,getValue(P_FSG_40_0_0_59_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_59_1_0" ,getValue(P_FSG_40_0_0_59_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_59_1_1" ,getValue(P_FSG_40_0_0_59_1_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_59_1_2" ,getValue(P_FSG_40_0_0_59_1_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_59_1_3" ,getValue(P_FSG_40_0_0_59_1_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_59_3" ,getValue(P_FSG_40_0_0_59_3), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_59_3_range" ,getValue(P_FSG_40_0_0_59_3_range), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_59_2" ,getValue(P_FSG_40_0_0_59_2), profileFile);
    writeProfileFloat("BAP" ,"P_FSG_40_0_0_59_2_range" ,getValue(P_FSG_40_0_0_59_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60Changed_BTN" ,getValue(A_FSG_40_0_0_60Changed_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60Status_BTN" ,getValue(A_FSG_40_0_0_60Status_BTN), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_FctLstItemEn" ,getValue(A_FSG_40_0_0_60_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_FctEn" ,getValue(A_FSG_40_0_0_60_FctEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_ErrEn" ,getValue(A_FSG_40_0_0_60_ErrEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_IntTlgEn" ,getValue(A_FSG_40_0_0_60_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_SegmEn" ,getValue(A_FSG_40_0_0_60_SegmEn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_AT" ,getValue(A_FSG_40_0_0_60_AT), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_ErrCode" ,getValue(A_FSG_40_0_0_60_ErrCode), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_DataIndex_SetGet_Incr" ,getValue(A_FSG_40_0_0_60_DataIndex_SetGet_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_DataIndex_Incr" ,getValue(A_FSG_40_0_0_60_DataIndex_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_DataIndex_Decr" ,getValue(A_FSG_40_0_0_60_DataIndex_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_loadArray_Btn" ,getValue(A_FSG_40_0_0_60_loadArray_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_generateData_Btn" ,getValue(A_FSG_40_0_0_60_generateData_Btn), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Data_2_len" ,getValue(A_FSG_40_0_0_60_Data_2_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Data_2_cnt" ,getValue(A_FSG_40_0_0_60_Data_2_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Data_3" ,getValue(A_FSG_40_0_0_60_Data_3), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Data_4_len" ,getValue(A_FSG_40_0_0_60_Data_4_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Data_4_cnt" ,getValue(A_FSG_40_0_0_60_Data_4_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_60_2" ,getValue(A_FSG_40_0_0_60_2), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_60_2_range" ,getValue(A_FSG_40_0_0_60_2_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_1" ,getValue(A_FSG_40_0_0_60_1), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_60_Data_1_SetGet_range" ,getValue(A_FSG_40_0_0_60_Data_1_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_60_Data_1_range" ,getValue(A_FSG_40_0_0_60_Data_1_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_60_3" ,getValue(A_FSG_40_0_0_60_3), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_60_3_range" ,getValue(A_FSG_40_0_0_60_3_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_RecAdr" ,getValue(A_FSG_40_0_0_60_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Direction" ,getValue(A_FSG_40_0_0_60_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Shift" ,getValue(A_FSG_40_0_0_60_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_TransPos" ,getValue(A_FSG_40_0_0_60_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_IndexSize" ,getValue(A_FSG_40_0_0_60_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Start" ,getValue(A_FSG_40_0_0_60_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Elements" ,getValue(A_FSG_40_0_0_60_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Changed_RecAdr" ,getValue(A_FSG_40_0_0_60_Changed_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Changed_Direction" ,getValue(A_FSG_40_0_0_60_Changed_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Changed_Shift" ,getValue(A_FSG_40_0_0_60_Changed_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Changed_TransPos" ,getValue(A_FSG_40_0_0_60_Changed_TransPos), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Changed_IndexSize" ,getValue(A_FSG_40_0_0_60_Changed_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Changed_Start" ,getValue(A_FSG_40_0_0_60_Changed_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Changed_Elements" ,getValue(A_FSG_40_0_0_60_Changed_Elements), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_DataIndex_SetGet" ,getValue(A_FSG_40_0_0_60_DataIndex_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_DataIndex_SetGet_Incr" ,getValue(A_FSG_40_0_0_60_DataIndex_SetGet_Incr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_DataIndex_SetGet_Decr" ,getValue(A_FSG_40_0_0_60_DataIndex_SetGet_Decr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Data_2_SetGet_len" ,getValue(A_FSG_40_0_0_60_Data_2_SetGet_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Data_2_SetGet_cnt" ,getValue(A_FSG_40_0_0_60_Data_2_SetGet_cnt), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Data_3_SetGet" ,getValue(A_FSG_40_0_0_60_Data_3_SetGet), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Data_4_SetGet_len" ,getValue(A_FSG_40_0_0_60_Data_4_SetGet_len), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_Data_4_SetGet_cnt" ,getValue(A_FSG_40_0_0_60_Data_4_SetGet_cnt), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_60_2_SetGet" ,getValue(A_FSG_40_0_0_60_2_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_60_2_SetGet_range" ,getValue(A_FSG_40_0_0_60_2_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_1_SetGet" ,getValue(A_FSG_40_0_0_60_1_SetGet), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_60_Data_1_SetGet_range" ,getValue(A_FSG_40_0_0_60_Data_1_SetGet_range), profileFile);
    writeProfileFloat("BAP" ,"A_FSG_40_0_0_60_Data_1_SetGet_range" ,getValue(A_FSG_40_0_0_60_Data_1_SetGet_range), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_SetGet_RecAdr" ,getValue(A_FSG_40_0_0_60_SetGet_RecAdr), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_SetGet_Direction" ,getValue(A_FSG_40_0_0_60_SetGet_Direction), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_SetGet_Shift" ,getValue(A_FSG_40_0_0_60_SetGet_Shift), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_SetGet_IndexSize" ,getValue(A_FSG_40_0_0_60_SetGet_IndexSize), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_SetGet_Start" ,getValue(A_FSG_40_0_0_60_SetGet_Start), profileFile);
    writeProfileInt("BAP" ,"A_FSG_40_0_0_60_SetGet_Elements" ,getValue(A_FSG_40_0_0_60_SetGet_Elements), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61Status_BTN" ,getValue(P_FSG_40_0_0_61Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_FctLstItemEn" ,getValue(P_FSG_40_0_0_61_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_FctEn" ,getValue(P_FSG_40_0_0_61_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_ErrEn" ,getValue(P_FSG_40_0_0_61_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_IntTlgEn" ,getValue(P_FSG_40_0_0_61_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_SegmEn" ,getValue(P_FSG_40_0_0_61_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_ErrCode" ,getValue(P_FSG_40_0_0_61_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_7" ,getValue(P_FSG_40_0_0_61_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_7_0" ,getValue(P_FSG_40_0_0_61_7_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_6" ,getValue(P_FSG_40_0_0_61_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_6_0" ,getValue(P_FSG_40_0_0_61_6_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_5" ,getValue(P_FSG_40_0_0_61_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_5_0" ,getValue(P_FSG_40_0_0_61_5_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_8" ,getValue(P_FSG_40_0_0_61_8), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_4" ,getValue(P_FSG_40_0_0_61_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_4_0" ,getValue(P_FSG_40_0_0_61_4_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_3" ,getValue(P_FSG_40_0_0_61_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_3_0" ,getValue(P_FSG_40_0_0_61_3_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_2" ,getValue(P_FSG_40_0_0_61_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_2_0" ,getValue(P_FSG_40_0_0_61_2_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_1" ,getValue(P_FSG_40_0_0_61_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_1_0" ,getValue(P_FSG_40_0_0_61_1_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_9" ,getValue(P_FSG_40_0_0_61_9), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_9_0" ,getValue(P_FSG_40_0_0_61_9_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_9_1" ,getValue(P_FSG_40_0_0_61_9_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_9_2" ,getValue(P_FSG_40_0_0_61_9_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_9_3" ,getValue(P_FSG_40_0_0_61_9_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_9_4" ,getValue(P_FSG_40_0_0_61_9_4), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_9_5" ,getValue(P_FSG_40_0_0_61_9_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_9_6" ,getValue(P_FSG_40_0_0_61_9_6), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_9_7" ,getValue(P_FSG_40_0_0_61_9_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_61_9_8" ,getValue(P_FSG_40_0_0_61_9_8), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62Status_BTN" ,getValue(P_FSG_40_0_0_62Status_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_FctLstItemEn" ,getValue(P_FSG_40_0_0_62_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_FctEn" ,getValue(P_FSG_40_0_0_62_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_ErrEn" ,getValue(P_FSG_40_0_0_62_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_IntTlgEn" ,getValue(P_FSG_40_0_0_62_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_SegmEn" ,getValue(P_FSG_40_0_0_62_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_ErrCode" ,getValue(P_FSG_40_0_0_62_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_3" ,getValue(P_FSG_40_0_0_62_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_3_0" ,getValue(P_FSG_40_0_0_62_3_0), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_3_1" ,getValue(P_FSG_40_0_0_62_3_1), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_3_2" ,getValue(P_FSG_40_0_0_62_3_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_3_3" ,getValue(P_FSG_40_0_0_62_3_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_3_5" ,getValue(P_FSG_40_0_0_62_3_5), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_2" ,getValue(P_FSG_40_0_0_62_2), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_2_3" ,getValue(P_FSG_40_0_0_62_2_3), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_2_7" ,getValue(P_FSG_40_0_0_62_2_7), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_1_16" ,getValue(P_FSG_40_0_0_62_1_16), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_1_17" ,getValue(P_FSG_40_0_0_62_1_17), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_1_18" ,getValue(P_FSG_40_0_0_62_1_18), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_1_19" ,getValue(P_FSG_40_0_0_62_1_19), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_1_20" ,getValue(P_FSG_40_0_0_62_1_20), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_1_21" ,getValue(P_FSG_40_0_0_62_1_21), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_1_22" ,getValue(P_FSG_40_0_0_62_1_22), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_1_23" ,getValue(P_FSG_40_0_0_62_1_23), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_1_24" ,getValue(P_FSG_40_0_0_62_1_24), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_1_25" ,getValue(P_FSG_40_0_0_62_1_25), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_1_33" ,getValue(P_FSG_40_0_0_62_1_33), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_1_34" ,getValue(P_FSG_40_0_0_62_1_34), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_1_42" ,getValue(P_FSG_40_0_0_62_1_42), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_1_43" ,getValue(P_FSG_40_0_0_62_1_43), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_1_44" ,getValue(P_FSG_40_0_0_62_1_44), profileFile);
    writeProfileInt("BAP" ,"P_FSG_40_0_0_62_1_45" ,getValue(P_FSG_40_0_0_62_1_45), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_63Result_BTN" ,getValue(M_FSG_40_0_0_63Result_BTN), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_63_FctLstItemEn" ,getValue(M_FSG_40_0_0_63_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_63_FctEn" ,getValue(M_FSG_40_0_0_63_FctEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_63_ErrEn" ,getValue(M_FSG_40_0_0_63_ErrEn), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_63_ErrCode" ,getValue(M_FSG_40_0_0_63_ErrCode), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_63_Result_1" ,getValue(M_FSG_40_0_0_63_Result_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_63_Result_2" ,getValue(M_FSG_40_0_0_63_Result_2), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_63_Processing_1" ,getValue(M_FSG_40_0_0_63_Processing_1), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_63_Processing_2_range" ,getValue(M_FSG_40_0_0_63_Processing_2_range), profileFile);
    writeProfileFloat("BAP" ,"M_FSG_40_0_0_63_Processing_2_range" ,getValue(M_FSG_40_0_0_63_Processing_2_range), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_63_Start_1" ,getValue(M_FSG_40_0_0_63_Start_1), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_63_Start_2" ,getValue(M_FSG_40_0_0_63_Start_2), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_63_Start_3" ,getValue(M_FSG_40_0_0_63_Start_3), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_63_Start_4" ,getValue(M_FSG_40_0_0_63_Start_4), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_63_Start_5" ,getValue(M_FSG_40_0_0_63_Start_5), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_63_Start_6" ,getValue(M_FSG_40_0_0_63_Start_6), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_63_Start_7_len" ,getValue(M_FSG_40_0_0_63_Start_7_len), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_63_Start_7_cnt" ,getValue(M_FSG_40_0_0_63_Start_7_cnt), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_63_Start_8_len" ,getValue(M_FSG_40_0_0_63_Start_8_len), profileFile);
    writeProfileInt("BAP" ,"M_FSG_40_0_0_63_Start_8_cnt" ,getValue(M_FSG_40_0_0_63_Start_8_cnt), profileFile);
    writeProfileInt("BAP" ,"C_FSG_42_0_0_0_1_FctLstItemEn" ,getValue(C_FSG_42_0_0_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_42_0_0_0_1_FctEn" ,getValue(C_FSG_42_0_0_0_1_FctEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_42_0_0_0_1_ErrEn" ,getValue(C_FSG_42_0_0_0_1_ErrEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_42_0_0_0_1_IntTlgEn" ,getValue(C_FSG_42_0_0_0_1_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_42_0_0_0_1_SegmEn" ,getValue(C_FSG_42_0_0_0_1_SegmEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_42_0_0_0_1_ErrCode" ,getValue(C_FSG_42_0_0_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_0_2Reset_BTN" ,getValue(P_FSG_42_0_0_0_2Reset_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_0_2_FctLstItemEn" ,getValue(P_FSG_42_0_0_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_0_2_FctEn" ,getValue(P_FSG_42_0_0_0_2_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_0_2_ErrEn" ,getValue(P_FSG_42_0_0_0_2_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_0_2_ErrCode" ,getValue(P_FSG_42_0_0_0_2_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_0_3_FctLstItemEn" ,getValue(P_FSG_42_0_0_0_3_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_0_3_FctEn" ,getValue(P_FSG_42_0_0_0_3_FctEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_0_3_ErrEn" ,getValue(P_FSG_42_0_0_0_3_ErrEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_0_3_IntTlgEn" ,getValue(P_FSG_42_0_0_0_3_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_0_3_SegmEn" ,getValue(P_FSG_42_0_0_0_3_SegmEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_0_3_ErrCode" ,getValue(P_FSG_42_0_0_0_3_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_3_09" ,getValue(P_FSG_42_0_0_16_3_09), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_3_08" ,getValue(P_FSG_42_0_0_16_3_08), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_3_07" ,getValue(P_FSG_42_0_0_16_3_07), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_3_06" ,getValue(P_FSG_42_0_0_16_3_06), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_3_05" ,getValue(P_FSG_42_0_0_16_3_05), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_3_04" ,getValue(P_FSG_42_0_0_16_3_04), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_3_03" ,getValue(P_FSG_42_0_0_16_3_03), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_3_02" ,getValue(P_FSG_42_0_0_16_3_02), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_16_3_01" ,getValue(P_FSG_42_0_0_16_3_01), profileFile);
    writeProfileInt("BAP" ,"ERRORLIST_FSG42_0_VT" ,getValue(ERRORLIST_FSG42_0_VT), profileFile);
    writeProfileInt("BAP" ,"ON_OFF_FSG42_0" ,getValue(ON_OFF_FSG42_0), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_42_0_0_DFMajor" ,getValue(BAPCFG_FSG_42_0_0_DFMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_42_0_0_DFMinor" ,getValue(BAPCFG_FSG_42_0_0_DFMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_42_0_0_LsgClassMajor" ,getValue(BAPCFG_FSG_42_0_0_LsgClassMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_42_0_0_LsgClassMinor" ,getValue(BAPCFG_FSG_42_0_0_LsgClassMinor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_42_0_0_ProtocolMajor" ,getValue(BAPCFG_FSG_42_0_0_ProtocolMajor), profileFile);
    writeProfileInt("BAP" ,"BAPCFG_FSG_42_0_0_ProtocolMinor" ,getValue(BAPCFG_FSG_42_0_0_ProtocolMinor), profileFile);
    writeProfileInt("BAP" ,"C_FSG_42_0_0_1_FctLstItemEn" ,getValue(C_FSG_42_0_0_1_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_42_0_0_1_FctEn" ,getValue(C_FSG_42_0_0_1_FctEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_42_0_0_1_ErrEn" ,getValue(C_FSG_42_0_0_1_ErrEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_42_0_0_1_IntTlgEn" ,getValue(C_FSG_42_0_0_1_IntTlgEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_42_0_0_1_SegmEn" ,getValue(C_FSG_42_0_0_1_SegmEn), profileFile);
    writeProfileInt("BAP" ,"C_FSG_42_0_0_1_ErrCode" ,getValue(C_FSG_42_0_0_1_ErrCode), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_2Reset_BTN" ,getValue(P_FSG_42_0_0_2Reset_BTN), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_2_FctLstItemEn" ,getValue(P_FSG_42_0_0_2_FctLstItemEn), profileFile);
    writeProfileInt("BAP" ,"P_FSG_42_0_0_2_FctEn" ,getValue(P_FSG_42_0_0_2_FctEn), profileFile);
