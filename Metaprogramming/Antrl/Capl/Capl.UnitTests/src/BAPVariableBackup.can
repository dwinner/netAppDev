    putValue( A_FSG_40_0_0_60Status_BTN, getProfileInt( "BAP", "A_FSG_40_0_0_60Status_BTN", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_FctLstItemEn, getProfileInt( "BAP", "A_FSG_40_0_0_60_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_FctEn, getProfileInt( "BAP", "A_FSG_40_0_0_60_FctEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_ErrEn, getProfileInt( "BAP", "A_FSG_40_0_0_60_ErrEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_IntTlgEn, getProfileInt( "BAP", "A_FSG_40_0_0_60_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_SegmEn, getProfileInt( "BAP", "A_FSG_40_0_0_60_SegmEn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_AT, getProfileInt( "BAP", "A_FSG_40_0_0_60_AT", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_ErrCode, getProfileInt( "BAP", "A_FSG_40_0_0_60_ErrCode", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_DataIndex_SetGet_Incr, getProfileInt( "BAP", "A_FSG_40_0_0_60_DataIndex_SetGet_Incr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_40_0_0_60_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_40_0_0_60_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_loadArray_Btn, getProfileInt( "BAP", "A_FSG_40_0_0_60_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_generateData_Btn, getProfileInt( "BAP", "A_FSG_40_0_0_60_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Data_2_len, getProfileInt( "BAP", "A_FSG_40_0_0_60_Data_2_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Data_2_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_60_Data_2_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Data_3, getProfileInt( "BAP", "A_FSG_40_0_0_60_Data_3", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Data_4_len, getProfileInt( "BAP", "A_FSG_40_0_0_60_Data_4_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Data_4_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_60_Data_4_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_2, getProfileFloat( "BAP", "A_FSG_40_0_0_60_2", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_2_range, getProfileFloat( "BAP", "A_FSG_40_0_0_60_2_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_1, getProfileInt( "BAP", "A_FSG_40_0_0_60_1", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Data_1_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_60_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Data_1_range, getProfileFloat( "BAP", "A_FSG_40_0_0_60_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_3, getProfileFloat( "BAP", "A_FSG_40_0_0_60_3", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_3_range, getProfileFloat( "BAP", "A_FSG_40_0_0_60_3_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_RecAdr, getProfileInt( "BAP", "A_FSG_40_0_0_60_RecAdr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Direction, getProfileInt( "BAP", "A_FSG_40_0_0_60_Direction", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Shift, getProfileInt( "BAP", "A_FSG_40_0_0_60_Shift", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_TransPos, getProfileInt( "BAP", "A_FSG_40_0_0_60_TransPos", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_IndexSize, getProfileInt( "BAP", "A_FSG_40_0_0_60_IndexSize", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Start, getProfileInt( "BAP", "A_FSG_40_0_0_60_Start", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Elements, getProfileInt( "BAP", "A_FSG_40_0_0_60_Elements", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_40_0_0_60_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Changed_Direction, getProfileInt( "BAP", "A_FSG_40_0_0_60_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Changed_Shift, getProfileInt( "BAP", "A_FSG_40_0_0_60_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Changed_TransPos, getProfileInt( "BAP", "A_FSG_40_0_0_60_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_40_0_0_60_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Changed_Start, getProfileInt( "BAP", "A_FSG_40_0_0_60_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Changed_Elements, getProfileInt( "BAP", "A_FSG_40_0_0_60_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_DataIndex_SetGet, getProfileInt( "BAP", "A_FSG_40_0_0_60_DataIndex_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_DataIndex_SetGet_Incr, getProfileInt( "BAP", "A_FSG_40_0_0_60_DataIndex_SetGet_Incr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_DataIndex_SetGet_Decr, getProfileInt( "BAP", "A_FSG_40_0_0_60_DataIndex_SetGet_Decr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Data_2_SetGet_len, getProfileInt( "BAP", "A_FSG_40_0_0_60_Data_2_SetGet_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Data_2_SetGet_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_60_Data_2_SetGet_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Data_3_SetGet, getProfileInt( "BAP", "A_FSG_40_0_0_60_Data_3_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Data_4_SetGet_len, getProfileInt( "BAP", "A_FSG_40_0_0_60_Data_4_SetGet_len", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Data_4_SetGet_cnt, getProfileInt( "BAP", "A_FSG_40_0_0_60_Data_4_SetGet_cnt", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_2_SetGet, getProfileFloat( "BAP", "A_FSG_40_0_0_60_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_60_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_1_SetGet, getProfileInt( "BAP", "A_FSG_40_0_0_60_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Data_1_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_60_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_Data_1_SetGet_range, getProfileFloat( "BAP", "A_FSG_40_0_0_60_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_40_0_0_60_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_SetGet_Direction, getProfileInt( "BAP", "A_FSG_40_0_0_60_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_SetGet_Shift, getProfileInt( "BAP", "A_FSG_40_0_0_60_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_40_0_0_60_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_SetGet_Start, getProfileInt( "BAP", "A_FSG_40_0_0_60_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_40_0_0_60_SetGet_Elements, getProfileInt( "BAP", "A_FSG_40_0_0_60_SetGet_Elements", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_61Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_61_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_61_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_61_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_IntTlgEn, getProfileInt( "BAP", "P_FSG_40_0_0_61_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_SegmEn, getProfileInt( "BAP", "P_FSG_40_0_0_61_SegmEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_61_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_7, getProfileInt( "BAP", "P_FSG_40_0_0_61_7", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_7_0, getProfileInt( "BAP", "P_FSG_40_0_0_61_7_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_6, getProfileInt( "BAP", "P_FSG_40_0_0_61_6", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_6_0, getProfileInt( "BAP", "P_FSG_40_0_0_61_6_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_5, getProfileInt( "BAP", "P_FSG_40_0_0_61_5", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_5_0, getProfileInt( "BAP", "P_FSG_40_0_0_61_5_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_8, getProfileInt( "BAP", "P_FSG_40_0_0_61_8", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_4, getProfileInt( "BAP", "P_FSG_40_0_0_61_4", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_4_0, getProfileInt( "BAP", "P_FSG_40_0_0_61_4_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_3, getProfileInt( "BAP", "P_FSG_40_0_0_61_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_3_0, getProfileInt( "BAP", "P_FSG_40_0_0_61_3_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_2, getProfileInt( "BAP", "P_FSG_40_0_0_61_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_2_0, getProfileInt( "BAP", "P_FSG_40_0_0_61_2_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_1, getProfileInt( "BAP", "P_FSG_40_0_0_61_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_1_0, getProfileInt( "BAP", "P_FSG_40_0_0_61_1_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_9, getProfileInt( "BAP", "P_FSG_40_0_0_61_9", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_9_0, getProfileInt( "BAP", "P_FSG_40_0_0_61_9_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_9_1, getProfileInt( "BAP", "P_FSG_40_0_0_61_9_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_9_2, getProfileInt( "BAP", "P_FSG_40_0_0_61_9_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_9_3, getProfileInt( "BAP", "P_FSG_40_0_0_61_9_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_9_4, getProfileInt( "BAP", "P_FSG_40_0_0_61_9_4", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_9_5, getProfileInt( "BAP", "P_FSG_40_0_0_61_9_5", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_9_6, getProfileInt( "BAP", "P_FSG_40_0_0_61_9_6", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_9_7, getProfileInt( "BAP", "P_FSG_40_0_0_61_9_7", 0, profileFile ) );
    putValue( P_FSG_40_0_0_61_9_8, getProfileInt( "BAP", "P_FSG_40_0_0_61_9_8", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62Status_BTN, getProfileInt( "BAP", "P_FSG_40_0_0_62Status_BTN", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_FctLstItemEn, getProfileInt( "BAP", "P_FSG_40_0_0_62_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_FctEn, getProfileInt( "BAP", "P_FSG_40_0_0_62_FctEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_ErrEn, getProfileInt( "BAP", "P_FSG_40_0_0_62_ErrEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_IntTlgEn, getProfileInt( "BAP", "P_FSG_40_0_0_62_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_SegmEn, getProfileInt( "BAP", "P_FSG_40_0_0_62_SegmEn", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_ErrCode, getProfileInt( "BAP", "P_FSG_40_0_0_62_ErrCode", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_3, getProfileInt( "BAP", "P_FSG_40_0_0_62_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_3_0, getProfileInt( "BAP", "P_FSG_40_0_0_62_3_0", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_3_1, getProfileInt( "BAP", "P_FSG_40_0_0_62_3_1", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_3_2, getProfileInt( "BAP", "P_FSG_40_0_0_62_3_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_3_3, getProfileInt( "BAP", "P_FSG_40_0_0_62_3_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_3_5, getProfileInt( "BAP", "P_FSG_40_0_0_62_3_5", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_2, getProfileInt( "BAP", "P_FSG_40_0_0_62_2", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_2_3, getProfileInt( "BAP", "P_FSG_40_0_0_62_2_3", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_2_7, getProfileInt( "BAP", "P_FSG_40_0_0_62_2_7", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_1_16, getProfileInt( "BAP", "P_FSG_40_0_0_62_1_16", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_1_17, getProfileInt( "BAP", "P_FSG_40_0_0_62_1_17", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_1_18, getProfileInt( "BAP", "P_FSG_40_0_0_62_1_18", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_1_19, getProfileInt( "BAP", "P_FSG_40_0_0_62_1_19", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_1_20, getProfileInt( "BAP", "P_FSG_40_0_0_62_1_20", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_1_21, getProfileInt( "BAP", "P_FSG_40_0_0_62_1_21", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_1_22, getProfileInt( "BAP", "P_FSG_40_0_0_62_1_22", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_1_23, getProfileInt( "BAP", "P_FSG_40_0_0_62_1_23", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_1_24, getProfileInt( "BAP", "P_FSG_40_0_0_62_1_24", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_1_25, getProfileInt( "BAP", "P_FSG_40_0_0_62_1_25", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_1_33, getProfileInt( "BAP", "P_FSG_40_0_0_62_1_33", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_1_34, getProfileInt( "BAP", "P_FSG_40_0_0_62_1_34", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_1_42, getProfileInt( "BAP", "P_FSG_40_0_0_62_1_42", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_1_43, getProfileInt( "BAP", "P_FSG_40_0_0_62_1_43", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_1_44, getProfileInt( "BAP", "P_FSG_40_0_0_62_1_44", 0, profileFile ) );
    putValue( P_FSG_40_0_0_62_1_45, getProfileInt( "BAP", "P_FSG_40_0_0_62_1_45", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63Result_BTN, getProfileInt( "BAP", "M_FSG_40_0_0_63Result_BTN", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_FctLstItemEn, getProfileInt( "BAP", "M_FSG_40_0_0_63_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_FctEn, getProfileInt( "BAP", "M_FSG_40_0_0_63_FctEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_ErrEn, getProfileInt( "BAP", "M_FSG_40_0_0_63_ErrEn", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_ErrCode, getProfileInt( "BAP", "M_FSG_40_0_0_63_ErrCode", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_Result_1, getProfileInt( "BAP", "M_FSG_40_0_0_63_Result_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_Result_2, getProfileInt( "BAP", "M_FSG_40_0_0_63_Result_2", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_Processing_1, getProfileInt( "BAP", "M_FSG_40_0_0_63_Processing_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_Processing_2_range, getProfileFloat( "BAP", "M_FSG_40_0_0_63_Processing_2_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_Processing_2_range, getProfileFloat( "BAP", "M_FSG_40_0_0_63_Processing_2_range", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_Start_1, getProfileInt( "BAP", "M_FSG_40_0_0_63_Start_1", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_Start_2, getProfileInt( "BAP", "M_FSG_40_0_0_63_Start_2", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_Start_3, getProfileInt( "BAP", "M_FSG_40_0_0_63_Start_3", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_Start_4, getProfileInt( "BAP", "M_FSG_40_0_0_63_Start_4", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_Start_5, getProfileInt( "BAP", "M_FSG_40_0_0_63_Start_5", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_Start_6, getProfileInt( "BAP", "M_FSG_40_0_0_63_Start_6", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_Start_7_len, getProfileInt( "BAP", "M_FSG_40_0_0_63_Start_7_len", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_Start_7_cnt, getProfileInt( "BAP", "M_FSG_40_0_0_63_Start_7_cnt", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_Start_8_len, getProfileInt( "BAP", "M_FSG_40_0_0_63_Start_8_len", 0, profileFile ) );
    putValue( M_FSG_40_0_0_63_Start_8_cnt, getProfileInt( "BAP", "M_FSG_40_0_0_63_Start_8_cnt", 0, profileFile ) );
    putValue( C_FSG_42_0_0_0_1_FctLstItemEn, getProfileInt( "BAP", "C_FSG_42_0_0_0_1_FctLstItemEn", 0, profileFile ) );
    putValue( C_FSG_42_0_0_0_1_FctEn, getProfileInt( "BAP", "C_FSG_42_0_0_0_1_FctEn", 0, profileFile ) );
    putValue( C_FSG_42_0_0_0_1_ErrEn, getProfileInt( "BAP", "C_FSG_42_0_0_0_1_ErrEn", 0, profileFile ) );
    putValue( C_FSG_42_0_0_0_1_IntTlgEn, getProfileInt( "BAP", "C_FSG_42_0_0_0_1_IntTlgEn", 0, profileFile ) );
    putValue( C_FSG_42_0_0_0_1_SegmEn, getProfileInt( "BAP", "C_FSG_42_0_0_0_1_SegmEn", 0, profileFile ) );
    putValue( C_FSG_42_0_0_0_1_ErrCode, getProfileInt( "BAP", "C_FSG_42_0_0_0_1_ErrCode", 0, profileFile ) );
    putValue( P_FSG_42_0_0_0_2Reset_BTN, getProfileInt( "BAP", "P_FSG_42_0_0_0_2Reset_BTN", 0, profileFile ) );
    putValue( P_FSG_42_0_0_0_2_FctLstItemEn, getProfileInt( "BAP", "P_FSG_42_0_0_0_2_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_0_2_FctEn, getProfileInt( "BAP", "P_FSG_42_0_0_0_2_FctEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_0_2_ErrEn, getProfileInt( "BAP", "P_FSG_42_0_0_0_2_ErrEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_0_2_ErrCode, getProfileInt( "BAP", "P_FSG_42_0_0_0_2_ErrCode", 0, profileFile ) );
    putValue( P_FSG_42_0_0_0_3_FctLstItemEn, getProfileInt( "BAP", "P_FSG_42_0_0_0_3_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_0_3_FctEn, getProfileInt( "BAP", "P_FSG_42_0_0_0_3_FctEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_0_3_ErrEn, getProfileInt( "BAP", "P_FSG_42_0_0_0_3_ErrEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_0_3_IntTlgEn, getProfileInt( "BAP", "P_FSG_42_0_0_0_3_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_0_3_SegmEn, getProfileInt( "BAP", "P_FSG_42_0_0_0_3_SegmEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_0_3_ErrCode, getProfileInt( "BAP", "P_FSG_42_0_0_0_3_ErrCode", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_3_09, getProfileInt( "BAP", "P_FSG_42_0_0_16_3_09", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_3_08, getProfileInt( "BAP", "P_FSG_42_0_0_16_3_08", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_3_07, getProfileInt( "BAP", "P_FSG_42_0_0_16_3_07", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_3_06, getProfileInt( "BAP", "P_FSG_42_0_0_16_3_06", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_3_05, getProfileInt( "BAP", "P_FSG_42_0_0_16_3_05", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_3_04, getProfileInt( "BAP", "P_FSG_42_0_0_16_3_04", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_3_03, getProfileInt( "BAP", "P_FSG_42_0_0_16_3_03", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_3_02, getProfileInt( "BAP", "P_FSG_42_0_0_16_3_02", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_3_01, getProfileInt( "BAP", "P_FSG_42_0_0_16_3_01", 0, profileFile ) );
    putValue( ERRORLIST_FSG42_0_VT, getProfileInt( "BAP", "ERRORLIST_FSG42_0_VT", 0, profileFile ) );
    putValue( ON_OFF_FSG42_0, getProfileInt( "BAP", "ON_OFF_FSG42_0", 0, profileFile ) );
    putValue( BAPCFG_FSG_42_0_0_DFMajor, getProfileInt( "BAP", "BAPCFG_FSG_42_0_0_DFMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_42_0_0_DFMinor, getProfileInt( "BAP", "BAPCFG_FSG_42_0_0_DFMinor", 0, profileFile ) );
    putValue( BAPCFG_FSG_42_0_0_LsgClassMajor, getProfileInt( "BAP", "BAPCFG_FSG_42_0_0_LsgClassMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_42_0_0_LsgClassMinor, getProfileInt( "BAP", "BAPCFG_FSG_42_0_0_LsgClassMinor", 0, profileFile ) );
    putValue( BAPCFG_FSG_42_0_0_ProtocolMajor, getProfileInt( "BAP", "BAPCFG_FSG_42_0_0_ProtocolMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_42_0_0_ProtocolMinor, getProfileInt( "BAP", "BAPCFG_FSG_42_0_0_ProtocolMinor", 0, profileFile ) );
    putValue( C_FSG_42_0_0_1_FctLstItemEn, getProfileInt( "BAP", "C_FSG_42_0_0_1_FctLstItemEn", 0, profileFile ) );
    putValue( C_FSG_42_0_0_1_FctEn, getProfileInt( "BAP", "C_FSG_42_0_0_1_FctEn", 0, profileFile ) );
    putValue( C_FSG_42_0_0_1_ErrEn, getProfileInt( "BAP", "C_FSG_42_0_0_1_ErrEn", 0, profileFile ) );
    putValue( C_FSG_42_0_0_1_IntTlgEn, getProfileInt( "BAP", "C_FSG_42_0_0_1_IntTlgEn", 0, profileFile ) );
    putValue( C_FSG_42_0_0_1_SegmEn, getProfileInt( "BAP", "C_FSG_42_0_0_1_SegmEn", 0, profileFile ) );
    putValue( C_FSG_42_0_0_1_ErrCode, getProfileInt( "BAP", "C_FSG_42_0_0_1_ErrCode", 0, profileFile ) );
    putValue( P_FSG_42_0_0_2Reset_BTN, getProfileInt( "BAP", "P_FSG_42_0_0_2Reset_BTN", 0, profileFile ) );
    putValue( P_FSG_42_0_0_2_FctLstItemEn, getProfileInt( "BAP", "P_FSG_42_0_0_2_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_2_FctEn, getProfileInt( "BAP", "P_FSG_42_0_0_2_FctEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_2_ErrEn, getProfileInt( "BAP", "P_FSG_42_0_0_2_ErrEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_2_ErrCode, getProfileInt( "BAP", "P_FSG_42_0_0_2_ErrCode", 0, profileFile ) );
    putValue( P_FSG_42_0_0_2, getProfileFloat( "BAP", "P_FSG_42_0_0_2", 0, profileFile ) );
    putValue( P_FSG_42_0_0_2_range, getProfileFloat( "BAP", "P_FSG_42_0_0_2_range", 0, profileFile ) );
    putValue( P_FSG_42_0_0_3Status_BTN, getProfileInt( "BAP", "P_FSG_42_0_0_3Status_BTN", 0, profileFile ) );
    putValue( P_FSG_42_0_0_3_FctLstItemEn, getProfileInt( "BAP", "P_FSG_42_0_0_3_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_3_FctEn, getProfileInt( "BAP", "P_FSG_42_0_0_3_FctEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_3_ErrEn, getProfileInt( "BAP", "P_FSG_42_0_0_3_ErrEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_3_IntTlgEn, getProfileInt( "BAP", "P_FSG_42_0_0_3_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_3_SegmEn, getProfileInt( "BAP", "P_FSG_42_0_0_3_SegmEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_3_ErrCode, getProfileInt( "BAP", "P_FSG_42_0_0_3_ErrCode", 0, profileFile ) );
    putValue( P_FSG_42_0_0_4Status_BTN, getProfileInt( "BAP", "P_FSG_42_0_0_4Status_BTN", 0, profileFile ) );
    putValue( P_FSG_42_0_0_4_FctLstItemEn, getProfileInt( "BAP", "P_FSG_42_0_0_4_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_4_FctEn, getProfileInt( "BAP", "P_FSG_42_0_0_4_FctEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_4_ErrEn, getProfileInt( "BAP", "P_FSG_42_0_0_4_ErrEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_4_ErrCode, getProfileInt( "BAP", "P_FSG_42_0_0_4_ErrCode", 0, profileFile ) );
    putValue( P_FSG_42_0_0_4, getProfileInt( "BAP", "P_FSG_42_0_0_4", 0, profileFile ) );
    putValue( P_FSG_42_0_0_13Status_BTN, getProfileInt( "BAP", "P_FSG_42_0_0_13Status_BTN", 0, profileFile ) );
    putValue( P_FSG_42_0_0_13_FctLstItemEn, getProfileInt( "BAP", "P_FSG_42_0_0_13_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_13_FctEn, getProfileInt( "BAP", "P_FSG_42_0_0_13_FctEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_13_ErrEn, getProfileInt( "BAP", "P_FSG_42_0_0_13_ErrEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_13_ErrCode, getProfileInt( "BAP", "P_FSG_42_0_0_13_ErrCode", 0, profileFile ) );
    putValue( P_FSG_42_0_0_13_2, getProfileFloat( "BAP", "P_FSG_42_0_0_13_2", 0, profileFile ) );
    putValue( P_FSG_42_0_0_13_2_range, getProfileFloat( "BAP", "P_FSG_42_0_0_13_2_range", 0, profileFile ) );
    putValue( P_FSG_42_0_0_13_1, getProfileFloat( "BAP", "P_FSG_42_0_0_13_1", 0, profileFile ) );
    putValue( P_FSG_42_0_0_13_1_range, getProfileFloat( "BAP", "P_FSG_42_0_0_13_1_range", 0, profileFile ) );
    putValue( P_FSG_42_0_0_14Status_BTN, getProfileInt( "BAP", "P_FSG_42_0_0_14Status_BTN", 0, profileFile ) );
    putValue( P_FSG_42_0_0_14_FctLstItemEn, getProfileInt( "BAP", "P_FSG_42_0_0_14_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_14_FctEn, getProfileInt( "BAP", "P_FSG_42_0_0_14_FctEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_14_ErrEn, getProfileInt( "BAP", "P_FSG_42_0_0_14_ErrEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_14_ErrCode, getProfileInt( "BAP", "P_FSG_42_0_0_14_ErrCode", 0, profileFile ) );
    putValue( P_FSG_42_0_0_14_2, getProfileFloat( "BAP", "P_FSG_42_0_0_14_2", 0, profileFile ) );
    putValue( P_FSG_42_0_0_14_2_range, getProfileFloat( "BAP", "P_FSG_42_0_0_14_2_range", 0, profileFile ) );
    putValue( P_FSG_42_0_0_14_1, getProfileFloat( "BAP", "P_FSG_42_0_0_14_1", 0, profileFile ) );
    putValue( P_FSG_42_0_0_14_1_range, getProfileFloat( "BAP", "P_FSG_42_0_0_14_1_range", 0, profileFile ) );
    putValue( P_FSG_42_0_0_15Status_BTN, getProfileInt( "BAP", "P_FSG_42_0_0_15Status_BTN", 0, profileFile ) );
    putValue( P_FSG_42_0_0_15_FctLstItemEn, getProfileInt( "BAP", "P_FSG_42_0_0_15_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_15_FctEn, getProfileInt( "BAP", "P_FSG_42_0_0_15_FctEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_15_ErrEn, getProfileInt( "BAP", "P_FSG_42_0_0_15_ErrEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_15_ErrCode, getProfileInt( "BAP", "P_FSG_42_0_0_15_ErrCode", 0, profileFile ) );
    putValue( P_FSG_42_0_0_15_2, getProfileFloat( "BAP", "P_FSG_42_0_0_15_2", 0, profileFile ) );
    putValue( P_FSG_42_0_0_15_2_range, getProfileFloat( "BAP", "P_FSG_42_0_0_15_2_range", 0, profileFile ) );
    putValue( P_FSG_42_0_0_15_1, getProfileInt( "BAP", "P_FSG_42_0_0_15_1", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16Status_BTN, getProfileInt( "BAP", "P_FSG_42_0_0_16Status_BTN", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_FctLstItemEn, getProfileInt( "BAP", "P_FSG_42_0_0_16_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_FctEn, getProfileInt( "BAP", "P_FSG_42_0_0_16_FctEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_ErrEn, getProfileInt( "BAP", "P_FSG_42_0_0_16_ErrEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_IntTlgEn, getProfileInt( "BAP", "P_FSG_42_0_0_16_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_SegmEn, getProfileInt( "BAP", "P_FSG_42_0_0_16_SegmEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_ErrCode, getProfileInt( "BAP", "P_FSG_42_0_0_16_ErrCode", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_2, getProfileFloat( "BAP", "P_FSG_42_0_0_16_2", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_2_range, getProfileFloat( "BAP", "P_FSG_42_0_0_16_2_range", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_1, getProfileInt( "BAP", "P_FSG_42_0_0_16_1", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_4, getProfileInt( "BAP", "P_FSG_42_0_0_16_4", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_4_0, getProfileInt( "BAP", "P_FSG_42_0_0_16_4_0", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_4_1, getProfileInt( "BAP", "P_FSG_42_0_0_16_4_1", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_5, getProfileInt( "BAP", "P_FSG_42_0_0_16_5", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_3_len, getProfileInt( "BAP", "P_FSG_42_0_0_16_3_len", 0, profileFile ) );
    putValue( P_FSG_42_0_0_16_3_cnt, getProfileInt( "BAP", "P_FSG_42_0_0_16_3_cnt", 0, profileFile ) );
    putValue( P_FSG_42_0_0_17Status_BTN, getProfileInt( "BAP", "P_FSG_42_0_0_17Status_BTN", 0, profileFile ) );
    putValue( P_FSG_42_0_0_17_FctLstItemEn, getProfileInt( "BAP", "P_FSG_42_0_0_17_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_17_FctEn, getProfileInt( "BAP", "P_FSG_42_0_0_17_FctEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_17_ErrEn, getProfileInt( "BAP", "P_FSG_42_0_0_17_ErrEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_17_ErrCode, getProfileInt( "BAP", "P_FSG_42_0_0_17_ErrCode", 0, profileFile ) );
    putValue( P_FSG_42_0_0_17_2, getProfileInt( "BAP", "P_FSG_42_0_0_17_2", 0, profileFile ) );
    putValue( P_FSG_42_0_0_17_3, getProfileInt( "BAP", "P_FSG_42_0_0_17_3", 0, profileFile ) );
    putValue( P_FSG_42_0_0_17_3_0, getProfileInt( "BAP", "P_FSG_42_0_0_17_3_0", 0, profileFile ) );
    putValue( P_FSG_42_0_0_17_1, getProfileFloat( "BAP", "P_FSG_42_0_0_17_1", 0, profileFile ) );
    putValue( P_FSG_42_0_0_17_1_range, getProfileFloat( "BAP", "P_FSG_42_0_0_17_1_range", 0, profileFile ) );
    putValue( P_FSG_42_0_0_18Status_BTN, getProfileInt( "BAP", "P_FSG_42_0_0_18Status_BTN", 0, profileFile ) );
    putValue( P_FSG_42_0_0_18_FctLstItemEn, getProfileInt( "BAP", "P_FSG_42_0_0_18_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_18_FctEn, getProfileInt( "BAP", "P_FSG_42_0_0_18_FctEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_18_ErrEn, getProfileInt( "BAP", "P_FSG_42_0_0_18_ErrEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_18_ErrCode, getProfileInt( "BAP", "P_FSG_42_0_0_18_ErrCode", 0, profileFile ) );
    putValue( P_FSG_42_0_0_18_4, getProfileFloat( "BAP", "P_FSG_42_0_0_18_4", 0, profileFile ) );
    putValue( P_FSG_42_0_0_18_4_range, getProfileFloat( "BAP", "P_FSG_42_0_0_18_4_range", 0, profileFile ) );
    putValue( P_FSG_42_0_0_18_3, getProfileFloat( "BAP", "P_FSG_42_0_0_18_3", 0, profileFile ) );
    putValue( P_FSG_42_0_0_18_3_range, getProfileFloat( "BAP", "P_FSG_42_0_0_18_3_range", 0, profileFile ) );
    putValue( P_FSG_42_0_0_18_2, getProfileInt( "BAP", "P_FSG_42_0_0_18_2", 0, profileFile ) );
    putValue( P_FSG_42_0_0_18_2_0, getProfileInt( "BAP", "P_FSG_42_0_0_18_2_0", 0, profileFile ) );
    putValue( P_FSG_42_0_0_18_1, getProfileFloat( "BAP", "P_FSG_42_0_0_18_1", 0, profileFile ) );
    putValue( P_FSG_42_0_0_18_1_range, getProfileFloat( "BAP", "P_FSG_42_0_0_18_1_range", 0, profileFile ) );
    putValue( P_FSG_42_0_0_18_5, getProfileFloat( "BAP", "P_FSG_42_0_0_18_5", 0, profileFile ) );
    putValue( P_FSG_42_0_0_18_5_range, getProfileFloat( "BAP", "P_FSG_42_0_0_18_5_range", 0, profileFile ) );
    putValue( P_FSG_42_0_0_19Status_BTN, getProfileInt( "BAP", "P_FSG_42_0_0_19Status_BTN", 0, profileFile ) );
    putValue( P_FSG_42_0_0_19_FctLstItemEn, getProfileInt( "BAP", "P_FSG_42_0_0_19_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_19_FctEn, getProfileInt( "BAP", "P_FSG_42_0_0_19_FctEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_19_ErrEn, getProfileInt( "BAP", "P_FSG_42_0_0_19_ErrEn", 0, profileFile ) );
    putValue( P_FSG_42_0_0_19_ErrCode, getProfileInt( "BAP", "P_FSG_42_0_0_19_ErrCode", 0, profileFile ) );
    putValue( P_FSG_42_0_0_19_3, getProfileInt( "BAP", "P_FSG_42_0_0_19_3", 0, profileFile ) );
    putValue( P_FSG_42_0_0_19_2, getProfileInt( "BAP", "P_FSG_42_0_0_19_2", 0, profileFile ) );
    putValue( P_FSG_42_0_0_19_6, getProfileInt( "BAP", "P_FSG_42_0_0_19_6", 0, profileFile ) );
    putValue( P_FSG_42_0_0_19_1, getProfileInt( "BAP", "P_FSG_42_0_0_19_1", 0, profileFile ) );
    putValue( P_FSG_42_0_0_19_1_0, getProfileInt( "BAP", "P_FSG_42_0_0_19_1_0", 0, profileFile ) );
    putValue( P_FSG_42_0_0_19_1_1, getProfileInt( "BAP", "P_FSG_42_0_0_19_1_1", 0, profileFile ) );
    putValue( P_FSG_42_0_0_19_1_2, getProfileInt( "BAP", "P_FSG_42_0_0_19_1_2", 0, profileFile ) );
    putValue( P_FSG_42_0_0_19_5, getProfileInt( "BAP", "P_FSG_42_0_0_19_5", 0, profileFile ) );
    putValue( P_FSG_42_0_0_19_4, getProfileInt( "BAP", "P_FSG_42_0_0_19_4", 0, profileFile ) );
    putValue( C_FSG_49_0_0_0_1_FctLstItemEn, getProfileInt( "BAP", "C_FSG_49_0_0_0_1_FctLstItemEn", 0, profileFile ) );
    putValue( C_FSG_49_0_0_0_1_FctEn, getProfileInt( "BAP", "C_FSG_49_0_0_0_1_FctEn", 0, profileFile ) );
    putValue( C_FSG_49_0_0_0_1_ErrEn, getProfileInt( "BAP", "C_FSG_49_0_0_0_1_ErrEn", 0, profileFile ) );
    putValue( C_FSG_49_0_0_0_1_IntTlgEn, getProfileInt( "BAP", "C_FSG_49_0_0_0_1_IntTlgEn", 0, profileFile ) );
    putValue( C_FSG_49_0_0_0_1_SegmEn, getProfileInt( "BAP", "C_FSG_49_0_0_0_1_SegmEn", 0, profileFile ) );
    putValue( C_FSG_49_0_0_0_1_ErrCode, getProfileInt( "BAP", "C_FSG_49_0_0_0_1_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_0_2Reset_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_0_2Reset_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_0_2_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_0_2_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_0_2_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_0_2_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_0_2_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_0_2_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_0_2_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_0_2_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_0_3_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_0_3_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_0_3_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_0_3_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_0_3_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_0_3_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_0_3_IntTlgEn, getProfileInt( "BAP", "P_FSG_49_0_0_0_3_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_0_3_SegmEn, getProfileInt( "BAP", "P_FSG_49_0_0_0_3_SegmEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_0_3_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_0_3_ErrCode", 0, profileFile ) );
    putValue( FSG49_WriteTabActivation, getProfileInt( "BAP", "FSG49_WriteTabActivation", 0, profileFile ) );
    putValue( M_FSG_49_0_0_34_3min_TO, getProfileInt( "BAP", "M_FSG_49_0_0_34_3min_TO", 0, profileFile ) );
    putValue( M_FSG_49_0_0_45_3min_TO, getProfileInt( "BAP", "M_FSG_49_0_0_45_3min_TO", 0, profileFile ) );
    putValue( ERRORLIST_FSG49_0_VT, getProfileInt( "BAP", "ERRORLIST_FSG49_0_VT", 0, profileFile ) );
    putValue( BusType_FSG49_0, getProfileInt( "BAP", "BusType_FSG49_0", 0, profileFile ) );
    putValue( ON_OFF_FSG49_0, getProfileInt( "BAP", "ON_OFF_FSG49_0", 0, profileFile ) );
    putValue( BAPCFG_FSG_49_0_0_DFMajor, getProfileInt( "BAP", "BAPCFG_FSG_49_0_0_DFMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_49_0_0_DFMinor, getProfileInt( "BAP", "BAPCFG_FSG_49_0_0_DFMinor", 0, profileFile ) );
    putValue( BAPCFG_FSG_49_0_0_LsgClassMajor, getProfileInt( "BAP", "BAPCFG_FSG_49_0_0_LsgClassMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_49_0_0_LsgClassMinor, getProfileInt( "BAP", "BAPCFG_FSG_49_0_0_LsgClassMinor", 0, profileFile ) );
    putValue( BAPCFG_FSG_49_0_0_ProtocolMajor, getProfileInt( "BAP", "BAPCFG_FSG_49_0_0_ProtocolMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_49_0_0_ProtocolMinor, getProfileInt( "BAP", "BAPCFG_FSG_49_0_0_ProtocolMinor", 0, profileFile ) );
    putValue( C_FSG_49_0_0_1_FctLstItemEn, getProfileInt( "BAP", "C_FSG_49_0_0_1_FctLstItemEn", 0, profileFile ) );
    putValue( C_FSG_49_0_0_1_FctEn, getProfileInt( "BAP", "C_FSG_49_0_0_1_FctEn", 0, profileFile ) );
    putValue( C_FSG_49_0_0_1_ErrEn, getProfileInt( "BAP", "C_FSG_49_0_0_1_ErrEn", 0, profileFile ) );
    putValue( C_FSG_49_0_0_1_IntTlgEn, getProfileInt( "BAP", "C_FSG_49_0_0_1_IntTlgEn", 0, profileFile ) );
    putValue( C_FSG_49_0_0_1_SegmEn, getProfileInt( "BAP", "C_FSG_49_0_0_1_SegmEn", 0, profileFile ) );
    putValue( C_FSG_49_0_0_1_ErrCode, getProfileInt( "BAP", "C_FSG_49_0_0_1_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_2Reset_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_2Reset_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_2_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_2_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_2_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_2_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_2_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_2_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_2_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_2_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_2, getProfileFloat( "BAP", "P_FSG_49_0_0_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_2_range, getProfileFloat( "BAP", "P_FSG_49_0_0_2_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_3Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_3Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_3_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_3_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_3_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_3_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_3_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_3_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_3_IntTlgEn, getProfileInt( "BAP", "P_FSG_49_0_0_3_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_3_SegmEn, getProfileInt( "BAP", "P_FSG_49_0_0_3_SegmEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_3_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_3_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_4Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_4Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_4_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_4_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_4_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_4_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_4_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_4_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_4_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_4_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_4, getProfileInt( "BAP", "P_FSG_49_0_0_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_14Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_14_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_14_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_14_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_14_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_3, getProfileInt( "BAP", "P_FSG_49_0_0_14_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_3_0, getProfileInt( "BAP", "P_FSG_49_0_0_14_3_0", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_3_1, getProfileInt( "BAP", "P_FSG_49_0_0_14_3_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_3_2, getProfileInt( "BAP", "P_FSG_49_0_0_14_3_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_3_3, getProfileInt( "BAP", "P_FSG_49_0_0_14_3_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_3_4, getProfileInt( "BAP", "P_FSG_49_0_0_14_3_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_3_5, getProfileInt( "BAP", "P_FSG_49_0_0_14_3_5", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_3_6, getProfileInt( "BAP", "P_FSG_49_0_0_14_3_6", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_3_7, getProfileInt( "BAP", "P_FSG_49_0_0_14_3_7", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_1, getProfileFloat( "BAP", "P_FSG_49_0_0_14_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_1_range, getProfileFloat( "BAP", "P_FSG_49_0_0_14_1_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_4, getProfileInt( "BAP", "P_FSG_49_0_0_14_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_4_0, getProfileInt( "BAP", "P_FSG_49_0_0_14_4_0", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_4_1, getProfileInt( "BAP", "P_FSG_49_0_0_14_4_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_4_2, getProfileInt( "BAP", "P_FSG_49_0_0_14_4_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_4_3, getProfileInt( "BAP", "P_FSG_49_0_0_14_4_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_4_4, getProfileInt( "BAP", "P_FSG_49_0_0_14_4_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_2, getProfileInt( "BAP", "P_FSG_49_0_0_14_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_2_0, getProfileInt( "BAP", "P_FSG_49_0_0_14_2_0", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_2_1, getProfileInt( "BAP", "P_FSG_49_0_0_14_2_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_2_2, getProfileInt( "BAP", "P_FSG_49_0_0_14_2_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_2_3, getProfileInt( "BAP", "P_FSG_49_0_0_14_2_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_2_4, getProfileInt( "BAP", "P_FSG_49_0_0_14_2_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_2_5, getProfileInt( "BAP", "P_FSG_49_0_0_14_2_5", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_2_6, getProfileInt( "BAP", "P_FSG_49_0_0_14_2_6", 0, profileFile ) );
    putValue( P_FSG_49_0_0_14_2_7, getProfileInt( "BAP", "P_FSG_49_0_0_14_2_7", 0, profileFile ) );
    putValue( P_FSG_49_0_0_15Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_15Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_15_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_15_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_15_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_15_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_15_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_15_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_15_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_15_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_15_2, getProfileInt( "BAP", "P_FSG_49_0_0_15_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_15_1, getProfileInt( "BAP", "P_FSG_49_0_0_15_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_16Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_16_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_16_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_16_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_16_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_1, getProfileInt( "BAP", "P_FSG_49_0_0_16_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_6, getProfileInt( "BAP", "P_FSG_49_0_0_16_6", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_6_0, getProfileInt( "BAP", "P_FSG_49_0_0_16_6_0", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_6_1, getProfileInt( "BAP", "P_FSG_49_0_0_16_6_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_2, getProfileFloat( "BAP", "P_FSG_49_0_0_16_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_2_range, getProfileFloat( "BAP", "P_FSG_49_0_0_16_2_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_7, getProfileFloat( "BAP", "P_FSG_49_0_0_16_7", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_7_range, getProfileFloat( "BAP", "P_FSG_49_0_0_16_7_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_5, getProfileInt( "BAP", "P_FSG_49_0_0_16_5", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_4, getProfileInt( "BAP", "P_FSG_49_0_0_16_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_4_0, getProfileInt( "BAP", "P_FSG_49_0_0_16_4_0", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_4_1, getProfileInt( "BAP", "P_FSG_49_0_0_16_4_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_4_2, getProfileInt( "BAP", "P_FSG_49_0_0_16_4_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_4_3, getProfileInt( "BAP", "P_FSG_49_0_0_16_4_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_16_3, getProfileInt( "BAP", "P_FSG_49_0_0_16_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_17Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_17Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_17_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_17_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_17_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_17_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_17_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_17_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_17_IntTlgEn, getProfileInt( "BAP", "P_FSG_49_0_0_17_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_17_SegmEn, getProfileInt( "BAP", "P_FSG_49_0_0_17_SegmEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_17_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_17_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_17_1_len, getProfileInt( "BAP", "P_FSG_49_0_0_17_1_len", 0, profileFile ) );
    putValue( P_FSG_49_0_0_17_1_cnt, getProfileInt( "BAP", "P_FSG_49_0_0_17_1_cnt", 0, profileFile ) );
    putValue( P_FSG_49_0_0_18Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_18Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_18_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_18_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_18_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_18_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_18_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_18_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_18_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_18_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_18_1, getProfileFloat( "BAP", "P_FSG_49_0_0_18_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_18_1_range, getProfileFloat( "BAP", "P_FSG_49_0_0_18_1_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_18_5, getProfileFloat( "BAP", "P_FSG_49_0_0_18_5", 0, profileFile ) );
    putValue( P_FSG_49_0_0_18_5_range, getProfileFloat( "BAP", "P_FSG_49_0_0_18_5_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_18_3, getProfileFloat( "BAP", "P_FSG_49_0_0_18_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_18_3_range, getProfileFloat( "BAP", "P_FSG_49_0_0_18_3_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_18_6, getProfileInt( "BAP", "P_FSG_49_0_0_18_6", 0, profileFile ) );
    putValue( P_FSG_49_0_0_18_4, getProfileFloat( "BAP", "P_FSG_49_0_0_18_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_18_4_range, getProfileFloat( "BAP", "P_FSG_49_0_0_18_4_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_18_2, getProfileFloat( "BAP", "P_FSG_49_0_0_18_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_18_2_range, getProfileFloat( "BAP", "P_FSG_49_0_0_18_2_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_19Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_19Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_19_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_19_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_19_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_19_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_19_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_19_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_19_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_19_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_19, getProfileInt( "BAP", "P_FSG_49_0_0_19", 0, profileFile ) );
    putValue( P_FSG_49_0_0_19_1, getProfileInt( "BAP", "P_FSG_49_0_0_19_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_19_1_0, getProfileInt( "BAP", "P_FSG_49_0_0_19_1_0", 0, profileFile ) );
    putValue( P_FSG_49_0_0_19_1_1, getProfileInt( "BAP", "P_FSG_49_0_0_19_1_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_19_1_2, getProfileInt( "BAP", "P_FSG_49_0_0_19_1_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_19_1_3, getProfileInt( "BAP", "P_FSG_49_0_0_19_1_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_19_1_4, getProfileInt( "BAP", "P_FSG_49_0_0_19_1_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_19_1_5, getProfileInt( "BAP", "P_FSG_49_0_0_19_1_5", 0, profileFile ) );
    putValue( P_FSG_49_0_0_19_1_6, getProfileInt( "BAP", "P_FSG_49_0_0_19_1_6", 0, profileFile ) );
    putValue( P_FSG_49_0_0_19_1_7, getProfileInt( "BAP", "P_FSG_49_0_0_19_1_7", 0, profileFile ) );
    putValue( P_FSG_49_0_0_20Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_20Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_20_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_20_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_20_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_20_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_20_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_20_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_20_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_20_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_20_2, getProfileInt( "BAP", "P_FSG_49_0_0_20_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_20_1, getProfileInt( "BAP", "P_FSG_49_0_0_20_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_21Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_21_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_21_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_21_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_IntTlgEn, getProfileInt( "BAP", "P_FSG_49_0_0_21_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_SegmEn, getProfileInt( "BAP", "P_FSG_49_0_0_21_SegmEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_21_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_9, getProfileInt( "BAP", "P_FSG_49_0_0_21_9", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_5, getProfileInt( "BAP", "P_FSG_49_0_0_21_5", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_4_len, getProfileInt( "BAP", "P_FSG_49_0_0_21_4_len", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_4_cnt, getProfileInt( "BAP", "P_FSG_49_0_0_21_4_cnt", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_3, getProfileFloat( "BAP", "P_FSG_49_0_0_21_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_3_range, getProfileFloat( "BAP", "P_FSG_49_0_0_21_3_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_1_len, getProfileInt( "BAP", "P_FSG_49_0_0_21_1_len", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_1_cnt, getProfileInt( "BAP", "P_FSG_49_0_0_21_1_cnt", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_6_len, getProfileInt( "BAP", "P_FSG_49_0_0_21_6_len", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_6_cnt, getProfileInt( "BAP", "P_FSG_49_0_0_21_6_cnt", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_2, getProfileInt( "BAP", "P_FSG_49_0_0_21_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_7, getProfileInt( "BAP", "P_FSG_49_0_0_21_7", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_10, getProfileInt( "BAP", "P_FSG_49_0_0_21_10", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_10_0, getProfileInt( "BAP", "P_FSG_49_0_0_21_10_0", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_10_1, getProfileInt( "BAP", "P_FSG_49_0_0_21_10_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_10_2, getProfileInt( "BAP", "P_FSG_49_0_0_21_10_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_10_3, getProfileInt( "BAP", "P_FSG_49_0_0_21_10_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_11, getProfileInt( "BAP", "P_FSG_49_0_0_21_11", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_11_0, getProfileInt( "BAP", "P_FSG_49_0_0_21_11_0", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_11_1, getProfileInt( "BAP", "P_FSG_49_0_0_21_11_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_11_2, getProfileInt( "BAP", "P_FSG_49_0_0_21_11_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_11_3, getProfileInt( "BAP", "P_FSG_49_0_0_21_11_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_8_len, getProfileInt( "BAP", "P_FSG_49_0_0_21_8_len", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_8_cnt, getProfileInt( "BAP", "P_FSG_49_0_0_21_8_cnt", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_12, getProfileFloat( "BAP", "P_FSG_49_0_0_21_12", 0, profileFile ) );
    putValue( P_FSG_49_0_0_21_12_range, getProfileFloat( "BAP", "P_FSG_49_0_0_21_12_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_22Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_22_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_22_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_22_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22_IntTlgEn, getProfileInt( "BAP", "P_FSG_49_0_0_22_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22_SegmEn, getProfileInt( "BAP", "P_FSG_49_0_0_22_SegmEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_22_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22_5, getProfileFloat( "BAP", "P_FSG_49_0_0_22_5", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22_5_range, getProfileFloat( "BAP", "P_FSG_49_0_0_22_5_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22_6, getProfileFloat( "BAP", "P_FSG_49_0_0_22_6", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22_6_range, getProfileFloat( "BAP", "P_FSG_49_0_0_22_6_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22_4, getProfileFloat( "BAP", "P_FSG_49_0_0_22_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22_4_range, getProfileFloat( "BAP", "P_FSG_49_0_0_22_4_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22_2, getProfileFloat( "BAP", "P_FSG_49_0_0_22_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22_2_range, getProfileFloat( "BAP", "P_FSG_49_0_0_22_2_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22_1, getProfileFloat( "BAP", "P_FSG_49_0_0_22_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22_1_range, getProfileFloat( "BAP", "P_FSG_49_0_0_22_1_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22_3, getProfileFloat( "BAP", "P_FSG_49_0_0_22_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_22_3_range, getProfileFloat( "BAP", "P_FSG_49_0_0_22_3_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23Changed_BTN, getProfileInt( "BAP", "A_FSG_49_0_0_23Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23Status_BTN, getProfileInt( "BAP", "A_FSG_49_0_0_23Status_BTN", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_FctLstItemEn, getProfileInt( "BAP", "A_FSG_49_0_0_23_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_FctEn, getProfileInt( "BAP", "A_FSG_49_0_0_23_FctEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_ErrEn, getProfileInt( "BAP", "A_FSG_49_0_0_23_ErrEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_IntTlgEn, getProfileInt( "BAP", "A_FSG_49_0_0_23_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_SegmEn, getProfileInt( "BAP", "A_FSG_49_0_0_23_SegmEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_AT, getProfileInt( "BAP", "A_FSG_49_0_0_23_AT", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_ErrCode, getProfileInt( "BAP", "A_FSG_49_0_0_23_ErrCode", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_DataIndex, getProfileInt( "BAP", "A_FSG_49_0_0_23_DataIndex", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_49_0_0_23_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_49_0_0_23_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_loadArray_Btn, getProfileInt( "BAP", "A_FSG_49_0_0_23_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_generateData_Btn, getProfileInt( "BAP", "A_FSG_49_0_0_23_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_3, getProfileInt( "BAP", "A_FSG_49_0_0_23_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_2, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_3, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_3_0, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_3_0", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_3_1, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_3_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_3_2, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_3_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_3_3, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_3_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_3_4, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_3_4", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_3_5, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_3_5", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_3_6, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_3_6", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_3_7, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_3_7", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_3_8, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_3_8", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_3_9, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_3_9", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_3_10, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_3_10", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_3_11, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_3_11", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_3_12, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_3_12", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_5, getProfileFloat( "BAP", "A_FSG_49_0_0_23_5", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_5_range, getProfileFloat( "BAP", "A_FSG_49_0_0_23_5_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_1, getProfileInt( "BAP", "A_FSG_49_0_0_23_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_4, getProfileFloat( "BAP", "A_FSG_49_0_0_23_4", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_4_range, getProfileFloat( "BAP", "A_FSG_49_0_0_23_4_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_7_len, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_7_len", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_7_cnt, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_7_cnt", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_5, getProfileFloat( "BAP", "A_FSG_49_0_0_23_Data_5", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_5_range, getProfileFloat( "BAP", "A_FSG_49_0_0_23_Data_5_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_1, getProfileFloat( "BAP", "A_FSG_49_0_0_23_Data_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_1_range, getProfileFloat( "BAP", "A_FSG_49_0_0_23_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_8_len, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_8_len", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_8_cnt, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_8_cnt", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_6, getProfileInt( "BAP", "A_FSG_49_0_0_23_Data_6", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_2, getProfileFloat( "BAP", "A_FSG_49_0_0_23_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_2_range, getProfileFloat( "BAP", "A_FSG_49_0_0_23_2_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_4, getProfileFloat( "BAP", "A_FSG_49_0_0_23_Data_4", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Data_4_range, getProfileFloat( "BAP", "A_FSG_49_0_0_23_Data_4_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_23_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_23_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_23_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_TransPos, getProfileInt( "BAP", "A_FSG_49_0_0_23_TransPos", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_23_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Start, getProfileInt( "BAP", "A_FSG_49_0_0_23_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_23_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_1_Changed, getProfileInt( "BAP", "A_FSG_49_0_0_23_1_Changed", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_2_Changed, getProfileFloat( "BAP", "A_FSG_49_0_0_23_2_Changed", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_2_Changed_range, getProfileFloat( "BAP", "A_FSG_49_0_0_23_2_Changed_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_23_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Changed_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_23_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Changed_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_23_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Changed_TransPos, getProfileInt( "BAP", "A_FSG_49_0_0_23_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_23_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Changed_Start, getProfileInt( "BAP", "A_FSG_49_0_0_23_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_Changed_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_23_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_2_SetGet, getProfileFloat( "BAP", "A_FSG_49_0_0_23_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_49_0_0_23_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_1_SetGet, getProfileInt( "BAP", "A_FSG_49_0_0_23_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_3_SetGet, getProfileInt( "BAP", "A_FSG_49_0_0_23_3_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_4_SetGet, getProfileFloat( "BAP", "A_FSG_49_0_0_23_4_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_4_SetGet_range, getProfileFloat( "BAP", "A_FSG_49_0_0_23_4_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_23_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_SetGet_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_23_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_SetGet_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_23_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_23_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_SetGet_Start, getProfileInt( "BAP", "A_FSG_49_0_0_23_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_23_SetGet_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_23_SetGet_Elements", 0, profileFile ) );
    putValue( M_FSG_49_0_0_24Result_BTN, getProfileInt( "BAP", "M_FSG_49_0_0_24Result_BTN", 0, profileFile ) );
    putValue( M_FSG_49_0_0_24_FctLstItemEn, getProfileInt( "BAP", "M_FSG_49_0_0_24_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_24_FctEn, getProfileInt( "BAP", "M_FSG_49_0_0_24_FctEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_24_ErrEn, getProfileInt( "BAP", "M_FSG_49_0_0_24_ErrEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_24_ErrCode, getProfileInt( "BAP", "M_FSG_49_0_0_24_ErrCode", 0, profileFile ) );
    putValue( M_FSG_49_0_0_24_Result, getProfileInt( "BAP", "M_FSG_49_0_0_24_Result", 0, profileFile ) );
    putValue( M_FSG_49_0_0_24_Result_1, getProfileInt( "BAP", "M_FSG_49_0_0_24_Result_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_24_Processing, getProfileInt( "BAP", "M_FSG_49_0_0_24_Processing", 0, profileFile ) );
    putValue( M_FSG_49_0_0_24_Processing_1, getProfileFloat( "BAP", "M_FSG_49_0_0_24_Processing_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_24_Processing_1_range, getProfileFloat( "BAP", "M_FSG_49_0_0_24_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_49_0_0_24_Start_1, getProfileInt( "BAP", "M_FSG_49_0_0_24_Start_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_24_Start_2, getProfileFloat( "BAP", "M_FSG_49_0_0_24_Start_2", 0, profileFile ) );
    putValue( M_FSG_49_0_0_24_Start_2_range, getProfileFloat( "BAP", "M_FSG_49_0_0_24_Start_2_range", 0, profileFile ) );
    putValue( M_FSG_49_0_0_24_Start_3, getProfileInt( "BAP", "M_FSG_49_0_0_24_Start_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_25Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_25_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_25_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_25_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_25_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_2, getProfileInt( "BAP", "P_FSG_49_0_0_25_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_2_0, getProfileInt( "BAP", "P_FSG_49_0_0_25_2_0", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_2_1, getProfileInt( "BAP", "P_FSG_49_0_0_25_2_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_2_2, getProfileInt( "BAP", "P_FSG_49_0_0_25_2_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_2_3, getProfileInt( "BAP", "P_FSG_49_0_0_25_2_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_2_4, getProfileInt( "BAP", "P_FSG_49_0_0_25_2_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_2_5, getProfileInt( "BAP", "P_FSG_49_0_0_25_2_5", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_2_6, getProfileInt( "BAP", "P_FSG_49_0_0_25_2_6", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_1, getProfileInt( "BAP", "P_FSG_49_0_0_25_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_1_0, getProfileInt( "BAP", "P_FSG_49_0_0_25_1_0", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_1_1, getProfileInt( "BAP", "P_FSG_49_0_0_25_1_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_1_2, getProfileInt( "BAP", "P_FSG_49_0_0_25_1_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_1_3, getProfileInt( "BAP", "P_FSG_49_0_0_25_1_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_1_4, getProfileInt( "BAP", "P_FSG_49_0_0_25_1_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_1_5, getProfileInt( "BAP", "P_FSG_49_0_0_25_1_5", 0, profileFile ) );
    putValue( P_FSG_49_0_0_25_1_6, getProfileInt( "BAP", "P_FSG_49_0_0_25_1_6", 0, profileFile ) );
    putValue( P_FSG_49_0_0_26Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_26Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_26_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_26_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_26_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_26_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_26_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_26_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_26_IntTlgEn, getProfileInt( "BAP", "P_FSG_49_0_0_26_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_26_SegmEn, getProfileInt( "BAP", "P_FSG_49_0_0_26_SegmEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_26_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_26_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_26_2_Hour, getProfileFloat( "BAP", "P_FSG_49_0_0_26_2_Hour", 0, profileFile ) );
    putValue( P_FSG_49_0_0_26_2_Hour_range, getProfileFloat( "BAP", "P_FSG_49_0_0_26_2_Hour_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_26_2_Minute, getProfileFloat( "BAP", "P_FSG_49_0_0_26_2_Minute", 0, profileFile ) );
    putValue( P_FSG_49_0_0_26_2_Minute_range, getProfileFloat( "BAP", "P_FSG_49_0_0_26_2_Minute_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_26_3_len, getProfileInt( "BAP", "P_FSG_49_0_0_26_3_len", 0, profileFile ) );
    putValue( P_FSG_49_0_0_26_3_cnt, getProfileInt( "BAP", "P_FSG_49_0_0_26_3_cnt", 0, profileFile ) );
    putValue( P_FSG_49_0_0_26_1_CurrentMsgNumber, getProfileFloat( "BAP", "P_FSG_49_0_0_26_1_CurrentMsgNumber", 0, profileFile ) );
    putValue( P_FSG_49_0_0_26_1_CurrentMsgNumber_range, getProfileFloat( "BAP", "P_FSG_49_0_0_26_1_CurrentMsgNumber_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_26_1_TotalMsgNumber, getProfileFloat( "BAP", "P_FSG_49_0_0_26_1_TotalMsgNumber", 0, profileFile ) );
    putValue( P_FSG_49_0_0_26_1_TotalMsgNumber_range, getProfileFloat( "BAP", "P_FSG_49_0_0_26_1_TotalMsgNumber_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27Changed_BTN, getProfileInt( "BAP", "A_FSG_49_0_0_27Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27Status_BTN, getProfileInt( "BAP", "A_FSG_49_0_0_27Status_BTN", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_FctLstItemEn, getProfileInt( "BAP", "A_FSG_49_0_0_27_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_FctEn, getProfileInt( "BAP", "A_FSG_49_0_0_27_FctEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_ErrEn, getProfileInt( "BAP", "A_FSG_49_0_0_27_ErrEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_IntTlgEn, getProfileInt( "BAP", "A_FSG_49_0_0_27_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_SegmEn, getProfileInt( "BAP", "A_FSG_49_0_0_27_SegmEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_AT, getProfileInt( "BAP", "A_FSG_49_0_0_27_AT", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_ErrCode, getProfileInt( "BAP", "A_FSG_49_0_0_27_ErrCode", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_DataIndex, getProfileInt( "BAP", "A_FSG_49_0_0_27_DataIndex", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_49_0_0_27_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_49_0_0_27_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_loadArray_Btn, getProfileInt( "BAP", "A_FSG_49_0_0_27_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_generateData_Btn, getProfileInt( "BAP", "A_FSG_49_0_0_27_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Data_4, getProfileFloat( "BAP", "A_FSG_49_0_0_27_Data_4", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Data_4_range, getProfileFloat( "BAP", "A_FSG_49_0_0_27_Data_4_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_2, getProfileFloat( "BAP", "A_FSG_49_0_0_27_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_2_range, getProfileFloat( "BAP", "A_FSG_49_0_0_27_2_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_1, getProfileInt( "BAP", "A_FSG_49_0_0_27_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Data_1, getProfileFloat( "BAP", "A_FSG_49_0_0_27_Data_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Data_1_range, getProfileFloat( "BAP", "A_FSG_49_0_0_27_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_3, getProfileFloat( "BAP", "A_FSG_49_0_0_27_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_3_range, getProfileFloat( "BAP", "A_FSG_49_0_0_27_3_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Data_5_len, getProfileInt( "BAP", "A_FSG_49_0_0_27_Data_5_len", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Data_5_cnt, getProfileInt( "BAP", "A_FSG_49_0_0_27_Data_5_cnt", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Data_2, getProfileInt( "BAP", "A_FSG_49_0_0_27_Data_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Data_2_0, getProfileInt( "BAP", "A_FSG_49_0_0_27_Data_2_0", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Data_3, getProfileFloat( "BAP", "A_FSG_49_0_0_27_Data_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Data_3_range, getProfileFloat( "BAP", "A_FSG_49_0_0_27_Data_3_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_27_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_27_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_27_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_TransPos, getProfileInt( "BAP", "A_FSG_49_0_0_27_TransPos", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_27_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Start, getProfileInt( "BAP", "A_FSG_49_0_0_27_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_27_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_27_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Changed_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_27_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Changed_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_27_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Changed_TransPos, getProfileInt( "BAP", "A_FSG_49_0_0_27_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_27_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Changed_Start, getProfileInt( "BAP", "A_FSG_49_0_0_27_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_Changed_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_27_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_2_SetGet, getProfileFloat( "BAP", "A_FSG_49_0_0_27_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_49_0_0_27_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_1_SetGet, getProfileInt( "BAP", "A_FSG_49_0_0_27_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_27_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_SetGet_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_27_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_SetGet_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_27_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_27_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_SetGet_Start, getProfileInt( "BAP", "A_FSG_49_0_0_27_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_27_SetGet_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_27_SetGet_Elements", 0, profileFile ) );
    putValue( P_FSG_49_0_0_28Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_28Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_28_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_28_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_28_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_28_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_28_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_28_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_28_IntTlgEn, getProfileInt( "BAP", "P_FSG_49_0_0_28_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_28_SegmEn, getProfileInt( "BAP", "P_FSG_49_0_0_28_SegmEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_28_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_28_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_28_1, getProfileInt( "BAP", "P_FSG_49_0_0_28_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_28_2_len, getProfileInt( "BAP", "P_FSG_49_0_0_28_2_len", 0, profileFile ) );
    putValue( P_FSG_49_0_0_28_2_cnt, getProfileInt( "BAP", "P_FSG_49_0_0_28_2_cnt", 0, profileFile ) );
    putValue( M_FSG_49_0_0_29Result_BTN, getProfileInt( "BAP", "M_FSG_49_0_0_29Result_BTN", 0, profileFile ) );
    putValue( M_FSG_49_0_0_29_FctLstItemEn, getProfileInt( "BAP", "M_FSG_49_0_0_29_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_29_FctEn, getProfileInt( "BAP", "M_FSG_49_0_0_29_FctEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_29_ErrEn, getProfileInt( "BAP", "M_FSG_49_0_0_29_ErrEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_29_ErrCode, getProfileInt( "BAP", "M_FSG_49_0_0_29_ErrCode", 0, profileFile ) );
    putValue( M_FSG_49_0_0_29_Result, getProfileInt( "BAP", "M_FSG_49_0_0_29_Result", 0, profileFile ) );
    putValue( M_FSG_49_0_0_29_Result_1, getProfileInt( "BAP", "M_FSG_49_0_0_29_Result_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_29_Processing, getProfileInt( "BAP", "M_FSG_49_0_0_29_Processing", 0, profileFile ) );
    putValue( M_FSG_49_0_0_29_Processing_1, getProfileFloat( "BAP", "M_FSG_49_0_0_29_Processing_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_29_Processing_1_range, getProfileFloat( "BAP", "M_FSG_49_0_0_29_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_49_0_0_29_Start, getProfileInt( "BAP", "M_FSG_49_0_0_29_Start", 0, profileFile ) );
    putValue( M_FSG_49_0_0_29_Start_0, getProfileInt( "BAP", "M_FSG_49_0_0_29_Start_0", 0, profileFile ) );
    putValue( P_FSG_49_0_0_30Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_30Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_30_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_30_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_30_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_30_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_30_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_30_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_30_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_30_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_30, getProfileInt( "BAP", "P_FSG_49_0_0_30", 0, profileFile ) );
    putValue( P_FSG_49_0_0_30_1, getProfileInt( "BAP", "P_FSG_49_0_0_30_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_31Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_31Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_31_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_31_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_31_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_31_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_31_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_31_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_31_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_31_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_31, getProfileInt( "BAP", "P_FSG_49_0_0_31", 0, profileFile ) );
    putValue( P_FSG_49_0_0_31_1, getProfileInt( "BAP", "P_FSG_49_0_0_31_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32Changed_BTN, getProfileInt( "BAP", "A_FSG_49_0_0_32Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32Status_BTN, getProfileInt( "BAP", "A_FSG_49_0_0_32Status_BTN", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_FctLstItemEn, getProfileInt( "BAP", "A_FSG_49_0_0_32_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_FctEn, getProfileInt( "BAP", "A_FSG_49_0_0_32_FctEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_ErrEn, getProfileInt( "BAP", "A_FSG_49_0_0_32_ErrEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_IntTlgEn, getProfileInt( "BAP", "A_FSG_49_0_0_32_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_SegmEn, getProfileInt( "BAP", "A_FSG_49_0_0_32_SegmEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_AT, getProfileInt( "BAP", "A_FSG_49_0_0_32_AT", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_ErrCode, getProfileInt( "BAP", "A_FSG_49_0_0_32_ErrCode", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_DataIndex, getProfileInt( "BAP", "A_FSG_49_0_0_32_DataIndex", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_49_0_0_32_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_49_0_0_32_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_loadArray_Btn, getProfileInt( "BAP", "A_FSG_49_0_0_32_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_generateData_Btn, getProfileInt( "BAP", "A_FSG_49_0_0_32_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Data_4, getProfileInt( "BAP", "A_FSG_49_0_0_32_Data_4", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Data_5, getProfileInt( "BAP", "A_FSG_49_0_0_32_Data_5", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Data_5_0, getProfileInt( "BAP", "A_FSG_49_0_0_32_Data_5_0", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Data_5_1, getProfileInt( "BAP", "A_FSG_49_0_0_32_Data_5_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Data_5_2, getProfileInt( "BAP", "A_FSG_49_0_0_32_Data_5_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Data_5_3, getProfileInt( "BAP", "A_FSG_49_0_0_32_Data_5_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Data_5_4, getProfileInt( "BAP", "A_FSG_49_0_0_32_Data_5_4", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Data_5_5, getProfileInt( "BAP", "A_FSG_49_0_0_32_Data_5_5", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Data_5_6, getProfileInt( "BAP", "A_FSG_49_0_0_32_Data_5_6", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_3, getProfileFloat( "BAP", "A_FSG_49_0_0_32_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_3_range, getProfileFloat( "BAP", "A_FSG_49_0_0_32_3_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_1, getProfileInt( "BAP", "A_FSG_49_0_0_32_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Data_6_len, getProfileInt( "BAP", "A_FSG_49_0_0_32_Data_6_len", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Data_6_cnt, getProfileInt( "BAP", "A_FSG_49_0_0_32_Data_6_cnt", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Data_2, getProfileInt( "BAP", "A_FSG_49_0_0_32_Data_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Data_3, getProfileFloat( "BAP", "A_FSG_49_0_0_32_Data_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Data_3_range, getProfileFloat( "BAP", "A_FSG_49_0_0_32_Data_3_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Data_1, getProfileFloat( "BAP", "A_FSG_49_0_0_32_Data_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Data_1_range, getProfileFloat( "BAP", "A_FSG_49_0_0_32_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_2, getProfileFloat( "BAP", "A_FSG_49_0_0_32_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_2_range, getProfileFloat( "BAP", "A_FSG_49_0_0_32_2_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_32_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_32_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_32_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_TransPos, getProfileInt( "BAP", "A_FSG_49_0_0_32_TransPos", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_32_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Start, getProfileInt( "BAP", "A_FSG_49_0_0_32_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_32_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_32_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Changed_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_32_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Changed_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_32_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Changed_TransPos, getProfileInt( "BAP", "A_FSG_49_0_0_32_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_32_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Changed_Start, getProfileInt( "BAP", "A_FSG_49_0_0_32_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_Changed_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_32_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_2_SetGet, getProfileFloat( "BAP", "A_FSG_49_0_0_32_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_49_0_0_32_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_1_SetGet, getProfileInt( "BAP", "A_FSG_49_0_0_32_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_32_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_SetGet_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_32_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_SetGet_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_32_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_32_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_SetGet_Start, getProfileInt( "BAP", "A_FSG_49_0_0_32_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_32_SetGet_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_32_SetGet_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33Changed_BTN, getProfileInt( "BAP", "A_FSG_49_0_0_33Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33Status_BTN, getProfileInt( "BAP", "A_FSG_49_0_0_33Status_BTN", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_FctLstItemEn, getProfileInt( "BAP", "A_FSG_49_0_0_33_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_FctEn, getProfileInt( "BAP", "A_FSG_49_0_0_33_FctEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_ErrEn, getProfileInt( "BAP", "A_FSG_49_0_0_33_ErrEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_IntTlgEn, getProfileInt( "BAP", "A_FSG_49_0_0_33_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_SegmEn, getProfileInt( "BAP", "A_FSG_49_0_0_33_SegmEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_AT, getProfileInt( "BAP", "A_FSG_49_0_0_33_AT", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_ErrCode, getProfileInt( "BAP", "A_FSG_49_0_0_33_ErrCode", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_DataIndex, getProfileInt( "BAP", "A_FSG_49_0_0_33_DataIndex", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_49_0_0_33_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_49_0_0_33_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_loadArray_Btn, getProfileInt( "BAP", "A_FSG_49_0_0_33_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_generateData_Btn, getProfileInt( "BAP", "A_FSG_49_0_0_33_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_5_len, getProfileInt( "BAP", "A_FSG_49_0_0_33_Data_5_len", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_5_cnt, getProfileInt( "BAP", "A_FSG_49_0_0_33_Data_5_cnt", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_3, getProfileInt( "BAP", "A_FSG_49_0_0_33_Data_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_2, getProfileFloat( "BAP", "A_FSG_49_0_0_33_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_2_range, getProfileFloat( "BAP", "A_FSG_49_0_0_33_2_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_1, getProfileInt( "BAP", "A_FSG_49_0_0_33_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_1, getProfileFloat( "BAP", "A_FSG_49_0_0_33_Data_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_1_range, getProfileFloat( "BAP", "A_FSG_49_0_0_33_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_3, getProfileFloat( "BAP", "A_FSG_49_0_0_33_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_3_range, getProfileFloat( "BAP", "A_FSG_49_0_0_33_3_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_4, getProfileInt( "BAP", "A_FSG_49_0_0_33_Data_4", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_4_0, getProfileInt( "BAP", "A_FSG_49_0_0_33_Data_4_0", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_4_1, getProfileInt( "BAP", "A_FSG_49_0_0_33_Data_4_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_4_2, getProfileInt( "BAP", "A_FSG_49_0_0_33_Data_4_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_4_3, getProfileInt( "BAP", "A_FSG_49_0_0_33_Data_4_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_4_4, getProfileInt( "BAP", "A_FSG_49_0_0_33_Data_4_4", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_4_5, getProfileInt( "BAP", "A_FSG_49_0_0_33_Data_4_5", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_4_6, getProfileInt( "BAP", "A_FSG_49_0_0_33_Data_4_6", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_4_7, getProfileInt( "BAP", "A_FSG_49_0_0_33_Data_4_7", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_4_8, getProfileInt( "BAP", "A_FSG_49_0_0_33_Data_4_8", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_4_9, getProfileInt( "BAP", "A_FSG_49_0_0_33_Data_4_9", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_4_10, getProfileInt( "BAP", "A_FSG_49_0_0_33_Data_4_10", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_2, getProfileFloat( "BAP", "A_FSG_49_0_0_33_Data_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Data_2_range, getProfileFloat( "BAP", "A_FSG_49_0_0_33_Data_2_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_33_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_33_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_33_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_TransPos, getProfileInt( "BAP", "A_FSG_49_0_0_33_TransPos", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_33_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Start, getProfileInt( "BAP", "A_FSG_49_0_0_33_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_33_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_33_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Changed_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_33_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Changed_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_33_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Changed_TransPos, getProfileInt( "BAP", "A_FSG_49_0_0_33_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_33_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Changed_Start, getProfileInt( "BAP", "A_FSG_49_0_0_33_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_Changed_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_33_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_2_SetGet, getProfileFloat( "BAP", "A_FSG_49_0_0_33_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_49_0_0_33_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_1_SetGet, getProfileInt( "BAP", "A_FSG_49_0_0_33_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_33_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_SetGet_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_33_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_SetGet_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_33_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_33_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_SetGet_Start, getProfileInt( "BAP", "A_FSG_49_0_0_33_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_33_SetGet_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_33_SetGet_Elements", 0, profileFile ) );
    putValue( M_FSG_49_0_0_34Result_BTN, getProfileInt( "BAP", "M_FSG_49_0_0_34Result_BTN", 0, profileFile ) );
    putValue( M_FSG_49_0_0_34_FctLstItemEn, getProfileInt( "BAP", "M_FSG_49_0_0_34_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_34_FctEn, getProfileInt( "BAP", "M_FSG_49_0_0_34_FctEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_34_ErrEn, getProfileInt( "BAP", "M_FSG_49_0_0_34_ErrEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_34_ErrCode, getProfileInt( "BAP", "M_FSG_49_0_0_34_ErrCode", 0, profileFile ) );
    putValue( M_FSG_49_0_0_34_Result, getProfileInt( "BAP", "M_FSG_49_0_0_34_Result", 0, profileFile ) );
    putValue( M_FSG_49_0_0_34_Result_1, getProfileInt( "BAP", "M_FSG_49_0_0_34_Result_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_34_Processing, getProfileInt( "BAP", "M_FSG_49_0_0_34_Processing", 0, profileFile ) );
    putValue( M_FSG_49_0_0_34_Processing_1, getProfileFloat( "BAP", "M_FSG_49_0_0_34_Processing_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_34_Processing_1_range, getProfileFloat( "BAP", "M_FSG_49_0_0_34_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_49_0_0_34_Start, getProfileInt( "BAP", "M_FSG_49_0_0_34_Start", 0, profileFile ) );
    putValue( M_FSG_49_0_0_34_Start_1, getProfileFloat( "BAP", "M_FSG_49_0_0_34_Start_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_34_Start_1_range, getProfileFloat( "BAP", "M_FSG_49_0_0_34_Start_1_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_35Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_35Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_35_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_35_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_35_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_35_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_35_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_35_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_35_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_35_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_35_3, getProfileFloat( "BAP", "P_FSG_49_0_0_35_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_35_3_range, getProfileFloat( "BAP", "P_FSG_49_0_0_35_3_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_35_1, getProfileFloat( "BAP", "P_FSG_49_0_0_35_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_35_1_range, getProfileFloat( "BAP", "P_FSG_49_0_0_35_1_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_35_2, getProfileFloat( "BAP", "P_FSG_49_0_0_35_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_35_2_range, getProfileFloat( "BAP", "P_FSG_49_0_0_35_2_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36Changed_BTN, getProfileInt( "BAP", "A_FSG_49_0_0_36Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36Status_BTN, getProfileInt( "BAP", "A_FSG_49_0_0_36Status_BTN", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_FctLstItemEn, getProfileInt( "BAP", "A_FSG_49_0_0_36_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_FctEn, getProfileInt( "BAP", "A_FSG_49_0_0_36_FctEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_ErrEn, getProfileInt( "BAP", "A_FSG_49_0_0_36_ErrEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_IntTlgEn, getProfileInt( "BAP", "A_FSG_49_0_0_36_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_SegmEn, getProfileInt( "BAP", "A_FSG_49_0_0_36_SegmEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_AT, getProfileInt( "BAP", "A_FSG_49_0_0_36_AT", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_ErrCode, getProfileInt( "BAP", "A_FSG_49_0_0_36_ErrCode", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_DataIndex, getProfileInt( "BAP", "A_FSG_49_0_0_36_DataIndex", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_49_0_0_36_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_49_0_0_36_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_loadArray_Btn, getProfileInt( "BAP", "A_FSG_49_0_0_36_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_generateData_Btn, getProfileInt( "BAP", "A_FSG_49_0_0_36_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Data_4_len, getProfileInt( "BAP", "A_FSG_49_0_0_36_Data_4_len", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Data_4_cnt, getProfileInt( "BAP", "A_FSG_49_0_0_36_Data_4_cnt", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Data_3, getProfileInt( "BAP", "A_FSG_49_0_0_36_Data_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Data_3_0, getProfileInt( "BAP", "A_FSG_49_0_0_36_Data_3_0", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Data_3_1, getProfileInt( "BAP", "A_FSG_49_0_0_36_Data_3_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Data_3_2, getProfileInt( "BAP", "A_FSG_49_0_0_36_Data_3_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Data_3_3, getProfileInt( "BAP", "A_FSG_49_0_0_36_Data_3_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Data_3_4, getProfileInt( "BAP", "A_FSG_49_0_0_36_Data_3_4", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Data_3_5, getProfileInt( "BAP", "A_FSG_49_0_0_36_Data_3_5", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Data_3_6, getProfileInt( "BAP", "A_FSG_49_0_0_36_Data_3_6", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Data_2, getProfileInt( "BAP", "A_FSG_49_0_0_36_Data_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_2, getProfileFloat( "BAP", "A_FSG_49_0_0_36_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_2_range, getProfileFloat( "BAP", "A_FSG_49_0_0_36_2_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_1, getProfileInt( "BAP", "A_FSG_49_0_0_36_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Data_1, getProfileFloat( "BAP", "A_FSG_49_0_0_36_Data_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Data_1_range, getProfileFloat( "BAP", "A_FSG_49_0_0_36_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_4, getProfileFloat( "BAP", "A_FSG_49_0_0_36_4", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_4_range, getProfileFloat( "BAP", "A_FSG_49_0_0_36_4_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_3, getProfileFloat( "BAP", "A_FSG_49_0_0_36_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_3_range, getProfileFloat( "BAP", "A_FSG_49_0_0_36_3_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_36_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_36_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_36_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_TransPos, getProfileInt( "BAP", "A_FSG_49_0_0_36_TransPos", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_36_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Start, getProfileInt( "BAP", "A_FSG_49_0_0_36_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_36_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_36_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Changed_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_36_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Changed_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_36_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Changed_TransPos, getProfileInt( "BAP", "A_FSG_49_0_0_36_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_36_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Changed_Start, getProfileInt( "BAP", "A_FSG_49_0_0_36_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_Changed_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_36_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_2_SetGet, getProfileFloat( "BAP", "A_FSG_49_0_0_36_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_49_0_0_36_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_1_SetGet, getProfileInt( "BAP", "A_FSG_49_0_0_36_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_36_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_SetGet_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_36_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_SetGet_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_36_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_36_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_SetGet_Start, getProfileInt( "BAP", "A_FSG_49_0_0_36_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_36_SetGet_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_36_SetGet_Elements", 0, profileFile ) );
    putValue( P_FSG_49_0_0_37Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_37Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_37_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_37_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_37_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_37_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_37_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_37_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_37_IntTlgEn, getProfileInt( "BAP", "P_FSG_49_0_0_37_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_37_SegmEn, getProfileInt( "BAP", "P_FSG_49_0_0_37_SegmEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_37_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_37_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_37_1, getProfileInt( "BAP", "P_FSG_49_0_0_37_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_37_2_len, getProfileInt( "BAP", "P_FSG_49_0_0_37_2_len", 0, profileFile ) );
    putValue( P_FSG_49_0_0_37_2_cnt, getProfileInt( "BAP", "P_FSG_49_0_0_37_2_cnt", 0, profileFile ) );
    putValue( M_FSG_49_0_0_38Result_BTN, getProfileInt( "BAP", "M_FSG_49_0_0_38Result_BTN", 0, profileFile ) );
    putValue( M_FSG_49_0_0_38_FctLstItemEn, getProfileInt( "BAP", "M_FSG_49_0_0_38_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_38_FctEn, getProfileInt( "BAP", "M_FSG_49_0_0_38_FctEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_38_ErrEn, getProfileInt( "BAP", "M_FSG_49_0_0_38_ErrEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_38_ErrCode, getProfileInt( "BAP", "M_FSG_49_0_0_38_ErrCode", 0, profileFile ) );
    putValue( M_FSG_49_0_0_38_Result, getProfileInt( "BAP", "M_FSG_49_0_0_38_Result", 0, profileFile ) );
    putValue( M_FSG_49_0_0_38_Result_1, getProfileInt( "BAP", "M_FSG_49_0_0_38_Result_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_38_Processing, getProfileInt( "BAP", "M_FSG_49_0_0_38_Processing", 0, profileFile ) );
    putValue( M_FSG_49_0_0_38_Processing_1, getProfileFloat( "BAP", "M_FSG_49_0_0_38_Processing_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_38_Processing_1_range, getProfileFloat( "BAP", "M_FSG_49_0_0_38_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_49_0_0_38_Start_1, getProfileInt( "BAP", "M_FSG_49_0_0_38_Start_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_38_Start_2, getProfileFloat( "BAP", "M_FSG_49_0_0_38_Start_2", 0, profileFile ) );
    putValue( M_FSG_49_0_0_38_Start_2_range, getProfileFloat( "BAP", "M_FSG_49_0_0_38_Start_2_range", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39Result_BTN, getProfileInt( "BAP", "M_FSG_49_0_0_39Result_BTN", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39_FctLstItemEn, getProfileInt( "BAP", "M_FSG_49_0_0_39_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39_FctEn, getProfileInt( "BAP", "M_FSG_49_0_0_39_FctEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39_ErrEn, getProfileInt( "BAP", "M_FSG_49_0_0_39_ErrEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39_IntTlgEn, getProfileInt( "BAP", "M_FSG_49_0_0_39_IntTlgEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39_SegmEn, getProfileInt( "BAP", "M_FSG_49_0_0_39_SegmEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39_ErrCode, getProfileInt( "BAP", "M_FSG_49_0_0_39_ErrCode", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39_Result_1, getProfileInt( "BAP", "M_FSG_49_0_0_39_Result_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39_Result_2_len, getProfileInt( "BAP", "M_FSG_49_0_0_39_Result_2_len", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39_Result_2_cnt, getProfileInt( "BAP", "M_FSG_49_0_0_39_Result_2_cnt", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39_Result_3_len, getProfileInt( "BAP", "M_FSG_49_0_0_39_Result_3_len", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39_Result_3_cnt, getProfileInt( "BAP", "M_FSG_49_0_0_39_Result_3_cnt", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39_Result_4_len, getProfileInt( "BAP", "M_FSG_49_0_0_39_Result_4_len", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39_Result_4_cnt, getProfileInt( "BAP", "M_FSG_49_0_0_39_Result_4_cnt", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39_Processing_1_len, getProfileInt( "BAP", "M_FSG_49_0_0_39_Processing_1_len", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39_Processing_1_cnt, getProfileInt( "BAP", "M_FSG_49_0_0_39_Processing_1_cnt", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39_Start, getProfileInt( "BAP", "M_FSG_49_0_0_39_Start", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39_Start_1, getProfileFloat( "BAP", "M_FSG_49_0_0_39_Start_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_39_Start_1_range, getProfileFloat( "BAP", "M_FSG_49_0_0_39_Start_1_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_40Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_40Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_40_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_40_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_40_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_40_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_40_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_40_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_40_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_40_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_40, getProfileInt( "BAP", "P_FSG_49_0_0_40", 0, profileFile ) );
    putValue( P_FSG_49_0_0_40_1, getProfileInt( "BAP", "P_FSG_49_0_0_40_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_41Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_41Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_41_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_41_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_41_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_41_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_41_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_41_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_41_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_41_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_41, getProfileInt( "BAP", "P_FSG_49_0_0_41", 0, profileFile ) );
    putValue( P_FSG_49_0_0_41_1, getProfileInt( "BAP", "P_FSG_49_0_0_41_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_42Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_42_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_42_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_42_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_IntTlgEn, getProfileInt( "BAP", "P_FSG_49_0_0_42_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_SegmEn, getProfileInt( "BAP", "P_FSG_49_0_0_42_SegmEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_42_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_3, getProfileInt( "BAP", "P_FSG_49_0_0_42_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_3_1, getProfileInt( "BAP", "P_FSG_49_0_0_42_3_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_3_4, getProfileInt( "BAP", "P_FSG_49_0_0_42_3_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_2, getProfileInt( "BAP", "P_FSG_49_0_0_42_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_2_0, getProfileInt( "BAP", "P_FSG_49_0_0_42_2_0", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_2_1, getProfileInt( "BAP", "P_FSG_49_0_0_42_2_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_2_3, getProfileInt( "BAP", "P_FSG_49_0_0_42_2_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_2_4, getProfileInt( "BAP", "P_FSG_49_0_0_42_2_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_2_5, getProfileInt( "BAP", "P_FSG_49_0_0_42_2_5", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_2_6, getProfileInt( "BAP", "P_FSG_49_0_0_42_2_6", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_2_7, getProfileInt( "BAP", "P_FSG_49_0_0_42_2_7", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_16, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_16", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_17, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_17", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_18, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_18", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_19, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_19", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_20, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_20", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_21, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_21", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_22, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_22", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_25, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_25", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_26, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_26", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_28, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_28", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_30, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_30", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_31, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_31", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_35, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_35", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_37, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_37", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_40, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_40", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_41, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_41", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_43, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_43", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_46, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_46", 0, profileFile ) );
    putValue( P_FSG_49_0_0_42_1_47, getProfileInt( "BAP", "P_FSG_49_0_0_42_1_47", 0, profileFile ) );
    putValue( P_FSG_49_0_0_43Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_43Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_43_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_43_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_43_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_43_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_43_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_43_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_43_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_43_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_43, getProfileInt( "BAP", "P_FSG_49_0_0_43", 0, profileFile ) );
    putValue( P_FSG_49_0_0_43_1, getProfileInt( "BAP", "P_FSG_49_0_0_43_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_43_1_0, getProfileInt( "BAP", "P_FSG_49_0_0_43_1_0", 0, profileFile ) );
    putValue( P_FSG_49_0_0_43_1_1, getProfileInt( "BAP", "P_FSG_49_0_0_43_1_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44Result_BTN, getProfileInt( "BAP", "M_FSG_49_0_0_44Result_BTN", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_FctLstItemEn, getProfileInt( "BAP", "M_FSG_49_0_0_44_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_FctEn, getProfileInt( "BAP", "M_FSG_49_0_0_44_FctEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_ErrEn, getProfileInt( "BAP", "M_FSG_49_0_0_44_ErrEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_IntTlgEn, getProfileInt( "BAP", "M_FSG_49_0_0_44_IntTlgEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_SegmEn, getProfileInt( "BAP", "M_FSG_49_0_0_44_SegmEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_ErrCode, getProfileInt( "BAP", "M_FSG_49_0_0_44_ErrCode", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Result_1, getProfileInt( "BAP", "M_FSG_49_0_0_44_Result_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Result_2, getProfileFloat( "BAP", "M_FSG_49_0_0_44_Result_2", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Result_2_range, getProfileFloat( "BAP", "M_FSG_49_0_0_44_Result_2_range", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Result_3, getProfileFloat( "BAP", "M_FSG_49_0_0_44_Result_3", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Result_3_range, getProfileFloat( "BAP", "M_FSG_49_0_0_44_Result_3_range", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Result_4, getProfileFloat( "BAP", "M_FSG_49_0_0_44_Result_4", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Result_4_range, getProfileFloat( "BAP", "M_FSG_49_0_0_44_Result_4_range", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Processing_1, getProfileFloat( "BAP", "M_FSG_49_0_0_44_Processing_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Processing_1_range, getProfileFloat( "BAP", "M_FSG_49_0_0_44_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Processing_2, getProfileFloat( "BAP", "M_FSG_49_0_0_44_Processing_2", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Processing_2_range, getProfileFloat( "BAP", "M_FSG_49_0_0_44_Processing_2_range", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Processing_3, getProfileFloat( "BAP", "M_FSG_49_0_0_44_Processing_3", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Processing_3_range, getProfileFloat( "BAP", "M_FSG_49_0_0_44_Processing_3_range", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Processing_4, getProfileFloat( "BAP", "M_FSG_49_0_0_44_Processing_4", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Processing_4_range, getProfileFloat( "BAP", "M_FSG_49_0_0_44_Processing_4_range", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Start_1, getProfileFloat( "BAP", "M_FSG_49_0_0_44_Start_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Start_1_range, getProfileFloat( "BAP", "M_FSG_49_0_0_44_Start_1_range", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Start_2, getProfileFloat( "BAP", "M_FSG_49_0_0_44_Start_2", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Start_2_range, getProfileFloat( "BAP", "M_FSG_49_0_0_44_Start_2_range", 0, profileFile ) );
    putValue( M_FSG_49_0_0_44_Start_3, getProfileInt( "BAP", "M_FSG_49_0_0_44_Start_3", 0, profileFile ) );
    putValue( M_FSG_49_0_0_45Result_BTN, getProfileInt( "BAP", "M_FSG_49_0_0_45Result_BTN", 0, profileFile ) );
    putValue( M_FSG_49_0_0_45_FctLstItemEn, getProfileInt( "BAP", "M_FSG_49_0_0_45_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_45_FctEn, getProfileInt( "BAP", "M_FSG_49_0_0_45_FctEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_45_ErrEn, getProfileInt( "BAP", "M_FSG_49_0_0_45_ErrEn", 0, profileFile ) );
    putValue( M_FSG_49_0_0_45_ErrCode, getProfileInt( "BAP", "M_FSG_49_0_0_45_ErrCode", 0, profileFile ) );
    putValue( M_FSG_49_0_0_45_Result, getProfileInt( "BAP", "M_FSG_49_0_0_45_Result", 0, profileFile ) );
    putValue( M_FSG_49_0_0_45_Result_1, getProfileInt( "BAP", "M_FSG_49_0_0_45_Result_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_45_Processing, getProfileInt( "BAP", "M_FSG_49_0_0_45_Processing", 0, profileFile ) );
    putValue( M_FSG_49_0_0_45_Processing_1, getProfileFloat( "BAP", "M_FSG_49_0_0_45_Processing_1", 0, profileFile ) );
    putValue( M_FSG_49_0_0_45_Processing_1_range, getProfileFloat( "BAP", "M_FSG_49_0_0_45_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_49_0_0_45_Start, getProfileInt( "BAP", "M_FSG_49_0_0_45_Start", 0, profileFile ) );
    putValue( M_FSG_49_0_0_45_Start_1, getProfileInt( "BAP", "M_FSG_49_0_0_45_Start_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_46Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_46Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_46_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_46_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_46_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_46_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_46_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_46_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_46_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_46_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_46_1, getProfileInt( "BAP", "P_FSG_49_0_0_46_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_46_2, getProfileFloat( "BAP", "P_FSG_49_0_0_46_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_46_2_range, getProfileFloat( "BAP", "P_FSG_49_0_0_46_2_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_46_3, getProfileInt( "BAP", "P_FSG_49_0_0_46_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_46_4, getProfileFloat( "BAP", "P_FSG_49_0_0_46_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_46_4_range, getProfileFloat( "BAP", "P_FSG_49_0_0_46_4_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_47Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_47Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_47_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_47_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_47_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_47_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_47_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_47_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_47_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_47_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_47_3, getProfileFloat( "BAP", "P_FSG_49_0_0_47_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_47_3_range, getProfileFloat( "BAP", "P_FSG_49_0_0_47_3_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_47_4, getProfileFloat( "BAP", "P_FSG_49_0_0_47_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_47_4_range, getProfileFloat( "BAP", "P_FSG_49_0_0_47_4_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_47_1, getProfileInt( "BAP", "P_FSG_49_0_0_47_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_47_2, getProfileInt( "BAP", "P_FSG_49_0_0_47_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_47_2_0, getProfileInt( "BAP", "P_FSG_49_0_0_47_2_0", 0, profileFile ) );
    putValue( P_FSG_49_0_0_48Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_48Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_48_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_48_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_48_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_48_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_48_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_48_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_48_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_48_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_48_2, getProfileFloat( "BAP", "P_FSG_49_0_0_48_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_48_2_range, getProfileFloat( "BAP", "P_FSG_49_0_0_48_2_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_48_1, getProfileInt( "BAP", "P_FSG_49_0_0_48_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_49Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_49Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_49_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_49_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_49_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_49_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_49_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_49_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_49_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_49_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_49_2, getProfileFloat( "BAP", "P_FSG_49_0_0_49_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_49_2_range, getProfileFloat( "BAP", "P_FSG_49_0_0_49_2_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_49_1, getProfileInt( "BAP", "P_FSG_49_0_0_49_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_49_3, getProfileFloat( "BAP", "P_FSG_49_0_0_49_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_49_3_range, getProfileFloat( "BAP", "P_FSG_49_0_0_49_3_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50Changed_BTN, getProfileInt( "BAP", "A_FSG_49_0_0_50Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50Status_BTN, getProfileInt( "BAP", "A_FSG_49_0_0_50Status_BTN", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_FctLstItemEn, getProfileInt( "BAP", "A_FSG_49_0_0_50_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_FctEn, getProfileInt( "BAP", "A_FSG_49_0_0_50_FctEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_ErrEn, getProfileInt( "BAP", "A_FSG_49_0_0_50_ErrEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_IntTlgEn, getProfileInt( "BAP", "A_FSG_49_0_0_50_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_SegmEn, getProfileInt( "BAP", "A_FSG_49_0_0_50_SegmEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_AT, getProfileInt( "BAP", "A_FSG_49_0_0_50_AT", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_ErrCode, getProfileInt( "BAP", "A_FSG_49_0_0_50_ErrCode", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_DataIndex, getProfileInt( "BAP", "A_FSG_49_0_0_50_DataIndex", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_49_0_0_50_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_49_0_0_50_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_loadArray_Btn, getProfileInt( "BAP", "A_FSG_49_0_0_50_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_generateData_Btn, getProfileInt( "BAP", "A_FSG_49_0_0_50_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_8_len, getProfileInt( "BAP", "A_FSG_49_0_0_50_Data_8_len", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_8_cnt, getProfileInt( "BAP", "A_FSG_49_0_0_50_Data_8_cnt", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_2, getProfileInt( "BAP", "A_FSG_49_0_0_50_Data_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_2_0, getProfileInt( "BAP", "A_FSG_49_0_0_50_Data_2_0", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_2_1, getProfileInt( "BAP", "A_FSG_49_0_0_50_Data_2_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_2_2, getProfileInt( "BAP", "A_FSG_49_0_0_50_Data_2_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_2_3, getProfileInt( "BAP", "A_FSG_49_0_0_50_Data_2_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_2_4, getProfileInt( "BAP", "A_FSG_49_0_0_50_Data_2_4", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_2_5, getProfileInt( "BAP", "A_FSG_49_0_0_50_Data_2_5", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_2_6, getProfileInt( "BAP", "A_FSG_49_0_0_50_Data_2_6", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_3, getProfileFloat( "BAP", "A_FSG_49_0_0_50_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_3_range, getProfileFloat( "BAP", "A_FSG_49_0_0_50_3_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_1, getProfileInt( "BAP", "A_FSG_49_0_0_50_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_4_len, getProfileInt( "BAP", "A_FSG_49_0_0_50_Data_4_len", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_4_cnt, getProfileInt( "BAP", "A_FSG_49_0_0_50_Data_4_cnt", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_6, getProfileInt( "BAP", "A_FSG_49_0_0_50_Data_6", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_1, getProfileFloat( "BAP", "A_FSG_49_0_0_50_Data_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_1_range, getProfileFloat( "BAP", "A_FSG_49_0_0_50_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_5_len, getProfileInt( "BAP", "A_FSG_49_0_0_50_Data_5_len", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_5_cnt, getProfileInt( "BAP", "A_FSG_49_0_0_50_Data_5_cnt", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_2, getProfileFloat( "BAP", "A_FSG_49_0_0_50_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_2_range, getProfileFloat( "BAP", "A_FSG_49_0_0_50_2_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_7_len, getProfileInt( "BAP", "A_FSG_49_0_0_50_Data_7_len", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_7_cnt, getProfileInt( "BAP", "A_FSG_49_0_0_50_Data_7_cnt", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_3, getProfileFloat( "BAP", "A_FSG_49_0_0_50_Data_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Data_3_range, getProfileFloat( "BAP", "A_FSG_49_0_0_50_Data_3_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_50_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_50_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_50_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_TransPos, getProfileInt( "BAP", "A_FSG_49_0_0_50_TransPos", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_50_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Start, getProfileInt( "BAP", "A_FSG_49_0_0_50_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_50_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_50_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Changed_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_50_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Changed_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_50_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Changed_TransPos, getProfileInt( "BAP", "A_FSG_49_0_0_50_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_50_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Changed_Start, getProfileInt( "BAP", "A_FSG_49_0_0_50_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_Changed_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_50_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_2_SetGet, getProfileFloat( "BAP", "A_FSG_49_0_0_50_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_49_0_0_50_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_1_SetGet, getProfileInt( "BAP", "A_FSG_49_0_0_50_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_50_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_SetGet_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_50_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_SetGet_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_50_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_50_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_SetGet_Start, getProfileInt( "BAP", "A_FSG_49_0_0_50_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_50_SetGet_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_50_SetGet_Elements", 0, profileFile ) );
    putValue( P_FSG_49_0_0_51Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_51Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_51_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_51_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_51_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_51_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_51_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_51_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_51_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_51_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_51_4, getProfileFloat( "BAP", "P_FSG_49_0_0_51_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_51_4_range, getProfileFloat( "BAP", "P_FSG_49_0_0_51_4_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_51_1, getProfileFloat( "BAP", "P_FSG_49_0_0_51_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_51_1_range, getProfileFloat( "BAP", "P_FSG_49_0_0_51_1_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_51_2, getProfileFloat( "BAP", "P_FSG_49_0_0_51_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_51_2_range, getProfileFloat( "BAP", "P_FSG_49_0_0_51_2_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_51_3, getProfileFloat( "BAP", "P_FSG_49_0_0_51_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_51_3_range, getProfileFloat( "BAP", "P_FSG_49_0_0_51_3_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_52Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_52Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_52_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_52_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_52_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_52_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_52_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_52_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_52_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_52_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_52_4, getProfileFloat( "BAP", "P_FSG_49_0_0_52_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_52_4_range, getProfileFloat( "BAP", "P_FSG_49_0_0_52_4_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_52_1, getProfileFloat( "BAP", "P_FSG_49_0_0_52_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_52_1_range, getProfileFloat( "BAP", "P_FSG_49_0_0_52_1_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_52_2, getProfileFloat( "BAP", "P_FSG_49_0_0_52_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_52_2_range, getProfileFloat( "BAP", "P_FSG_49_0_0_52_2_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_52_3, getProfileInt( "BAP", "P_FSG_49_0_0_52_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_52_3_0, getProfileInt( "BAP", "P_FSG_49_0_0_52_3_0", 0, profileFile ) );
    putValue( P_FSG_49_0_0_53Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_53Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_53_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_53_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_53_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_53_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_53_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_53_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_53_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_53_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_53_4, getProfileFloat( "BAP", "P_FSG_49_0_0_53_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_53_4_range, getProfileFloat( "BAP", "P_FSG_49_0_0_53_4_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_53_3, getProfileFloat( "BAP", "P_FSG_49_0_0_53_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_53_3_range, getProfileFloat( "BAP", "P_FSG_49_0_0_53_3_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_53_2, getProfileFloat( "BAP", "P_FSG_49_0_0_53_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_53_2_range, getProfileFloat( "BAP", "P_FSG_49_0_0_53_2_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_53_6, getProfileFloat( "BAP", "P_FSG_49_0_0_53_6", 0, profileFile ) );
    putValue( P_FSG_49_0_0_53_6_range, getProfileFloat( "BAP", "P_FSG_49_0_0_53_6_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_53_5, getProfileFloat( "BAP", "P_FSG_49_0_0_53_5", 0, profileFile ) );
    putValue( P_FSG_49_0_0_53_5_range, getProfileFloat( "BAP", "P_FSG_49_0_0_53_5_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_53_1, getProfileFloat( "BAP", "P_FSG_49_0_0_53_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_53_1_range, getProfileFloat( "BAP", "P_FSG_49_0_0_53_1_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_54Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_54_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_54_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_54_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_IntTlgEn, getProfileInt( "BAP", "P_FSG_49_0_0_54_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_SegmEn, getProfileInt( "BAP", "P_FSG_49_0_0_54_SegmEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_54_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_16_len, getProfileInt( "BAP", "P_FSG_49_0_0_54_16_len", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_16_cnt, getProfileInt( "BAP", "P_FSG_49_0_0_54_16_cnt", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_14_len, getProfileInt( "BAP", "P_FSG_49_0_0_54_14_len", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_14_cnt, getProfileInt( "BAP", "P_FSG_49_0_0_54_14_cnt", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_12_len, getProfileInt( "BAP", "P_FSG_49_0_0_54_12_len", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_12_cnt, getProfileInt( "BAP", "P_FSG_49_0_0_54_12_cnt", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_10_len, getProfileInt( "BAP", "P_FSG_49_0_0_54_10_len", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_10_cnt, getProfileInt( "BAP", "P_FSG_49_0_0_54_10_cnt", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_8_len, getProfileInt( "BAP", "P_FSG_49_0_0_54_8_len", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_8_cnt, getProfileInt( "BAP", "P_FSG_49_0_0_54_8_cnt", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_6_len, getProfileInt( "BAP", "P_FSG_49_0_0_54_6_len", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_6_cnt, getProfileInt( "BAP", "P_FSG_49_0_0_54_6_cnt", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_4_len, getProfileInt( "BAP", "P_FSG_49_0_0_54_4_len", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_4_cnt, getProfileInt( "BAP", "P_FSG_49_0_0_54_4_cnt", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_1_len, getProfileInt( "BAP", "P_FSG_49_0_0_54_1_len", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_1_cnt, getProfileInt( "BAP", "P_FSG_49_0_0_54_1_cnt", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_19, getProfileInt( "BAP", "P_FSG_49_0_0_54_19", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_19_0, getProfileInt( "BAP", "P_FSG_49_0_0_54_19_0", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_19_1, getProfileInt( "BAP", "P_FSG_49_0_0_54_19_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_19_2, getProfileInt( "BAP", "P_FSG_49_0_0_54_19_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_19_3, getProfileInt( "BAP", "P_FSG_49_0_0_54_19_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_19_4, getProfileInt( "BAP", "P_FSG_49_0_0_54_19_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_19_5, getProfileInt( "BAP", "P_FSG_49_0_0_54_19_5", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_19_6, getProfileInt( "BAP", "P_FSG_49_0_0_54_19_6", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_3, getProfileFloat( "BAP", "P_FSG_49_0_0_54_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_3_range, getProfileFloat( "BAP", "P_FSG_49_0_0_54_3_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_20, getProfileFloat( "BAP", "P_FSG_49_0_0_54_20", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_20_range, getProfileFloat( "BAP", "P_FSG_49_0_0_54_20_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_17, getProfileInt( "BAP", "P_FSG_49_0_0_54_17", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_18, getProfileInt( "BAP", "P_FSG_49_0_0_54_18", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_18_0, getProfileInt( "BAP", "P_FSG_49_0_0_54_18_0", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_18_1, getProfileInt( "BAP", "P_FSG_49_0_0_54_18_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_18_2, getProfileInt( "BAP", "P_FSG_49_0_0_54_18_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_18_3, getProfileInt( "BAP", "P_FSG_49_0_0_54_18_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_18_4, getProfileInt( "BAP", "P_FSG_49_0_0_54_18_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_15, getProfileInt( "BAP", "P_FSG_49_0_0_54_15", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_13, getProfileInt( "BAP", "P_FSG_49_0_0_54_13", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_11, getProfileInt( "BAP", "P_FSG_49_0_0_54_11", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_9, getProfileInt( "BAP", "P_FSG_49_0_0_54_9", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_7, getProfileInt( "BAP", "P_FSG_49_0_0_54_7", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_5, getProfileInt( "BAP", "P_FSG_49_0_0_54_5", 0, profileFile ) );
    putValue( P_FSG_49_0_0_54_2, getProfileInt( "BAP", "P_FSG_49_0_0_54_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_55Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_55Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_55_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_55_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_55_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_55_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_55_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_55_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_55_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_55_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_55_4, getProfileFloat( "BAP", "P_FSG_49_0_0_55_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_55_4_range, getProfileFloat( "BAP", "P_FSG_49_0_0_55_4_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_55_3, getProfileFloat( "BAP", "P_FSG_49_0_0_55_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_55_3_range, getProfileFloat( "BAP", "P_FSG_49_0_0_55_3_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_55_1, getProfileFloat( "BAP", "P_FSG_49_0_0_55_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_55_1_range, getProfileFloat( "BAP", "P_FSG_49_0_0_55_1_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_55_6, getProfileFloat( "BAP", "P_FSG_49_0_0_55_6", 0, profileFile ) );
    putValue( P_FSG_49_0_0_55_6_range, getProfileFloat( "BAP", "P_FSG_49_0_0_55_6_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_55_2, getProfileFloat( "BAP", "P_FSG_49_0_0_55_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_55_2_range, getProfileFloat( "BAP", "P_FSG_49_0_0_55_2_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_55_5, getProfileFloat( "BAP", "P_FSG_49_0_0_55_5", 0, profileFile ) );
    putValue( P_FSG_49_0_0_55_5_range, getProfileFloat( "BAP", "P_FSG_49_0_0_55_5_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56Changed_BTN, getProfileInt( "BAP", "A_FSG_49_0_0_56Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56Status_BTN, getProfileInt( "BAP", "A_FSG_49_0_0_56Status_BTN", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_FctLstItemEn, getProfileInt( "BAP", "A_FSG_49_0_0_56_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_FctEn, getProfileInt( "BAP", "A_FSG_49_0_0_56_FctEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_ErrEn, getProfileInt( "BAP", "A_FSG_49_0_0_56_ErrEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_IntTlgEn, getProfileInt( "BAP", "A_FSG_49_0_0_56_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_SegmEn, getProfileInt( "BAP", "A_FSG_49_0_0_56_SegmEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_AT, getProfileInt( "BAP", "A_FSG_49_0_0_56_AT", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_ErrCode, getProfileInt( "BAP", "A_FSG_49_0_0_56_ErrCode", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_DataIndex, getProfileInt( "BAP", "A_FSG_49_0_0_56_DataIndex", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_49_0_0_56_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_49_0_0_56_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_loadArray_Btn, getProfileInt( "BAP", "A_FSG_49_0_0_56_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_generateData_Btn, getProfileInt( "BAP", "A_FSG_49_0_0_56_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_4, getProfileInt( "BAP", "A_FSG_49_0_0_56_Data_4", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_4_0, getProfileInt( "BAP", "A_FSG_49_0_0_56_Data_4_0", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_4_1, getProfileInt( "BAP", "A_FSG_49_0_0_56_Data_4_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_4_2, getProfileInt( "BAP", "A_FSG_49_0_0_56_Data_4_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_4_3, getProfileInt( "BAP", "A_FSG_49_0_0_56_Data_4_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_4_4, getProfileInt( "BAP", "A_FSG_49_0_0_56_Data_4_4", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_4_5, getProfileInt( "BAP", "A_FSG_49_0_0_56_Data_4_5", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_4_6, getProfileInt( "BAP", "A_FSG_49_0_0_56_Data_4_6", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_4_7, getProfileInt( "BAP", "A_FSG_49_0_0_56_Data_4_7", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_4_8, getProfileInt( "BAP", "A_FSG_49_0_0_56_Data_4_8", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_4_9, getProfileInt( "BAP", "A_FSG_49_0_0_56_Data_4_9", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_4_10, getProfileInt( "BAP", "A_FSG_49_0_0_56_Data_4_10", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_4_11, getProfileInt( "BAP", "A_FSG_49_0_0_56_Data_4_11", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_3, getProfileFloat( "BAP", "A_FSG_49_0_0_56_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_3_range, getProfileFloat( "BAP", "A_FSG_49_0_0_56_3_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_1, getProfileInt( "BAP", "A_FSG_49_0_0_56_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_3, getProfileInt( "BAP", "A_FSG_49_0_0_56_Data_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_5_len, getProfileInt( "BAP", "A_FSG_49_0_0_56_Data_5_len", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_5_cnt, getProfileInt( "BAP", "A_FSG_49_0_0_56_Data_5_cnt", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_2, getProfileFloat( "BAP", "A_FSG_49_0_0_56_Data_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_2_range, getProfileFloat( "BAP", "A_FSG_49_0_0_56_Data_2_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_1, getProfileFloat( "BAP", "A_FSG_49_0_0_56_Data_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_1_range, getProfileFloat( "BAP", "A_FSG_49_0_0_56_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_6_len, getProfileInt( "BAP", "A_FSG_49_0_0_56_Data_6_len", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Data_6_cnt, getProfileInt( "BAP", "A_FSG_49_0_0_56_Data_6_cnt", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_2, getProfileFloat( "BAP", "A_FSG_49_0_0_56_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_2_range, getProfileFloat( "BAP", "A_FSG_49_0_0_56_2_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_56_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_56_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_56_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_TransPos, getProfileInt( "BAP", "A_FSG_49_0_0_56_TransPos", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_56_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Start, getProfileInt( "BAP", "A_FSG_49_0_0_56_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_56_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_56_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Changed_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_56_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Changed_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_56_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Changed_TransPos, getProfileInt( "BAP", "A_FSG_49_0_0_56_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_56_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Changed_Start, getProfileInt( "BAP", "A_FSG_49_0_0_56_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_Changed_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_56_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_2_SetGet, getProfileFloat( "BAP", "A_FSG_49_0_0_56_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_49_0_0_56_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_1_SetGet, getProfileInt( "BAP", "A_FSG_49_0_0_56_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_56_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_SetGet_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_56_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_SetGet_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_56_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_56_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_SetGet_Start, getProfileInt( "BAP", "A_FSG_49_0_0_56_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_56_SetGet_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_56_SetGet_Elements", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_57Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_57_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_57_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_57_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_IntTlgEn, getProfileInt( "BAP", "P_FSG_49_0_0_57_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_SegmEn, getProfileInt( "BAP", "P_FSG_49_0_0_57_SegmEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_57_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_6, getProfileFloat( "BAP", "P_FSG_49_0_0_57_6", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_6_range, getProfileFloat( "BAP", "P_FSG_49_0_0_57_6_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_5, getProfileFloat( "BAP", "P_FSG_49_0_0_57_5", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_5_range, getProfileFloat( "BAP", "P_FSG_49_0_0_57_5_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_2_len, getProfileInt( "BAP", "P_FSG_49_0_0_57_2_len", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_2_cnt, getProfileInt( "BAP", "P_FSG_49_0_0_57_2_cnt", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_4, getProfileFloat( "BAP", "P_FSG_49_0_0_57_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_4_range, getProfileFloat( "BAP", "P_FSG_49_0_0_57_4_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_1, getProfileInt( "BAP", "P_FSG_49_0_0_57_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_3_len, getProfileInt( "BAP", "P_FSG_49_0_0_57_3_len", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_3_cnt, getProfileInt( "BAP", "P_FSG_49_0_0_57_3_cnt", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_7, getProfileFloat( "BAP", "P_FSG_49_0_0_57_7", 0, profileFile ) );
    putValue( P_FSG_49_0_0_57_7_range, getProfileFloat( "BAP", "P_FSG_49_0_0_57_7_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58Changed_BTN, getProfileInt( "BAP", "A_FSG_49_0_0_58Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58Status_BTN, getProfileInt( "BAP", "A_FSG_49_0_0_58Status_BTN", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_FctLstItemEn, getProfileInt( "BAP", "A_FSG_49_0_0_58_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_FctEn, getProfileInt( "BAP", "A_FSG_49_0_0_58_FctEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_ErrEn, getProfileInt( "BAP", "A_FSG_49_0_0_58_ErrEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_IntTlgEn, getProfileInt( "BAP", "A_FSG_49_0_0_58_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_SegmEn, getProfileInt( "BAP", "A_FSG_49_0_0_58_SegmEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_AT, getProfileInt( "BAP", "A_FSG_49_0_0_58_AT", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_ErrCode, getProfileInt( "BAP", "A_FSG_49_0_0_58_ErrCode", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_DataIndex, getProfileInt( "BAP", "A_FSG_49_0_0_58_DataIndex", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_49_0_0_58_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_49_0_0_58_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_loadArray_Btn, getProfileInt( "BAP", "A_FSG_49_0_0_58_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_generateData_Btn, getProfileInt( "BAP", "A_FSG_49_0_0_58_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_3, getProfileFloat( "BAP", "A_FSG_49_0_0_58_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_3_range, getProfileFloat( "BAP", "A_FSG_49_0_0_58_3_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_1, getProfileInt( "BAP", "A_FSG_49_0_0_58_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Data_6_len, getProfileInt( "BAP", "A_FSG_49_0_0_58_Data_6_len", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Data_6_cnt, getProfileInt( "BAP", "A_FSG_49_0_0_58_Data_6_cnt", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Data_1, getProfileFloat( "BAP", "A_FSG_49_0_0_58_Data_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Data_1_range, getProfileFloat( "BAP", "A_FSG_49_0_0_58_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Data_3, getProfileFloat( "BAP", "A_FSG_49_0_0_58_Data_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Data_3_range, getProfileFloat( "BAP", "A_FSG_49_0_0_58_Data_3_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_2, getProfileFloat( "BAP", "A_FSG_49_0_0_58_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_2_range, getProfileFloat( "BAP", "A_FSG_49_0_0_58_2_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Data_4_len, getProfileInt( "BAP", "A_FSG_49_0_0_58_Data_4_len", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Data_4_cnt, getProfileInt( "BAP", "A_FSG_49_0_0_58_Data_4_cnt", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Data_5, getProfileFloat( "BAP", "A_FSG_49_0_0_58_Data_5", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Data_5_range, getProfileFloat( "BAP", "A_FSG_49_0_0_58_Data_5_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Data_2, getProfileInt( "BAP", "A_FSG_49_0_0_58_Data_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_58_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_58_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_58_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_TransPos, getProfileInt( "BAP", "A_FSG_49_0_0_58_TransPos", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_58_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Start, getProfileInt( "BAP", "A_FSG_49_0_0_58_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_58_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_58_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Changed_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_58_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Changed_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_58_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Changed_TransPos, getProfileInt( "BAP", "A_FSG_49_0_0_58_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_58_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Changed_Start, getProfileInt( "BAP", "A_FSG_49_0_0_58_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_Changed_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_58_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_2_SetGet, getProfileFloat( "BAP", "A_FSG_49_0_0_58_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_49_0_0_58_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_1_SetGet, getProfileInt( "BAP", "A_FSG_49_0_0_58_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_58_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_SetGet_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_58_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_SetGet_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_58_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_58_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_SetGet_Start, getProfileInt( "BAP", "A_FSG_49_0_0_58_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_58_SetGet_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_58_SetGet_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59Changed_BTN, getProfileInt( "BAP", "A_FSG_49_0_0_59Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59Status_BTN, getProfileInt( "BAP", "A_FSG_49_0_0_59Status_BTN", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_FctLstItemEn, getProfileInt( "BAP", "A_FSG_49_0_0_59_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_FctEn, getProfileInt( "BAP", "A_FSG_49_0_0_59_FctEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_ErrEn, getProfileInt( "BAP", "A_FSG_49_0_0_59_ErrEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_IntTlgEn, getProfileInt( "BAP", "A_FSG_49_0_0_59_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_SegmEn, getProfileInt( "BAP", "A_FSG_49_0_0_59_SegmEn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_AT, getProfileInt( "BAP", "A_FSG_49_0_0_59_AT", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_ErrCode, getProfileInt( "BAP", "A_FSG_49_0_0_59_ErrCode", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_DataIndex, getProfileInt( "BAP", "A_FSG_49_0_0_59_DataIndex", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_49_0_0_59_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_49_0_0_59_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_loadArray_Btn, getProfileInt( "BAP", "A_FSG_49_0_0_59_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_generateData_Btn, getProfileInt( "BAP", "A_FSG_49_0_0_59_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_4, getProfileInt( "BAP", "A_FSG_49_0_0_59_Data_4", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_4_0, getProfileInt( "BAP", "A_FSG_49_0_0_59_Data_4_0", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_4_1, getProfileInt( "BAP", "A_FSG_49_0_0_59_Data_4_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_4_2, getProfileInt( "BAP", "A_FSG_49_0_0_59_Data_4_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_4_3, getProfileInt( "BAP", "A_FSG_49_0_0_59_Data_4_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_4_4, getProfileInt( "BAP", "A_FSG_49_0_0_59_Data_4_4", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_4_5, getProfileInt( "BAP", "A_FSG_49_0_0_59_Data_4_5", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_4_6, getProfileInt( "BAP", "A_FSG_49_0_0_59_Data_4_6", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_4_7, getProfileInt( "BAP", "A_FSG_49_0_0_59_Data_4_7", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_4_8, getProfileInt( "BAP", "A_FSG_49_0_0_59_Data_4_8", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_4_9, getProfileInt( "BAP", "A_FSG_49_0_0_59_Data_4_9", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_4_10, getProfileInt( "BAP", "A_FSG_49_0_0_59_Data_4_10", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_4_11, getProfileInt( "BAP", "A_FSG_49_0_0_59_Data_4_11", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_3, getProfileFloat( "BAP", "A_FSG_49_0_0_59_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_3_range, getProfileFloat( "BAP", "A_FSG_49_0_0_59_3_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_1, getProfileInt( "BAP", "A_FSG_49_0_0_59_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_3, getProfileInt( "BAP", "A_FSG_49_0_0_59_Data_3", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_5_len, getProfileInt( "BAP", "A_FSG_49_0_0_59_Data_5_len", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_5_cnt, getProfileInt( "BAP", "A_FSG_49_0_0_59_Data_5_cnt", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_2, getProfileFloat( "BAP", "A_FSG_49_0_0_59_Data_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_2_range, getProfileFloat( "BAP", "A_FSG_49_0_0_59_Data_2_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_1, getProfileFloat( "BAP", "A_FSG_49_0_0_59_Data_1", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_1_range, getProfileFloat( "BAP", "A_FSG_49_0_0_59_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_6_len, getProfileInt( "BAP", "A_FSG_49_0_0_59_Data_6_len", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Data_6_cnt, getProfileInt( "BAP", "A_FSG_49_0_0_59_Data_6_cnt", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_2, getProfileFloat( "BAP", "A_FSG_49_0_0_59_2", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_2_range, getProfileFloat( "BAP", "A_FSG_49_0_0_59_2_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_59_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_59_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_59_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_TransPos, getProfileInt( "BAP", "A_FSG_49_0_0_59_TransPos", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_59_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Start, getProfileInt( "BAP", "A_FSG_49_0_0_59_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_59_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_59_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Changed_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_59_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Changed_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_59_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Changed_TransPos, getProfileInt( "BAP", "A_FSG_49_0_0_59_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_59_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Changed_Start, getProfileInt( "BAP", "A_FSG_49_0_0_59_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_Changed_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_59_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_2_SetGet, getProfileFloat( "BAP", "A_FSG_49_0_0_59_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_49_0_0_59_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_1_SetGet, getProfileInt( "BAP", "A_FSG_49_0_0_59_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_49_0_0_59_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_SetGet_Direction, getProfileInt( "BAP", "A_FSG_49_0_0_59_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_SetGet_Shift, getProfileInt( "BAP", "A_FSG_49_0_0_59_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_49_0_0_59_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_SetGet_Start, getProfileInt( "BAP", "A_FSG_49_0_0_59_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_49_0_0_59_SetGet_Elements, getProfileInt( "BAP", "A_FSG_49_0_0_59_SetGet_Elements", 0, profileFile ) );
    putValue( P_FSG_49_0_0_60Status_BTN, getProfileInt( "BAP", "P_FSG_49_0_0_60Status_BTN", 0, profileFile ) );
    putValue( P_FSG_49_0_0_60_FctLstItemEn, getProfileInt( "BAP", "P_FSG_49_0_0_60_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_60_FctEn, getProfileInt( "BAP", "P_FSG_49_0_0_60_FctEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_60_ErrEn, getProfileInt( "BAP", "P_FSG_49_0_0_60_ErrEn", 0, profileFile ) );
    putValue( P_FSG_49_0_0_60_ErrCode, getProfileInt( "BAP", "P_FSG_49_0_0_60_ErrCode", 0, profileFile ) );
    putValue( P_FSG_49_0_0_60_5, getProfileFloat( "BAP", "P_FSG_49_0_0_60_5", 0, profileFile ) );
    putValue( P_FSG_49_0_0_60_5_range, getProfileFloat( "BAP", "P_FSG_49_0_0_60_5_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_60_4, getProfileFloat( "BAP", "P_FSG_49_0_0_60_4", 0, profileFile ) );
    putValue( P_FSG_49_0_0_60_4_range, getProfileFloat( "BAP", "P_FSG_49_0_0_60_4_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_60_1, getProfileInt( "BAP", "P_FSG_49_0_0_60_1", 0, profileFile ) );
    putValue( P_FSG_49_0_0_60_8, getProfileFloat( "BAP", "P_FSG_49_0_0_60_8", 0, profileFile ) );
    putValue( P_FSG_49_0_0_60_8_range, getProfileFloat( "BAP", "P_FSG_49_0_0_60_8_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_60_3, getProfileInt( "BAP", "P_FSG_49_0_0_60_3", 0, profileFile ) );
    putValue( P_FSG_49_0_0_60_2, getProfileInt( "BAP", "P_FSG_49_0_0_60_2", 0, profileFile ) );
    putValue( P_FSG_49_0_0_60_7, getProfileFloat( "BAP", "P_FSG_49_0_0_60_7", 0, profileFile ) );
    putValue( P_FSG_49_0_0_60_7_range, getProfileFloat( "BAP", "P_FSG_49_0_0_60_7_range", 0, profileFile ) );
    putValue( P_FSG_49_0_0_60_6, getProfileFloat( "BAP", "P_FSG_49_0_0_60_6", 0, profileFile ) );
    putValue( P_FSG_49_0_0_60_6_range, getProfileFloat( "BAP", "P_FSG_49_0_0_60_6_range", 0, profileFile ) );
    putValue( C_FSG_50_0_0_0_1_FctLstItemEn, getProfileInt( "BAP", "C_FSG_50_0_0_0_1_FctLstItemEn", 0, profileFile ) );
    putValue( C_FSG_50_0_0_0_1_FctEn, getProfileInt( "BAP", "C_FSG_50_0_0_0_1_FctEn", 0, profileFile ) );
    putValue( C_FSG_50_0_0_0_1_ErrEn, getProfileInt( "BAP", "C_FSG_50_0_0_0_1_ErrEn", 0, profileFile ) );
    putValue( C_FSG_50_0_0_0_1_IntTlgEn, getProfileInt( "BAP", "C_FSG_50_0_0_0_1_IntTlgEn", 0, profileFile ) );
    putValue( C_FSG_50_0_0_0_1_SegmEn, getProfileInt( "BAP", "C_FSG_50_0_0_0_1_SegmEn", 0, profileFile ) );
    putValue( C_FSG_50_0_0_0_1_ErrCode, getProfileInt( "BAP", "C_FSG_50_0_0_0_1_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_0_2Reset_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_0_2Reset_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_0_2_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_0_2_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_0_2_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_0_2_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_0_2_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_0_2_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_0_2_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_0_2_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_0_3_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_0_3_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_0_3_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_0_3_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_0_3_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_0_3_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_0_3_IntTlgEn, getProfileInt( "BAP", "P_FSG_50_0_0_0_3_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_0_3_SegmEn, getProfileInt( "BAP", "P_FSG_50_0_0_0_3_SegmEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_0_3_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_0_3_ErrCode", 0, profileFile ) );
    putValue( FSG50_0_0_Channel, getProfileInt( "BAP", "FSG50_0_0_Channel", 0, profileFile ) );
    putValue( FSG50_0_0_BusType, getProfileInt( "BAP", "FSG50_0_0_BusType", 0, profileFile ) );
    putValue( FSG50_0_1_Channel, getProfileInt( "BAP", "FSG50_0_1_Channel", 0, profileFile ) );
    putValue( FSG50_0_1_BusType, getProfileInt( "BAP", "FSG50_0_1_BusType", 0, profileFile ) );
    putValue( FSG50_0_2_Channel, getProfileInt( "BAP", "FSG50_0_2_Channel", 0, profileFile ) );
    putValue( FSG50_0_2_BusType, getProfileInt( "BAP", "FSG50_0_2_BusType", 0, profileFile ) );
    putValue( FSG50_0_3_Channel, getProfileInt( "BAP", "FSG50_0_3_Channel", 0, profileFile ) );
    putValue( FSG50_0_3_BusType, getProfileInt( "BAP", "FSG50_0_3_BusType", 0, profileFile ) );
    putValue( FSG50_0_4_Channel, getProfileInt( "BAP", "FSG50_0_4_Channel", 0, profileFile ) );
    putValue( FSG50_0_4_BusType, getProfileInt( "BAP", "FSG50_0_4_BusType", 0, profileFile ) );
    putValue( FSG50_0_5_Channel, getProfileInt( "BAP", "FSG50_0_5_Channel", 0, profileFile ) );
    putValue( FSG50_0_5_BusType, getProfileInt( "BAP", "FSG50_0_5_BusType", 0, profileFile ) );
    putValue( FSG50_0_6_Channel, getProfileInt( "BAP", "FSG50_0_6_Channel", 0, profileFile ) );
    putValue( FSG50_0_6_BusType, getProfileInt( "BAP", "FSG50_0_6_BusType", 0, profileFile ) );
    putValue( FSG50_0_7_Channel, getProfileInt( "BAP", "FSG50_0_7_Channel", 0, profileFile ) );
    putValue( FSG50_0_7_BusType, getProfileInt( "BAP", "FSG50_0_7_BusType", 0, profileFile ) );
    putValue( ERRORLIST_FSG50_0_VT, getProfileInt( "BAP", "ERRORLIST_FSG50_0_VT", 0, profileFile ) );
    putValue( BusType_FSG50_0, getProfileInt( "BAP", "BusType_FSG50_0", 0, profileFile ) );
    putValue( ON_OFF_FSG50_0, getProfileInt( "BAP", "ON_OFF_FSG50_0", 0, profileFile ) );
    putValue( BAPCFG_FSG_50_0_0_DFMajor, getProfileInt( "BAP", "BAPCFG_FSG_50_0_0_DFMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_50_0_0_DFMinor, getProfileInt( "BAP", "BAPCFG_FSG_50_0_0_DFMinor", 0, profileFile ) );
    putValue( BAPCFG_FSG_50_0_0_LsgClassMajor, getProfileInt( "BAP", "BAPCFG_FSG_50_0_0_LsgClassMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_50_0_0_LsgClassMinor, getProfileInt( "BAP", "BAPCFG_FSG_50_0_0_LsgClassMinor", 0, profileFile ) );
    putValue( BAPCFG_FSG_50_0_0_ProtocolMajor, getProfileInt( "BAP", "BAPCFG_FSG_50_0_0_ProtocolMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_50_0_0_ProtocolMinor, getProfileInt( "BAP", "BAPCFG_FSG_50_0_0_ProtocolMinor", 0, profileFile ) );
    putValue( C_FSG_50_0_0_1_FctLstItemEn, getProfileInt( "BAP", "C_FSG_50_0_0_1_FctLstItemEn", 0, profileFile ) );
    putValue( C_FSG_50_0_0_1_FctEn, getProfileInt( "BAP", "C_FSG_50_0_0_1_FctEn", 0, profileFile ) );
    putValue( C_FSG_50_0_0_1_ErrEn, getProfileInt( "BAP", "C_FSG_50_0_0_1_ErrEn", 0, profileFile ) );
    putValue( C_FSG_50_0_0_1_IntTlgEn, getProfileInt( "BAP", "C_FSG_50_0_0_1_IntTlgEn", 0, profileFile ) );
    putValue( C_FSG_50_0_0_1_SegmEn, getProfileInt( "BAP", "C_FSG_50_0_0_1_SegmEn", 0, profileFile ) );
    putValue( C_FSG_50_0_0_1_ErrCode, getProfileInt( "BAP", "C_FSG_50_0_0_1_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_2Reset_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_2Reset_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_2_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_2_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_2_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_2_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_2_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_2_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_2_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_2_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_2, getProfileFloat( "BAP", "P_FSG_50_0_0_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_2_range, getProfileFloat( "BAP", "P_FSG_50_0_0_2_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_3Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_3Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_3_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_3_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_3_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_3_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_3_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_3_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_3_IntTlgEn, getProfileInt( "BAP", "P_FSG_50_0_0_3_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_3_SegmEn, getProfileInt( "BAP", "P_FSG_50_0_0_3_SegmEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_3_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_3_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_4Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_4Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_4_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_4_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_4_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_4_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_4_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_4_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_4_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_4_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_4, getProfileInt( "BAP", "P_FSG_50_0_0_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_15Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_15Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_15_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_15_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_15_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_15_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_15_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_15_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_15_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_15_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_15, getProfileInt( "BAP", "P_FSG_50_0_0_15", 0, profileFile ) );
    putValue( P_FSG_50_0_0_15_1, getProfileInt( "BAP", "P_FSG_50_0_0_15_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_16Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_16Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_16_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_16_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_16_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_16_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_16_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_16_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_16_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_16_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_16_1, getProfileInt( "BAP", "P_FSG_50_0_0_16_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_16_2, getProfileFloat( "BAP", "P_FSG_50_0_0_16_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_16_2_range, getProfileFloat( "BAP", "P_FSG_50_0_0_16_2_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_17Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_17Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_17_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_17_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_17_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_17_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_17_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_17_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_17_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_17_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_17, getProfileInt( "BAP", "P_FSG_50_0_0_17", 0, profileFile ) );
    putValue( P_FSG_50_0_0_17_1, getProfileInt( "BAP", "P_FSG_50_0_0_17_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_18Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_18Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_18_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_18_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_18_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_18_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_18_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_18_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_18_IntTlgEn, getProfileInt( "BAP", "P_FSG_50_0_0_18_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_18_SegmEn, getProfileInt( "BAP", "P_FSG_50_0_0_18_SegmEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_18_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_18_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_18_2_BargraphOnOff, getProfileInt( "BAP", "P_FSG_50_0_0_18_2_BargraphOnOff", 0, profileFile ) );
    putValue( P_FSG_50_0_0_18_2_Bargraph, getProfileFloat( "BAP", "P_FSG_50_0_0_18_2_Bargraph", 0, profileFile ) );
    putValue( P_FSG_50_0_0_18_2_Bargraph_range, getProfileFloat( "BAP", "P_FSG_50_0_0_18_2_Bargraph_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_18_1_Distance, getProfileFloat( "BAP", "P_FSG_50_0_0_18_1_Distance", 0, profileFile ) );
    putValue( P_FSG_50_0_0_18_1_Distance_range, getProfileFloat( "BAP", "P_FSG_50_0_0_18_1_Distance_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_18_1_Unit, getProfileInt( "BAP", "P_FSG_50_0_0_18_1_Unit", 0, profileFile ) );
    putValue( P_FSG_50_0_0_18_3, getProfileInt( "BAP", "P_FSG_50_0_0_18_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_18_3_0, getProfileInt( "BAP", "P_FSG_50_0_0_18_3_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_19Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_19Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_19_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_19_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_19_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_19_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_19_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_19_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_19_IntTlgEn, getProfileInt( "BAP", "P_FSG_50_0_0_19_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_19_SegmEn, getProfileInt( "BAP", "P_FSG_50_0_0_19_SegmEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_19_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_19_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_19_1_len, getProfileInt( "BAP", "P_FSG_50_0_0_19_1_len", 0, profileFile ) );
    putValue( P_FSG_50_0_0_19_1_cnt, getProfileInt( "BAP", "P_FSG_50_0_0_19_1_cnt", 0, profileFile ) );
    putValue( P_FSG_50_0_0_20Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_20Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_20_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_20_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_20_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_20_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_20_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_20_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_20_IntTlgEn, getProfileInt( "BAP", "P_FSG_50_0_0_20_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_20_SegmEn, getProfileInt( "BAP", "P_FSG_50_0_0_20_SegmEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_20_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_20_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_20_2_len, getProfileInt( "BAP", "P_FSG_50_0_0_20_2_len", 0, profileFile ) );
    putValue( P_FSG_50_0_0_20_2_cnt, getProfileInt( "BAP", "P_FSG_50_0_0_20_2_cnt", 0, profileFile ) );
    putValue( P_FSG_50_0_0_20_1_len, getProfileInt( "BAP", "P_FSG_50_0_0_20_1_len", 0, profileFile ) );
    putValue( P_FSG_50_0_0_20_1_cnt, getProfileInt( "BAP", "P_FSG_50_0_0_20_1_cnt", 0, profileFile ) );
    putValue( P_FSG_50_0_0_21Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_21Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_21_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_21_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_21_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_21_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_21_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_21_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_21_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_21_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_21_2, getProfileInt( "BAP", "P_FSG_50_0_0_21_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_21_2_0, getProfileInt( "BAP", "P_FSG_50_0_0_21_2_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_21_1_Distance, getProfileFloat( "BAP", "P_FSG_50_0_0_21_1_Distance", 0, profileFile ) );
    putValue( P_FSG_50_0_0_21_1_Distance_range, getProfileFloat( "BAP", "P_FSG_50_0_0_21_1_Distance_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_21_1_Unit, getProfileInt( "BAP", "P_FSG_50_0_0_21_1_Unit", 0, profileFile ) );
    putValue( P_FSG_50_0_0_21_3, getProfileInt( "BAP", "P_FSG_50_0_0_21_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_21_3_0, getProfileInt( "BAP", "P_FSG_50_0_0_21_3_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_22Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_22_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_22_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_22_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_IntTlgEn, getProfileInt( "BAP", "P_FSG_50_0_0_22_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_SegmEn, getProfileInt( "BAP", "P_FSG_50_0_0_22_SegmEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_22_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_1_TimeInfoType, getProfileInt( "BAP", "P_FSG_50_0_0_22_1_TimeInfoType", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_1_NavigationTimeFormat, getProfileInt( "BAP", "P_FSG_50_0_0_22_1_NavigationTimeFormat", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_1_Minute, getProfileFloat( "BAP", "P_FSG_50_0_0_22_1_Minute", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_1_Minute_range, getProfileFloat( "BAP", "P_FSG_50_0_0_22_1_Minute_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_1_Hour, getProfileFloat( "BAP", "P_FSG_50_0_0_22_1_Hour", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_1_Hour_range, getProfileFloat( "BAP", "P_FSG_50_0_0_22_1_Hour_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_1_Day, getProfileFloat( "BAP", "P_FSG_50_0_0_22_1_Day", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_1_Day_range, getProfileFloat( "BAP", "P_FSG_50_0_0_22_1_Day_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_1_Month, getProfileFloat( "BAP", "P_FSG_50_0_0_22_1_Month", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_1_Month_range, getProfileFloat( "BAP", "P_FSG_50_0_0_22_1_Month_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_1_Year, getProfileFloat( "BAP", "P_FSG_50_0_0_22_1_Year", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_1_Year_range, getProfileFloat( "BAP", "P_FSG_50_0_0_22_1_Year_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_2, getProfileInt( "BAP", "P_FSG_50_0_0_22_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_2_1, getProfileInt( "BAP", "P_FSG_50_0_0_22_2_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_2_2, getProfileInt( "BAP", "P_FSG_50_0_0_22_2_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_2_3, getProfileInt( "BAP", "P_FSG_50_0_0_22_2_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_2_4, getProfileInt( "BAP", "P_FSG_50_0_0_22_2_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_22_2_5, getProfileInt( "BAP", "P_FSG_50_0_0_22_2_5", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_23Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_23_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_23_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_23_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_IntTlgEn, getProfileInt( "BAP", "P_FSG_50_0_0_23_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_SegmEn, getProfileInt( "BAP", "P_FSG_50_0_0_23_SegmEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_23_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_MainElement, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_MainElement", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_Direction, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_Direction", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_Direction_range, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_Direction_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_Z_LevelGuidance, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_Z_LevelGuidance", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_Sidestreets_len, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_Sidestreets_len", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_Sidestreets_cnt, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_Sidestreets_cnt", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_MainElement, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_MainElement", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_Direction, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_Direction", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_Direction_range, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_Direction_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_Z_LevelGuidance, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_Z_LevelGuidance", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_Sidestreets_len, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_Sidestreets_len", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_Sidestreets_cnt, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_Sidestreets_cnt", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_MainElement, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_MainElement", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_Direction, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_Direction", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_Direction_range, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_Direction_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_Z_LevelGuidance, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_Z_LevelGuidance", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_Sidestreets_len, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_Sidestreets_len", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_Sidestreets_cnt, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_Sidestreets_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24Changed_BTN, getProfileInt( "BAP", "A_FSG_50_0_0_24Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24Status_BTN, getProfileInt( "BAP", "A_FSG_50_0_0_24Status_BTN", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_FctLstItemEn, getProfileInt( "BAP", "A_FSG_50_0_0_24_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_FctEn, getProfileInt( "BAP", "A_FSG_50_0_0_24_FctEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_ErrEn, getProfileInt( "BAP", "A_FSG_50_0_0_24_ErrEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_IntTlgEn, getProfileInt( "BAP", "A_FSG_50_0_0_24_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_SegmEn, getProfileInt( "BAP", "A_FSG_50_0_0_24_SegmEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_AT, getProfileInt( "BAP", "A_FSG_50_0_0_24_AT", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_ErrCode, getProfileInt( "BAP", "A_FSG_50_0_0_24_ErrCode", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_DataIndex, getProfileInt( "BAP", "A_FSG_50_0_0_24_DataIndex", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_50_0_0_24_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_50_0_0_24_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_loadArray_Btn, getProfileInt( "BAP", "A_FSG_50_0_0_24_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_generateData_Btn, getProfileInt( "BAP", "A_FSG_50_0_0_24_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_4, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_len, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_8, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_8", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_3, getProfileInt( "BAP", "A_FSG_50_0_0_24_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_2, getProfileFloat( "BAP", "A_FSG_50_0_0_24_Data_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_2_range, getProfileFloat( "BAP", "A_FSG_50_0_0_24_Data_2_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_5, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_7, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_7", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_1, getProfileInt( "BAP", "A_FSG_50_0_0_24_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_6, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_6", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_1, getProfileFloat( "BAP", "A_FSG_50_0_0_24_Data_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_1_range, getProfileFloat( "BAP", "A_FSG_50_0_0_24_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_2, getProfileFloat( "BAP", "A_FSG_50_0_0_24_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_2_range, getProfileFloat( "BAP", "A_FSG_50_0_0_24_2_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_24_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_24_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_24_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_TransPos, getProfileInt( "BAP", "A_FSG_50_0_0_24_TransPos", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_24_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Start, getProfileInt( "BAP", "A_FSG_50_0_0_24_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_24_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_1_Changed, getProfileInt( "BAP", "A_FSG_50_0_0_24_1_Changed", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_24_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Changed_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_24_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Changed_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_24_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Changed_TransPos, getProfileInt( "BAP", "A_FSG_50_0_0_24_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_24_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Changed_Start, getProfileInt( "BAP", "A_FSG_50_0_0_24_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Changed_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_24_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_2_SetGet, getProfileFloat( "BAP", "A_FSG_50_0_0_24_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_50_0_0_24_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_1_SetGet, getProfileInt( "BAP", "A_FSG_50_0_0_24_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_24_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_SetGet_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_24_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_SetGet_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_24_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_24_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_SetGet_Start, getProfileInt( "BAP", "A_FSG_50_0_0_24_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_SetGet_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_24_SetGet_Elements", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_25Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_25_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_25_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_25_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_IntTlgEn, getProfileInt( "BAP", "P_FSG_50_0_0_25_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_SegmEn, getProfileInt( "BAP", "P_FSG_50_0_0_25_SegmEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_25_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_1, getProfileFloat( "BAP", "P_FSG_50_0_0_25_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_1_range, getProfileFloat( "BAP", "P_FSG_50_0_0_25_1_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_3, getProfileInt( "BAP", "P_FSG_50_0_0_25_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_2, getProfileInt( "BAP", "P_FSG_50_0_0_25_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_4_Priority, getProfileFloat( "BAP", "P_FSG_50_0_0_25_4_Priority", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_4_Priority_range, getProfileFloat( "BAP", "P_FSG_50_0_0_25_4_Priority_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_4_StreetName_len, getProfileInt( "BAP", "P_FSG_50_0_0_25_4_StreetName_len", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_4_StreetName_cnt, getProfileInt( "BAP", "P_FSG_50_0_0_25_4_StreetName_cnt", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_4_Location_len, getProfileInt( "BAP", "P_FSG_50_0_0_25_4_Location_len", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_4_Location_cnt, getProfileInt( "BAP", "P_FSG_50_0_0_25_4_Location_cnt", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_4_Infotext_len, getProfileInt( "BAP", "P_FSG_50_0_0_25_4_Infotext_len", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_4_Infotext_cnt, getProfileInt( "BAP", "P_FSG_50_0_0_25_4_Infotext_cnt", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_4_Length_Validity, getProfileInt( "BAP", "P_FSG_50_0_0_25_4_Length_Validity", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_4_Length_Validity_0, getProfileInt( "BAP", "P_FSG_50_0_0_25_4_Length_Validity_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_4_Length_Value, getProfileFloat( "BAP", "P_FSG_50_0_0_25_4_Length_Value", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_4_Length_Value_range, getProfileFloat( "BAP", "P_FSG_50_0_0_25_4_Length_Value_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_25_4_Length_Unit, getProfileInt( "BAP", "P_FSG_50_0_0_25_4_Length_Unit", 0, profileFile ) );
    putValue( P_FSG_50_0_0_26Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_26Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_26_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_26_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_26_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_26_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_26_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_26_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_26_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_26_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_26, getProfileInt( "BAP", "P_FSG_50_0_0_26", 0, profileFile ) );
    putValue( P_FSG_50_0_0_26_1, getProfileInt( "BAP", "P_FSG_50_0_0_26_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_27Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_27Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_27_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_27_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_27_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_27_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_27_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_27_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_27_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_27_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_27, getProfileInt( "BAP", "P_FSG_50_0_0_27", 0, profileFile ) );
    putValue( P_FSG_50_0_0_27_1, getProfileInt( "BAP", "P_FSG_50_0_0_27_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_28Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_28Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_28_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_28_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_28_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_28_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_28_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_28_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_28_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_28_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_28_1, getProfileInt( "BAP", "P_FSG_50_0_0_28_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_28_1_0, getProfileInt( "BAP", "P_FSG_50_0_0_28_1_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_28_2, getProfileInt( "BAP", "P_FSG_50_0_0_28_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29Changed_BTN, getProfileInt( "BAP", "A_FSG_50_0_0_29Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29Status_BTN, getProfileInt( "BAP", "A_FSG_50_0_0_29Status_BTN", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_FctLstItemEn, getProfileInt( "BAP", "A_FSG_50_0_0_29_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_FctEn, getProfileInt( "BAP", "A_FSG_50_0_0_29_FctEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_ErrEn, getProfileInt( "BAP", "A_FSG_50_0_0_29_ErrEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_IntTlgEn, getProfileInt( "BAP", "A_FSG_50_0_0_29_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_SegmEn, getProfileInt( "BAP", "A_FSG_50_0_0_29_SegmEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_AT, getProfileInt( "BAP", "A_FSG_50_0_0_29_AT", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_ErrCode, getProfileInt( "BAP", "A_FSG_50_0_0_29_ErrCode", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_DataIndex, getProfileInt( "BAP", "A_FSG_50_0_0_29_DataIndex", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_50_0_0_29_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_50_0_0_29_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_loadArray_Btn, getProfileInt( "BAP", "A_FSG_50_0_0_29_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_generateData_Btn, getProfileInt( "BAP", "A_FSG_50_0_0_29_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_Data_2, getProfileInt( "BAP", "A_FSG_50_0_0_29_Data_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_2, getProfileFloat( "BAP", "A_FSG_50_0_0_29_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_2_range, getProfileFloat( "BAP", "A_FSG_50_0_0_29_2_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_1, getProfileInt( "BAP", "A_FSG_50_0_0_29_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_Data_1, getProfileFloat( "BAP", "A_FSG_50_0_0_29_Data_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_Data_1_range, getProfileFloat( "BAP", "A_FSG_50_0_0_29_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_3, getProfileFloat( "BAP", "A_FSG_50_0_0_29_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_3_range, getProfileFloat( "BAP", "A_FSG_50_0_0_29_3_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_Data_3_len, getProfileInt( "BAP", "A_FSG_50_0_0_29_Data_3_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_Data_3_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_29_Data_3_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_29_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_29_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_29_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_TransPos, getProfileInt( "BAP", "A_FSG_50_0_0_29_TransPos", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_29_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_Start, getProfileInt( "BAP", "A_FSG_50_0_0_29_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_29_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_29_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_Changed_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_29_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_Changed_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_29_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_Changed_TransPos, getProfileInt( "BAP", "A_FSG_50_0_0_29_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_29_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_Changed_Start, getProfileInt( "BAP", "A_FSG_50_0_0_29_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_Changed_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_29_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_2_SetGet, getProfileFloat( "BAP", "A_FSG_50_0_0_29_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_50_0_0_29_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_1_SetGet, getProfileInt( "BAP", "A_FSG_50_0_0_29_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_29_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_SetGet_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_29_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_SetGet_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_29_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_29_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_SetGet_Start, getProfileInt( "BAP", "A_FSG_50_0_0_29_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_29_SetGet_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_29_SetGet_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30Changed_BTN, getProfileInt( "BAP", "A_FSG_50_0_0_30Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30Status_BTN, getProfileInt( "BAP", "A_FSG_50_0_0_30Status_BTN", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_FctLstItemEn, getProfileInt( "BAP", "A_FSG_50_0_0_30_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_FctEn, getProfileInt( "BAP", "A_FSG_50_0_0_30_FctEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_ErrEn, getProfileInt( "BAP", "A_FSG_50_0_0_30_ErrEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_IntTlgEn, getProfileInt( "BAP", "A_FSG_50_0_0_30_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_SegmEn, getProfileInt( "BAP", "A_FSG_50_0_0_30_SegmEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_AT, getProfileInt( "BAP", "A_FSG_50_0_0_30_AT", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_ErrCode, getProfileInt( "BAP", "A_FSG_50_0_0_30_ErrCode", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_DataIndex, getProfileInt( "BAP", "A_FSG_50_0_0_30_DataIndex", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_50_0_0_30_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_50_0_0_30_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_loadArray_Btn, getProfileInt( "BAP", "A_FSG_50_0_0_30_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_generateData_Btn, getProfileInt( "BAP", "A_FSG_50_0_0_30_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_Data_2, getProfileInt( "BAP", "A_FSG_50_0_0_30_Data_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_2, getProfileFloat( "BAP", "A_FSG_50_0_0_30_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_2_range, getProfileFloat( "BAP", "A_FSG_50_0_0_30_2_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_1, getProfileInt( "BAP", "A_FSG_50_0_0_30_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_Data_1, getProfileFloat( "BAP", "A_FSG_50_0_0_30_Data_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_Data_1_range, getProfileFloat( "BAP", "A_FSG_50_0_0_30_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_3, getProfileFloat( "BAP", "A_FSG_50_0_0_30_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_3_range, getProfileFloat( "BAP", "A_FSG_50_0_0_30_3_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_Data_3_len, getProfileInt( "BAP", "A_FSG_50_0_0_30_Data_3_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_Data_3_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_30_Data_3_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_30_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_30_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_30_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_TransPos, getProfileInt( "BAP", "A_FSG_50_0_0_30_TransPos", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_30_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_Start, getProfileInt( "BAP", "A_FSG_50_0_0_30_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_30_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_30_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_Changed_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_30_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_Changed_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_30_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_Changed_TransPos, getProfileInt( "BAP", "A_FSG_50_0_0_30_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_30_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_Changed_Start, getProfileInt( "BAP", "A_FSG_50_0_0_30_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_Changed_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_30_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_2_SetGet, getProfileFloat( "BAP", "A_FSG_50_0_0_30_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_50_0_0_30_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_1_SetGet, getProfileInt( "BAP", "A_FSG_50_0_0_30_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_30_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_SetGet_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_30_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_SetGet_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_30_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_30_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_SetGet_Start, getProfileInt( "BAP", "A_FSG_50_0_0_30_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_30_SetGet_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_30_SetGet_Elements", 0, profileFile ) );
    putValue( P_FSG_50_0_0_31Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_31Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_31_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_31_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_31_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_31_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_31_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_31_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_31_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_31_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_31, getProfileInt( "BAP", "P_FSG_50_0_0_31", 0, profileFile ) );
    putValue( P_FSG_50_0_0_31_1, getProfileInt( "BAP", "P_FSG_50_0_0_31_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32Changed_BTN, getProfileInt( "BAP", "A_FSG_50_0_0_32Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32Status_BTN, getProfileInt( "BAP", "A_FSG_50_0_0_32Status_BTN", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_FctLstItemEn, getProfileInt( "BAP", "A_FSG_50_0_0_32_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_FctEn, getProfileInt( "BAP", "A_FSG_50_0_0_32_FctEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_ErrEn, getProfileInt( "BAP", "A_FSG_50_0_0_32_ErrEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_IntTlgEn, getProfileInt( "BAP", "A_FSG_50_0_0_32_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_SegmEn, getProfileInt( "BAP", "A_FSG_50_0_0_32_SegmEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_AT, getProfileInt( "BAP", "A_FSG_50_0_0_32_AT", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_ErrCode, getProfileInt( "BAP", "A_FSG_50_0_0_32_ErrCode", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_DataIndex, getProfileInt( "BAP", "A_FSG_50_0_0_32_DataIndex", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_50_0_0_32_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_50_0_0_32_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_loadArray_Btn, getProfileInt( "BAP", "A_FSG_50_0_0_32_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_generateData_Btn, getProfileInt( "BAP", "A_FSG_50_0_0_32_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_Data_3_len, getProfileInt( "BAP", "A_FSG_50_0_0_32_Data_3_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_Data_3_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_32_Data_3_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_Data_2_len, getProfileInt( "BAP", "A_FSG_50_0_0_32_Data_2_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_Data_2_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_32_Data_2_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_2, getProfileFloat( "BAP", "A_FSG_50_0_0_32_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_2_range, getProfileFloat( "BAP", "A_FSG_50_0_0_32_2_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_1, getProfileInt( "BAP", "A_FSG_50_0_0_32_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_Data_1, getProfileFloat( "BAP", "A_FSG_50_0_0_32_Data_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_Data_1_range, getProfileFloat( "BAP", "A_FSG_50_0_0_32_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_3, getProfileFloat( "BAP", "A_FSG_50_0_0_32_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_3_range, getProfileFloat( "BAP", "A_FSG_50_0_0_32_3_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_32_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_32_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_32_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_TransPos, getProfileInt( "BAP", "A_FSG_50_0_0_32_TransPos", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_32_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_Start, getProfileInt( "BAP", "A_FSG_50_0_0_32_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_32_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_32_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_Changed_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_32_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_Changed_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_32_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_Changed_TransPos, getProfileInt( "BAP", "A_FSG_50_0_0_32_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_32_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_Changed_Start, getProfileInt( "BAP", "A_FSG_50_0_0_32_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_Changed_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_32_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_2_SetGet, getProfileFloat( "BAP", "A_FSG_50_0_0_32_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_50_0_0_32_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_1_SetGet, getProfileInt( "BAP", "A_FSG_50_0_0_32_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_32_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_SetGet_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_32_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_SetGet_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_32_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_32_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_SetGet_Start, getProfileInt( "BAP", "A_FSG_50_0_0_32_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_32_SetGet_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_32_SetGet_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33Changed_BTN, getProfileInt( "BAP", "A_FSG_50_0_0_33Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33Status_BTN, getProfileInt( "BAP", "A_FSG_50_0_0_33Status_BTN", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_FctLstItemEn, getProfileInt( "BAP", "A_FSG_50_0_0_33_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_FctEn, getProfileInt( "BAP", "A_FSG_50_0_0_33_FctEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_ErrEn, getProfileInt( "BAP", "A_FSG_50_0_0_33_ErrEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_IntTlgEn, getProfileInt( "BAP", "A_FSG_50_0_0_33_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_SegmEn, getProfileInt( "BAP", "A_FSG_50_0_0_33_SegmEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_AT, getProfileInt( "BAP", "A_FSG_50_0_0_33_AT", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_ErrCode, getProfileInt( "BAP", "A_FSG_50_0_0_33_ErrCode", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_DataIndex, getProfileInt( "BAP", "A_FSG_50_0_0_33_DataIndex", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_50_0_0_33_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_50_0_0_33_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_loadArray_Btn, getProfileInt( "BAP", "A_FSG_50_0_0_33_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_generateData_Btn, getProfileInt( "BAP", "A_FSG_50_0_0_33_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_12, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_12", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_10_len, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_10_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_10_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_10_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_9_len, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_9_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_9_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_9_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_5, getProfileFloat( "BAP", "A_FSG_50_0_0_33_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_5_range, getProfileFloat( "BAP", "A_FSG_50_0_0_33_5_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_4, getProfileFloat( "BAP", "A_FSG_50_0_0_33_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_4_range, getProfileFloat( "BAP", "A_FSG_50_0_0_33_4_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_1, getProfileInt( "BAP", "A_FSG_50_0_0_33_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_4_len, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_4_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_4_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_4_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_11, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_11", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_2_len, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_2_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_2_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_2_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_5_len, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_5_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_5_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_5_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_1, getProfileFloat( "BAP", "A_FSG_50_0_0_33_Data_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_1_range, getProfileFloat( "BAP", "A_FSG_50_0_0_33_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_3_len, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_3_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_3_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_3_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_3, getProfileInt( "BAP", "A_FSG_50_0_0_33_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_2, getProfileFloat( "BAP", "A_FSG_50_0_0_33_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_2_range, getProfileFloat( "BAP", "A_FSG_50_0_0_33_2_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_8_len, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_8_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_8_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_8_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_7_len, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_7_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_7_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_7_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_6_len, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_6_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Data_6_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_33_Data_6_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_33_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_33_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_33_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_TransPos, getProfileInt( "BAP", "A_FSG_50_0_0_33_TransPos", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_33_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Start, getProfileInt( "BAP", "A_FSG_50_0_0_33_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_33_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_33_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Changed_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_33_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Changed_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_33_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Changed_TransPos, getProfileInt( "BAP", "A_FSG_50_0_0_33_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_33_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Changed_Start, getProfileInt( "BAP", "A_FSG_50_0_0_33_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_Changed_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_33_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_3_SetGet, getProfileInt( "BAP", "A_FSG_50_0_0_33_3_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_2_SetGet, getProfileFloat( "BAP", "A_FSG_50_0_0_33_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_50_0_0_33_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_1_SetGet, getProfileInt( "BAP", "A_FSG_50_0_0_33_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_4_SetGet, getProfileFloat( "BAP", "A_FSG_50_0_0_33_4_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_4_SetGet_range, getProfileFloat( "BAP", "A_FSG_50_0_0_33_4_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_33_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_SetGet_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_33_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_SetGet_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_33_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_33_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_SetGet_Start, getProfileInt( "BAP", "A_FSG_50_0_0_33_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_33_SetGet_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_33_SetGet_Elements", 0, profileFile ) );
    putValue( M_FSG_50_0_0_34Result_BTN, getProfileInt( "BAP", "M_FSG_50_0_0_34Result_BTN", 0, profileFile ) );
    putValue( M_FSG_50_0_0_34_FctLstItemEn, getProfileInt( "BAP", "M_FSG_50_0_0_34_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_34_FctEn, getProfileInt( "BAP", "M_FSG_50_0_0_34_FctEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_34_ErrEn, getProfileInt( "BAP", "M_FSG_50_0_0_34_ErrEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_34_ErrCode, getProfileInt( "BAP", "M_FSG_50_0_0_34_ErrCode", 0, profileFile ) );
    putValue( M_FSG_50_0_0_34_Result, getProfileInt( "BAP", "M_FSG_50_0_0_34_Result", 0, profileFile ) );
    putValue( M_FSG_50_0_0_34_Result_1, getProfileInt( "BAP", "M_FSG_50_0_0_34_Result_1", 0, profileFile ) );
    putValue( M_FSG_50_0_0_34_Processing, getProfileInt( "BAP", "M_FSG_50_0_0_34_Processing", 0, profileFile ) );
    putValue( M_FSG_50_0_0_34_Processing_1, getProfileFloat( "BAP", "M_FSG_50_0_0_34_Processing_1", 0, profileFile ) );
    putValue( M_FSG_50_0_0_34_Processing_1_range, getProfileFloat( "BAP", "M_FSG_50_0_0_34_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_34_Start_1, getProfileInt( "BAP", "M_FSG_50_0_0_34_Start_1", 0, profileFile ) );
    putValue( M_FSG_50_0_0_34_Start_2, getProfileInt( "BAP", "M_FSG_50_0_0_34_Start_2", 0, profileFile ) );
    putValue( M_FSG_50_0_0_34_Start_3, getProfileFloat( "BAP", "M_FSG_50_0_0_34_Start_3", 0, profileFile ) );
    putValue( M_FSG_50_0_0_34_Start_3_range, getProfileFloat( "BAP", "M_FSG_50_0_0_34_Start_3_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_35Result_BTN, getProfileInt( "BAP", "M_FSG_50_0_0_35Result_BTN", 0, profileFile ) );
    putValue( M_FSG_50_0_0_35_FctLstItemEn, getProfileInt( "BAP", "M_FSG_50_0_0_35_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_35_FctEn, getProfileInt( "BAP", "M_FSG_50_0_0_35_FctEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_35_ErrEn, getProfileInt( "BAP", "M_FSG_50_0_0_35_ErrEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_35_ErrCode, getProfileInt( "BAP", "M_FSG_50_0_0_35_ErrCode", 0, profileFile ) );
    putValue( M_FSG_50_0_0_35_Result, getProfileInt( "BAP", "M_FSG_50_0_0_35_Result", 0, profileFile ) );
    putValue( M_FSG_50_0_0_35_Result_1, getProfileInt( "BAP", "M_FSG_50_0_0_35_Result_1", 0, profileFile ) );
    putValue( M_FSG_50_0_0_35_Processing, getProfileInt( "BAP", "M_FSG_50_0_0_35_Processing", 0, profileFile ) );
    putValue( M_FSG_50_0_0_35_Processing_1, getProfileFloat( "BAP", "M_FSG_50_0_0_35_Processing_1", 0, profileFile ) );
    putValue( M_FSG_50_0_0_35_Processing_1_range, getProfileFloat( "BAP", "M_FSG_50_0_0_35_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_35_Start, getProfileInt( "BAP", "M_FSG_50_0_0_35_Start", 0, profileFile ) );
    putValue( M_FSG_50_0_0_35_Start_1, getProfileInt( "BAP", "M_FSG_50_0_0_35_Start_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_36Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_36Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_36_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_36_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_36_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_36_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_36_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_36_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_36_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_36_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_36, getProfileInt( "BAP", "P_FSG_50_0_0_36", 0, profileFile ) );
    putValue( P_FSG_50_0_0_36_1, getProfileInt( "BAP", "P_FSG_50_0_0_36_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_37Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_37_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_37_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_37_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_IntTlgEn, getProfileInt( "BAP", "P_FSG_50_0_0_37_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_SegmEn, getProfileInt( "BAP", "P_FSG_50_0_0_37_SegmEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_37_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_3, getProfileInt( "BAP", "P_FSG_50_0_0_37_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_3_0, getProfileInt( "BAP", "P_FSG_50_0_0_37_3_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_3_1, getProfileInt( "BAP", "P_FSG_50_0_0_37_3_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_3_4, getProfileInt( "BAP", "P_FSG_50_0_0_37_3_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_2, getProfileInt( "BAP", "P_FSG_50_0_0_37_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_2_0, getProfileInt( "BAP", "P_FSG_50_0_0_37_2_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_2_1, getProfileInt( "BAP", "P_FSG_50_0_0_37_2_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_2_2, getProfileInt( "BAP", "P_FSG_50_0_0_37_2_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_2_5, getProfileInt( "BAP", "P_FSG_50_0_0_37_2_5", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_2_6, getProfileInt( "BAP", "P_FSG_50_0_0_37_2_6", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_2_7, getProfileInt( "BAP", "P_FSG_50_0_0_37_2_7", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_16, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_16", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_17, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_17", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_18, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_18", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_19, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_19", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_20, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_20", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_21, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_21", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_22, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_22", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_23, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_23", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_25, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_25", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_26, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_26", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_27, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_27", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_28, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_28", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_31, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_31", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_36, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_36", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_38, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_38", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_39, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_39", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_40, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_40", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_43, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_43", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_44, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_44", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_45, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_45", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_46, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_46", 0, profileFile ) );
    putValue( P_FSG_50_0_0_37_1_47, getProfileInt( "BAP", "P_FSG_50_0_0_37_1_47", 0, profileFile ) );
    putValue( P_FSG_50_0_0_38Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_38Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_38_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_38_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_38_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_38_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_38_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_38_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_38_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_38_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_38, getProfileInt( "BAP", "P_FSG_50_0_0_38", 0, profileFile ) );
    putValue( P_FSG_50_0_0_38_1, getProfileInt( "BAP", "P_FSG_50_0_0_38_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_39Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_39Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_39_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_39_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_39_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_39_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_39_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_39_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_39_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_39_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_39, getProfileInt( "BAP", "P_FSG_50_0_0_39", 0, profileFile ) );
    putValue( P_FSG_50_0_0_39_1, getProfileInt( "BAP", "P_FSG_50_0_0_39_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_40Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_40Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_40_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_40_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_40_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_40_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_40_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_40_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_40_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_40_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_40, getProfileInt( "BAP", "P_FSG_50_0_0_40", 0, profileFile ) );
    putValue( P_FSG_50_0_0_40_1, getProfileInt( "BAP", "P_FSG_50_0_0_40_1", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41Result_BTN, getProfileInt( "BAP", "M_FSG_50_0_0_41Result_BTN", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_FctLstItemEn, getProfileInt( "BAP", "M_FSG_50_0_0_41_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_FctEn, getProfileInt( "BAP", "M_FSG_50_0_0_41_FctEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_ErrEn, getProfileInt( "BAP", "M_FSG_50_0_0_41_ErrEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_IntTlgEn, getProfileInt( "BAP", "M_FSG_50_0_0_41_IntTlgEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_SegmEn, getProfileInt( "BAP", "M_FSG_50_0_0_41_SegmEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_ErrCode, getProfileInt( "BAP", "M_FSG_50_0_0_41_ErrCode", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_Result_1, getProfileInt( "BAP", "M_FSG_50_0_0_41_Result_1", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_Result_2, getProfileFloat( "BAP", "M_FSG_50_0_0_41_Result_2", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_Result_2_range, getProfileFloat( "BAP", "M_FSG_50_0_0_41_Result_2_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_Result_3, getProfileFloat( "BAP", "M_FSG_50_0_0_41_Result_3", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_Result_3_range, getProfileFloat( "BAP", "M_FSG_50_0_0_41_Result_3_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_Result_4, getProfileFloat( "BAP", "M_FSG_50_0_0_41_Result_4", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_Result_4_range, getProfileFloat( "BAP", "M_FSG_50_0_0_41_Result_4_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_Processing_1_len, getProfileInt( "BAP", "M_FSG_50_0_0_41_Processing_1_len", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_Processing_1_cnt, getProfileInt( "BAP", "M_FSG_50_0_0_41_Processing_1_cnt", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_Start_1, getProfileFloat( "BAP", "M_FSG_50_0_0_41_Start_1", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_Start_1_range, getProfileFloat( "BAP", "M_FSG_50_0_0_41_Start_1_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_Start_2, getProfileFloat( "BAP", "M_FSG_50_0_0_41_Start_2", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_Start_2_range, getProfileFloat( "BAP", "M_FSG_50_0_0_41_Start_2_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_41_Start_3, getProfileInt( "BAP", "M_FSG_50_0_0_41_Start_3", 0, profileFile ) );
    putValue( M_FSG_50_0_0_42Result_BTN, getProfileInt( "BAP", "M_FSG_50_0_0_42Result_BTN", 0, profileFile ) );
    putValue( M_FSG_50_0_0_42_FctLstItemEn, getProfileInt( "BAP", "M_FSG_50_0_0_42_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_42_FctEn, getProfileInt( "BAP", "M_FSG_50_0_0_42_FctEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_42_ErrEn, getProfileInt( "BAP", "M_FSG_50_0_0_42_ErrEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_42_ErrCode, getProfileInt( "BAP", "M_FSG_50_0_0_42_ErrCode", 0, profileFile ) );
    putValue( M_FSG_50_0_0_42_Result_1, getProfileInt( "BAP", "M_FSG_50_0_0_42_Result_1", 0, profileFile ) );
    putValue( M_FSG_50_0_0_42_Result_2, getProfileFloat( "BAP", "M_FSG_50_0_0_42_Result_2", 0, profileFile ) );
    putValue( M_FSG_50_0_0_42_Result_2_range, getProfileFloat( "BAP", "M_FSG_50_0_0_42_Result_2_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_42_Result_3, getProfileFloat( "BAP", "M_FSG_50_0_0_42_Result_3", 0, profileFile ) );
    putValue( M_FSG_50_0_0_42_Result_3_range, getProfileFloat( "BAP", "M_FSG_50_0_0_42_Result_3_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_42_Processing_1, getProfileFloat( "BAP", "M_FSG_50_0_0_42_Processing_1", 0, profileFile ) );
    putValue( M_FSG_50_0_0_42_Processing_1_range, getProfileFloat( "BAP", "M_FSG_50_0_0_42_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_42_Processing_2, getProfileFloat( "BAP", "M_FSG_50_0_0_42_Processing_2", 0, profileFile ) );
    putValue( M_FSG_50_0_0_42_Processing_2_range, getProfileFloat( "BAP", "M_FSG_50_0_0_42_Processing_2_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_42_Start_1, getProfileInt( "BAP", "M_FSG_50_0_0_42_Start_1", 0, profileFile ) );
    putValue( M_FSG_50_0_0_42_Start_2_len, getProfileInt( "BAP", "M_FSG_50_0_0_42_Start_2_len", 0, profileFile ) );
    putValue( M_FSG_50_0_0_42_Start_2_cnt, getProfileInt( "BAP", "M_FSG_50_0_0_42_Start_2_cnt", 0, profileFile ) );
    putValue( P_FSG_50_0_0_43Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_43Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_43_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_43_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_43_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_43_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_43_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_43_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_43_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_43_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_43_4, getProfileInt( "BAP", "P_FSG_50_0_0_43_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_43_4_0, getProfileInt( "BAP", "P_FSG_50_0_0_43_4_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_43_4_1, getProfileInt( "BAP", "P_FSG_50_0_0_43_4_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_43_4_2, getProfileInt( "BAP", "P_FSG_50_0_0_43_4_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_43_4_3, getProfileInt( "BAP", "P_FSG_50_0_0_43_4_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_43_4_4, getProfileInt( "BAP", "P_FSG_50_0_0_43_4_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_43_4_5, getProfileInt( "BAP", "P_FSG_50_0_0_43_4_5", 0, profileFile ) );
    putValue( P_FSG_50_0_0_43_3, getProfileInt( "BAP", "P_FSG_50_0_0_43_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_43_2, getProfileInt( "BAP", "P_FSG_50_0_0_43_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_43_1, getProfileInt( "BAP", "P_FSG_50_0_0_43_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_44Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_44_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_44_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_44_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_IntTlgEn, getProfileInt( "BAP", "P_FSG_50_0_0_44_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_SegmEn, getProfileInt( "BAP", "P_FSG_50_0_0_44_SegmEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_44_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_7, getProfileInt( "BAP", "P_FSG_50_0_0_44_7", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_7_0, getProfileInt( "BAP", "P_FSG_50_0_0_44_7_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_5, getProfileInt( "BAP", "P_FSG_50_0_0_44_5", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_5_0, getProfileInt( "BAP", "P_FSG_50_0_0_44_5_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_5_1, getProfileInt( "BAP", "P_FSG_50_0_0_44_5_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_5_2, getProfileInt( "BAP", "P_FSG_50_0_0_44_5_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_4, getProfileInt( "BAP", "P_FSG_50_0_0_44_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_4_0, getProfileInt( "BAP", "P_FSG_50_0_0_44_4_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_4_1, getProfileInt( "BAP", "P_FSG_50_0_0_44_4_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_4_2, getProfileInt( "BAP", "P_FSG_50_0_0_44_4_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_1, getProfileInt( "BAP", "P_FSG_50_0_0_44_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_2, getProfileInt( "BAP", "P_FSG_50_0_0_44_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_6, getProfileInt( "BAP", "P_FSG_50_0_0_44_6", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_3, getProfileInt( "BAP", "P_FSG_50_0_0_44_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_3_0, getProfileInt( "BAP", "P_FSG_50_0_0_44_3_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_3_1, getProfileInt( "BAP", "P_FSG_50_0_0_44_3_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_3_2, getProfileInt( "BAP", "P_FSG_50_0_0_44_3_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_44_3_3, getProfileInt( "BAP", "P_FSG_50_0_0_44_3_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_45Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_45Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_45_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_45_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_45_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_45_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_45_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_45_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_45_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_45_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_45_6, getProfileInt( "BAP", "P_FSG_50_0_0_45_6", 0, profileFile ) );
    putValue( P_FSG_50_0_0_45_6_0, getProfileInt( "BAP", "P_FSG_50_0_0_45_6_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_45_5, getProfileInt( "BAP", "P_FSG_50_0_0_45_5", 0, profileFile ) );
    putValue( P_FSG_50_0_0_45_2, getProfileInt( "BAP", "P_FSG_50_0_0_45_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_45_4, getProfileFloat( "BAP", "P_FSG_50_0_0_45_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_45_4_range, getProfileFloat( "BAP", "P_FSG_50_0_0_45_4_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_45_3, getProfileInt( "BAP", "P_FSG_50_0_0_45_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_45_3_0, getProfileInt( "BAP", "P_FSG_50_0_0_45_3_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_45_1, getProfileFloat( "BAP", "P_FSG_50_0_0_45_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_45_1_range, getProfileFloat( "BAP", "P_FSG_50_0_0_45_1_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_46Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_46_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_46_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_46_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_IntTlgEn, getProfileInt( "BAP", "P_FSG_50_0_0_46_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_SegmEn, getProfileInt( "BAP", "P_FSG_50_0_0_46_SegmEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_46_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_3, getProfileFloat( "BAP", "P_FSG_50_0_0_46_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_3_range, getProfileFloat( "BAP", "P_FSG_50_0_0_46_3_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_7_len, getProfileInt( "BAP", "P_FSG_50_0_0_46_7_len", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_7_cnt, getProfileInt( "BAP", "P_FSG_50_0_0_46_7_cnt", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_5_len, getProfileInt( "BAP", "P_FSG_50_0_0_46_5_len", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_5_cnt, getProfileInt( "BAP", "P_FSG_50_0_0_46_5_cnt", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_1_Latitude, getProfileFloat( "BAP", "P_FSG_50_0_0_46_1_Latitude", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_1_Latitude_range, getProfileFloat( "BAP", "P_FSG_50_0_0_46_1_Latitude_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_1_Longitude, getProfileFloat( "BAP", "P_FSG_50_0_0_46_1_Longitude", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_1_Longitude_range, getProfileFloat( "BAP", "P_FSG_50_0_0_46_1_Longitude_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_6_len, getProfileInt( "BAP", "P_FSG_50_0_0_46_6_len", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_6_cnt, getProfileInt( "BAP", "P_FSG_50_0_0_46_6_cnt", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_2, getProfileFloat( "BAP", "P_FSG_50_0_0_46_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_2_range, getProfileFloat( "BAP", "P_FSG_50_0_0_46_2_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_4, getProfileInt( "BAP", "P_FSG_50_0_0_46_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_8_len, getProfileInt( "BAP", "P_FSG_50_0_0_46_8_len", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_8_cnt, getProfileInt( "BAP", "P_FSG_50_0_0_46_8_cnt", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_10_len, getProfileInt( "BAP", "P_FSG_50_0_0_46_10_len", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_10_cnt, getProfileInt( "BAP", "P_FSG_50_0_0_46_10_cnt", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_9_len, getProfileInt( "BAP", "P_FSG_50_0_0_46_9_len", 0, profileFile ) );
    putValue( P_FSG_50_0_0_46_9_cnt, getProfileInt( "BAP", "P_FSG_50_0_0_46_9_cnt", 0, profileFile ) );
    putValue( P_FSG_50_0_0_47Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_47Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_47_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_47_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_47_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_47_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_47_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_47_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_47_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_47_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_47_1, getProfileFloat( "BAP", "P_FSG_50_0_0_47_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_47_1_range, getProfileFloat( "BAP", "P_FSG_50_0_0_47_1_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_47_2, getProfileInt( "BAP", "P_FSG_50_0_0_47_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_48Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_48Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_48_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_48_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_48_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_48_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_48_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_48_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_48_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_48_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_48_1, getProfileInt( "BAP", "P_FSG_50_0_0_48_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_48_2, getProfileFloat( "BAP", "P_FSG_50_0_0_48_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_48_2_range, getProfileFloat( "BAP", "P_FSG_50_0_0_48_2_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_48_3, getProfileInt( "BAP", "P_FSG_50_0_0_48_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_49Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_49Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_49_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_49_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_49_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_49_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_49_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_49_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_49_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_49_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_49_1, getProfileInt( "BAP", "P_FSG_50_0_0_49_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_49_2, getProfileFloat( "BAP", "P_FSG_50_0_0_49_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_49_2_range, getProfileFloat( "BAP", "P_FSG_50_0_0_49_2_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_50Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_50_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_50_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_50_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_IntTlgEn, getProfileInt( "BAP", "P_FSG_50_0_0_50_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_SegmEn, getProfileInt( "BAP", "P_FSG_50_0_0_50_SegmEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_50_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_1, getProfileInt( "BAP", "P_FSG_50_0_0_50_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_1_0, getProfileInt( "BAP", "P_FSG_50_0_0_50_1_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_1_1, getProfileInt( "BAP", "P_FSG_50_0_0_50_1_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_4_TimeInfoType, getProfileInt( "BAP", "P_FSG_50_0_0_50_4_TimeInfoType", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_4_NavigationTimeFormat, getProfileInt( "BAP", "P_FSG_50_0_0_50_4_NavigationTimeFormat", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_4_Minute, getProfileFloat( "BAP", "P_FSG_50_0_0_50_4_Minute", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_4_Minute_range, getProfileFloat( "BAP", "P_FSG_50_0_0_50_4_Minute_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_4_Hour, getProfileFloat( "BAP", "P_FSG_50_0_0_50_4_Hour", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_4_Hour_range, getProfileFloat( "BAP", "P_FSG_50_0_0_50_4_Hour_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_4_Day, getProfileFloat( "BAP", "P_FSG_50_0_0_50_4_Day", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_4_Day_range, getProfileFloat( "BAP", "P_FSG_50_0_0_50_4_Day_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_4_Month, getProfileFloat( "BAP", "P_FSG_50_0_0_50_4_Month", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_4_Month_range, getProfileFloat( "BAP", "P_FSG_50_0_0_50_4_Month_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_4_Year, getProfileFloat( "BAP", "P_FSG_50_0_0_50_4_Year", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_4_Year_range, getProfileFloat( "BAP", "P_FSG_50_0_0_50_4_Year_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_3_Distance, getProfileFloat( "BAP", "P_FSG_50_0_0_50_3_Distance", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_3_Distance_range, getProfileFloat( "BAP", "P_FSG_50_0_0_50_3_Distance_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_3_Unit, getProfileInt( "BAP", "P_FSG_50_0_0_50_3_Unit", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_3_TypeOfDistance, getProfileInt( "BAP", "P_FSG_50_0_0_50_3_TypeOfDistance", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_5, getProfileInt( "BAP", "P_FSG_50_0_0_50_5", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_5_0, getProfileInt( "BAP", "P_FSG_50_0_0_50_5_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_5_1, getProfileInt( "BAP", "P_FSG_50_0_0_50_5_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_5_2, getProfileInt( "BAP", "P_FSG_50_0_0_50_5_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_5_3, getProfileInt( "BAP", "P_FSG_50_0_0_50_5_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_5_4, getProfileInt( "BAP", "P_FSG_50_0_0_50_5_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_5_5, getProfileInt( "BAP", "P_FSG_50_0_0_50_5_5", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_2_Minute, getProfileFloat( "BAP", "P_FSG_50_0_0_50_2_Minute", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_2_Minute_range, getProfileFloat( "BAP", "P_FSG_50_0_0_50_2_Minute_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_2_Hour, getProfileFloat( "BAP", "P_FSG_50_0_0_50_2_Hour", 0, profileFile ) );
    putValue( P_FSG_50_0_0_50_2_Hour_range, getProfileFloat( "BAP", "P_FSG_50_0_0_50_2_Hour_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_51Result_BTN, getProfileInt( "BAP", "M_FSG_50_0_0_51Result_BTN", 0, profileFile ) );
    putValue( M_FSG_50_0_0_51_FctLstItemEn, getProfileInt( "BAP", "M_FSG_50_0_0_51_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_51_FctEn, getProfileInt( "BAP", "M_FSG_50_0_0_51_FctEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_51_ErrEn, getProfileInt( "BAP", "M_FSG_50_0_0_51_ErrEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_51_ErrCode, getProfileInt( "BAP", "M_FSG_50_0_0_51_ErrCode", 0, profileFile ) );
    putValue( M_FSG_50_0_0_51_Result_1, getProfileFloat( "BAP", "M_FSG_50_0_0_51_Result_1", 0, profileFile ) );
    putValue( M_FSG_50_0_0_51_Result_1_range, getProfileFloat( "BAP", "M_FSG_50_0_0_51_Result_1_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_51_Result_2, getProfileInt( "BAP", "M_FSG_50_0_0_51_Result_2", 0, profileFile ) );
    putValue( M_FSG_50_0_0_51_Processing_1, getProfileFloat( "BAP", "M_FSG_50_0_0_51_Processing_1", 0, profileFile ) );
    putValue( M_FSG_50_0_0_51_Processing_1_range, getProfileFloat( "BAP", "M_FSG_50_0_0_51_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_51_Processing_2, getProfileFloat( "BAP", "M_FSG_50_0_0_51_Processing_2", 0, profileFile ) );
    putValue( M_FSG_50_0_0_51_Processing_2_range, getProfileFloat( "BAP", "M_FSG_50_0_0_51_Processing_2_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_51_Start_1, getProfileInt( "BAP", "M_FSG_50_0_0_51_Start_1", 0, profileFile ) );
    putValue( M_FSG_50_0_0_51_Start_2, getProfileInt( "BAP", "M_FSG_50_0_0_51_Start_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52Changed_BTN, getProfileInt( "BAP", "A_FSG_50_0_0_52Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52Status_BTN, getProfileInt( "BAP", "A_FSG_50_0_0_52Status_BTN", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_FctLstItemEn, getProfileInt( "BAP", "A_FSG_50_0_0_52_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_FctEn, getProfileInt( "BAP", "A_FSG_50_0_0_52_FctEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_ErrEn, getProfileInt( "BAP", "A_FSG_50_0_0_52_ErrEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_IntTlgEn, getProfileInt( "BAP", "A_FSG_50_0_0_52_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_SegmEn, getProfileInt( "BAP", "A_FSG_50_0_0_52_SegmEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_AT, getProfileInt( "BAP", "A_FSG_50_0_0_52_AT", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_ErrCode, getProfileInt( "BAP", "A_FSG_50_0_0_52_ErrCode", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_DataIndex, getProfileInt( "BAP", "A_FSG_50_0_0_52_DataIndex", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_50_0_0_52_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_50_0_0_52_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_loadArray_Btn, getProfileInt( "BAP", "A_FSG_50_0_0_52_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_generateData_Btn, getProfileInt( "BAP", "A_FSG_50_0_0_52_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Data_6, getProfileInt( "BAP", "A_FSG_50_0_0_52_Data_6", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_3, getProfileFloat( "BAP", "A_FSG_50_0_0_52_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_3_range, getProfileFloat( "BAP", "A_FSG_50_0_0_52_3_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_1, getProfileInt( "BAP", "A_FSG_50_0_0_52_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Data_8_len, getProfileInt( "BAP", "A_FSG_50_0_0_52_Data_8_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Data_8_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_52_Data_8_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Data_7_len, getProfileInt( "BAP", "A_FSG_50_0_0_52_Data_7_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Data_7_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_52_Data_7_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Data_3, getProfileInt( "BAP", "A_FSG_50_0_0_52_Data_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Data_9_len, getProfileInt( "BAP", "A_FSG_50_0_0_52_Data_9_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Data_9_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_52_Data_9_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Data_2, getProfileInt( "BAP", "A_FSG_50_0_0_52_Data_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Data_1, getProfileFloat( "BAP", "A_FSG_50_0_0_52_Data_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Data_1_range, getProfileFloat( "BAP", "A_FSG_50_0_0_52_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Data_5, getProfileFloat( "BAP", "A_FSG_50_0_0_52_Data_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Data_5_range, getProfileFloat( "BAP", "A_FSG_50_0_0_52_Data_5_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_2, getProfileFloat( "BAP", "A_FSG_50_0_0_52_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_2_range, getProfileFloat( "BAP", "A_FSG_50_0_0_52_2_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Data_10_len, getProfileInt( "BAP", "A_FSG_50_0_0_52_Data_10_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Data_10_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_52_Data_10_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Data_4, getProfileInt( "BAP", "A_FSG_50_0_0_52_Data_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_52_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_52_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_52_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_TransPos, getProfileInt( "BAP", "A_FSG_50_0_0_52_TransPos", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_52_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Start, getProfileInt( "BAP", "A_FSG_50_0_0_52_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_52_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_52_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Changed_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_52_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Changed_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_52_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Changed_TransPos, getProfileInt( "BAP", "A_FSG_50_0_0_52_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_52_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Changed_Start, getProfileInt( "BAP", "A_FSG_50_0_0_52_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_Changed_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_52_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_2_SetGet, getProfileFloat( "BAP", "A_FSG_50_0_0_52_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_50_0_0_52_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_1_SetGet, getProfileInt( "BAP", "A_FSG_50_0_0_52_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_52_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_SetGet_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_52_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_SetGet_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_52_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_52_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_SetGet_Start, getProfileInt( "BAP", "A_FSG_50_0_0_52_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_52_SetGet_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_52_SetGet_Elements", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_53Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_53_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_53_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_53_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_53_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_1, getProfileInt( "BAP", "P_FSG_50_0_0_53_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_1_0, getProfileInt( "BAP", "P_FSG_50_0_0_53_1_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_1_1, getProfileInt( "BAP", "P_FSG_50_0_0_53_1_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_1_2, getProfileInt( "BAP", "P_FSG_50_0_0_53_1_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_6, getProfileFloat( "BAP", "P_FSG_50_0_0_53_6", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_6_range, getProfileFloat( "BAP", "P_FSG_50_0_0_53_6_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_5, getProfileFloat( "BAP", "P_FSG_50_0_0_53_5", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_5_range, getProfileFloat( "BAP", "P_FSG_50_0_0_53_5_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_4, getProfileFloat( "BAP", "P_FSG_50_0_0_53_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_4_range, getProfileFloat( "BAP", "P_FSG_50_0_0_53_4_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_2, getProfileInt( "BAP", "P_FSG_50_0_0_53_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_2_0, getProfileInt( "BAP", "P_FSG_50_0_0_53_2_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_3, getProfileInt( "BAP", "P_FSG_50_0_0_53_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_3_0, getProfileInt( "BAP", "P_FSG_50_0_0_53_3_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_3_1, getProfileInt( "BAP", "P_FSG_50_0_0_53_3_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_3_2, getProfileInt( "BAP", "P_FSG_50_0_0_53_3_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_3_3, getProfileInt( "BAP", "P_FSG_50_0_0_53_3_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_3_4, getProfileInt( "BAP", "P_FSG_50_0_0_53_3_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_53_3_5, getProfileInt( "BAP", "P_FSG_50_0_0_53_3_5", 0, profileFile ) );
    putValue( P_FSG_50_0_0_54Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_54Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_54_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_54_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_54_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_54_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_54_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_54_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_54_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_54_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_54, getProfileInt( "BAP", "P_FSG_50_0_0_54", 0, profileFile ) );
    putValue( P_FSG_50_0_0_54_1, getProfileInt( "BAP", "P_FSG_50_0_0_54_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_54_1_0, getProfileInt( "BAP", "P_FSG_50_0_0_54_1_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_54_1_1, getProfileInt( "BAP", "P_FSG_50_0_0_54_1_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_54_1_2, getProfileInt( "BAP", "P_FSG_50_0_0_54_1_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_55Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_55Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_55_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_55_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_55_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_55_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_55_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_55_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_55_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_55_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_55_1, getProfileInt( "BAP", "P_FSG_50_0_0_55_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_55_4, getProfileFloat( "BAP", "P_FSG_50_0_0_55_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_55_4_range, getProfileFloat( "BAP", "P_FSG_50_0_0_55_4_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_55_3, getProfileFloat( "BAP", "P_FSG_50_0_0_55_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_55_3_range, getProfileFloat( "BAP", "P_FSG_50_0_0_55_3_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_55_2, getProfileFloat( "BAP", "P_FSG_50_0_0_55_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_55_2_range, getProfileFloat( "BAP", "P_FSG_50_0_0_55_2_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_56Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_56Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_56_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_56_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_56_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_56_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_56_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_56_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_56_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_56_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_56_2, getProfileFloat( "BAP", "P_FSG_50_0_0_56_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_56_2_range, getProfileFloat( "BAP", "P_FSG_50_0_0_56_2_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_56_1, getProfileInt( "BAP", "P_FSG_50_0_0_56_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_57Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_57_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_57_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_57_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_57_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_4, getProfileFloat( "BAP", "P_FSG_50_0_0_57_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_4_range, getProfileFloat( "BAP", "P_FSG_50_0_0_57_4_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_3, getProfileFloat( "BAP", "P_FSG_50_0_0_57_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_3_range, getProfileFloat( "BAP", "P_FSG_50_0_0_57_3_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_2, getProfileInt( "BAP", "P_FSG_50_0_0_57_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_2_0, getProfileInt( "BAP", "P_FSG_50_0_0_57_2_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_2_1, getProfileInt( "BAP", "P_FSG_50_0_0_57_2_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_2_2, getProfileInt( "BAP", "P_FSG_50_0_0_57_2_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_2_3, getProfileInt( "BAP", "P_FSG_50_0_0_57_2_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_2_4, getProfileInt( "BAP", "P_FSG_50_0_0_57_2_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_2_5, getProfileInt( "BAP", "P_FSG_50_0_0_57_2_5", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_2_6, getProfileInt( "BAP", "P_FSG_50_0_0_57_2_6", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_2_7, getProfileInt( "BAP", "P_FSG_50_0_0_57_2_7", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_1, getProfileInt( "BAP", "P_FSG_50_0_0_57_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_1_0, getProfileInt( "BAP", "P_FSG_50_0_0_57_1_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_1_1, getProfileInt( "BAP", "P_FSG_50_0_0_57_1_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_1_2, getProfileInt( "BAP", "P_FSG_50_0_0_57_1_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_1_3, getProfileInt( "BAP", "P_FSG_50_0_0_57_1_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_1_4, getProfileInt( "BAP", "P_FSG_50_0_0_57_1_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_1_5, getProfileInt( "BAP", "P_FSG_50_0_0_57_1_5", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_1_6, getProfileInt( "BAP", "P_FSG_50_0_0_57_1_6", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_1_7, getProfileInt( "BAP", "P_FSG_50_0_0_57_1_7", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_6, getProfileFloat( "BAP", "P_FSG_50_0_0_57_6", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_6_range, getProfileFloat( "BAP", "P_FSG_50_0_0_57_6_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_5, getProfileFloat( "BAP", "P_FSG_50_0_0_57_5", 0, profileFile ) );
    putValue( P_FSG_50_0_0_57_5_range, getProfileFloat( "BAP", "P_FSG_50_0_0_57_5_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58Changed_BTN, getProfileInt( "BAP", "A_FSG_50_0_0_58Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58Status_BTN, getProfileInt( "BAP", "A_FSG_50_0_0_58Status_BTN", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_FctLstItemEn, getProfileInt( "BAP", "A_FSG_50_0_0_58_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_FctEn, getProfileInt( "BAP", "A_FSG_50_0_0_58_FctEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_ErrEn, getProfileInt( "BAP", "A_FSG_50_0_0_58_ErrEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_IntTlgEn, getProfileInt( "BAP", "A_FSG_50_0_0_58_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_SegmEn, getProfileInt( "BAP", "A_FSG_50_0_0_58_SegmEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_AT, getProfileInt( "BAP", "A_FSG_50_0_0_58_AT", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_ErrCode, getProfileInt( "BAP", "A_FSG_50_0_0_58_ErrCode", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_DataIndex, getProfileInt( "BAP", "A_FSG_50_0_0_58_DataIndex", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_50_0_0_58_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_50_0_0_58_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_loadArray_Btn, getProfileInt( "BAP", "A_FSG_50_0_0_58_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_generateData_Btn, getProfileInt( "BAP", "A_FSG_50_0_0_58_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Data_2, getProfileInt( "BAP", "A_FSG_50_0_0_58_Data_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Data_4, getProfileFloat( "BAP", "A_FSG_50_0_0_58_Data_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Data_4_range, getProfileFloat( "BAP", "A_FSG_50_0_0_58_Data_4_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Data_5_len, getProfileInt( "BAP", "A_FSG_50_0_0_58_Data_5_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Data_5_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_58_Data_5_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_2, getProfileFloat( "BAP", "A_FSG_50_0_0_58_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_2_range, getProfileFloat( "BAP", "A_FSG_50_0_0_58_2_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_1, getProfileInt( "BAP", "A_FSG_50_0_0_58_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Data_3_len, getProfileInt( "BAP", "A_FSG_50_0_0_58_Data_3_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Data_3_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_58_Data_3_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Data_1, getProfileFloat( "BAP", "A_FSG_50_0_0_58_Data_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Data_1_range, getProfileFloat( "BAP", "A_FSG_50_0_0_58_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_3, getProfileFloat( "BAP", "A_FSG_50_0_0_58_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_3_range, getProfileFloat( "BAP", "A_FSG_50_0_0_58_3_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_58_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_58_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_58_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_TransPos, getProfileInt( "BAP", "A_FSG_50_0_0_58_TransPos", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_58_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Start, getProfileInt( "BAP", "A_FSG_50_0_0_58_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_58_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_58_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Changed_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_58_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Changed_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_58_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Changed_TransPos, getProfileInt( "BAP", "A_FSG_50_0_0_58_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_58_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Changed_Start, getProfileInt( "BAP", "A_FSG_50_0_0_58_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_Changed_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_58_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_2_SetGet, getProfileFloat( "BAP", "A_FSG_50_0_0_58_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_50_0_0_58_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_1_SetGet, getProfileInt( "BAP", "A_FSG_50_0_0_58_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_58_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_SetGet_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_58_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_SetGet_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_58_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_58_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_SetGet_Start, getProfileInt( "BAP", "A_FSG_50_0_0_58_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_58_SetGet_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_58_SetGet_Elements", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59Result_BTN, getProfileInt( "BAP", "M_FSG_50_0_0_59Result_BTN", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_FctLstItemEn, getProfileInt( "BAP", "M_FSG_50_0_0_59_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_FctEn, getProfileInt( "BAP", "M_FSG_50_0_0_59_FctEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_ErrEn, getProfileInt( "BAP", "M_FSG_50_0_0_59_ErrEn", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_ErrCode, getProfileInt( "BAP", "M_FSG_50_0_0_59_ErrCode", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_Result_1, getProfileInt( "BAP", "M_FSG_50_0_0_59_Result_1", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_Result_2, getProfileFloat( "BAP", "M_FSG_50_0_0_59_Result_2", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_Result_2_range, getProfileFloat( "BAP", "M_FSG_50_0_0_59_Result_2_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_Result_3, getProfileInt( "BAP", "M_FSG_50_0_0_59_Result_3", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_Processing_1, getProfileInt( "BAP", "M_FSG_50_0_0_59_Processing_1", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_Processing_2, getProfileFloat( "BAP", "M_FSG_50_0_0_59_Processing_2", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_Processing_2_range, getProfileFloat( "BAP", "M_FSG_50_0_0_59_Processing_2_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_Processing_3, getProfileFloat( "BAP", "M_FSG_50_0_0_59_Processing_3", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_Processing_3_range, getProfileFloat( "BAP", "M_FSG_50_0_0_59_Processing_3_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_Start_1, getProfileInt( "BAP", "M_FSG_50_0_0_59_Start_1", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_Start_2, getProfileFloat( "BAP", "M_FSG_50_0_0_59_Start_2", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_Start_2_range, getProfileFloat( "BAP", "M_FSG_50_0_0_59_Start_2_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_Start_3, getProfileFloat( "BAP", "M_FSG_50_0_0_59_Start_3", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_Start_3_range, getProfileFloat( "BAP", "M_FSG_50_0_0_59_Start_3_range", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_Start_4, getProfileFloat( "BAP", "M_FSG_50_0_0_59_Start_4", 0, profileFile ) );
    putValue( M_FSG_50_0_0_59_Start_4_range, getProfileFloat( "BAP", "M_FSG_50_0_0_59_Start_4_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60Status_BTN, getProfileInt( "BAP", "P_FSG_50_0_0_60Status_BTN", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_FctLstItemEn, getProfileInt( "BAP", "P_FSG_50_0_0_60_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_FctEn, getProfileInt( "BAP", "P_FSG_50_0_0_60_FctEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_ErrEn, getProfileInt( "BAP", "P_FSG_50_0_0_60_ErrEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_IntTlgEn, getProfileInt( "BAP", "P_FSG_50_0_0_60_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_SegmEn, getProfileInt( "BAP", "P_FSG_50_0_0_60_SegmEn", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_ErrCode, getProfileInt( "BAP", "P_FSG_50_0_0_60_ErrCode", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_6, getProfileFloat( "BAP", "P_FSG_50_0_0_60_6", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_6_range, getProfileFloat( "BAP", "P_FSG_50_0_0_60_6_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_4, getProfileFloat( "BAP", "P_FSG_50_0_0_60_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_4_range, getProfileFloat( "BAP", "P_FSG_50_0_0_60_4_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_5, getProfileFloat( "BAP", "P_FSG_50_0_0_60_5", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_5_range, getProfileFloat( "BAP", "P_FSG_50_0_0_60_5_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_2, getProfileFloat( "BAP", "P_FSG_50_0_0_60_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_2_range, getProfileFloat( "BAP", "P_FSG_50_0_0_60_2_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_3, getProfileInt( "BAP", "P_FSG_50_0_0_60_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_8, getProfileInt( "BAP", "P_FSG_50_0_0_60_8", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_8_0, getProfileInt( "BAP", "P_FSG_50_0_0_60_8_0", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_8_1, getProfileInt( "BAP", "P_FSG_50_0_0_60_8_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_7, getProfileFloat( "BAP", "P_FSG_50_0_0_60_7", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_7_range, getProfileFloat( "BAP", "P_FSG_50_0_0_60_7_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_1_Distance, getProfileFloat( "BAP", "P_FSG_50_0_0_60_1_Distance", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_1_Distance_range, getProfileFloat( "BAP", "P_FSG_50_0_0_60_1_Distance_range", 0, profileFile ) );
    putValue( P_FSG_50_0_0_60_1_Unit, getProfileInt( "BAP", "P_FSG_50_0_0_60_1_Unit", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61Changed_BTN, getProfileInt( "BAP", "A_FSG_50_0_0_61Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61Status_BTN, getProfileInt( "BAP", "A_FSG_50_0_0_61Status_BTN", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_FctLstItemEn, getProfileInt( "BAP", "A_FSG_50_0_0_61_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_FctEn, getProfileInt( "BAP", "A_FSG_50_0_0_61_FctEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_ErrEn, getProfileInt( "BAP", "A_FSG_50_0_0_61_ErrEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_IntTlgEn, getProfileInt( "BAP", "A_FSG_50_0_0_61_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_SegmEn, getProfileInt( "BAP", "A_FSG_50_0_0_61_SegmEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_AT, getProfileInt( "BAP", "A_FSG_50_0_0_61_AT", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_ErrCode, getProfileInt( "BAP", "A_FSG_50_0_0_61_ErrCode", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_DataIndex, getProfileInt( "BAP", "A_FSG_50_0_0_61_DataIndex", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_50_0_0_61_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_50_0_0_61_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_loadArray_Btn, getProfileInt( "BAP", "A_FSG_50_0_0_61_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_generateData_Btn, getProfileInt( "BAP", "A_FSG_50_0_0_61_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Data_8, getProfileInt( "BAP", "A_FSG_50_0_0_61_Data_8", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Data_7_len, getProfileInt( "BAP", "A_FSG_50_0_0_61_Data_7_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Data_7_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_61_Data_7_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_3, getProfileInt( "BAP", "A_FSG_50_0_0_61_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Data_9, getProfileInt( "BAP", "A_FSG_50_0_0_61_Data_9", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Data_12, getProfileInt( "BAP", "A_FSG_50_0_0_61_Data_12", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_1, getProfileInt( "BAP", "A_FSG_50_0_0_61_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Data_10, getProfileInt( "BAP", "A_FSG_50_0_0_61_Data_10", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Data_1, getProfileFloat( "BAP", "A_FSG_50_0_0_61_Data_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Data_1_range, getProfileFloat( "BAP", "A_FSG_50_0_0_61_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Data_4, getProfileFloat( "BAP", "A_FSG_50_0_0_61_Data_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Data_4_range, getProfileFloat( "BAP", "A_FSG_50_0_0_61_Data_4_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Data_2, getProfileInt( "BAP", "A_FSG_50_0_0_61_Data_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_2, getProfileFloat( "BAP", "A_FSG_50_0_0_61_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_2_range, getProfileFloat( "BAP", "A_FSG_50_0_0_61_2_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Data_3, getProfileFloat( "BAP", "A_FSG_50_0_0_61_Data_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Data_3_range, getProfileFloat( "BAP", "A_FSG_50_0_0_61_Data_3_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Data_6, getProfileInt( "BAP", "A_FSG_50_0_0_61_Data_6", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_4, getProfileFloat( "BAP", "A_FSG_50_0_0_61_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_4_range, getProfileFloat( "BAP", "A_FSG_50_0_0_61_4_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Data_11, getProfileInt( "BAP", "A_FSG_50_0_0_61_Data_11", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Data_11_0, getProfileInt( "BAP", "A_FSG_50_0_0_61_Data_11_0", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Data_11_1, getProfileInt( "BAP", "A_FSG_50_0_0_61_Data_11_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Data_5, getProfileInt( "BAP", "A_FSG_50_0_0_61_Data_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_5, getProfileFloat( "BAP", "A_FSG_50_0_0_61_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_5_range, getProfileFloat( "BAP", "A_FSG_50_0_0_61_5_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_61_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_61_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_61_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_TransPos, getProfileInt( "BAP", "A_FSG_50_0_0_61_TransPos", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_61_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Start, getProfileInt( "BAP", "A_FSG_50_0_0_61_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_61_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_3_Changed, getProfileFloat( "BAP", "A_FSG_50_0_0_61_3_Changed", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_3_Changed_range, getProfileFloat( "BAP", "A_FSG_50_0_0_61_3_Changed_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_1_Changed, getProfileInt( "BAP", "A_FSG_50_0_0_61_1_Changed", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_2_Changed, getProfileFloat( "BAP", "A_FSG_50_0_0_61_2_Changed", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_2_Changed_range, getProfileFloat( "BAP", "A_FSG_50_0_0_61_2_Changed_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_61_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Changed_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_61_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Changed_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_61_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Changed_TransPos, getProfileInt( "BAP", "A_FSG_50_0_0_61_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_61_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Changed_Start, getProfileInt( "BAP", "A_FSG_50_0_0_61_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_Changed_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_61_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_2_SetGet, getProfileFloat( "BAP", "A_FSG_50_0_0_61_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_50_0_0_61_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_1_SetGet, getProfileInt( "BAP", "A_FSG_50_0_0_61_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_61_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_SetGet_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_61_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_SetGet_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_61_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_61_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_SetGet_Start, getProfileInt( "BAP", "A_FSG_50_0_0_61_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_61_SetGet_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_61_SetGet_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62Changed_BTN, getProfileInt( "BAP", "A_FSG_50_0_0_62Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62Status_BTN, getProfileInt( "BAP", "A_FSG_50_0_0_62Status_BTN", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_FctLstItemEn, getProfileInt( "BAP", "A_FSG_50_0_0_62_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_FctEn, getProfileInt( "BAP", "A_FSG_50_0_0_62_FctEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_ErrEn, getProfileInt( "BAP", "A_FSG_50_0_0_62_ErrEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_IntTlgEn, getProfileInt( "BAP", "A_FSG_50_0_0_62_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_SegmEn, getProfileInt( "BAP", "A_FSG_50_0_0_62_SegmEn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_AT, getProfileInt( "BAP", "A_FSG_50_0_0_62_AT", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_ErrCode, getProfileInt( "BAP", "A_FSG_50_0_0_62_ErrCode", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_DataIndex, getProfileInt( "BAP", "A_FSG_50_0_0_62_DataIndex", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_50_0_0_62_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_50_0_0_62_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_loadArray_Btn, getProfileInt( "BAP", "A_FSG_50_0_0_62_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_generateData_Btn, getProfileInt( "BAP", "A_FSG_50_0_0_62_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Data_2, getProfileInt( "BAP", "A_FSG_50_0_0_62_Data_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Data_5_len, getProfileInt( "BAP", "A_FSG_50_0_0_62_Data_5_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Data_5_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_62_Data_5_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_2, getProfileFloat( "BAP", "A_FSG_50_0_0_62_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_2_range, getProfileFloat( "BAP", "A_FSG_50_0_0_62_2_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_1, getProfileInt( "BAP", "A_FSG_50_0_0_62_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Data_3_len, getProfileInt( "BAP", "A_FSG_50_0_0_62_Data_3_len", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Data_3_cnt, getProfileInt( "BAP", "A_FSG_50_0_0_62_Data_3_cnt", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Data_1, getProfileFloat( "BAP", "A_FSG_50_0_0_62_Data_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Data_1_range, getProfileFloat( "BAP", "A_FSG_50_0_0_62_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_3, getProfileFloat( "BAP", "A_FSG_50_0_0_62_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_3_range, getProfileFloat( "BAP", "A_FSG_50_0_0_62_3_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Data_4, getProfileFloat( "BAP", "A_FSG_50_0_0_62_Data_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Data_4_range, getProfileFloat( "BAP", "A_FSG_50_0_0_62_Data_4_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_62_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_62_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_62_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_TransPos, getProfileInt( "BAP", "A_FSG_50_0_0_62_TransPos", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_62_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Start, getProfileInt( "BAP", "A_FSG_50_0_0_62_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_62_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_62_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Changed_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_62_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Changed_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_62_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Changed_TransPos, getProfileInt( "BAP", "A_FSG_50_0_0_62_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_62_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Changed_Start, getProfileInt( "BAP", "A_FSG_50_0_0_62_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_Changed_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_62_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_2_SetGet, getProfileFloat( "BAP", "A_FSG_50_0_0_62_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_50_0_0_62_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_1_SetGet, getProfileInt( "BAP", "A_FSG_50_0_0_62_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_50_0_0_62_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_SetGet_Direction, getProfileInt( "BAP", "A_FSG_50_0_0_62_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_SetGet_Shift, getProfileInt( "BAP", "A_FSG_50_0_0_62_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_50_0_0_62_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_SetGet_Start, getProfileInt( "BAP", "A_FSG_50_0_0_62_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_50_0_0_62_SetGet_Elements, getProfileInt( "BAP", "A_FSG_50_0_0_62_SetGet_Elements", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_1, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_2, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_3, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_4, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_5, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_5", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_6, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_6", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_7, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_7", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_8, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_8", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_9, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_9", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_10, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_10", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_11, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_11", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_12, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_12", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_13, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_13", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_14, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_14", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_15, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_15", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_16, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_16", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_17, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_17", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_18, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_18", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_19, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_19", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_1, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_2, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_3, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_4, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_5, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_5", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_6, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_6", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_7, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_7", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_8, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_8", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_9, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_9", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_10, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_10", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_11, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_11", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_12, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_12", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_13, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_13", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_14, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_14", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_15, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_15", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_16, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_16", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_17, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_17", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_18, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_18", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_19, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_19", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_1, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_2, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_2", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_3, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_3", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_4, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_4", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_5, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_5", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_6, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_6", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_7, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_7", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_8, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_8", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_9, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_9", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_10, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_10", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_11, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_11", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_12, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_12", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_13, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_13", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_14, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_14", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_15, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_15", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_16, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_16", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_17, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_17", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_18, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_18", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_19, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_19", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_FRU, getProfileInt( "BAP", "A_FSG_50_0_0_24_FRU", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24Status_BTN2, getProfileInt( "BAP", "A_FSG_50_0_0_24Status_BTN2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_len_8, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_len_8", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_len_6, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_len_6", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_len_5, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_len_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_len_4, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_len_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_len_3, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_len_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_len_2, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_len_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_len_1, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_len_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_3_1, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_3_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_2_1, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_2_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_1_1, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_1_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_2_1, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_2_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_1_1, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_1_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_1_2, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_1_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_2_2, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_2_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_3_2, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_3_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_1_2, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_1_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_2_2, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_2_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_1_3, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_1_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_2_3, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_2_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_1_3, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_1_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_3_3, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_3_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_2_3, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_2_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_1_4, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_1_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_2_4, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_2_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_3_4, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_3_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_1_4, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_1_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_2_4, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_2_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_1_5, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_1_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_2_5, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_2_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_3_5, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_3_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_1_5, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_1_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_2_5, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_2_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_1_6, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_1_6", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_2_6, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_2_6", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_3_6, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_3_6", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_1_6, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_1_6", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_2_6, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_2_6", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_1_7, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_1_7", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_2_7, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_2_7", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_3_7, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_3_7", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_1_7, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_1_7", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_2_7, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_2_7", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_1_8, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_1_8", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_2_8, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_2_8", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_3_8, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_3_8", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_1_8, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_1_8", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_2_8, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_2_8", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_2_8, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_2_8", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_2_7, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_2_7", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_2_6, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_2_6", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_2_5, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_2_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_2_4, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_2_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_2_3, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_2_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_2_2, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_2_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_2_1, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_2_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_1_8, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_1_8", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_1_7, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_1_7", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_1_6, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_1_6", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_1_5, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_1_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_1_4, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_1_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_1_3, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_1_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_1_2, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_1_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_1_1, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_1_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_8_8, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_8_8", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_8_7, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_8_7", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_8_6, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_8_6", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_8_5, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_8_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_8_4, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_8_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_8_3, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_8_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_8_2, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_8_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_8_1, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_8_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_7_8, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_7_8", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_7_7, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_7_7", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_7_6, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_7_6", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_7_5, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_7_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_7_4, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_7_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_7_3, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_7_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_7_2, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_7_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_7_1, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_7_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_6_8, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_6_8", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_6_7, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_6_7", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_6_6, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_6_6", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_6_5, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_6_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_6_4, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_6_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_6_3, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_6_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_6_2, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_6_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_6_1, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_6_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_5_8, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_5_8", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_5_7, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_5_7", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_5_6, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_5_6", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_5_5, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_5_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_5_4, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_5_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_5_3, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_5_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_5_2, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_5_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_5_1, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_5_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_4_8, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_4_8", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_4_7, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_4_7", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_4_6, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_4_6", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_4_5, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_4_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_4_4, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_4_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_4_3, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_4_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_4_2, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_4_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_4_1, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_4_1", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_3_8, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_3_8", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_3_7, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_3_7", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_3_6, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_3_6", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_3_5, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_3_5", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_3_4, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_3_4", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_3_3, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_3_3", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_3_2, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_3_2", 0, profileFile ) );
    putValue( A_FSG_50_0_0_24_Data_3_empty_3_1, getProfileInt( "BAP", "A_FSG_50_0_0_24_Data_3_empty_3_1", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_3_BuildString, getProfileInt( "BAP", "P_FSG_50_0_0_23_3_BuildString", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_2_BuildString, getProfileInt( "BAP", "P_FSG_50_0_0_23_2_BuildString", 0, profileFile ) );
    putValue( P_FSG_50_0_0_23_1_BuildString, getProfileInt( "BAP", "P_FSG_50_0_0_23_1_BuildString", 0, profileFile ) );
    putValue( C_FSG_52_0_0_0_1_FctLstItemEn, getProfileInt( "BAP", "C_FSG_52_0_0_0_1_FctLstItemEn", 0, profileFile ) );
    putValue( C_FSG_52_0_0_0_1_FctEn, getProfileInt( "BAP", "C_FSG_52_0_0_0_1_FctEn", 0, profileFile ) );
    putValue( C_FSG_52_0_0_0_1_ErrEn, getProfileInt( "BAP", "C_FSG_52_0_0_0_1_ErrEn", 0, profileFile ) );
    putValue( C_FSG_52_0_0_0_1_IntTlgEn, getProfileInt( "BAP", "C_FSG_52_0_0_0_1_IntTlgEn", 0, profileFile ) );
    putValue( C_FSG_52_0_0_0_1_SegmEn, getProfileInt( "BAP", "C_FSG_52_0_0_0_1_SegmEn", 0, profileFile ) );
    putValue( C_FSG_52_0_0_0_1_ErrCode, getProfileInt( "BAP", "C_FSG_52_0_0_0_1_ErrCode", 0, profileFile ) );
    putValue( P_FSG_52_0_0_0_2Reset_BTN, getProfileInt( "BAP", "P_FSG_52_0_0_0_2Reset_BTN", 0, profileFile ) );
    putValue( P_FSG_52_0_0_0_2_FctLstItemEn, getProfileInt( "BAP", "P_FSG_52_0_0_0_2_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_0_2_FctEn, getProfileInt( "BAP", "P_FSG_52_0_0_0_2_FctEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_0_2_ErrEn, getProfileInt( "BAP", "P_FSG_52_0_0_0_2_ErrEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_0_2_ErrCode, getProfileInt( "BAP", "P_FSG_52_0_0_0_2_ErrCode", 0, profileFile ) );
    putValue( P_FSG_52_0_0_0_3_FctLstItemEn, getProfileInt( "BAP", "P_FSG_52_0_0_0_3_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_0_3_FctEn, getProfileInt( "BAP", "P_FSG_52_0_0_0_3_FctEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_0_3_ErrEn, getProfileInt( "BAP", "P_FSG_52_0_0_0_3_ErrEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_0_3_IntTlgEn, getProfileInt( "BAP", "P_FSG_52_0_0_0_3_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_0_3_SegmEn, getProfileInt( "BAP", "P_FSG_52_0_0_0_3_SegmEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_0_3_ErrCode, getProfileInt( "BAP", "P_FSG_52_0_0_0_3_ErrCode", 0, profileFile ) );
    putValue( ERRORLIST_FSG52_0_VT, getProfileInt( "BAP", "ERRORLIST_FSG52_0_VT", 0, profileFile ) );
    putValue( ON_OFF_FSG52_0, getProfileInt( "BAP", "ON_OFF_FSG52_0", 0, profileFile ) );
    putValue( BAPCFG_FSG_52_0_0_DFMajor, getProfileInt( "BAP", "BAPCFG_FSG_52_0_0_DFMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_52_0_0_DFMinor, getProfileInt( "BAP", "BAPCFG_FSG_52_0_0_DFMinor", 0, profileFile ) );
    putValue( BAPCFG_FSG_52_0_0_LsgClassMajor, getProfileInt( "BAP", "BAPCFG_FSG_52_0_0_LsgClassMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_52_0_0_LsgClassMinor, getProfileInt( "BAP", "BAPCFG_FSG_52_0_0_LsgClassMinor", 0, profileFile ) );
    putValue( BAPCFG_FSG_52_0_0_ProtocolMajor, getProfileInt( "BAP", "BAPCFG_FSG_52_0_0_ProtocolMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_52_0_0_ProtocolMinor, getProfileInt( "BAP", "BAPCFG_FSG_52_0_0_ProtocolMinor", 0, profileFile ) );
    putValue( C_FSG_52_0_0_1_FctLstItemEn, getProfileInt( "BAP", "C_FSG_52_0_0_1_FctLstItemEn", 0, profileFile ) );
    putValue( C_FSG_52_0_0_1_FctEn, getProfileInt( "BAP", "C_FSG_52_0_0_1_FctEn", 0, profileFile ) );
    putValue( C_FSG_52_0_0_1_ErrEn, getProfileInt( "BAP", "C_FSG_52_0_0_1_ErrEn", 0, profileFile ) );
    putValue( C_FSG_52_0_0_1_IntTlgEn, getProfileInt( "BAP", "C_FSG_52_0_0_1_IntTlgEn", 0, profileFile ) );
    putValue( C_FSG_52_0_0_1_SegmEn, getProfileInt( "BAP", "C_FSG_52_0_0_1_SegmEn", 0, profileFile ) );
    putValue( C_FSG_52_0_0_1_ErrCode, getProfileInt( "BAP", "C_FSG_52_0_0_1_ErrCode", 0, profileFile ) );
    putValue( P_FSG_52_0_0_2Reset_BTN, getProfileInt( "BAP", "P_FSG_52_0_0_2Reset_BTN", 0, profileFile ) );
    putValue( P_FSG_52_0_0_2_FctLstItemEn, getProfileInt( "BAP", "P_FSG_52_0_0_2_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_2_FctEn, getProfileInt( "BAP", "P_FSG_52_0_0_2_FctEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_2_ErrEn, getProfileInt( "BAP", "P_FSG_52_0_0_2_ErrEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_2_ErrCode, getProfileInt( "BAP", "P_FSG_52_0_0_2_ErrCode", 0, profileFile ) );
    putValue( P_FSG_52_0_0_2, getProfileFloat( "BAP", "P_FSG_52_0_0_2", 0, profileFile ) );
    putValue( P_FSG_52_0_0_2_range, getProfileFloat( "BAP", "P_FSG_52_0_0_2_range", 0, profileFile ) );
    putValue( P_FSG_52_0_0_3Status_BTN, getProfileInt( "BAP", "P_FSG_52_0_0_3Status_BTN", 0, profileFile ) );
    putValue( P_FSG_52_0_0_3_FctLstItemEn, getProfileInt( "BAP", "P_FSG_52_0_0_3_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_3_FctEn, getProfileInt( "BAP", "P_FSG_52_0_0_3_FctEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_3_ErrEn, getProfileInt( "BAP", "P_FSG_52_0_0_3_ErrEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_3_IntTlgEn, getProfileInt( "BAP", "P_FSG_52_0_0_3_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_3_SegmEn, getProfileInt( "BAP", "P_FSG_52_0_0_3_SegmEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_3_ErrCode, getProfileInt( "BAP", "P_FSG_52_0_0_3_ErrCode", 0, profileFile ) );
    putValue( P_FSG_52_0_0_4Status_BTN, getProfileInt( "BAP", "P_FSG_52_0_0_4Status_BTN", 0, profileFile ) );
    putValue( P_FSG_52_0_0_4_FctLstItemEn, getProfileInt( "BAP", "P_FSG_52_0_0_4_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_4_FctEn, getProfileInt( "BAP", "P_FSG_52_0_0_4_FctEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_4_ErrEn, getProfileInt( "BAP", "P_FSG_52_0_0_4_ErrEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_4_ErrCode, getProfileInt( "BAP", "P_FSG_52_0_0_4_ErrCode", 0, profileFile ) );
    putValue( P_FSG_52_0_0_4, getProfileInt( "BAP", "P_FSG_52_0_0_4", 0, profileFile ) );
    putValue( P_FSG_52_0_0_14Status_BTN, getProfileInt( "BAP", "P_FSG_52_0_0_14Status_BTN", 0, profileFile ) );
    putValue( P_FSG_52_0_0_14_FctLstItemEn, getProfileInt( "BAP", "P_FSG_52_0_0_14_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_14_FctEn, getProfileInt( "BAP", "P_FSG_52_0_0_14_FctEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_14_ErrEn, getProfileInt( "BAP", "P_FSG_52_0_0_14_ErrEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_14_ErrCode, getProfileInt( "BAP", "P_FSG_52_0_0_14_ErrCode", 0, profileFile ) );
    putValue( P_FSG_52_0_0_14, getProfileInt( "BAP", "P_FSG_52_0_0_14", 0, profileFile ) );
    putValue( P_FSG_52_0_0_14_1, getProfileInt( "BAP", "P_FSG_52_0_0_14_1", 0, profileFile ) );
    putValue( P_FSG_52_0_0_14_1_0, getProfileInt( "BAP", "P_FSG_52_0_0_14_1_0", 0, profileFile ) );
    putValue( P_FSG_52_0_0_14_1_1, getProfileInt( "BAP", "P_FSG_52_0_0_14_1_1", 0, profileFile ) );
    putValue( P_FSG_52_0_0_14_1_2, getProfileInt( "BAP", "P_FSG_52_0_0_14_1_2", 0, profileFile ) );
    putValue( P_FSG_52_0_0_14_1_3, getProfileInt( "BAP", "P_FSG_52_0_0_14_1_3", 0, profileFile ) );
    putValue( P_FSG_52_0_0_14_1_4, getProfileInt( "BAP", "P_FSG_52_0_0_14_1_4", 0, profileFile ) );
    putValue( P_FSG_52_0_0_15Status_BTN, getProfileInt( "BAP", "P_FSG_52_0_0_15Status_BTN", 0, profileFile ) );
    putValue( P_FSG_52_0_0_15_FctLstItemEn, getProfileInt( "BAP", "P_FSG_52_0_0_15_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_15_FctEn, getProfileInt( "BAP", "P_FSG_52_0_0_15_FctEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_15_ErrEn, getProfileInt( "BAP", "P_FSG_52_0_0_15_ErrEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_15_ErrCode, getProfileInt( "BAP", "P_FSG_52_0_0_15_ErrCode", 0, profileFile ) );
    putValue( P_FSG_52_0_0_15, getProfileInt( "BAP", "P_FSG_52_0_0_15", 0, profileFile ) );
    putValue( P_FSG_52_0_0_15_1, getProfileInt( "BAP", "P_FSG_52_0_0_15_1", 0, profileFile ) );
    putValue( P_FSG_52_0_0_16Status_BTN, getProfileInt( "BAP", "P_FSG_52_0_0_16Status_BTN", 0, profileFile ) );
    putValue( P_FSG_52_0_0_16_FctLstItemEn, getProfileInt( "BAP", "P_FSG_52_0_0_16_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_16_FctEn, getProfileInt( "BAP", "P_FSG_52_0_0_16_FctEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_16_ErrEn, getProfileInt( "BAP", "P_FSG_52_0_0_16_ErrEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_16_ErrCode, getProfileInt( "BAP", "P_FSG_52_0_0_16_ErrCode", 0, profileFile ) );
    putValue( P_FSG_52_0_0_16, getProfileInt( "BAP", "P_FSG_52_0_0_16", 0, profileFile ) );
    putValue( P_FSG_52_0_0_16_1, getProfileInt( "BAP", "P_FSG_52_0_0_16_1", 0, profileFile ) );
    putValue( P_FSG_52_0_0_16_1_0, getProfileInt( "BAP", "P_FSG_52_0_0_16_1_0", 0, profileFile ) );
    putValue( P_FSG_52_0_0_16_1_1, getProfileInt( "BAP", "P_FSG_52_0_0_16_1_1", 0, profileFile ) );
    putValue( P_FSG_52_0_0_16_1_2, getProfileInt( "BAP", "P_FSG_52_0_0_16_1_2", 0, profileFile ) );
    putValue( P_FSG_52_0_0_16_1_3, getProfileInt( "BAP", "P_FSG_52_0_0_16_1_3", 0, profileFile ) );
    putValue( P_FSG_52_0_0_16_1_4, getProfileInt( "BAP", "P_FSG_52_0_0_16_1_4", 0, profileFile ) );
    putValue( P_FSG_52_0_0_16_1_5, getProfileInt( "BAP", "P_FSG_52_0_0_16_1_5", 0, profileFile ) );
    putValue( P_FSG_52_0_0_17Status_BTN, getProfileInt( "BAP", "P_FSG_52_0_0_17Status_BTN", 0, profileFile ) );
    putValue( P_FSG_52_0_0_17StatusAck_BTN, getProfileInt( "BAP", "P_FSG_52_0_0_17StatusAck_BTN", 0, profileFile ) );
    putValue( P_FSG_52_0_0_17_FctLstItemEn, getProfileInt( "BAP", "P_FSG_52_0_0_17_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_17_FctEn, getProfileInt( "BAP", "P_FSG_52_0_0_17_FctEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_17_ErrEn, getProfileInt( "BAP", "P_FSG_52_0_0_17_ErrEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_17_ErrCode, getProfileInt( "BAP", "P_FSG_52_0_0_17_ErrCode", 0, profileFile ) );
    putValue( P_FSG_52_0_0_17_Ack_5, getProfileInt( "BAP", "P_FSG_52_0_0_17_Ack_5", 0, profileFile ) );
    putValue( P_FSG_52_0_0_17_Ack_4, getProfileInt( "BAP", "P_FSG_52_0_0_17_Ack_4", 0, profileFile ) );
    putValue( P_FSG_52_0_0_17_Ack_3, getProfileInt( "BAP", "P_FSG_52_0_0_17_Ack_3", 0, profileFile ) );
    putValue( P_FSG_52_0_0_17_Ack_2, getProfileInt( "BAP", "P_FSG_52_0_0_17_Ack_2", 0, profileFile ) );
    putValue( P_FSG_52_0_0_17_Ack_1, getProfileInt( "BAP", "P_FSG_52_0_0_17_Ack_1", 0, profileFile ) );
    putValue( P_FSG_52_0_0_17_5, getProfileInt( "BAP", "P_FSG_52_0_0_17_5", 0, profileFile ) );
    putValue( P_FSG_52_0_0_17_4, getProfileInt( "BAP", "P_FSG_52_0_0_17_4", 0, profileFile ) );
    putValue( P_FSG_52_0_0_17_3, getProfileInt( "BAP", "P_FSG_52_0_0_17_3", 0, profileFile ) );
    putValue( P_FSG_52_0_0_17_2, getProfileInt( "BAP", "P_FSG_52_0_0_17_2", 0, profileFile ) );
    putValue( P_FSG_52_0_0_17_1, getProfileInt( "BAP", "P_FSG_52_0_0_17_1", 0, profileFile ) );
    putValue( P_FSG_52_0_0_18Status_BTN, getProfileInt( "BAP", "P_FSG_52_0_0_18Status_BTN", 0, profileFile ) );
    putValue( P_FSG_52_0_0_18_FctLstItemEn, getProfileInt( "BAP", "P_FSG_52_0_0_18_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_18_FctEn, getProfileInt( "BAP", "P_FSG_52_0_0_18_FctEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_18_ErrEn, getProfileInt( "BAP", "P_FSG_52_0_0_18_ErrEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_18_ErrCode, getProfileInt( "BAP", "P_FSG_52_0_0_18_ErrCode", 0, profileFile ) );
    putValue( P_FSG_52_0_0_18_2, getProfileInt( "BAP", "P_FSG_52_0_0_18_2", 0, profileFile ) );
    putValue( P_FSG_52_0_0_18_1, getProfileInt( "BAP", "P_FSG_52_0_0_18_1", 0, profileFile ) );
    putValue( P_FSG_52_0_0_18_3, getProfileInt( "BAP", "P_FSG_52_0_0_18_3", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19Status_BTN, getProfileInt( "BAP", "P_FSG_52_0_0_19Status_BTN", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_FctLstItemEn, getProfileInt( "BAP", "P_FSG_52_0_0_19_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_FctEn, getProfileInt( "BAP", "P_FSG_52_0_0_19_FctEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_ErrEn, getProfileInt( "BAP", "P_FSG_52_0_0_19_ErrEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_IntTlgEn, getProfileInt( "BAP", "P_FSG_52_0_0_19_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_SegmEn, getProfileInt( "BAP", "P_FSG_52_0_0_19_SegmEn", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_ErrCode, getProfileInt( "BAP", "P_FSG_52_0_0_19_ErrCode", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_10, getProfileInt( "BAP", "P_FSG_52_0_0_19_10", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_4, getProfileInt( "BAP", "P_FSG_52_0_0_19_4", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_9_len, getProfileInt( "BAP", "P_FSG_52_0_0_19_9_len", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_9_cnt, getProfileInt( "BAP", "P_FSG_52_0_0_19_9_cnt", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_11, getProfileFloat( "BAP", "P_FSG_52_0_0_19_11", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_11_range, getProfileFloat( "BAP", "P_FSG_52_0_0_19_11_range", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_2, getProfileInt( "BAP", "P_FSG_52_0_0_19_2", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_8_OptionType, getProfileInt( "BAP", "P_FSG_52_0_0_19_8_OptionType", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_8_OptionString_len, getProfileInt( "BAP", "P_FSG_52_0_0_19_8_OptionString_len", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_8_OptionString_cnt, getProfileInt( "BAP", "P_FSG_52_0_0_19_8_OptionString_cnt", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_7_OptionType, getProfileInt( "BAP", "P_FSG_52_0_0_19_7_OptionType", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_7_OptionString_len, getProfileInt( "BAP", "P_FSG_52_0_0_19_7_OptionString_len", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_7_OptionString_cnt, getProfileInt( "BAP", "P_FSG_52_0_0_19_7_OptionString_cnt", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_3, getProfileInt( "BAP", "P_FSG_52_0_0_19_3", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_6_OptionType, getProfileInt( "BAP", "P_FSG_52_0_0_19_6_OptionType", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_6_OptionString_len, getProfileInt( "BAP", "P_FSG_52_0_0_19_6_OptionString_len", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_6_OptionString_cnt, getProfileInt( "BAP", "P_FSG_52_0_0_19_6_OptionString_cnt", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_5_OptionType, getProfileInt( "BAP", "P_FSG_52_0_0_19_5_OptionType", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_5_OptionString_len, getProfileInt( "BAP", "P_FSG_52_0_0_19_5_OptionString_len", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_5_OptionString_cnt, getProfileInt( "BAP", "P_FSG_52_0_0_19_5_OptionString_cnt", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_1, getProfileFloat( "BAP", "P_FSG_52_0_0_19_1", 0, profileFile ) );
    putValue( P_FSG_52_0_0_19_1_range, getProfileFloat( "BAP", "P_FSG_52_0_0_19_1_range", 0, profileFile ) );
    putValue( M_FSG_52_0_0_20Result_BTN, getProfileInt( "BAP", "M_FSG_52_0_0_20Result_BTN", 0, profileFile ) );
    putValue( M_FSG_52_0_0_20_FctLstItemEn, getProfileInt( "BAP", "M_FSG_52_0_0_20_FctLstItemEn", 0, profileFile ) );
    putValue( M_FSG_52_0_0_20_FctEn, getProfileInt( "BAP", "M_FSG_52_0_0_20_FctEn", 0, profileFile ) );
    putValue( M_FSG_52_0_0_20_ErrEn, getProfileInt( "BAP", "M_FSG_52_0_0_20_ErrEn", 0, profileFile ) );
    putValue( M_FSG_52_0_0_20_ErrCode, getProfileInt( "BAP", "M_FSG_52_0_0_20_ErrCode", 0, profileFile ) );
    putValue( M_FSG_52_0_0_20_Result, getProfileInt( "BAP", "M_FSG_52_0_0_20_Result", 0, profileFile ) );
    putValue( M_FSG_52_0_0_20_Result_1, getProfileInt( "BAP", "M_FSG_52_0_0_20_Result_1", 0, profileFile ) );
    putValue( M_FSG_52_0_0_20_Processing_1_range, getProfileInt( "BAP", "M_FSG_52_0_0_20_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_52_0_0_20_Processing_1_range, getProfileFloat( "BAP", "M_FSG_52_0_0_20_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_52_0_0_20_Processing_1_range, getProfileFloat( "BAP", "M_FSG_52_0_0_20_Processing_1_range", 0, profileFile ) );
    putValue( M_FSG_52_0_0_20_Start_1, getProfileFloat( "BAP", "M_FSG_52_0_0_20_Start_1", 0, profileFile ) );
    putValue( M_FSG_52_0_0_20_Start_1_range, getProfileFloat( "BAP", "M_FSG_52_0_0_20_Start_1_range", 0, profileFile ) );
    putValue( M_FSG_52_0_0_20_Start_2, getProfileInt( "BAP", "M_FSG_52_0_0_20_Start_2", 0, profileFile ) );
    putValue( C_FSG_60_0_0_0_1_FctLstItemEn, getProfileInt( "BAP", "C_FSG_60_0_0_0_1_FctLstItemEn", 0, profileFile ) );
    putValue( C_FSG_60_0_0_0_1_FctEn, getProfileInt( "BAP", "C_FSG_60_0_0_0_1_FctEn", 0, profileFile ) );
    putValue( C_FSG_60_0_0_0_1_ErrEn, getProfileInt( "BAP", "C_FSG_60_0_0_0_1_ErrEn", 0, profileFile ) );
    putValue( C_FSG_60_0_0_0_1_IntTlgEn, getProfileInt( "BAP", "C_FSG_60_0_0_0_1_IntTlgEn", 0, profileFile ) );
    putValue( C_FSG_60_0_0_0_1_SegmEn, getProfileInt( "BAP", "C_FSG_60_0_0_0_1_SegmEn", 0, profileFile ) );
    putValue( C_FSG_60_0_0_0_1_ErrCode, getProfileInt( "BAP", "C_FSG_60_0_0_0_1_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_0_2Reset_BTN, getProfileInt( "BAP", "P_FSG_60_0_0_0_2Reset_BTN", 0, profileFile ) );
    putValue( P_FSG_60_0_0_0_2_FctLstItemEn, getProfileInt( "BAP", "P_FSG_60_0_0_0_2_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_0_2_FctEn, getProfileInt( "BAP", "P_FSG_60_0_0_0_2_FctEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_0_2_ErrEn, getProfileInt( "BAP", "P_FSG_60_0_0_0_2_ErrEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_0_2_ErrCode, getProfileInt( "BAP", "P_FSG_60_0_0_0_2_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_0_3_FctLstItemEn, getProfileInt( "BAP", "P_FSG_60_0_0_0_3_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_0_3_FctEn, getProfileInt( "BAP", "P_FSG_60_0_0_0_3_FctEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_0_3_ErrEn, getProfileInt( "BAP", "P_FSG_60_0_0_0_3_ErrEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_0_3_IntTlgEn, getProfileInt( "BAP", "P_FSG_60_0_0_0_3_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_0_3_SegmEn, getProfileInt( "BAP", "P_FSG_60_0_0_0_3_SegmEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_0_3_ErrCode, getProfileInt( "BAP", "P_FSG_60_0_0_0_3_ErrCode", 0, profileFile ) );
    putValue( ERRORLIST_FSG60_0_VT, getProfileInt( "BAP", "ERRORLIST_FSG60_0_VT", 0, profileFile ) );
    putValue( BusType_FSG60_0, getProfileInt( "BAP", "BusType_FSG60_0", 0, profileFile ) );
    putValue( ON_OFF_FSG60_0, getProfileInt( "BAP", "ON_OFF_FSG60_0", 0, profileFile ) );
    putValue( BAPCFG_FSG_60_0_0_DFMajor, getProfileInt( "BAP", "BAPCFG_FSG_60_0_0_DFMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_60_0_0_DFMinor, getProfileInt( "BAP", "BAPCFG_FSG_60_0_0_DFMinor", 0, profileFile ) );
    putValue( BAPCFG_FSG_60_0_0_LsgClassMajor, getProfileInt( "BAP", "BAPCFG_FSG_60_0_0_LsgClassMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_60_0_0_LsgClassMinor, getProfileInt( "BAP", "BAPCFG_FSG_60_0_0_LsgClassMinor", 0, profileFile ) );
    putValue( BAPCFG_FSG_60_0_0_ProtocolMajor, getProfileInt( "BAP", "BAPCFG_FSG_60_0_0_ProtocolMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_60_0_0_ProtocolMinor, getProfileInt( "BAP", "BAPCFG_FSG_60_0_0_ProtocolMinor", 0, profileFile ) );
    putValue( C_FSG_60_0_0_1_FctLstItemEn, getProfileInt( "BAP", "C_FSG_60_0_0_1_FctLstItemEn", 0, profileFile ) );
    putValue( C_FSG_60_0_0_1_FctEn, getProfileInt( "BAP", "C_FSG_60_0_0_1_FctEn", 0, profileFile ) );
    putValue( C_FSG_60_0_0_1_ErrEn, getProfileInt( "BAP", "C_FSG_60_0_0_1_ErrEn", 0, profileFile ) );
    putValue( C_FSG_60_0_0_1_IntTlgEn, getProfileInt( "BAP", "C_FSG_60_0_0_1_IntTlgEn", 0, profileFile ) );
    putValue( C_FSG_60_0_0_1_SegmEn, getProfileInt( "BAP", "C_FSG_60_0_0_1_SegmEn", 0, profileFile ) );
    putValue( C_FSG_60_0_0_1_ErrCode, getProfileInt( "BAP", "C_FSG_60_0_0_1_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_2Reset_BTN, getProfileInt( "BAP", "P_FSG_60_0_0_2Reset_BTN", 0, profileFile ) );
    putValue( P_FSG_60_0_0_2_FctLstItemEn, getProfileInt( "BAP", "P_FSG_60_0_0_2_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_2_FctEn, getProfileInt( "BAP", "P_FSG_60_0_0_2_FctEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_2_ErrEn, getProfileInt( "BAP", "P_FSG_60_0_0_2_ErrEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_2_ErrCode, getProfileInt( "BAP", "P_FSG_60_0_0_2_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_2, getProfileFloat( "BAP", "P_FSG_60_0_0_2", 0, profileFile ) );
    putValue( P_FSG_60_0_0_2_range, getProfileFloat( "BAP", "P_FSG_60_0_0_2_range", 0, profileFile ) );
    putValue( P_FSG_60_0_0_3Status_BTN, getProfileInt( "BAP", "P_FSG_60_0_0_3Status_BTN", 0, profileFile ) );
    putValue( P_FSG_60_0_0_3_FctLstItemEn, getProfileInt( "BAP", "P_FSG_60_0_0_3_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_3_FctEn, getProfileInt( "BAP", "P_FSG_60_0_0_3_FctEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_3_ErrEn, getProfileInt( "BAP", "P_FSG_60_0_0_3_ErrEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_3_IntTlgEn, getProfileInt( "BAP", "P_FSG_60_0_0_3_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_3_SegmEn, getProfileInt( "BAP", "P_FSG_60_0_0_3_SegmEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_3_ErrCode, getProfileInt( "BAP", "P_FSG_60_0_0_3_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_4Status_BTN, getProfileInt( "BAP", "P_FSG_60_0_0_4Status_BTN", 0, profileFile ) );
    putValue( P_FSG_60_0_0_4_FctLstItemEn, getProfileInt( "BAP", "P_FSG_60_0_0_4_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_4_FctEn, getProfileInt( "BAP", "P_FSG_60_0_0_4_FctEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_4_ErrEn, getProfileInt( "BAP", "P_FSG_60_0_0_4_ErrEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_4_ErrCode, getProfileInt( "BAP", "P_FSG_60_0_0_4_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_4, getProfileInt( "BAP", "P_FSG_60_0_0_4", 0, profileFile ) );
    putValue( P_FSG_60_0_0_13Status_BTN, getProfileInt( "BAP", "P_FSG_60_0_0_13Status_BTN", 0, profileFile ) );
    putValue( P_FSG_60_0_0_13_FctLstItemEn, getProfileInt( "BAP", "P_FSG_60_0_0_13_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_13_FctEn, getProfileInt( "BAP", "P_FSG_60_0_0_13_FctEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_13_ErrEn, getProfileInt( "BAP", "P_FSG_60_0_0_13_ErrEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_13_ErrCode, getProfileInt( "BAP", "P_FSG_60_0_0_13_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_13, getProfileInt( "BAP", "P_FSG_60_0_0_13", 0, profileFile ) );
    putValue( P_FSG_60_0_0_13_1, getProfileInt( "BAP", "P_FSG_60_0_0_13_1", 0, profileFile ) );
    putValue( P_FSG_60_0_0_13_1_0, getProfileInt( "BAP", "P_FSG_60_0_0_13_1_0", 0, profileFile ) );
    putValue( P_FSG_60_0_0_13_1_4, getProfileInt( "BAP", "P_FSG_60_0_0_13_1_4", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14Status_BTN, getProfileInt( "BAP", "P_FSG_60_0_0_14Status_BTN", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_FctLstItemEn, getProfileInt( "BAP", "P_FSG_60_0_0_14_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_FctEn, getProfileInt( "BAP", "P_FSG_60_0_0_14_FctEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_ErrEn, getProfileInt( "BAP", "P_FSG_60_0_0_14_ErrEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_ErrCode, getProfileInt( "BAP", "P_FSG_60_0_0_14_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_3, getProfileFloat( "BAP", "P_FSG_60_0_0_14_3", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_3_range, getProfileFloat( "BAP", "P_FSG_60_0_0_14_3_range", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_1, getProfileInt( "BAP", "P_FSG_60_0_0_14_1", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_1_0, getProfileInt( "BAP", "P_FSG_60_0_0_14_1_0", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_1_1, getProfileInt( "BAP", "P_FSG_60_0_0_14_1_1", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_1_2, getProfileInt( "BAP", "P_FSG_60_0_0_14_1_2", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_1_3, getProfileInt( "BAP", "P_FSG_60_0_0_14_1_3", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_1_4, getProfileInt( "BAP", "P_FSG_60_0_0_14_1_4", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_1_5, getProfileInt( "BAP", "P_FSG_60_0_0_14_1_5", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_2, getProfileFloat( "BAP", "P_FSG_60_0_0_14_2", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_2_range, getProfileFloat( "BAP", "P_FSG_60_0_0_14_2_range", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_6, getProfileFloat( "BAP", "P_FSG_60_0_0_14_6", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_6_range, getProfileFloat( "BAP", "P_FSG_60_0_0_14_6_range", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_5, getProfileFloat( "BAP", "P_FSG_60_0_0_14_5", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_5_range, getProfileFloat( "BAP", "P_FSG_60_0_0_14_5_range", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_4, getProfileFloat( "BAP", "P_FSG_60_0_0_14_4", 0, profileFile ) );
    putValue( P_FSG_60_0_0_14_4_range, getProfileFloat( "BAP", "P_FSG_60_0_0_14_4_range", 0, profileFile ) );
    putValue( P_FSG_60_0_0_15Status_BTN, getProfileInt( "BAP", "P_FSG_60_0_0_15Status_BTN", 0, profileFile ) );
    putValue( P_FSG_60_0_0_15_FctLstItemEn, getProfileInt( "BAP", "P_FSG_60_0_0_15_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_15_FctEn, getProfileInt( "BAP", "P_FSG_60_0_0_15_FctEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_15_ErrEn, getProfileInt( "BAP", "P_FSG_60_0_0_15_ErrEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_15_ErrCode, getProfileInt( "BAP", "P_FSG_60_0_0_15_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_15, getProfileInt( "BAP", "P_FSG_60_0_0_15", 0, profileFile ) );
    putValue( P_FSG_60_0_0_15_1, getProfileInt( "BAP", "P_FSG_60_0_0_15_1", 0, profileFile ) );
    putValue( P_FSG_60_0_0_16Status_BTN, getProfileInt( "BAP", "P_FSG_60_0_0_16Status_BTN", 0, profileFile ) );
    putValue( P_FSG_60_0_0_16_FctLstItemEn, getProfileInt( "BAP", "P_FSG_60_0_0_16_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_16_FctEn, getProfileInt( "BAP", "P_FSG_60_0_0_16_FctEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_16_ErrEn, getProfileInt( "BAP", "P_FSG_60_0_0_16_ErrEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_16_ErrCode, getProfileInt( "BAP", "P_FSG_60_0_0_16_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_16_1, getProfileInt( "BAP", "P_FSG_60_0_0_16_1", 0, profileFile ) );
    putValue( P_FSG_60_0_0_16_2, getProfileInt( "BAP", "P_FSG_60_0_0_16_2", 0, profileFile ) );
    putValue( P_FSG_60_0_0_16_3, getProfileInt( "BAP", "P_FSG_60_0_0_16_3", 0, profileFile ) );
    putValue( P_FSG_60_0_0_16_3_0, getProfileInt( "BAP", "P_FSG_60_0_0_16_3_0", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17Status_BTN, getProfileInt( "BAP", "P_FSG_60_0_0_17Status_BTN", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_FctLstItemEn, getProfileInt( "BAP", "P_FSG_60_0_0_17_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_FctEn, getProfileInt( "BAP", "P_FSG_60_0_0_17_FctEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_ErrEn, getProfileInt( "BAP", "P_FSG_60_0_0_17_ErrEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_ErrCode, getProfileInt( "BAP", "P_FSG_60_0_0_17_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_1, getProfileInt( "BAP", "P_FSG_60_0_0_17_1", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_2, getProfileInt( "BAP", "P_FSG_60_0_0_17_2", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_4, getProfileInt( "BAP", "P_FSG_60_0_0_17_4", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_4_0, getProfileInt( "BAP", "P_FSG_60_0_0_17_4_0", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_4_1, getProfileInt( "BAP", "P_FSG_60_0_0_17_4_1", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_4_2, getProfileInt( "BAP", "P_FSG_60_0_0_17_4_2", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_4_3, getProfileInt( "BAP", "P_FSG_60_0_0_17_4_3", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_4_4, getProfileInt( "BAP", "P_FSG_60_0_0_17_4_4", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_4_5, getProfileInt( "BAP", "P_FSG_60_0_0_17_4_5", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_4_6, getProfileInt( "BAP", "P_FSG_60_0_0_17_4_6", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_4_7, getProfileInt( "BAP", "P_FSG_60_0_0_17_4_7", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_4_8, getProfileInt( "BAP", "P_FSG_60_0_0_17_4_8", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_4_9, getProfileInt( "BAP", "P_FSG_60_0_0_17_4_9", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_4_10, getProfileInt( "BAP", "P_FSG_60_0_0_17_4_10", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_4_11, getProfileInt( "BAP", "P_FSG_60_0_0_17_4_11", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_4_12, getProfileInt( "BAP", "P_FSG_60_0_0_17_4_12", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_4_13, getProfileInt( "BAP", "P_FSG_60_0_0_17_4_13", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_4_14, getProfileInt( "BAP", "P_FSG_60_0_0_17_4_14", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_4_15, getProfileInt( "BAP", "P_FSG_60_0_0_17_4_15", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_3_Value, getProfileFloat( "BAP", "P_FSG_60_0_0_17_3_Value", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_3_Value_range, getProfileFloat( "BAP", "P_FSG_60_0_0_17_3_Value_range", 0, profileFile ) );
    putValue( P_FSG_60_0_0_17_3_Unit, getProfileInt( "BAP", "P_FSG_60_0_0_17_3_Unit", 0, profileFile ) );
    putValue( P_FSG_60_0_0_18Status_BTN, getProfileInt( "BAP", "P_FSG_60_0_0_18Status_BTN", 0, profileFile ) );
    putValue( P_FSG_60_0_0_18_FctLstItemEn, getProfileInt( "BAP", "P_FSG_60_0_0_18_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_18_FctEn, getProfileInt( "BAP", "P_FSG_60_0_0_18_FctEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_18_ErrEn, getProfileInt( "BAP", "P_FSG_60_0_0_18_ErrEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_18_ErrCode, getProfileInt( "BAP", "P_FSG_60_0_0_18_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_18_4, getProfileFloat( "BAP", "P_FSG_60_0_0_18_4", 0, profileFile ) );
    putValue( P_FSG_60_0_0_18_4_range, getProfileFloat( "BAP", "P_FSG_60_0_0_18_4_range", 0, profileFile ) );
    putValue( P_FSG_60_0_0_18_2, getProfileInt( "BAP", "P_FSG_60_0_0_18_2", 0, profileFile ) );
    putValue( P_FSG_60_0_0_18_1, getProfileInt( "BAP", "P_FSG_60_0_0_18_1", 0, profileFile ) );
    putValue( P_FSG_60_0_0_18_1_0, getProfileInt( "BAP", "P_FSG_60_0_0_18_1_0", 0, profileFile ) );
    putValue( P_FSG_60_0_0_18_1_1, getProfileInt( "BAP", "P_FSG_60_0_0_18_1_1", 0, profileFile ) );
    putValue( P_FSG_60_0_0_18_3_Distance_Value, getProfileFloat( "BAP", "P_FSG_60_0_0_18_3_Distance_Value", 0, profileFile ) );
    putValue( P_FSG_60_0_0_18_3_Distance_Value_range, getProfileFloat( "BAP", "P_FSG_60_0_0_18_3_Distance_Value_range", 0, profileFile ) );
    putValue( P_FSG_60_0_0_18_3_Distance_Unit, getProfileInt( "BAP", "P_FSG_60_0_0_18_3_Distance_Unit", 0, profileFile ) );
    putValue( P_FSG_60_0_0_19Status_BTN, getProfileInt( "BAP", "P_FSG_60_0_0_19Status_BTN", 0, profileFile ) );
    putValue( P_FSG_60_0_0_19StatusAck_BTN, getProfileInt( "BAP", "P_FSG_60_0_0_19StatusAck_BTN", 0, profileFile ) );
    putValue( P_FSG_60_0_0_19_FctLstItemEn, getProfileInt( "BAP", "P_FSG_60_0_0_19_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_19_FctEn, getProfileInt( "BAP", "P_FSG_60_0_0_19_FctEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_19_ErrEn, getProfileInt( "BAP", "P_FSG_60_0_0_19_ErrEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_19_ErrCode, getProfileInt( "BAP", "P_FSG_60_0_0_19_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_19_Ack_2, getProfileInt( "BAP", "P_FSG_60_0_0_19_Ack_2", 0, profileFile ) );
    putValue( P_FSG_60_0_0_19_Ack_3, getProfileInt( "BAP", "P_FSG_60_0_0_19_Ack_3", 0, profileFile ) );
    putValue( P_FSG_60_0_0_19_Ack_1, getProfileFloat( "BAP", "P_FSG_60_0_0_19_Ack_1", 0, profileFile ) );
    putValue( P_FSG_60_0_0_19_Ack_1_range, getProfileFloat( "BAP", "P_FSG_60_0_0_19_Ack_1_range", 0, profileFile ) );
    putValue( P_FSG_60_0_0_19_2, getProfileInt( "BAP", "P_FSG_60_0_0_19_2", 0, profileFile ) );
    putValue( P_FSG_60_0_0_19_3, getProfileInt( "BAP", "P_FSG_60_0_0_19_3", 0, profileFile ) );
    putValue( P_FSG_60_0_0_19_1, getProfileFloat( "BAP", "P_FSG_60_0_0_19_1", 0, profileFile ) );
    putValue( P_FSG_60_0_0_19_1_range, getProfileFloat( "BAP", "P_FSG_60_0_0_19_1_range", 0, profileFile ) );
    putValue( P_FSG_60_0_0_20Status_BTN, getProfileInt( "BAP", "P_FSG_60_0_0_20Status_BTN", 0, profileFile ) );
    putValue( P_FSG_60_0_0_20_FctLstItemEn, getProfileInt( "BAP", "P_FSG_60_0_0_20_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_20_FctEn, getProfileInt( "BAP", "P_FSG_60_0_0_20_FctEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_20_ErrEn, getProfileInt( "BAP", "P_FSG_60_0_0_20_ErrEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_20_ErrCode, getProfileInt( "BAP", "P_FSG_60_0_0_20_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_20_2, getProfileFloat( "BAP", "P_FSG_60_0_0_20_2", 0, profileFile ) );
    putValue( P_FSG_60_0_0_20_2_range, getProfileFloat( "BAP", "P_FSG_60_0_0_20_2_range", 0, profileFile ) );
    putValue( P_FSG_60_0_0_20_1, getProfileFloat( "BAP", "P_FSG_60_0_0_20_1", 0, profileFile ) );
    putValue( P_FSG_60_0_0_20_1_range, getProfileFloat( "BAP", "P_FSG_60_0_0_20_1_range", 0, profileFile ) );
    putValue( P_FSG_60_0_0_21Status_BTN, getProfileInt( "BAP", "P_FSG_60_0_0_21Status_BTN", 0, profileFile ) );
    putValue( P_FSG_60_0_0_21_FctLstItemEn, getProfileInt( "BAP", "P_FSG_60_0_0_21_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_21_FctEn, getProfileInt( "BAP", "P_FSG_60_0_0_21_FctEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_21_ErrEn, getProfileInt( "BAP", "P_FSG_60_0_0_21_ErrEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_21_ErrCode, getProfileInt( "BAP", "P_FSG_60_0_0_21_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_21, getProfileInt( "BAP", "P_FSG_60_0_0_21", 0, profileFile ) );
    putValue( P_FSG_60_0_0_21_1, getProfileInt( "BAP", "P_FSG_60_0_0_21_1", 0, profileFile ) );
    putValue( P_FSG_60_0_0_21_1_0, getProfileInt( "BAP", "P_FSG_60_0_0_21_1_0", 0, profileFile ) );
    putValue( P_FSG_60_0_0_21_1_1, getProfileInt( "BAP", "P_FSG_60_0_0_21_1_1", 0, profileFile ) );
    putValue( P_FSG_60_0_0_21_1_2, getProfileInt( "BAP", "P_FSG_60_0_0_21_1_2", 0, profileFile ) );
    putValue( P_FSG_60_0_0_22Status_BTN, getProfileInt( "BAP", "P_FSG_60_0_0_22Status_BTN", 0, profileFile ) );
    putValue( P_FSG_60_0_0_22_FctLstItemEn, getProfileInt( "BAP", "P_FSG_60_0_0_22_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_22_FctEn, getProfileInt( "BAP", "P_FSG_60_0_0_22_FctEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_22_ErrEn, getProfileInt( "BAP", "P_FSG_60_0_0_22_ErrEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_22_ErrCode, getProfileInt( "BAP", "P_FSG_60_0_0_22_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_22_1, getProfileInt( "BAP", "P_FSG_60_0_0_22_1", 0, profileFile ) );
    putValue( P_FSG_60_0_0_22_2, getProfileInt( "BAP", "P_FSG_60_0_0_22_2", 0, profileFile ) );
    putValue( P_FSG_60_0_0_22_3, getProfileInt( "BAP", "P_FSG_60_0_0_22_3", 0, profileFile ) );
    putValue( P_FSG_60_0_0_22_3_0, getProfileInt( "BAP", "P_FSG_60_0_0_22_3_0", 0, profileFile ) );
    putValue( P_FSG_60_0_0_23Status_BTN, getProfileInt( "BAP", "P_FSG_60_0_0_23Status_BTN", 0, profileFile ) );
    putValue( P_FSG_60_0_0_23_FctLstItemEn, getProfileInt( "BAP", "P_FSG_60_0_0_23_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_23_FctEn, getProfileInt( "BAP", "P_FSG_60_0_0_23_FctEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_23_ErrEn, getProfileInt( "BAP", "P_FSG_60_0_0_23_ErrEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_23_ErrCode, getProfileInt( "BAP", "P_FSG_60_0_0_23_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_23_1, getProfileInt( "BAP", "P_FSG_60_0_0_23_1", 0, profileFile ) );
    putValue( P_FSG_60_0_0_23_2, getProfileInt( "BAP", "P_FSG_60_0_0_23_2", 0, profileFile ) );
    putValue( P_FSG_60_0_0_23_3, getProfileInt( "BAP", "P_FSG_60_0_0_23_3", 0, profileFile ) );
    putValue( P_FSG_60_0_0_23_3_0, getProfileInt( "BAP", "P_FSG_60_0_0_23_3_0", 0, profileFile ) );
    putValue( P_FSG_60_0_0_24Status_BTN, getProfileInt( "BAP", "P_FSG_60_0_0_24Status_BTN", 0, profileFile ) );
    putValue( P_FSG_60_0_0_24_FctLstItemEn, getProfileInt( "BAP", "P_FSG_60_0_0_24_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_24_FctEn, getProfileInt( "BAP", "P_FSG_60_0_0_24_FctEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_24_ErrEn, getProfileInt( "BAP", "P_FSG_60_0_0_24_ErrEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_24_ErrCode, getProfileInt( "BAP", "P_FSG_60_0_0_24_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_24_1, getProfileInt( "BAP", "P_FSG_60_0_0_24_1", 0, profileFile ) );
    putValue( P_FSG_60_0_0_24_2, getProfileInt( "BAP", "P_FSG_60_0_0_24_2", 0, profileFile ) );
    putValue( P_FSG_60_0_0_24_3, getProfileInt( "BAP", "P_FSG_60_0_0_24_3", 0, profileFile ) );
    putValue( P_FSG_60_0_0_24_3_0, getProfileInt( "BAP", "P_FSG_60_0_0_24_3_0", 0, profileFile ) );
    putValue( P_FSG_60_0_0_25Status_BTN, getProfileInt( "BAP", "P_FSG_60_0_0_25Status_BTN", 0, profileFile ) );
    putValue( P_FSG_60_0_0_25_FctLstItemEn, getProfileInt( "BAP", "P_FSG_60_0_0_25_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_25_FctEn, getProfileInt( "BAP", "P_FSG_60_0_0_25_FctEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_25_ErrEn, getProfileInt( "BAP", "P_FSG_60_0_0_25_ErrEn", 0, profileFile ) );
    putValue( P_FSG_60_0_0_25_ErrCode, getProfileInt( "BAP", "P_FSG_60_0_0_25_ErrCode", 0, profileFile ) );
    putValue( P_FSG_60_0_0_25_1, getProfileInt( "BAP", "P_FSG_60_0_0_25_1", 0, profileFile ) );
    putValue( P_FSG_60_0_0_25_2, getProfileInt( "BAP", "P_FSG_60_0_0_25_2", 0, profileFile ) );
    putValue( P_FSG_60_0_0_25_3, getProfileInt( "BAP", "P_FSG_60_0_0_25_3", 0, profileFile ) );
    putValue( P_FSG_60_0_0_25_3_0, getProfileInt( "BAP", "P_FSG_60_0_0_25_3_0", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26Changed_BTN, getProfileInt( "BAP", "A_FSG_60_0_0_26Changed_BTN", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26Status_BTN, getProfileInt( "BAP", "A_FSG_60_0_0_26Status_BTN", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_FctLstItemEn, getProfileInt( "BAP", "A_FSG_60_0_0_26_FctLstItemEn", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_FctEn, getProfileInt( "BAP", "A_FSG_60_0_0_26_FctEn", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_ErrEn, getProfileInt( "BAP", "A_FSG_60_0_0_26_ErrEn", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_IntTlgEn, getProfileInt( "BAP", "A_FSG_60_0_0_26_IntTlgEn", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_SegmEn, getProfileInt( "BAP", "A_FSG_60_0_0_26_SegmEn", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_AT, getProfileInt( "BAP", "A_FSG_60_0_0_26_AT", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_ErrCode, getProfileInt( "BAP", "A_FSG_60_0_0_26_ErrCode", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_DataIndex, getProfileInt( "BAP", "A_FSG_60_0_0_26_DataIndex", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_DataIndex_Incr, getProfileInt( "BAP", "A_FSG_60_0_0_26_DataIndex_Incr", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_DataIndex_Decr, getProfileInt( "BAP", "A_FSG_60_0_0_26_DataIndex_Decr", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_loadArray_Btn, getProfileInt( "BAP", "A_FSG_60_0_0_26_loadArray_Btn", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_generateData_Btn, getProfileInt( "BAP", "A_FSG_60_0_0_26_generateData_Btn", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_4, getProfileFloat( "BAP", "A_FSG_60_0_0_26_Data_4", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_4_range, getProfileFloat( "BAP", "A_FSG_60_0_0_26_Data_4_range", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_2, getProfileInt( "BAP", "A_FSG_60_0_0_26_2", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_3, getProfileFloat( "BAP", "A_FSG_60_0_0_26_3", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_3_range, getProfileFloat( "BAP", "A_FSG_60_0_0_26_3_range", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_7, getProfileFloat( "BAP", "A_FSG_60_0_0_26_7", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_7_range, getProfileFloat( "BAP", "A_FSG_60_0_0_26_7_range", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_3, getProfileInt( "BAP", "A_FSG_60_0_0_26_Data_3", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_3_0, getProfileInt( "BAP", "A_FSG_60_0_0_26_Data_3_0", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_3_4, getProfileInt( "BAP", "A_FSG_60_0_0_26_Data_3_4", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_3_5, getProfileInt( "BAP", "A_FSG_60_0_0_26_Data_3_5", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_3_6, getProfileInt( "BAP", "A_FSG_60_0_0_26_Data_3_6", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_3_7, getProfileInt( "BAP", "A_FSG_60_0_0_26_Data_3_7", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_5, getProfileInt( "BAP", "A_FSG_60_0_0_26_5", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_2, getProfileFloat( "BAP", "A_FSG_60_0_0_26_Data_2", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_2_range, getProfileFloat( "BAP", "A_FSG_60_0_0_26_Data_2_range", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_1, getProfileInt( "BAP", "A_FSG_60_0_0_26_1", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_5_len, getProfileInt( "BAP", "A_FSG_60_0_0_26_Data_5_len", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_5_cnt, getProfileInt( "BAP", "A_FSG_60_0_0_26_Data_5_cnt", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_6, getProfileFloat( "BAP", "A_FSG_60_0_0_26_6", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_6_range, getProfileFloat( "BAP", "A_FSG_60_0_0_26_6_range", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_4, getProfileInt( "BAP", "A_FSG_60_0_0_26_4", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_4_0, getProfileInt( "BAP", "A_FSG_60_0_0_26_4_0", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_4_1, getProfileInt( "BAP", "A_FSG_60_0_0_26_4_1", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_4_2, getProfileInt( "BAP", "A_FSG_60_0_0_26_4_2", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_1, getProfileFloat( "BAP", "A_FSG_60_0_0_26_Data_1", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_1_range, getProfileFloat( "BAP", "A_FSG_60_0_0_26_Data_1_range", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_RecAdr, getProfileInt( "BAP", "A_FSG_60_0_0_26_RecAdr", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Direction, getProfileInt( "BAP", "A_FSG_60_0_0_26_Direction", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Shift, getProfileInt( "BAP", "A_FSG_60_0_0_26_Shift", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_TransPos, getProfileInt( "BAP", "A_FSG_60_0_0_26_TransPos", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_IndexSize, getProfileInt( "BAP", "A_FSG_60_0_0_26_IndexSize", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Start, getProfileInt( "BAP", "A_FSG_60_0_0_26_Start", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Elements, getProfileInt( "BAP", "A_FSG_60_0_0_26_Elements", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_2_Changed, getProfileInt( "BAP", "A_FSG_60_0_0_26_2_Changed", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_1_Changed, getProfileInt( "BAP", "A_FSG_60_0_0_26_1_Changed", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_3_Changed, getProfileFloat( "BAP", "A_FSG_60_0_0_26_3_Changed", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_3_Changed_range, getProfileFloat( "BAP", "A_FSG_60_0_0_26_3_Changed_range", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Changed_RecAdr, getProfileInt( "BAP", "A_FSG_60_0_0_26_Changed_RecAdr", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Changed_Direction, getProfileInt( "BAP", "A_FSG_60_0_0_26_Changed_Direction", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Changed_Shift, getProfileInt( "BAP", "A_FSG_60_0_0_26_Changed_Shift", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Changed_TransPos, getProfileInt( "BAP", "A_FSG_60_0_0_26_Changed_TransPos", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Changed_IndexSize, getProfileInt( "BAP", "A_FSG_60_0_0_26_Changed_IndexSize", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Changed_Start, getProfileInt( "BAP", "A_FSG_60_0_0_26_Changed_Start", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Changed_Elements, getProfileInt( "BAP", "A_FSG_60_0_0_26_Changed_Elements", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_DataIndex_SetGet, getProfileInt( "BAP", "A_FSG_60_0_0_26_DataIndex_SetGet", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_DataIndex_SetGet_Incr, getProfileInt( "BAP", "A_FSG_60_0_0_26_DataIndex_SetGet_Incr", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_DataIndex_SetGet_Decr, getProfileInt( "BAP", "A_FSG_60_0_0_26_DataIndex_SetGet_Decr", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_4_SetGet, getProfileFloat( "BAP", "A_FSG_60_0_0_26_Data_4_SetGet", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_4_SetGet_range, getProfileFloat( "BAP", "A_FSG_60_0_0_26_Data_4_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_2_SetGet, getProfileInt( "BAP", "A_FSG_60_0_0_26_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_3_SetGet, getProfileFloat( "BAP", "A_FSG_60_0_0_26_3_SetGet", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_3_SetGet_range, getProfileFloat( "BAP", "A_FSG_60_0_0_26_3_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_3_SetGet, getProfileInt( "BAP", "A_FSG_60_0_0_26_Data_3_SetGet", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_3_SetGet_0, getProfileInt( "BAP", "A_FSG_60_0_0_26_Data_3_SetGet_0", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_3_SetGet_4, getProfileInt( "BAP", "A_FSG_60_0_0_26_Data_3_SetGet_4", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_3_SetGet_5, getProfileInt( "BAP", "A_FSG_60_0_0_26_Data_3_SetGet_5", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_3_SetGet_6, getProfileInt( "BAP", "A_FSG_60_0_0_26_Data_3_SetGet_6", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_3_SetGet_7, getProfileInt( "BAP", "A_FSG_60_0_0_26_Data_3_SetGet_7", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_4_SetGet, getProfileInt( "BAP", "A_FSG_60_0_0_26_4_SetGet", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_2_SetGet, getProfileFloat( "BAP", "A_FSG_60_0_0_26_Data_2_SetGet", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_2_SetGet_range, getProfileFloat( "BAP", "A_FSG_60_0_0_26_Data_2_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_1_SetGet, getProfileInt( "BAP", "A_FSG_60_0_0_26_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_5_SetGet_len, getProfileInt( "BAP", "A_FSG_60_0_0_26_Data_5_SetGet_len", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_5_SetGet_cnt, getProfileInt( "BAP", "A_FSG_60_0_0_26_Data_5_SetGet_cnt", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_5_SetGet, getProfileFloat( "BAP", "A_FSG_60_0_0_26_5_SetGet", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_5_SetGet_range, getProfileFloat( "BAP", "A_FSG_60_0_0_26_5_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_1_SetGet, getProfileFloat( "BAP", "A_FSG_60_0_0_26_Data_1_SetGet", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_Data_1_SetGet_range, getProfileFloat( "BAP", "A_FSG_60_0_0_26_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_SetGet_RecAdr, getProfileInt( "BAP", "A_FSG_60_0_0_26_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_SetGet_Direction, getProfileInt( "BAP", "A_FSG_60_0_0_26_SetGet_Direction", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_SetGet_Shift, getProfileInt( "BAP", "A_FSG_60_0_0_26_SetGet_Shift", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_SetGet_IndexSize, getProfileInt( "BAP", "A_FSG_60_0_0_26_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_SetGet_Start, getProfileInt( "BAP", "A_FSG_60_0_0_26_SetGet_Start", 0, profileFile ) );
    putValue( A_FSG_60_0_0_26_SetGet_Elements, getProfileInt( "BAP", "A_FSG_60_0_0_26_SetGet_Elements", 0, profileFile ) );
    putValue( ERRORLIST_ASG18_1_VT, getProfileInt( "BAP", "ERRORLIST_ASG18_1_VT", 0, profileFile ) );
    putValue( ON_OFF_ASG18_1, getProfileInt( "BAP", "ON_OFF_ASG18_1", 0, profileFile ) );
    putValue( BAPCFG_ASG_18_1_0_DFMajor, getProfileInt( "BAP", "BAPCFG_ASG_18_1_0_DFMajor", 0, profileFile ) );
    putValue( BAPCFG_ASG_18_1_0_DFMinor, getProfileInt( "BAP", "BAPCFG_ASG_18_1_0_DFMinor", 0, profileFile ) );
    putValue( BAPCFG_ASG_18_1_0_LsgClassMajor, getProfileInt( "BAP", "BAPCFG_ASG_18_1_0_LsgClassMajor", 0, profileFile ) );
    putValue( BAPCFG_ASG_18_1_0_LsgClassMinor, getProfileInt( "BAP", "BAPCFG_ASG_18_1_0_LsgClassMinor", 0, profileFile ) );
    putValue( BAPCFG_ASG_18_1_0_ProtocolMajor, getProfileInt( "BAP", "BAPCFG_ASG_18_1_0_ProtocolMajor", 0, profileFile ) );
    putValue( BAPCFG_ASG_18_1_0_ProtocolMinor, getProfileInt( "BAP", "BAPCFG_ASG_18_1_0_ProtocolMinor", 0, profileFile ) );
    putValue( C_ASG_18_1_0_1GetAll_BTN, getProfileInt( "BAP", "C_ASG_18_1_0_1GetAll_BTN", 0, profileFile ) );
    putValue( C_ASG_18_1_0_1_FctLstItemEn, getProfileInt( "BAP", "C_ASG_18_1_0_1_FctLstItemEn", 0, profileFile ) );
    putValue( C_ASG_18_1_0_1_ErrCode, getProfileInt( "BAP", "C_ASG_18_1_0_1_ErrCode", 0, profileFile ) );
    putValue( P_ASG_18_1_0_2Get_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_2Get_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_2_FctLstItemEn, getProfileInt( "BAP", "P_ASG_18_1_0_2_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_18_1_0_2_ErrCode, getProfileInt( "BAP", "P_ASG_18_1_0_2_ErrCode", 0, profileFile ) );
    putValue( P_ASG_18_1_0_2, getProfileInt( "BAP", "P_ASG_18_1_0_2", 0, profileFile ) );
    putValue( P_ASG_18_1_0_2_range, getProfileInt( "BAP", "P_ASG_18_1_0_2_range", 0, profileFile ) );
    putValue( P_ASG_18_1_0_3Get_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_3Get_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_3_FctLstItemEn, getProfileInt( "BAP", "P_ASG_18_1_0_3_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_18_1_0_3_ErrCode, getProfileInt( "BAP", "P_ASG_18_1_0_3_ErrCode", 0, profileFile ) );
    putValue( P_ASG_18_1_0_4Get_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_4Get_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_4_FctLstItemEn, getProfileInt( "BAP", "P_ASG_18_1_0_4_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_18_1_0_4_ErrCode, getProfileInt( "BAP", "P_ASG_18_1_0_4_ErrCode", 0, profileFile ) );
    putValue( P_ASG_18_1_0_4, getProfileInt( "BAP", "P_ASG_18_1_0_4", 0, profileFile ) );
    putValue( P_ASG_18_1_0_4_range, getProfileInt( "BAP", "P_ASG_18_1_0_4_range", 0, profileFile ) );
    putValue( P_ASG_18_1_0_13Get_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_13Get_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_13SetGet_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_13SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_13_FctLstItemEn, getProfileInt( "BAP", "P_ASG_18_1_0_13_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_18_1_0_13_ErrCode, getProfileInt( "BAP", "P_ASG_18_1_0_13_ErrCode", 0, profileFile ) );
    putValue( P_ASG_18_1_0_13, getProfileInt( "BAP", "P_ASG_18_1_0_13", 0, profileFile ) );
    putValue( P_ASG_18_1_0_13_1, getProfileInt( "BAP", "P_ASG_18_1_0_13_1", 0, profileFile ) );
    putValue( P_ASG_18_1_0_13_1_0, getProfileInt( "BAP", "P_ASG_18_1_0_13_1_0", 0, profileFile ) );
    putValue( P_ASG_18_1_0_13_1_4, getProfileInt( "BAP", "P_ASG_18_1_0_13_1_4", 0, profileFile ) );
    putValue( P_ASG_18_1_0_15Get_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_15Get_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_15_FctLstItemEn, getProfileInt( "BAP", "P_ASG_18_1_0_15_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_18_1_0_15_ErrCode, getProfileInt( "BAP", "P_ASG_18_1_0_15_ErrCode", 0, profileFile ) );
    putValue( P_ASG_18_1_0_15, getProfileInt( "BAP", "P_ASG_18_1_0_15", 0, profileFile ) );
    putValue( P_ASG_18_1_0_15_1, getProfileInt( "BAP", "P_ASG_18_1_0_15_1", 0, profileFile ) );
    putValue( P_ASG_18_1_0_16Get_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_16Get_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_16_FctLstItemEn, getProfileInt( "BAP", "P_ASG_18_1_0_16_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_18_1_0_16_ErrCode, getProfileInt( "BAP", "P_ASG_18_1_0_16_ErrCode", 0, profileFile ) );
    putValue( P_ASG_18_1_0_16_3, getProfileInt( "BAP", "P_ASG_18_1_0_16_3", 0, profileFile ) );
    putValue( P_ASG_18_1_0_16_3_range, getProfileInt( "BAP", "P_ASG_18_1_0_16_3_range", 0, profileFile ) );
    putValue( P_ASG_18_1_0_16_2, getProfileInt( "BAP", "P_ASG_18_1_0_16_2", 0, profileFile ) );
    putValue( P_ASG_18_1_0_16_2_0, getProfileInt( "BAP", "P_ASG_18_1_0_16_2_0", 0, profileFile ) );
    putValue( P_ASG_18_1_0_16_1, getProfileInt( "BAP", "P_ASG_18_1_0_16_1", 0, profileFile ) );
    putValue( P_ASG_18_1_0_17Get_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_17Get_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_17_FctLstItemEn, getProfileInt( "BAP", "P_ASG_18_1_0_17_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_18_1_0_17_ErrCode, getProfileInt( "BAP", "P_ASG_18_1_0_17_ErrCode", 0, profileFile ) );
    putValue( P_ASG_18_1_0_17_1, getProfileInt( "BAP", "P_ASG_18_1_0_17_1", 0, profileFile ) );
    putValue( P_ASG_18_1_0_17_2, getProfileInt( "BAP", "P_ASG_18_1_0_17_2", 0, profileFile ) );
    putValue( P_ASG_18_1_0_17_2_range, getProfileInt( "BAP", "P_ASG_18_1_0_17_2_range", 0, profileFile ) );
    putValue( P_ASG_18_1_0_18Get_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_18Get_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_18_FctLstItemEn, getProfileInt( "BAP", "P_ASG_18_1_0_18_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_18_1_0_18_ErrCode, getProfileInt( "BAP", "P_ASG_18_1_0_18_ErrCode", 0, profileFile ) );
    putValue( P_ASG_18_1_0_18_3, getProfileInt( "BAP", "P_ASG_18_1_0_18_3", 0, profileFile ) );
    putValue( P_ASG_18_1_0_18_3_range, getProfileInt( "BAP", "P_ASG_18_1_0_18_3_range", 0, profileFile ) );
    putValue( P_ASG_18_1_0_18_2, getProfileInt( "BAP", "P_ASG_18_1_0_18_2", 0, profileFile ) );
    putValue( P_ASG_18_1_0_18_2_0, getProfileInt( "BAP", "P_ASG_18_1_0_18_2_0", 0, profileFile ) );
    putValue( P_ASG_18_1_0_18_1, getProfileInt( "BAP", "P_ASG_18_1_0_18_1", 0, profileFile ) );
    putValue( P_ASG_18_1_0_19Get_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_19Get_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_19_FctLstItemEn, getProfileInt( "BAP", "P_ASG_18_1_0_19_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_18_1_0_19_ErrCode, getProfileInt( "BAP", "P_ASG_18_1_0_19_ErrCode", 0, profileFile ) );
    putValue( P_ASG_18_1_0_19_1, getProfileInt( "BAP", "P_ASG_18_1_0_19_1", 0, profileFile ) );
    putValue( P_ASG_18_1_0_19_2, getProfileInt( "BAP", "P_ASG_18_1_0_19_2", 0, profileFile ) );
    putValue( P_ASG_18_1_0_19_2_range, getProfileInt( "BAP", "P_ASG_18_1_0_19_2_range", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20StartResult_BTN, getProfileInt( "BAP", "M_ASG_18_1_0_20StartResult_BTN", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_FctLstItemEn, getProfileInt( "BAP", "M_ASG_18_1_0_20_FctLstItemEn", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_ErrCode, getProfileInt( "BAP", "M_ASG_18_1_0_20_ErrCode", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_Result, getProfileInt( "BAP", "M_ASG_18_1_0_20_Result", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_Result_1, getProfileInt( "BAP", "M_ASG_18_1_0_20_Result_1", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_Result_1_0, getProfileInt( "BAP", "M_ASG_18_1_0_20_Result_1_0", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_Result_1_1, getProfileInt( "BAP", "M_ASG_18_1_0_20_Result_1_1", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_Result_1_2, getProfileInt( "BAP", "M_ASG_18_1_0_20_Result_1_2", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_Result_1_3, getProfileInt( "BAP", "M_ASG_18_1_0_20_Result_1_3", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_Processing, getProfileInt( "BAP", "M_ASG_18_1_0_20_Processing", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_Processing_1, getProfileInt( "BAP", "M_ASG_18_1_0_20_Processing_1", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_Processing_1_0, getProfileInt( "BAP", "M_ASG_18_1_0_20_Processing_1_0", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_Processing_1_1, getProfileInt( "BAP", "M_ASG_18_1_0_20_Processing_1_1", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_Processing_1_2, getProfileInt( "BAP", "M_ASG_18_1_0_20_Processing_1_2", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_Processing_1_3, getProfileInt( "BAP", "M_ASG_18_1_0_20_Processing_1_3", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_Start, getProfileInt( "BAP", "M_ASG_18_1_0_20_Start", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_Start_1, getProfileInt( "BAP", "M_ASG_18_1_0_20_Start_1", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_Start_1_0, getProfileInt( "BAP", "M_ASG_18_1_0_20_Start_1_0", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_Start_1_1, getProfileInt( "BAP", "M_ASG_18_1_0_20_Start_1_1", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_Start_1_2, getProfileInt( "BAP", "M_ASG_18_1_0_20_Start_1_2", 0, profileFile ) );
    putValue( M_ASG_18_1_0_20_Start_1_3, getProfileInt( "BAP", "M_ASG_18_1_0_20_Start_1_3", 0, profileFile ) );
    putValue( P_ASG_18_1_0_21Get_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_21Get_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_21SetGet_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_21SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_21_FctLstItemEn, getProfileInt( "BAP", "P_ASG_18_1_0_21_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_18_1_0_21_ErrCode, getProfileInt( "BAP", "P_ASG_18_1_0_21_ErrCode", 0, profileFile ) );
    putValue( P_ASG_18_1_0_21_3, getProfileFloat( "BAP", "P_ASG_18_1_0_21_3", 0, profileFile ) );
    putValue( P_ASG_18_1_0_21_3_range, getProfileFloat( "BAP", "P_ASG_18_1_0_21_3_range", 0, profileFile ) );
    putValue( P_ASG_18_1_0_21_2, getProfileInt( "BAP", "P_ASG_18_1_0_21_2", 0, profileFile ) );
    putValue( P_ASG_18_1_0_21_2_0, getProfileInt( "BAP", "P_ASG_18_1_0_21_2_0", 0, profileFile ) );
    putValue( P_ASG_18_1_0_21_1, getProfileInt( "BAP", "P_ASG_18_1_0_21_1", 0, profileFile ) );
    putValue( P_ASG_18_1_0_21_4, getProfileInt( "BAP", "P_ASG_18_1_0_21_4", 0, profileFile ) );
    putValue( P_ASG_18_1_0_21_5, getProfileInt( "BAP", "P_ASG_18_1_0_21_5", 0, profileFile ) );
    putValue( P_ASG_18_1_0_21_5_0, getProfileInt( "BAP", "P_ASG_18_1_0_21_5_0", 0, profileFile ) );
    putValue( P_ASG_18_1_0_22Get_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_22Get_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_22SetGet_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_22SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_22_FctLstItemEn, getProfileInt( "BAP", "P_ASG_18_1_0_22_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_18_1_0_22_ErrCode, getProfileInt( "BAP", "P_ASG_18_1_0_22_ErrCode", 0, profileFile ) );
    putValue( P_ASG_18_1_0_22_3, getProfileFloat( "BAP", "P_ASG_18_1_0_22_3", 0, profileFile ) );
    putValue( P_ASG_18_1_0_22_3_range, getProfileFloat( "BAP", "P_ASG_18_1_0_22_3_range", 0, profileFile ) );
    putValue( P_ASG_18_1_0_22_2, getProfileInt( "BAP", "P_ASG_18_1_0_22_2", 0, profileFile ) );
    putValue( P_ASG_18_1_0_22_2_0, getProfileInt( "BAP", "P_ASG_18_1_0_22_2_0", 0, profileFile ) );
    putValue( P_ASG_18_1_0_22_1, getProfileInt( "BAP", "P_ASG_18_1_0_22_1", 0, profileFile ) );
    putValue( P_ASG_18_1_0_22_4, getProfileInt( "BAP", "P_ASG_18_1_0_22_4", 0, profileFile ) );
    putValue( P_ASG_18_1_0_22_5, getProfileInt( "BAP", "P_ASG_18_1_0_22_5", 0, profileFile ) );
    putValue( P_ASG_18_1_0_22_5_0, getProfileInt( "BAP", "P_ASG_18_1_0_22_5_0", 0, profileFile ) );
    putValue( P_ASG_18_1_0_23Get_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_23Get_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_23SetGet_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_23SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_23_FctLstItemEn, getProfileInt( "BAP", "P_ASG_18_1_0_23_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_18_1_0_23_ErrCode, getProfileInt( "BAP", "P_ASG_18_1_0_23_ErrCode", 0, profileFile ) );
    putValue( P_ASG_18_1_0_23_3, getProfileFloat( "BAP", "P_ASG_18_1_0_23_3", 0, profileFile ) );
    putValue( P_ASG_18_1_0_23_3_range, getProfileFloat( "BAP", "P_ASG_18_1_0_23_3_range", 0, profileFile ) );
    putValue( P_ASG_18_1_0_23_2, getProfileInt( "BAP", "P_ASG_18_1_0_23_2", 0, profileFile ) );
    putValue( P_ASG_18_1_0_23_2_0, getProfileInt( "BAP", "P_ASG_18_1_0_23_2_0", 0, profileFile ) );
    putValue( P_ASG_18_1_0_23_1, getProfileInt( "BAP", "P_ASG_18_1_0_23_1", 0, profileFile ) );
    putValue( P_ASG_18_1_0_23_4, getProfileInt( "BAP", "P_ASG_18_1_0_23_4", 0, profileFile ) );
    putValue( P_ASG_18_1_0_23_5, getProfileInt( "BAP", "P_ASG_18_1_0_23_5", 0, profileFile ) );
    putValue( P_ASG_18_1_0_23_5_0, getProfileInt( "BAP", "P_ASG_18_1_0_23_5_0", 0, profileFile ) );
    putValue( P_ASG_18_1_0_24Get_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_24Get_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_24SetGet_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_24SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_24_FctLstItemEn, getProfileInt( "BAP", "P_ASG_18_1_0_24_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_18_1_0_24_ErrCode, getProfileInt( "BAP", "P_ASG_18_1_0_24_ErrCode", 0, profileFile ) );
    putValue( P_ASG_18_1_0_24_3, getProfileFloat( "BAP", "P_ASG_18_1_0_24_3", 0, profileFile ) );
    putValue( P_ASG_18_1_0_24_3_range, getProfileFloat( "BAP", "P_ASG_18_1_0_24_3_range", 0, profileFile ) );
    putValue( P_ASG_18_1_0_24_2, getProfileInt( "BAP", "P_ASG_18_1_0_24_2", 0, profileFile ) );
    putValue( P_ASG_18_1_0_24_2_0, getProfileInt( "BAP", "P_ASG_18_1_0_24_2_0", 0, profileFile ) );
    putValue( P_ASG_18_1_0_24_1, getProfileInt( "BAP", "P_ASG_18_1_0_24_1", 0, profileFile ) );
    putValue( P_ASG_18_1_0_24_4, getProfileInt( "BAP", "P_ASG_18_1_0_24_4", 0, profileFile ) );
    putValue( P_ASG_18_1_0_24_5, getProfileInt( "BAP", "P_ASG_18_1_0_24_5", 0, profileFile ) );
    putValue( P_ASG_18_1_0_24_5_0, getProfileInt( "BAP", "P_ASG_18_1_0_24_5_0", 0, profileFile ) );
    putValue( P_ASG_18_1_0_25Get_BTN, getProfileInt( "BAP", "P_ASG_18_1_0_25Get_BTN", 0, profileFile ) );
    putValue( P_ASG_18_1_0_25_FctLstItemEn, getProfileInt( "BAP", "P_ASG_18_1_0_25_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_18_1_0_25_ErrCode, getProfileInt( "BAP", "P_ASG_18_1_0_25_ErrCode", 0, profileFile ) );
    putValue( P_ASG_18_1_0_25_1, getProfileInt( "BAP", "P_ASG_18_1_0_25_1", 0, profileFile ) );
    putValue( P_ASG_18_1_0_25_1_range, getProfileInt( "BAP", "P_ASG_18_1_0_25_1_range", 0, profileFile ) );
    putValue( P_ASG_18_1_0_25_2, getProfileInt( "BAP", "P_ASG_18_1_0_25_2", 0, profileFile ) );
    putValue( P_ASG_18_1_0_25_2_0, getProfileInt( "BAP", "P_ASG_18_1_0_25_2_0", 0, profileFile ) );
    putValue( P_ASG_18_1_0_25_3, getProfileInt( "BAP", "P_ASG_18_1_0_25_3", 0, profileFile ) );
    putValue( P_ASG_18_1_0_25_3_range, getProfileInt( "BAP", "P_ASG_18_1_0_25_3_range", 0, profileFile ) );
    putValue( ERRORLIST_ASG19_1_VT, getProfileInt( "BAP", "ERRORLIST_ASG19_1_VT", 0, profileFile ) );
    putValue( BusType_ASG19_1, getProfileInt( "BAP", "BusType_ASG19_1", 0, profileFile ) );
    putValue( ON_OFF_ASG19_1, getProfileInt( "BAP", "ON_OFF_ASG19_1", 0, profileFile ) );
    putValue( BAPCFG_ASG_19_1_0_DFMajor, getProfileInt( "BAP", "BAPCFG_ASG_19_1_0_DFMajor", 0, profileFile ) );
    putValue( BAPCFG_ASG_19_1_0_DFMinor, getProfileInt( "BAP", "BAPCFG_ASG_19_1_0_DFMinor", 0, profileFile ) );
    putValue( BAPCFG_ASG_19_1_0_LsgClassMajor, getProfileInt( "BAP", "BAPCFG_ASG_19_1_0_LsgClassMajor", 0, profileFile ) );
    putValue( BAPCFG_ASG_19_1_0_LsgClassMinor, getProfileInt( "BAP", "BAPCFG_ASG_19_1_0_LsgClassMinor", 0, profileFile ) );
    putValue( BAPCFG_ASG_19_1_0_ProtocolMajor, getProfileInt( "BAP", "BAPCFG_ASG_19_1_0_ProtocolMajor", 0, profileFile ) );
    putValue( BAPCFG_ASG_19_1_0_ProtocolMinor, getProfileInt( "BAP", "BAPCFG_ASG_19_1_0_ProtocolMinor", 0, profileFile ) );
    putValue( C_ASG_19_1_0_1GetAll_BTN, getProfileInt( "BAP", "C_ASG_19_1_0_1GetAll_BTN", 0, profileFile ) );
    putValue( C_ASG_19_1_0_1_FctLstItemEn, getProfileInt( "BAP", "C_ASG_19_1_0_1_FctLstItemEn", 0, profileFile ) );
    putValue( C_ASG_19_1_0_1_ErrCode, getProfileInt( "BAP", "C_ASG_19_1_0_1_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_2Get_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_2Get_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_2_FctLstItemEn, getProfileInt( "BAP", "P_ASG_19_1_0_2_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_19_1_0_2_ErrCode, getProfileInt( "BAP", "P_ASG_19_1_0_2_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_2, getProfileFloat( "BAP", "P_ASG_19_1_0_2", 0, profileFile ) );
    putValue( P_ASG_19_1_0_2_range, getProfileFloat( "BAP", "P_ASG_19_1_0_2_range", 0, profileFile ) );
    putValue( P_ASG_19_1_0_3Get_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_3Get_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_3_FctLstItemEn, getProfileInt( "BAP", "P_ASG_19_1_0_3_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_19_1_0_3_ErrCode, getProfileInt( "BAP", "P_ASG_19_1_0_3_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_4Get_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_4Get_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_4_FctLstItemEn, getProfileInt( "BAP", "P_ASG_19_1_0_4_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_19_1_0_4_ErrCode, getProfileInt( "BAP", "P_ASG_19_1_0_4_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_4, getProfileInt( "BAP", "P_ASG_19_1_0_4", 0, profileFile ) );
    putValue( P_ASG_19_1_0_13Get_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_13Get_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_13SetGet_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_13SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_13_FctLstItemEn, getProfileInt( "BAP", "P_ASG_19_1_0_13_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_19_1_0_13_ErrCode, getProfileInt( "BAP", "P_ASG_19_1_0_13_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_13, getProfileInt( "BAP", "P_ASG_19_1_0_13", 0, profileFile ) );
    putValue( P_ASG_19_1_0_13_1, getProfileInt( "BAP", "P_ASG_19_1_0_13_1", 0, profileFile ) );
    putValue( P_ASG_19_1_0_13_1_0, getProfileInt( "BAP", "P_ASG_19_1_0_13_1_0", 0, profileFile ) );
    putValue( P_ASG_19_1_0_13_1_4, getProfileInt( "BAP", "P_ASG_19_1_0_13_1_4", 0, profileFile ) );
    putValue( P_ASG_19_1_0_14Get_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_14Get_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_14_FctLstItemEn, getProfileInt( "BAP", "P_ASG_19_1_0_14_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_19_1_0_14_ErrCode, getProfileInt( "BAP", "P_ASG_19_1_0_14_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_14, getProfileInt( "BAP", "P_ASG_19_1_0_14", 0, profileFile ) );
    putValue( P_ASG_19_1_0_14_1, getProfileInt( "BAP", "P_ASG_19_1_0_14_1", 0, profileFile ) );
    putValue( P_ASG_19_1_0_14_1_0, getProfileInt( "BAP", "P_ASG_19_1_0_14_1_0", 0, profileFile ) );
    putValue( P_ASG_19_1_0_14_1_1, getProfileInt( "BAP", "P_ASG_19_1_0_14_1_1", 0, profileFile ) );
    putValue( P_ASG_19_1_0_15Get_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_15Get_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_15_FctLstItemEn, getProfileInt( "BAP", "P_ASG_19_1_0_15_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_19_1_0_15_ErrCode, getProfileInt( "BAP", "P_ASG_19_1_0_15_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_15, getProfileInt( "BAP", "P_ASG_19_1_0_15", 0, profileFile ) );
    putValue( P_ASG_19_1_0_15_1, getProfileInt( "BAP", "P_ASG_19_1_0_15_1", 0, profileFile ) );
    putValue( P_ASG_19_1_0_16Get_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_16Get_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_16SetGet_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_16SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_16_FctLstItemEn, getProfileInt( "BAP", "P_ASG_19_1_0_16_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_19_1_0_16_ErrCode, getProfileInt( "BAP", "P_ASG_19_1_0_16_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_16, getProfileInt( "BAP", "P_ASG_19_1_0_16", 0, profileFile ) );
    putValue( P_ASG_19_1_0_16_1, getProfileInt( "BAP", "P_ASG_19_1_0_16_1", 0, profileFile ) );
    putValue( P_ASG_19_1_0_17Get_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_17Get_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_17SetGet_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_17SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_17_FctLstItemEn, getProfileInt( "BAP", "P_ASG_19_1_0_17_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_19_1_0_17_ErrCode, getProfileInt( "BAP", "P_ASG_19_1_0_17_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_17, getProfileInt( "BAP", "P_ASG_19_1_0_17", 0, profileFile ) );
    putValue( P_ASG_19_1_0_17_1, getProfileInt( "BAP", "P_ASG_19_1_0_17_1", 0, profileFile ) );
    putValue( P_ASG_19_1_0_18Get_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_18Get_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_18SetGet_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_18SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_18_FctLstItemEn, getProfileInt( "BAP", "P_ASG_19_1_0_18_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_19_1_0_18_ErrCode, getProfileInt( "BAP", "P_ASG_19_1_0_18_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_18_1, getProfileInt( "BAP", "P_ASG_19_1_0_18_1", 0, profileFile ) );
    putValue( P_ASG_19_1_0_18_2, getProfileInt( "BAP", "P_ASG_19_1_0_18_2", 0, profileFile ) );
    putValue( P_ASG_19_1_0_19Get_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_19Get_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_19SetGet_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_19SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_19_FctLstItemEn, getProfileInt( "BAP", "P_ASG_19_1_0_19_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_19_1_0_19_ErrCode, getProfileInt( "BAP", "P_ASG_19_1_0_19_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_19, getProfileInt( "BAP", "P_ASG_19_1_0_19", 0, profileFile ) );
    putValue( P_ASG_19_1_0_19_1, getProfileInt( "BAP", "P_ASG_19_1_0_19_1", 0, profileFile ) );
    putValue( P_ASG_19_1_0_20Get_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_20Get_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_20SetGet_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_20SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_20_FctLstItemEn, getProfileInt( "BAP", "P_ASG_19_1_0_20_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_19_1_0_20_ErrCode, getProfileInt( "BAP", "P_ASG_19_1_0_20_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_20, getProfileInt( "BAP", "P_ASG_19_1_0_20", 0, profileFile ) );
    putValue( P_ASG_19_1_0_20_1, getProfileInt( "BAP", "P_ASG_19_1_0_20_1", 0, profileFile ) );
    putValue( P_ASG_19_1_0_21Get_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_21Get_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_21SetGet_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_21SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_21_FctLstItemEn, getProfileInt( "BAP", "P_ASG_19_1_0_21_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_19_1_0_21_ErrCode, getProfileInt( "BAP", "P_ASG_19_1_0_21_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_21_2, getProfileInt( "BAP", "P_ASG_19_1_0_21_2", 0, profileFile ) );
    putValue( P_ASG_19_1_0_21_1, getProfileInt( "BAP", "P_ASG_19_1_0_21_1", 0, profileFile ) );
    putValue( P_ASG_19_1_0_22Get_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_22Get_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_22SetGet_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_22SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_22_FctLstItemEn, getProfileInt( "BAP", "P_ASG_19_1_0_22_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_19_1_0_22_ErrCode, getProfileInt( "BAP", "P_ASG_19_1_0_22_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_22, getProfileInt( "BAP", "P_ASG_19_1_0_22", 0, profileFile ) );
    putValue( P_ASG_19_1_0_22_1, getProfileInt( "BAP", "P_ASG_19_1_0_22_1", 0, profileFile ) );
    putValue( P_ASG_19_1_0_23Get_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_23Get_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_23SetGet_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_23SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_23_FctLstItemEn, getProfileInt( "BAP", "P_ASG_19_1_0_23_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_19_1_0_23_ErrCode, getProfileInt( "BAP", "P_ASG_19_1_0_23_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_23, getProfileInt( "BAP", "P_ASG_19_1_0_23", 0, profileFile ) );
    putValue( P_ASG_19_1_0_23_1, getProfileInt( "BAP", "P_ASG_19_1_0_23_1", 0, profileFile ) );
    putValue( P_ASG_19_1_0_24Get_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_24Get_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_24SetGet_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_24SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_24_FctLstItemEn, getProfileInt( "BAP", "P_ASG_19_1_0_24_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_19_1_0_24_ErrCode, getProfileInt( "BAP", "P_ASG_19_1_0_24_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_24, getProfileInt( "BAP", "P_ASG_19_1_0_24", 0, profileFile ) );
    putValue( P_ASG_19_1_0_24_1, getProfileInt( "BAP", "P_ASG_19_1_0_24_1", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25Get_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_25Get_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_FctLstItemEn, getProfileInt( "BAP", "P_ASG_19_1_0_25_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_ErrCode, getProfileInt( "BAP", "P_ASG_19_1_0_25_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_6, getProfileFloat( "BAP", "P_ASG_19_1_0_25_6", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_6_range, getProfileFloat( "BAP", "P_ASG_19_1_0_25_6_range", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_1, getProfileInt( "BAP", "P_ASG_19_1_0_25_1", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_1_0, getProfileInt( "BAP", "P_ASG_19_1_0_25_1_0", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_1_1, getProfileInt( "BAP", "P_ASG_19_1_0_25_1_1", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_1_2, getProfileInt( "BAP", "P_ASG_19_1_0_25_1_2", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_1_3, getProfileInt( "BAP", "P_ASG_19_1_0_25_1_3", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_1_4, getProfileInt( "BAP", "P_ASG_19_1_0_25_1_4", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_1_5, getProfileInt( "BAP", "P_ASG_19_1_0_25_1_5", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_1_6, getProfileInt( "BAP", "P_ASG_19_1_0_25_1_6", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_1_7, getProfileInt( "BAP", "P_ASG_19_1_0_25_1_7", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_5, getProfileFloat( "BAP", "P_ASG_19_1_0_25_5", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_5_range, getProfileFloat( "BAP", "P_ASG_19_1_0_25_5_range", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_4, getProfileFloat( "BAP", "P_ASG_19_1_0_25_4", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_4_range, getProfileFloat( "BAP", "P_ASG_19_1_0_25_4_range", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_3, getProfileFloat( "BAP", "P_ASG_19_1_0_25_3", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_3_range, getProfileFloat( "BAP", "P_ASG_19_1_0_25_3_range", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_2, getProfileFloat( "BAP", "P_ASG_19_1_0_25_2", 0, profileFile ) );
    putValue( P_ASG_19_1_0_25_2_range, getProfileFloat( "BAP", "P_ASG_19_1_0_25_2_range", 0, profileFile ) );
    putValue( P_ASG_19_1_0_26Get_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_26Get_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_26SetGet_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_26SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_26_FctLstItemEn, getProfileInt( "BAP", "P_ASG_19_1_0_26_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_19_1_0_26_ErrCode, getProfileInt( "BAP", "P_ASG_19_1_0_26_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_26_2, getProfileInt( "BAP", "P_ASG_19_1_0_26_2", 0, profileFile ) );
    putValue( P_ASG_19_1_0_26_1, getProfileInt( "BAP", "P_ASG_19_1_0_26_1", 0, profileFile ) );
    putValue( P_ASG_19_1_0_26_3, getProfileInt( "BAP", "P_ASG_19_1_0_26_3", 0, profileFile ) );
    putValue( P_ASG_19_1_0_26_3_0, getProfileInt( "BAP", "P_ASG_19_1_0_26_3_0", 0, profileFile ) );
    putValue( P_ASG_19_1_0_27Get_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_27Get_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_27SetGet_BTN, getProfileInt( "BAP", "P_ASG_19_1_0_27SetGet_BTN", 0, profileFile ) );
    putValue( P_ASG_19_1_0_27_FctLstItemEn, getProfileInt( "BAP", "P_ASG_19_1_0_27_FctLstItemEn", 0, profileFile ) );
    putValue( P_ASG_19_1_0_27_ErrCode, getProfileInt( "BAP", "P_ASG_19_1_0_27_ErrCode", 0, profileFile ) );
    putValue( P_ASG_19_1_0_27_1, getProfileInt( "BAP", "P_ASG_19_1_0_27_1", 0, profileFile ) );
    putValue( P_ASG_19_1_0_27_2, getProfileFloat( "BAP", "P_ASG_19_1_0_27_2", 0, profileFile ) );
    putValue( P_ASG_19_1_0_27_2_range, getProfileFloat( "BAP", "P_ASG_19_1_0_27_2_range", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28Get_BTN, getProfileInt( "BAP", "A_ASG_19_1_0_28Get_BTN", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28SetGet_BTN, getProfileInt( "BAP", "A_ASG_19_1_0_28SetGet_BTN", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_FctLstItemEn, getProfileInt( "BAP", "A_ASG_19_1_0_28_FctLstItemEn", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_IntTlgEn, getProfileInt( "BAP", "A_ASG_19_1_0_28_IntTlgEn", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_SegmEn, getProfileInt( "BAP", "A_ASG_19_1_0_28_SegmEn", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_AT, getProfileInt( "BAP", "A_ASG_19_1_0_28_AT", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_ErrCode, getProfileInt( "BAP", "A_ASG_19_1_0_28_ErrCode", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_DataIndex_SetGet_Incr, getProfileInt( "BAP", "A_ASG_19_1_0_28_DataIndex_SetGet_Incr", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_DataIndex_Incr, getProfileInt( "BAP", "A_ASG_19_1_0_28_DataIndex_Incr", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_DataIndex_Decr, getProfileInt( "BAP", "A_ASG_19_1_0_28_DataIndex_Decr", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_loadArray_Btn, getProfileInt( "BAP", "A_ASG_19_1_0_28_loadArray_Btn", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_generateData_Btn, getProfileInt( "BAP", "A_ASG_19_1_0_28_generateData_Btn", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_2, getProfileInt( "BAP", "A_ASG_19_1_0_28_2", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_3, getProfileFloat( "BAP", "A_ASG_19_1_0_28_3", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_3_range, getProfileFloat( "BAP", "A_ASG_19_1_0_28_3_range", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_7, getProfileFloat( "BAP", "A_ASG_19_1_0_28_7", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_7_range, getProfileFloat( "BAP", "A_ASG_19_1_0_28_7_range", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_3, getProfileInt( "BAP", "A_ASG_19_1_0_28_Data_3", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_3_0, getProfileInt( "BAP", "A_ASG_19_1_0_28_Data_3_0", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_3_1, getProfileInt( "BAP", "A_ASG_19_1_0_28_Data_3_1", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_3_4, getProfileInt( "BAP", "A_ASG_19_1_0_28_Data_3_4", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_3_5, getProfileInt( "BAP", "A_ASG_19_1_0_28_Data_3_5", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_3_6, getProfileInt( "BAP", "A_ASG_19_1_0_28_Data_3_6", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_3_7, getProfileInt( "BAP", "A_ASG_19_1_0_28_Data_3_7", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_5, getProfileInt( "BAP", "A_ASG_19_1_0_28_5", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_2_SetGet_range, getProfileFloat( "BAP", "A_ASG_19_1_0_28_Data_2_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_2_range, getProfileFloat( "BAP", "A_ASG_19_1_0_28_Data_2_range", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_1, getProfileInt( "BAP", "A_ASG_19_1_0_28_1", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_4_len, getProfileInt( "BAP", "A_ASG_19_1_0_28_Data_4_len", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_6, getProfileFloat( "BAP", "A_ASG_19_1_0_28_6", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_6_range, getProfileFloat( "BAP", "A_ASG_19_1_0_28_6_range", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_4, getProfileInt( "BAP", "A_ASG_19_1_0_28_4", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_4_0, getProfileInt( "BAP", "A_ASG_19_1_0_28_4_0", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_4_1, getProfileInt( "BAP", "A_ASG_19_1_0_28_4_1", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_4_2, getProfileInt( "BAP", "A_ASG_19_1_0_28_4_2", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_1_SetGet_range, getProfileFloat( "BAP", "A_ASG_19_1_0_28_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_1_range, getProfileFloat( "BAP", "A_ASG_19_1_0_28_Data_1_range", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_RecAdr, getProfileInt( "BAP", "A_ASG_19_1_0_28_RecAdr", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Direction, getProfileInt( "BAP", "A_ASG_19_1_0_28_Direction", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Shift, getProfileInt( "BAP", "A_ASG_19_1_0_28_Shift", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_TransPos, getProfileInt( "BAP", "A_ASG_19_1_0_28_TransPos", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_IndexSize, getProfileInt( "BAP", "A_ASG_19_1_0_28_IndexSize", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Start, getProfileInt( "BAP", "A_ASG_19_1_0_28_Start", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Elements, getProfileInt( "BAP", "A_ASG_19_1_0_28_Elements", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_2_Changed, getProfileInt( "BAP", "A_ASG_19_1_0_28_2_Changed", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_1_Changed, getProfileInt( "BAP", "A_ASG_19_1_0_28_1_Changed", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_3_Changed, getProfileFloat( "BAP", "A_ASG_19_1_0_28_3_Changed", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_3_Changed_range, getProfileFloat( "BAP", "A_ASG_19_1_0_28_3_Changed_range", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Changed_RecAdr, getProfileInt( "BAP", "A_ASG_19_1_0_28_Changed_RecAdr", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Changed_Direction, getProfileInt( "BAP", "A_ASG_19_1_0_28_Changed_Direction", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Changed_Shift, getProfileInt( "BAP", "A_ASG_19_1_0_28_Changed_Shift", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Changed_TransPos, getProfileInt( "BAP", "A_ASG_19_1_0_28_Changed_TransPos", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Changed_IndexSize, getProfileInt( "BAP", "A_ASG_19_1_0_28_Changed_IndexSize", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Changed_Start, getProfileInt( "BAP", "A_ASG_19_1_0_28_Changed_Start", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Changed_Elements, getProfileInt( "BAP", "A_ASG_19_1_0_28_Changed_Elements", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_DataIndex_SetGet, getProfileInt( "BAP", "A_ASG_19_1_0_28_DataIndex_SetGet", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_DataIndex_SetGet_Incr, getProfileInt( "BAP", "A_ASG_19_1_0_28_DataIndex_SetGet_Incr", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_DataIndex_SetGet_Decr, getProfileInt( "BAP", "A_ASG_19_1_0_28_DataIndex_SetGet_Decr", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_2_SetGet, getProfileInt( "BAP", "A_ASG_19_1_0_28_2_SetGet", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_3_SetGet, getProfileFloat( "BAP", "A_ASG_19_1_0_28_3_SetGet", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_3_SetGet_range, getProfileFloat( "BAP", "A_ASG_19_1_0_28_3_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_3_SetGet, getProfileInt( "BAP", "A_ASG_19_1_0_28_Data_3_SetGet", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_3_SetGet_0, getProfileInt( "BAP", "A_ASG_19_1_0_28_Data_3_SetGet_0", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_3_SetGet_1, getProfileInt( "BAP", "A_ASG_19_1_0_28_Data_3_SetGet_1", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_3_SetGet_4, getProfileInt( "BAP", "A_ASG_19_1_0_28_Data_3_SetGet_4", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_3_SetGet_5, getProfileInt( "BAP", "A_ASG_19_1_0_28_Data_3_SetGet_5", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_3_SetGet_6, getProfileInt( "BAP", "A_ASG_19_1_0_28_Data_3_SetGet_6", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_3_SetGet_7, getProfileInt( "BAP", "A_ASG_19_1_0_28_Data_3_SetGet_7", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_4_SetGet, getProfileInt( "BAP", "A_ASG_19_1_0_28_4_SetGet", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_2_SetGet_range, getProfileFloat( "BAP", "A_ASG_19_1_0_28_Data_2_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_2_SetGet_range, getProfileFloat( "BAP", "A_ASG_19_1_0_28_Data_2_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_1_SetGet, getProfileInt( "BAP", "A_ASG_19_1_0_28_1_SetGet", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_4_SetGet_len, getProfileInt( "BAP", "A_ASG_19_1_0_28_Data_4_SetGet_len", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_5_SetGet, getProfileFloat( "BAP", "A_ASG_19_1_0_28_5_SetGet", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_5_SetGet_range, getProfileFloat( "BAP", "A_ASG_19_1_0_28_5_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_1_SetGet_range, getProfileFloat( "BAP", "A_ASG_19_1_0_28_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_Data_1_SetGet_range, getProfileFloat( "BAP", "A_ASG_19_1_0_28_Data_1_SetGet_range", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_SetGet_RecAdr, getProfileInt( "BAP", "A_ASG_19_1_0_28_SetGet_RecAdr", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_SetGet_Direction, getProfileInt( "BAP", "A_ASG_19_1_0_28_SetGet_Direction", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_SetGet_Shift, getProfileInt( "BAP", "A_ASG_19_1_0_28_SetGet_Shift", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_SetGet_IndexSize, getProfileInt( "BAP", "A_ASG_19_1_0_28_SetGet_IndexSize", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_SetGet_Start, getProfileInt( "BAP", "A_ASG_19_1_0_28_SetGet_Start", 0, profileFile ) );
    putValue( A_ASG_19_1_0_28_SetGet_Elements, getProfileInt( "BAP", "A_ASG_19_1_0_28_SetGet_Elements", 0, profileFile ) );
    putValue( C_FSG_33_0_0_0_1_FctLstItemEn, getProfileInt( "BAP", "C_FSG_33_0_0_0_1_FctLstItemEn", 0, profileFile ) );
    putValue( C_FSG_33_0_0_0_1_FctEn, getProfileInt( "BAP", "C_FSG_33_0_0_0_1_FctEn", 0, profileFile ) );
    putValue( C_FSG_33_0_0_0_1_ErrEn, getProfileInt( "BAP", "C_FSG_33_0_0_0_1_ErrEn", 0, profileFile ) );
    putValue( C_FSG_33_0_0_0_1_IntTlgEn, getProfileInt( "BAP", "C_FSG_33_0_0_0_1_IntTlgEn", 0, profileFile ) );
    putValue( C_FSG_33_0_0_0_1_SegmEn, getProfileInt( "BAP", "C_FSG_33_0_0_0_1_SegmEn", 0, profileFile ) );
    putValue( C_FSG_33_0_0_0_1_ErrCode, getProfileInt( "BAP", "C_FSG_33_0_0_0_1_ErrCode", 0, profileFile ) );
    putValue( P_FSG_33_0_0_0_2Reset_BTN, getProfileInt( "BAP", "P_FSG_33_0_0_0_2Reset_BTN", 0, profileFile ) );
    putValue( P_FSG_33_0_0_0_2_FctLstItemEn, getProfileInt( "BAP", "P_FSG_33_0_0_0_2_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_33_0_0_0_2_FctEn, getProfileInt( "BAP", "P_FSG_33_0_0_0_2_FctEn", 0, profileFile ) );
    putValue( P_FSG_33_0_0_0_2_ErrEn, getProfileInt( "BAP", "P_FSG_33_0_0_0_2_ErrEn", 0, profileFile ) );
    putValue( P_FSG_33_0_0_0_2_ErrCode, getProfileInt( "BAP", "P_FSG_33_0_0_0_2_ErrCode", 0, profileFile ) );
    putValue( P_FSG_33_0_0_0_3_FctLstItemEn, getProfileInt( "BAP", "P_FSG_33_0_0_0_3_FctLstItemEn", 0, profileFile ) );
    putValue( P_FSG_33_0_0_0_3_FctEn, getProfileInt( "BAP", "P_FSG_33_0_0_0_3_FctEn", 0, profileFile ) );
    putValue( P_FSG_33_0_0_0_3_ErrEn, getProfileInt( "BAP", "P_FSG_33_0_0_0_3_ErrEn", 0, profileFile ) );
    putValue( P_FSG_33_0_0_0_3_IntTlgEn, getProfileInt( "BAP", "P_FSG_33_0_0_0_3_IntTlgEn", 0, profileFile ) );
    putValue( P_FSG_33_0_0_0_3_SegmEn, getProfileInt( "BAP", "P_FSG_33_0_0_0_3_SegmEn", 0, profileFile ) );
    putValue( P_FSG_33_0_0_0_3_ErrCode, getProfileInt( "BAP", "P_FSG_33_0_0_0_3_ErrCode", 0, profileFile ) );
    putValue( FSG33_0_0_Channel, getProfileInt( "BAP", "FSG33_0_0_Channel", 0, profileFile ) );
    putValue( FSG33_0_0_BusType, getProfileInt( "BAP", "FSG33_0_0_BusType", 0, profileFile ) );
    putValue( FSG33_0_1_Channel, getProfileInt( "BAP", "FSG33_0_1_Channel", 0, profileFile ) );
    putValue( FSG33_0_1_BusType, getProfileInt( "BAP", "FSG33_0_1_BusType", 0, profileFile ) );
    putValue( FSG33_0_2_Channel, getProfileInt( "BAP", "FSG33_0_2_Channel", 0, profileFile ) );
    putValue( FSG33_0_2_BusType, getProfileInt( "BAP", "FSG33_0_2_BusType", 0, profileFile ) );
    putValue( FSG33_0_3_Channel, getProfileInt( "BAP", "FSG33_0_3_Channel", 0, profileFile ) );
    putValue( FSG33_0_3_BusType, getProfileInt( "BAP", "FSG33_0_3_BusType", 0, profileFile ) );
    putValue( FSG33_0_4_Channel, getProfileInt( "BAP", "FSG33_0_4_Channel", 0, profileFile ) );
    putValue( FSG33_0_4_BusType, getProfileInt( "BAP", "FSG33_0_4_BusType", 0, profileFile ) );
    putValue( ERRORLIST_FSG33_0_VT, getProfileInt( "BAP", "ERRORLIST_FSG33_0_VT", 0, profileFile ) );
    putValue( BusType_FSG33_0, getProfileInt( "BAP", "BusType_FSG33_0", 0, profileFile ) );
    putValue( ON_OFF_FSG33_0, getProfileInt( "BAP", "ON_OFF_FSG33_0", 0, profileFile ) );
    putValue( BAPCFG_FSG_33_0_0_DFMajor, getProfileInt( "BAP", "BAPCFG_FSG_33_0_0_DFMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_33_0_0_DFMinor, getProfileInt( "BAP", "BAPCFG_FSG_33_0_0_DFMinor", 0, profileFile ) );
    putValue( BAPCFG_FSG_33_0_0_LsgClassMajor, getProfileInt( "BAP", "BAPCFG_FSG_33_0_0_LsgClassMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_33_0_0_LsgClassMinor, getProfileInt( "BAP", "BAPCFG_FSG_33_0_0_LsgClassMinor", 0, profileFile ) );
    putValue( BAPCFG_FSG_33_0_0_ProtocolMajor, getProfileInt( "BAP", "BAPCFG_FSG_33_0_0_ProtocolMajor", 0, profileFile ) );
    putValue( BAPCFG_FSG_33_0_0_ProtocolMinor, getProfileInt( "BAP", "BAPCFG_FSG_33_0_0_ProtocolMinor", 0, profileFile ) );
    putValue( C_FSG_33_0_0_1_FctLstItemEn, getProfileInt( "BAP", "C_FSG_33_0_0_1_FctLstItemEn", 0, profileFile ) );
